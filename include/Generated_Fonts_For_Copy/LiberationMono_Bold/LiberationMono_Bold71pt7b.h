#ifndef _LIBERATIONMONO_BOLD71PT7B_H_
#define _LIBERATIONMONO_BOLD71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFE,
  0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x79, 0xFF,
  0xE0, 0x7F, 0xE1, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0x83, 0xFF, 0x0F, 0xF8,
  0x1E, 0x07, 0xFC, 0x3F, 0xE0, 0x78, 0x1F, 0xF8, 0xFF, 0x81, 0xE0, 0x7F,
  0xE3, 0xFE, 0x07, 0x80, 0xE0, 0x0F, 0xF8, 0x1E, 0x00, 0x00, 0x3F, 0xF0,
  0x78, 0x00, 0x00, 0xFF, 0xE1, 0xE0, 0x00, 0x01, 0xFF, 0xC7, 0x80, 0x00,
  0x07, 0xFF, 0xDE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xE3, 0xFF, 0xE0, 0x00, 0x07, 0x83, 0xFF, 0x80, 0x00, 0x1E,
  0x03, 0xFE, 0x00, 0x00, 0x78, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x1F, 0xF0,
  0x18, 0x07, 0x80, 0x7F, 0xDF, 0xF0, 0x1E, 0x01, 0xFF, 0x7F, 0xC0, 0x78,
  0x07, 0xFD, 0xFF, 0x01, 0xE0, 0x1F, 0xF7, 0xFE, 0x07, 0x80, 0xFF, 0xDF,
  0xFC, 0x1E, 0x03, 0xFE, 0x3F, 0xF8, 0x78, 0x3F, 0xF8, 0xFF, 0xF9, 0xE3,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xE1, 0xFC, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xE1, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xC3, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xFC,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x1F,
  0xE0, 0x7E, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x07,
  0xE0, 0x00, 0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFC,
  0x07, 0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x3F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xF0,
  0x3F, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0xFF, 0x80, 0xFF, 0x8F, 0xE0, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x3F, 0xC0,
  0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0x01, 0xFF,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x3F, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x08, 0x0F, 0xE0, 0x63, 0xE1,
  0xFC, 0x3C, 0x7F, 0x3F, 0x9F, 0x8F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7E, 0x03, 0xE0, 0x03, 0x80, 0x78, 0x00,
  0x20, 0x04, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x3F, 0x87, 0xFD, 0xFF, 0x87,
  0xF0, 0xFF, 0xBF, 0xF0, 0xFE, 0x1F, 0xF7, 0xFE, 0x1F, 0xC3, 0xFE, 0xFF,
  0xC3, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0x0F, 0xE1, 0xFF,
  0x7F, 0xE1, 0xFC, 0x3F, 0xEF, 0xFC, 0x3F, 0x87, 0xFD, 0xFF, 0x80, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xCF, 0xF8,
  0x00, 0x7F, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFC, 0x07,
  0xFC, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7, 0xFF,
  0x80, 0x0F, 0xFE, 0x3F, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xCF,
  0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xF3, 0xFF, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF,
  0x0F, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0xC0,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFC,
  0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0x1F, 0xF0,
  0x1F, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x03, 0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0x0F, 0x87, 0xC0,
  0x3F, 0xC7, 0xDF, 0x1F, 0x01, 0xFF, 0xCF, 0xBE, 0x3E, 0x07, 0xFF, 0x9F,
  0x3C, 0x7C, 0x1F, 0xC7, 0xFC, 0x7D, 0xF0, 0x3E, 0x07, 0xF8, 0xFB, 0xE0,
  0xFC, 0x07, 0xF1, 0xF7, 0xC1, 0xF0, 0x0F, 0xE3, 0xEF, 0x07, 0xE0, 0x1F,
  0xC7, 0xFE, 0x0F, 0x80, 0x3F, 0x07, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xF8,
  0x7C, 0x00, 0xFC, 0x1F, 0xF0, 0xF8, 0x01, 0xF8, 0x3F, 0xE3, 0xF0, 0x03,
  0xF0, 0x7F, 0xC7, 0xE0, 0x07, 0xC0, 0xFF, 0x0F, 0x80, 0x0F, 0x81, 0xFE,
  0x1F, 0x00, 0x1F, 0x03, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xF8, 0x7C, 0x00,
  0xFC, 0x1F, 0xF0, 0xF8, 0x01, 0xF0, 0x3F, 0xE1, 0xF0, 0x03, 0xE0, 0x7F,
  0xC3, 0xE0, 0x07, 0xC0, 0xFF, 0x87, 0xC0, 0x1F, 0x81, 0xEF, 0x0F, 0x80,
  0x3F, 0x03, 0xDE, 0x1F, 0x00, 0x7E, 0x0F, 0xBC, 0x3E, 0x00, 0xF8, 0x1F,
  0x7C, 0x7C, 0x03, 0xF0, 0x3C, 0xF8, 0xF8, 0x07, 0xE0, 0x79, 0xF1, 0xF8,
  0x1D, 0xC1, 0xF3, 0xE1, 0xF0, 0x7B, 0x87, 0xC3, 0xC3, 0xF1, 0xE7, 0x8F,
  0x07, 0xC3, 0xFF, 0xCF, 0xFE, 0x0F, 0x87, 0xFF, 0x1F, 0xF8, 0x1F, 0x07,
  0xFC, 0x1F, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x00, 0x00,
  0x70, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF,
  0xC0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0x06,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFE,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0x00,
  0x3F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x3F, 0xFE,
  0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x70, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x7F,
  0xF0, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0xE0,
  0x07, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF,
  0x3F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x1F,
  0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFF, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0x7F, 0x07,
  0xF7, 0xFF, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0x7F, 0x07, 0xEF, 0xFF, 0xF3,
  0xF8, 0xFE, 0xFF, 0xFF, 0x3F, 0x8F, 0xEF, 0xFF, 0xF3, 0xF8, 0xFE, 0xFF,
  0xFF, 0x3F, 0x8F, 0xCF, 0xFF, 0xF1, 0xFD, 0xFC, 0xFF, 0xFF, 0x1F, 0xDF,
  0xCF, 0xFF, 0xF1, 0xFD, 0xF8, 0xFF, 0xFF, 0x1F, 0xDF, 0x8F, 0xFF, 0xF0,
  0xFD, 0xF8, 0xFF, 0xFF, 0x0F, 0xDF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xE0, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFD, 0xFE, 0x03,
  0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x9F, 0xE0,
  0x7F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0xE3, 0xFC, 0x1F, 0xFF, 0xF1, 0xFE,
  0x0F, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x1F,
  0xE1, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0x9F, 0xFF, 0xF8, 0x3F, 0xCF, 0xFF, 0xFC,
  0x1F, 0xE7, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0x03, 0xFD, 0xFF, 0xFF,
  0x81, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0x9F, 0xF8, 0x00,
  0x7F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x3F, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF9,
  0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xF8,
  0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0xFF, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xFC,
  0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01,
  0xFF, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0xFF,
  0xDF, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xFF,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F,
  0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x01, 0xFF,
  0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x83,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xFE,
  0x1F, 0xE0, 0x3F, 0xE3, 0xFF, 0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0xF8, 0x7F,
  0x80, 0x7F, 0x8F, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0xF1, 0xFE, 0x01,
  0xFE, 0x7F, 0x7E, 0x3F, 0xC0, 0x3F, 0xCF, 0xEF, 0xEF, 0xF0, 0x07, 0xF9,
  0xFD, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE7,
  0xF7, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xEF, 0xFE,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xFF,
  0x0F, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xC0, 0x00, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0xE0,
  0xFF, 0xDF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0x3F, 0xFC, 0x00,
  0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xFC,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xE3,
  0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFC,
  0x0F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0x80, 0x7F, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xF3, 0xFE, 0x07, 0xFF, 0xFF,
  0x7F, 0xC1, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x3F, 0xEF, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xDF,
  0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xF0, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE,
  0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x03, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xDF,
  0xF8, 0x3F, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF,
  0x83, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xFF, 0xFE,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFC,
  0x07, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00,
  0x7F, 0xDF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xBF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x8F, 0xFF,
  0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFF, 0x3F,
  0xE0, 0x3F, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xE0,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x03,
  0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF7, 0xC1, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xEE, 0x00, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFC,
  0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF3, 0xFF, 0x87, 0xFF, 0x1F, 0xDF, 0xFE, 0x3F, 0xFC, 0x7F, 0x7F, 0xFD,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xE7, 0xFE, 0x3F, 0xFC, 0x7F, 0x9F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x7F, 0xC1, 0xFF, 0x03, 0xFD, 0xFF, 0x07, 0xFC,
  0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xC0, 0xFF, 0x7F,
  0x81, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0,
  0x3F, 0xDF, 0xE0, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE, 0x03, 0xFD, 0xFE,
  0x07, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F, 0x80,
  0xFF, 0x7F, 0x81, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x0F, 0xF7, 0xF8,
  0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE, 0x03,
  0xFD, 0xFE, 0x07, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0,
  0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x0F,
  0xF7, 0xF8, 0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F, 0x80, 0xFF, 0x7F, 0x81,
  0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x3F,
  0xDF, 0xE0, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFE, 0x03, 0xFD, 0xFE, 0x07,
  0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF,
  0x8F, 0xF8, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0x7C, 0x1F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0,
  0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xF7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0xFF,
  0xF8, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x3F,
  0xFB, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0xCF,
  0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xE7,
  0xFE, 0x1F, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF8, 0xFF,
  0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0xC0, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFD, 0xFF,
  0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xE7, 0xFC, 0x07, 0xFF, 0xF8,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0xF7, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x01, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x07, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xFF, 0xFD,
  0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC1, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFF, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0xE0, 0xFE, 0x07, 0xF8, 0x7F, 0xF8, 0x3F, 0x81, 0xFE,
  0x1F, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xEF, 0xC7, 0xF8, 0x0F, 0xE3, 0xFB,
  0xF1, 0xFE, 0x03, 0xF8, 0xFC, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x3F, 0x9F,
  0xC0, 0x3F, 0x9F, 0xC7, 0xE7, 0xF0, 0x0F, 0xF7, 0xE1, 0xF9, 0xFC, 0x01,
  0xFD, 0xF8, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF,
  0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00,
};

const GFXglyph LiberationMono_Bold71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 10, 47, 43, 16, -47 },
  { 60, 25, 22, 43, 9, -51 },
  { 129, 39, 47, 43, 2, -47 },
  { 359, 38, 59, 43, 2, -53 },
  { 640, 43, 49, 43, 0, -48 },
  { 904, 41, 49, 43, 1, -48 },
  { 1156, 9, 22, 43, 17, -51 },
  { 1181, 20, 66, 43, 12, -51 },
  { 1346, 20, 66, 43, 11, -51 },
  { 1511, 27, 26, 43, 8, -51 },
  { 1599, 36, 36, 43, 3, -41 },
  { 1761, 17, 23, 43, 9, -11 },
  { 1810, 20, 8, 43, 11, -23 },
  { 1830, 10, 11, 43, 16, -11 },
  { 1844, 36, 52, 43, 3, -51 },
  { 2078, 35, 49, 43, 4, -48 },
  { 2293, 35, 47, 43, 5, -47 },
  { 2499, 34, 48, 43, 4, -48 },
  { 2703, 36, 49, 43, 3, -48 },
  { 2924, 39, 47, 43, 2, -47 },
  { 3154, 35, 48, 43, 4, -47 },
  { 3364, 35, 49, 43, 4, -48 },
  { 3579, 33, 47, 43, 5, -47 },
  { 3773, 35, 49, 43, 4, -48 },
  { 3988, 34, 49, 43, 4, -48 },
  { 4197, 10, 38, 43, 16, -38 },
  { 4245, 17, 50, 43, 11, -38 },
  { 4352, 36, 39, 43, 3, -43 },
  { 4528, 36, 27, 43, 3, -37 },
  { 4650, 36, 39, 43, 3, -43 },
  { 4826, 36, 48, 43, 3, -48 },
  { 5042, 39, 61, 43, 2, -51 },
  { 5340, 43, 47, 43, 0, -47 },
  { 5593, 36, 47, 43, 5, -47 },
  { 5805, 38, 49, 43, 3, -48 },
  { 6038, 35, 47, 43, 5, -47 },
  { 6244, 35, 47, 43, 5, -47 },
  { 6450, 32, 47, 43, 6, -47 },
  { 6638, 36, 49, 43, 3, -48 },
  { 6859, 33, 47, 43, 5, -47 },
  { 7053, 32, 47, 43, 5, -47 },
  { 7241, 31, 48, 43, 4, -47 },
  { 7427, 38, 47, 43, 5, -47 },
  { 7651, 32, 47, 43, 7, -47 },
  { 7839, 36, 47, 43, 3, -47 },
  { 8051, 33, 47, 43, 5, -47 },
  { 8245, 38, 49, 43, 2, -48 },
  { 8478, 35, 47, 43, 5, -47 },
  { 8684, 39, 62, 43, 2, -48 },
  { 8987, 38, 47, 43, 5, -47 },
  { 9211, 39, 49, 43, 1, -48 },
  { 9450, 39, 47, 43, 2, -47 },
  { 9680, 34, 48, 43, 4, -47 },
  { 9884, 43, 47, 43, 0, -47 },
  { 10137, 43, 47, 43, 0, -47 },
  { 10390, 43, 47, 43, 0, -47 },
  { 10643, 42, 47, 43, 0, -47 },
  { 10890, 36, 47, 43, 3, -47 },
  { 11102, 21, 66, 43, 13, -51 },
  { 11276, 37, 52, 43, 3, -51 },
  { 11517, 21, 66, 43, 9, -51 },
  { 11691, 38, 31, 43, 2, -49 },
  { 11839, 43, 3, 43, 0, 4 },
  { 11856, 18, 10, 43, 12, -51 },
  { 11879, 37, 40, 43, 4, -39 },
  { 12064, 34, 52, 43, 5, -51 },
  { 12285, 34, 40, 43, 4, -39 },
  { 12455, 35, 52, 43, 3, -51 },
  { 12683, 36, 40, 43, 3, -39 },
  { 12863, 35, 52, 43, 4, -52 },
  { 13091, 35, 54, 43, 4, -39 },
  { 13328, 33, 51, 43, 5, -51 },
  { 13539, 36, 51, 43, 4, -51 },
  { 13769, 26, 66, 43, 4, -51 },
  { 13984, 35, 51, 43, 6, -51 },
  { 14208, 36, 51, 43, 4, -51 },
  { 14438, 38, 39, 43, 2, -39 },
  { 14624, 33, 39, 43, 5, -39 },
  { 14785, 36, 40, 43, 3, -39 },
  { 14965, 34, 54, 43, 5, -39 },
  { 15195, 35, 54, 43, 3, -39 },
  { 15432, 30, 39, 43, 7, -39 },
  { 15579, 34, 40, 43, 4, -39 },
  { 15749, 30, 49, 43, 6, -48 },
  { 15933, 33, 39, 43, 5, -38 },
  { 16094, 40, 38, 43, 1, -38 },
  { 16284, 42, 38, 43, 0, -38 },
  { 16484, 39, 38, 43, 2, -38 },
  { 16670, 40, 53, 43, 1, -38 },
  { 16935, 32, 38, 43, 5, -38 },
  { 17087, 29, 66, 43, 7, -51 },
  { 17327, 9, 67, 43, 17, -51 },
  { 17403, 30, 66, 43, 6, -51 },
  { 17651, 36, 11, 43, 3, -29 },
};

const GFXfont LiberationMono_Bold71pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold71pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold71pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _LIBERATIONMONO_BOLD71PT7B_H_
