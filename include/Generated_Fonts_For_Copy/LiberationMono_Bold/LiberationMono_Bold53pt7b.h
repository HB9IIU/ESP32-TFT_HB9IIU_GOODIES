#ifndef _LIBERATIONMONO_BOLD53PT7B_H_
#define _LIBERATIONMONO_BOLD53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3,
  0xF0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xC6, 0x7F,
  0xC7, 0xF8, 0x63, 0xFC, 0x7F, 0x06, 0x1F, 0xE7, 0xF0, 0x60, 0xFE, 0x7F,
  0x06, 0x0F, 0x07, 0xF0, 0x60, 0x00, 0x7F, 0x06, 0x00, 0x07, 0xF8, 0x60,
  0x00, 0x3F, 0xE6, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x06, 0x3F, 0xE0, 0x00, 0x60, 0xFE,
  0x00, 0x06, 0x07, 0xF0, 0x00, 0x60, 0x7F, 0x0C, 0x06, 0x07, 0xFF, 0xE0,
  0x60, 0x7F, 0xFE, 0x06, 0x07, 0xFF, 0xF0, 0x60, 0xFE, 0x7F, 0x86, 0x0F,
  0xE7, 0xFC, 0x63, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x3F, 0xF8, 0x00, 0x78,
  0x7F, 0xFC, 0x00, 0xF8, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x3E, 0x01, 0xE0,
  0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x80,
  0xF8, 0x3E, 0x0F, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x3E, 0x00,
  0xF8, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x7F, 0xFC, 0xF8, 0x00,
  0x3F, 0xF8, 0xF0, 0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x0F, 0x8F, 0xF8,
  0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x3E, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x1E, 0x00, 0x78, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x1F,
  0x01, 0xF0, 0x7C, 0x1F, 0x01, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x07, 0xC0, 0x7C, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x0F, 0x80, 0x3E, 0x3E,
  0x1F, 0x00, 0x3F, 0xFE, 0x1E, 0x00, 0x1F, 0xFC, 0x3C, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x07, 0x80, 0x7F, 0xF8, 0x0F, 0xC1, 0xFF, 0xF0, 0x1F, 0x03, 0xFF, 0xF0,
  0x3E, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x7F, 0x0F, 0xE3,
  0xE0, 0xFC, 0x0F, 0xEF, 0xC1, 0xF8, 0x0F, 0xFF, 0x83, 0xF0, 0x1F, 0xFE,
  0x07, 0xE0, 0x1F, 0xFC, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0x80, 0x1F, 0xE0,
  0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xF8, 0x7F, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xC0, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x41, 0xF0, 0x67, 0x0F,
  0x1E, 0x7C, 0xF3, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x9F, 0x03,
  0xF9, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0xF8, 0x0E, 0x07, 0x00, 0x40, 0x40,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0,
  0x1F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0xFC, 0xFF, 0xFE, 0x3F, 0x3F,
  0xFF, 0x8F, 0xCF, 0xFF, 0xE3, 0xF3, 0xFF, 0xF8, 0xFC, 0xFF, 0xFE, 0x3F,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0xFF,
  0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE,
  0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F,
  0x0F, 0xE0, 0x0E, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xF3, 0xFC, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xDF, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0,
  0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xF9, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF7, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x7F, 0xE7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x0E, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xFF, 0x83, 0xF9, 0xFF, 0xF0, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFE, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF,
  0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F,
  0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F,
  0xC7, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x9F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFF, 0x03,
  0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x3F,
  0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x7F, 0xDF, 0xE0, 0x3F, 0xF7, 0xFC, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xEF, 0xE0, 0x7F, 0xF3, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x3C, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x3F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x9F,
  0xF8, 0x1F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x7C, 0x07, 0x8F, 0x03,
  0xF9, 0xDE, 0x3C, 0x3F, 0xEF, 0x38, 0xE0, 0xF1, 0xFC, 0xE7, 0x87, 0x83,
  0xF3, 0x9E, 0x3C, 0x0F, 0x8F, 0x78, 0xF0, 0x3E, 0x3D, 0xC3, 0xC0, 0x78,
  0xF7, 0x1E, 0x01, 0xE3, 0xFC, 0x78, 0x0F, 0x8F, 0xF1, 0xE0, 0x3E, 0x3F,
  0xC7, 0x80, 0xF0, 0xFF, 0x3C, 0x03, 0xC3, 0xFC, 0xF0, 0x0F, 0x0F, 0xF3,
  0xC0, 0x3C, 0x3B, 0xCF, 0x00, 0xF0, 0xEF, 0x3C, 0x07, 0x83, 0xBC, 0xF0,
  0x1E, 0x0E, 0xF3, 0xC0, 0x78, 0x7B, 0xCF, 0x03, 0xE1, 0xCF, 0x1E, 0x0F,
  0x87, 0x1C, 0x78, 0x7E, 0x3C, 0x71, 0xE3, 0xB9, 0xE1, 0xE3, 0xFE, 0xFF,
  0x07, 0x8F, 0xF1, 0xFC, 0x0E, 0x0F, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x20, 0x0F,
  0x00, 0x03, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x7F,
  0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x8F, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x1F,
  0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xE0, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x70,
  0x7F, 0x80, 0x07, 0xF7, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFE,
  0x01, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xC1, 0xFF, 0xC7, 0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE,
  0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0xCF, 0xF0, 0x3F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x70, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xF0,
  0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0xFE,
  0x7F, 0xC0, 0x1F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x0E, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xEF, 0xF8, 0xFF, 0x9F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x07, 0xFC,
  0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF8, 0xFE, 0x01, 0xFF, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F, 0xF8,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0x8F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0,
  0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x01, 0xFF, 0x0F, 0xE0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x8F, 0xE0, 0x07, 0xFC, 0xFE, 0x00, 0x7F,
  0xCF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xDF, 0xFB, 0xE1, 0xF7, 0xFE, 0xF8,
  0x7D, 0xFF, 0xBE, 0x1F, 0x7F, 0xEF, 0xCF, 0xFF, 0xF9, 0xF3, 0xEF, 0xFE,
  0x7C, 0xFB, 0xFF, 0x9F, 0x3E, 0xFF, 0xE7, 0xCF, 0xBF, 0xF8, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF3, 0xFF, 0x8F, 0xFC, 0xFF, 0xE3, 0xFE, 0x3F, 0xF8, 0x7F,
  0x8F, 0xFE, 0x1F, 0xE3, 0xFF, 0x87, 0xF8, 0xFF, 0xE1, 0xFC, 0x3F, 0xF8,
  0x3F, 0x0F, 0xFE, 0x0F, 0xC3, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFE, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xEF, 0xC1, 0xFF, 0xF7, 0xE0, 0xFF, 0xF9, 0xF8, 0x7F, 0xFC, 0xFC,
  0x3F, 0xFE, 0x7E, 0x1F, 0xFF, 0x1F, 0x8F, 0xFF, 0x8F, 0xC7, 0xFF, 0xC7,
  0xF3, 0xFF, 0xE1, 0xF9, 0xFF, 0xF0, 0xFC, 0xFF, 0xF8, 0x3F, 0x7F, 0xFC,
  0x1F, 0xBF, 0xFE, 0x0F, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xF0,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xFB, 0xF8, 0x03,
  0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xFB,
  0xF8, 0x03, 0xFE, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFC,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0x8F, 0xE0,
  0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F,
  0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0,
  0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0x3E, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC7,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0,
  0x03, 0xFD, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8,
  0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1, 0xF8,
  0x1F, 0x9F, 0xF1, 0xF8, 0x1F, 0x9F, 0xF9, 0xF8, 0x1F, 0x9F, 0xF9, 0xF8,
  0x1F, 0x9F, 0xF9, 0xF8, 0x1F, 0xBF, 0xF9, 0xF8, 0x1F, 0xBE, 0x7D, 0xF0,
  0x0F, 0xBE, 0x7D, 0xF0, 0x0F, 0xBE, 0x7D, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC,
  0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF8, 0xFF, 0x87, 0xFF,
  0x0F, 0xFF, 0xEF, 0xFD, 0xFF, 0xFC, 0xFF, 0x9F, 0xFF, 0x1F, 0xF1, 0xFF,
  0xC1, 0xFE, 0x0F, 0xE0, 0x0F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x3F, 0x8F, 0xFC, 0x1F, 0xCF, 0xFF, 0x8F, 0xEF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0x8F, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x7F,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x80,
  0xFF, 0x7F, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xDF, 0xFF, 0x8F, 0xE7,
  0xFF, 0x87, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF8, 0x03, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x1F, 0xC1, 0xFF, 0x8F, 0xE3, 0xFF, 0xE7, 0xF3,
  0xFF, 0xFB, 0xF9, 0xFF, 0xFD, 0xFD, 0xFF, 0x0F, 0xFE, 0xFF, 0x01, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFE,
  0x01, 0xFF, 0x7F, 0x81, 0xFF, 0xBF, 0xE1, 0xFF, 0xCF, 0xFF, 0xEF, 0xE3,
  0xFF, 0xF7, 0xF1, 0xFF, 0xF3, 0xF8, 0x3F, 0xF1, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x1F, 0xC7, 0xF8, 0x03, 0xF1, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xBF, 0xC0, 0x07, 0xEF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xC7,
  0xF8, 0x03, 0xF9, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0xC7, 0xF0, 0xFF, 0xF9, 0xFC, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF,
  0xDF, 0xCF, 0xF8, 0x7F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFE, 0x01, 0xFF, 0x7F,
  0x80, 0x7F, 0xDF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFC, 0x0F, 0xFC,
  0xFF, 0x87, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0xF0, 0xFF, 0xFB,
  0xFC, 0x1F, 0xF8, 0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x3F, 0x8F, 0xFE, 0x1F, 0xCF, 0xFF, 0x8F, 0xEF, 0xFF, 0xE7,
  0xF7, 0xFF, 0xF3, 0xFF, 0x87, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0x7F,
  0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xFB,
  0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF3,
  0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF8, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x78, 0x0F, 0x8F, 0x9F, 0xE3, 0xFC, 0xF9, 0xFE, 0x7F, 0xEF,
  0xBF, 0xF7, 0xFE, 0xFB, 0x3F, 0xE7, 0xEF, 0xE3, 0xFC, 0x7F, 0xFE, 0x1F,
  0xC3, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8,
  0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x87,
  0xFF, 0x07, 0xF3, 0xFF, 0xE1, 0xFD, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFC, 0x3F, 0xE7, 0xFC, 0x07, 0xF9, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x3F,
  0x9F, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00,
  0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFC,
  0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x7F, 0x1F, 0xF8, 0x3F, 0x9F, 0xFE, 0x1F, 0xDF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0x1F, 0xF3, 0xFE, 0x03, 0xFD, 0xFF, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFD,
  0xFF, 0x01, 0xFE, 0xFF, 0xE3, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF,
  0x1F, 0xCF, 0xFF, 0x0F, 0xE3, 0xFF, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xC3,
  0xFF, 0xCF, 0xE3, 0xFF, 0xF7, 0xF3, 0xFF, 0xFB, 0xFB, 0xFE, 0x1F, 0xFD,
  0xFE, 0x07, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0xC3, 0xFF, 0x9F,
  0xFF, 0xDF, 0xCF, 0xFF, 0xEF, 0xE3, 0xFF, 0xE7, 0xF0, 0xFF, 0xE3, 0xF8,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xFB, 0xF9, 0xFF, 0xF7, 0xF7, 0xFF,
  0xEF, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xF8,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xE0, 0x01,
  0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8,
  0x0F, 0xFB, 0xFC, 0x0F, 0xFD, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0x7F, 0x3F,
  0xFF, 0xBF, 0x9F, 0xFF, 0x9F, 0xC7, 0xFF, 0x8F, 0xE0, 0xFF, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x07, 0xE0, 0x7C, 0x3E, 0x07, 0xE0, 0xFC,
  0x3E, 0x07, 0xE0, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC,
  0x3F, 0x0F, 0xF0, 0xF8, 0x1F, 0x1F, 0xF0, 0xF8, 0x1F, 0x1F, 0xF9, 0xF8,
  0x1F, 0x1E, 0xF9, 0xF8, 0x1F, 0x3E, 0x79, 0xF8, 0x1F, 0xBE, 0x7D, 0xF0,
  0x1F, 0xBC, 0x7D, 0xF0, 0x0F, 0xFC, 0x3D, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC1,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFD,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xF8,
};

const GFXglyph LiberationMono_Bold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 35, 32, 12, -35 },
  { 36, 19, 16, 32, 6, -38 },
  { 74, 28, 35, 32, 2, -35 },
  { 197, 28, 43, 32, 2, -39 },
  { 348, 32, 37, 32, 0, -36 },
  { 496, 31, 37, 32, 1, -36 },
  { 640, 7, 16, 32, 12, -38 },
  { 654, 15, 49, 32, 9, -38 },
  { 746, 15, 49, 32, 8, -38 },
  { 838, 20, 20, 32, 6, -38 },
  { 888, 26, 28, 32, 3, -32 },
  { 979, 12, 17, 32, 7, -8 },
  { 1005, 15, 6, 32, 8, -17 },
  { 1017, 8, 8, 32, 12, -8 },
  { 1025, 27, 39, 32, 2, -38 },
  { 1157, 26, 37, 32, 3, -36 },
  { 1278, 26, 35, 32, 4, -35 },
  { 1392, 26, 36, 32, 3, -36 },
  { 1509, 27, 37, 32, 2, -36 },
  { 1634, 28, 35, 32, 2, -35 },
  { 1757, 26, 36, 32, 3, -35 },
  { 1874, 26, 37, 32, 3, -36 },
  { 1995, 25, 35, 32, 3, -35 },
  { 2105, 26, 37, 32, 3, -36 },
  { 2226, 26, 37, 32, 3, -36 },
  { 2347, 8, 28, 32, 12, -28 },
  { 2375, 13, 37, 32, 8, -28 },
  { 2436, 26, 29, 32, 3, -32 },
  { 2531, 26, 20, 32, 3, -28 },
  { 2596, 26, 29, 32, 3, -32 },
  { 2691, 27, 36, 32, 2, -36 },
  { 2813, 30, 46, 32, 1, -38 },
  { 2986, 32, 35, 32, 0, -35 },
  { 3126, 27, 35, 32, 4, -35 },
  { 3245, 28, 37, 32, 2, -36 },
  { 3375, 27, 35, 32, 3, -35 },
  { 3494, 26, 35, 32, 4, -35 },
  { 3608, 25, 35, 32, 4, -35 },
  { 3718, 27, 37, 32, 2, -36 },
  { 3843, 24, 35, 32, 4, -35 },
  { 3948, 24, 35, 32, 4, -35 },
  { 4053, 23, 36, 32, 3, -35 },
  { 4157, 28, 35, 32, 4, -35 },
  { 4280, 24, 35, 32, 5, -35 },
  { 4385, 26, 35, 32, 3, -35 },
  { 4499, 25, 35, 32, 3, -35 },
  { 4609, 28, 37, 32, 2, -36 },
  { 4739, 26, 35, 32, 4, -35 },
  { 4853, 28, 46, 32, 2, -36 },
  { 5014, 28, 35, 32, 4, -35 },
  { 5137, 29, 37, 32, 1, -36 },
  { 5272, 28, 35, 32, 2, -35 },
  { 5395, 25, 36, 32, 3, -35 },
  { 5508, 32, 35, 32, 0, -35 },
  { 5648, 32, 35, 32, 0, -35 },
  { 5788, 32, 35, 32, 0, -35 },
  { 5928, 32, 35, 32, 0, -35 },
  { 6068, 27, 35, 32, 2, -35 },
  { 6187, 15, 49, 32, 10, -38 },
  { 6279, 28, 39, 32, 2, -38 },
  { 6416, 15, 49, 32, 7, -38 },
  { 6508, 29, 23, 32, 1, -36 },
  { 6592, 32, 2, 32, 0, 3 },
  { 6600, 13, 7, 32, 9, -38 },
  { 6612, 27, 30, 32, 3, -29 },
  { 6714, 25, 39, 32, 4, -38 },
  { 6836, 26, 30, 32, 3, -29 },
  { 6934, 25, 39, 32, 3, -38 },
  { 7056, 26, 30, 32, 3, -29 },
  { 7154, 26, 39, 32, 3, -39 },
  { 7281, 26, 40, 32, 3, -29 },
  { 7411, 25, 38, 32, 4, -38 },
  { 7530, 27, 38, 32, 3, -38 },
  { 7659, 19, 49, 32, 3, -38 },
  { 7776, 26, 38, 32, 4, -38 },
  { 7900, 27, 38, 32, 3, -38 },
  { 8029, 28, 29, 32, 2, -29 },
  { 8131, 26, 29, 32, 3, -29 },
  { 8226, 27, 30, 32, 2, -29 },
  { 8328, 25, 40, 32, 4, -29 },
  { 8453, 25, 40, 32, 3, -29 },
  { 8578, 23, 29, 32, 5, -29 },
  { 8662, 26, 30, 32, 3, -29 },
  { 8760, 23, 36, 32, 4, -35 },
  { 8864, 25, 29, 32, 3, -28 },
  { 8955, 30, 28, 32, 1, -28 },
  { 9060, 32, 28, 32, 0, -28 },
  { 9172, 30, 28, 32, 1, -28 },
  { 9277, 30, 39, 32, 1, -28 },
  { 9424, 24, 28, 32, 4, -28 },
  { 9508, 22, 49, 32, 5, -38 },
  { 9643, 7, 50, 32, 12, -38 },
  { 9687, 22, 49, 32, 5, -38 },
  { 9822, 27, 8, 32, 2, -22 },
};

const GFXfont LiberationMono_Bold53pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold53pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold53pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _LIBERATIONMONO_BOLD53PT7B_H_
