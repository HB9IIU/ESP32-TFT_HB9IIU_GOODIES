#ifndef _LIBERATIONMONO_BOLD36PT7B_H_
#define _LIBERATIONMONO_BOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xDE, 0x1E, 0xF0, 0xF7, 0x87,
  0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0x01, 0x81,
  0xC0, 0x38, 0x18, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x30,
  0x30, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x60, 0x70, 0x06,
  0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0x81, 0x80,
  0x38, 0x18, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF,
  0x9F, 0x9B, 0xF3, 0xE3, 0x3E, 0x7C, 0x63, 0x8F, 0x8C, 0x01, 0xF9, 0x80,
  0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x67, 0xE0, 0x0C, 0x7C, 0xE1, 0x87, 0xFC, 0x30, 0xF7, 0xC6, 0x3E,
  0xFC, 0xCF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0x80,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x71, 0xFE, 0x03,
  0xC7, 0x38, 0x0E, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x0E,
  0x1C, 0x70, 0x38, 0x73, 0x80, 0xE1, 0xCE, 0x01, 0xCE, 0x70, 0x07, 0xFB,
  0x80, 0x07, 0x8E, 0x00, 0x00, 0x73, 0xE0, 0x03, 0x9F, 0xC0, 0x0E, 0xE3,
  0x80, 0x73, 0x8E, 0x03, 0x8E, 0x3C, 0x0E, 0x38, 0x70, 0x70, 0xE1, 0xC3,
  0x83, 0x8F, 0x1E, 0x0E, 0x38, 0x70, 0x38, 0xE3, 0x80, 0x7F, 0x1E, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x1F, 0x00,
  0x70, 0x78, 0x07, 0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xE3, 0xFE, 0x0E, 0x1F,
  0xF8, 0xF1, 0xF3, 0xC7, 0x8F, 0x0F, 0x3C, 0xF8, 0x7F, 0xC7, 0xC1, 0xFE,
  0x1E, 0x07, 0xE0, 0xF0, 0x1F, 0x07, 0xC3, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F,
  0xF7, 0xE0, 0xFC, 0x07, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0x7C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x11, 0xE6, 0x7F, 0x7B,
  0xFF, 0xEF, 0xFF, 0xC3, 0xF0, 0x1F, 0xC0, 0xF7, 0x87, 0xCF, 0x0E, 0x3C,
  0x18, 0x40, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x9E, 0x7B, 0xE7, 0x9F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7C,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF,
  0x03, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x1F, 0xBE, 0x03, 0xEF, 0x80,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7E, 0x7F, 0xFF, 0x9F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07,
  0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07,
  0x80, 0xF0, 0x78, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7D, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xF0, 0x7E,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3E, 0x1F, 0x9F, 0x03, 0xC7, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0xF8, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFE, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x1F, 0x78, 0x07, 0xDF,
  0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0xBF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7E, 0x1F, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0x1F,
  0x87, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF7, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xEF,
  0xC3, 0xF7, 0xFF, 0xF9, 0xFF, 0xBC, 0x7F, 0xDE, 0x1F, 0x9F, 0x00, 0x0F,
  0x80, 0x07, 0xDE, 0x07, 0xCF, 0x87, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78,
  0x78, 0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x01, 0xFC,
  0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xF0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xFF,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0x07, 0x80,
  0xE0, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x0F, 0x36,
  0x61, 0xFB, 0x66, 0x38, 0xF7, 0xE7, 0x0F, 0x7E, 0x70, 0xE3, 0xE6, 0x0E,
  0x3C, 0xE0, 0xE3, 0xCE, 0x0E, 0x3C, 0xE0, 0xE7, 0xCE, 0x0C, 0x7C, 0xE1,
  0xC7, 0xCE, 0x1C, 0x6C, 0xE1, 0xC6, 0xCE, 0x3C, 0xEE, 0x62, 0xCC, 0xE7,
  0xEF, 0x86, 0x3C, 0x70, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x81,
  0xC0, 0x38, 0x1E, 0x0F, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0x7C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x80, 0x1E,
  0x3E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x0F,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0xBE, 0x00, 0x3E, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xC1, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xE0, 0x7C, 0xFC,
  0x0F, 0x9F, 0x83, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x30, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xC7, 0xE0, 0x3E, 0x3E, 0x07,
  0xE3, 0xF8, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x3F,
  0xBF, 0x07, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0,
  0xF8, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x38, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xDF, 0x1F,
  0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x83,
  0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xC0, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x78, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xCF, 0x80, 0xFD, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFE, 0xFC, 0x0F, 0xE7, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xEE, 0x1F,
  0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFC, 0xEF, 0xFF, 0x3B, 0xFD, 0xDE, 0xFF,
  0x77, 0xBF, 0xDF, 0xCF, 0xF7, 0xF3, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0xCF,
  0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xDE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFD, 0xE3, 0xFE, 0xF1, 0xFF, 0x7C, 0xFF, 0x9E, 0x7F, 0xCF,
  0x3F, 0xE3, 0xDF, 0xF1, 0xEF, 0xF8, 0xF7, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0xFC, 0x0F,
  0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0x1F, 0x87, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07,
  0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0x7C, 0xFC, 0x07,
  0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x1F, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xC7, 0xC0, 0xFC,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0x8F,
  0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0xFB,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xEF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0xC7, 0xE7, 0xFF,
  0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0xF9, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C,
  0x78, 0xF1, 0xF3, 0xE3, 0xC3, 0xCF, 0xCF, 0x0F, 0x3F, 0x3C, 0x3D, 0xFC,
  0xF0, 0xF7, 0xF7, 0xC3, 0xDD, 0xFE, 0x0F, 0x77, 0xF8, 0x1D, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x87, 0xC0, 0x7E,
  0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x7E, 0x01, 0xF8, 0xF8, 0x07,
  0xC3, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x3E, 0x00,
  0x7C, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0x7C, 0x07,
  0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0xBF, 0x00,
  0x3E, 0xFC, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x0F, 0x80, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x3C, 0xF0,
  0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xE3, 0x78, 0x7F, 0xEF, 0xEF, 0xF9,
  0xFC, 0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF1, 0xF0, 0x7D, 0xFE,
  0x1F, 0xFF, 0xC7, 0xF1, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xF7,
  0xC0, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x3F, 0x7C, 0x0F, 0x9F, 0x83, 0xE7, 0xF1, 0xF9, 0xEF, 0xFC, 0x79, 0xFE,
  0x3E, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x7C,
  0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0xF9, 0xF8, 0x7C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x1F, 0x1F, 0x3F, 0xEF, 0x9F, 0xFF, 0xDF, 0x8F, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xFD, 0xF8, 0xFE, 0x7F,
  0xDF, 0x3F, 0xEF, 0x87, 0xC7, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xE1, 0xF8, 0x7C, 0x7C, 0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x7D, 0xF8, 0x3E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x07, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xF8, 0xFE, 0x7C, 0x1F, 0x9F,
  0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xFC, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF9, 0xF8, 0x7E,
  0x3F, 0xF7, 0x87, 0xF9, 0xE0, 0xF8, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x9F,
  0x03, 0xE7, 0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0xF8, 0xF3, 0xFE, 0xF7, 0xFE, 0xF7, 0xFF, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x1F, 0xFF, 0xFB, 0xFF, 0xDF, 0xFC, 0x7F, 0x80, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x7E, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xE0, 0xF9,
  0xF0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xCF, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xC7, 0x9E, 0xFD, 0xFB, 0xFF,
  0xBF, 0xFC, 0xFC, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFC, 0x3C, 0x7F, 0x87,
  0x8F, 0xF0, 0xF1, 0xFE, 0x1E, 0x3F, 0xC3, 0xC7, 0xF8, 0x78, 0xFF, 0x0F,
  0x1F, 0xE1, 0xE3, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xFE, 0x1E,
  0x3F, 0xC3, 0xC7, 0x80, 0xF8, 0x7C, 0x7C, 0xFF, 0xBE, 0xFF, 0xDF, 0x7F,
  0xF7, 0xF1, 0xFB, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xBC,
  0x07, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x3E,
  0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xE0, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x7E, 0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7C, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0x00, 0xF8, 0xFC, 0x1E, 0x7F, 0x87, 0xBF, 0xF1, 0xFC,
  0x7E, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xFD, 0xF0, 0x1F, 0x7C, 0x07,
  0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F, 0xDF, 0x03, 0xE7,
  0xE0, 0xF9, 0xFC, 0x7E, 0x7F, 0xFF, 0x1F, 0x7F, 0x87, 0xCF, 0xC1, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF, 0xFB, 0xEF, 0xC7, 0xF7,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7E, 0xFC,
  0x7F, 0x7F, 0xFF, 0x9F, 0xF7, 0xC3, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x78,
  0x7F, 0x7C, 0xFF, 0x7D, 0xFF, 0x7F, 0xFF, 0x7F, 0xC0, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xCF, 0x83, 0xE7, 0x80, 0xFB,
  0xC0, 0x7D, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0xFB, 0xC0, 0x3F, 0xE0, 0x1E, 0xF8, 0x1F, 0x7F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xF0, 0x7E, 0xFE,
  0xFF, 0x7F, 0xEF, 0x9F, 0xF7, 0xC7, 0xE3, 0xE0, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0xFC, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x00,
  0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x3C, 0x39,
  0xE1, 0xE3, 0xCF, 0x1F, 0x1E, 0x38, 0xFC, 0xF1, 0xC7, 0xE7, 0x8F, 0x77,
  0x3C, 0x7B, 0xBD, 0xC3, 0xDC, 0xEE, 0x1F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x7C, 0x03,
  0xE7, 0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x9F, 0x00, 0xFB,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x7E, 0xF8, 0x03, 0xE0, 0xF8, 0x01,
  0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F,
  0x9F, 0x00, 0xF9, 0xE0, 0x07, 0x9E, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x7F, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xC0,
};

const GFXglyph LiberationMono_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 5, 24, 22, 8, -24 },
  { 16, 13, 11, 22, 4, -26 },
  { 34, 20, 24, 22, 1, -24 },
  { 94, 19, 29, 22, 1, -26 },
  { 163, 22, 24, 22, 0, -24 },
  { 229, 21, 24, 22, 0, -24 },
  { 292, 5, 11, 22, 8, -26 },
  { 299, 10, 33, 22, 6, -26 },
  { 341, 11, 33, 22, 5, -26 },
  { 387, 14, 13, 22, 4, -26 },
  { 410, 18, 18, 22, 2, -21 },
  { 451, 8, 12, 22, 5, -5 },
  { 463, 10, 4, 22, 6, -11 },
  { 468, 5, 5, 22, 8, -5 },
  { 472, 18, 26, 22, 2, -26 },
  { 531, 18, 24, 22, 2, -24 },
  { 585, 18, 24, 22, 2, -24 },
  { 639, 18, 24, 22, 2, -24 },
  { 693, 18, 24, 22, 2, -24 },
  { 747, 20, 24, 22, 1, -24 },
  { 807, 18, 24, 22, 2, -24 },
  { 861, 18, 24, 22, 2, -24 },
  { 915, 17, 24, 22, 2, -24 },
  { 966, 18, 24, 22, 2, -24 },
  { 1020, 17, 24, 22, 2, -24 },
  { 1071, 5, 19, 22, 8, -19 },
  { 1083, 8, 26, 22, 6, -19 },
  { 1109, 18, 20, 22, 2, -22 },
  { 1154, 18, 14, 22, 2, -19 },
  { 1186, 18, 20, 22, 2, -22 },
  { 1231, 19, 24, 22, 1, -24 },
  { 1288, 20, 31, 22, 1, -26 },
  { 1366, 22, 24, 22, 0, -24 },
  { 1432, 19, 24, 22, 2, -24 },
  { 1489, 20, 24, 22, 1, -24 },
  { 1549, 18, 24, 22, 2, -24 },
  { 1603, 18, 24, 22, 2, -24 },
  { 1657, 16, 24, 22, 3, -24 },
  { 1705, 19, 24, 22, 1, -24 },
  { 1762, 17, 24, 22, 2, -24 },
  { 1813, 16, 24, 22, 3, -24 },
  { 1861, 16, 24, 22, 2, -24 },
  { 1909, 20, 24, 22, 2, -24 },
  { 1969, 16, 24, 22, 4, -24 },
  { 2017, 18, 24, 22, 2, -24 },
  { 2071, 17, 24, 22, 2, -24 },
  { 2122, 19, 24, 22, 1, -24 },
  { 2179, 18, 24, 22, 2, -24 },
  { 2233, 20, 31, 22, 1, -24 },
  { 2311, 20, 24, 22, 2, -24 },
  { 2371, 19, 24, 22, 1, -24 },
  { 2428, 20, 24, 22, 1, -24 },
  { 2488, 17, 24, 22, 2, -24 },
  { 2539, 22, 24, 22, 0, -24 },
  { 2605, 22, 24, 22, 0, -24 },
  { 2671, 22, 24, 22, 0, -24 },
  { 2737, 22, 24, 22, 0, -24 },
  { 2803, 18, 24, 22, 2, -24 },
  { 2857, 10, 33, 22, 7, -26 },
  { 2899, 18, 26, 22, 2, -26 },
  { 2958, 11, 33, 22, 4, -26 },
  { 3004, 19, 16, 22, 1, -24 },
  { 3042, 22, 2, 22, 0, 2 },
  { 3048, 9, 5, 22, 6, -26 },
  { 3054, 19, 19, 22, 2, -19 },
  { 3100, 18, 26, 22, 2, -26 },
  { 3159, 18, 19, 22, 2, -19 },
  { 3202, 17, 26, 22, 2, -26 },
  { 3258, 18, 19, 22, 2, -19 },
  { 3301, 18, 26, 22, 2, -26 },
  { 3360, 18, 26, 22, 2, -19 },
  { 3419, 16, 26, 22, 3, -26 },
  { 3471, 18, 26, 22, 2, -26 },
  { 3530, 13, 33, 22, 2, -26 },
  { 3584, 18, 26, 22, 3, -26 },
  { 3643, 18, 26, 22, 2, -26 },
  { 3702, 19, 19, 22, 1, -19 },
  { 3748, 17, 19, 22, 2, -19 },
  { 3789, 18, 19, 22, 2, -19 },
  { 3832, 18, 26, 22, 2, -19 },
  { 3891, 17, 26, 22, 2, -19 },
  { 3947, 16, 19, 22, 3, -19 },
  { 3985, 17, 19, 22, 2, -19 },
  { 4026, 15, 24, 22, 3, -24 },
  { 4071, 17, 19, 22, 2, -19 },
  { 4112, 20, 19, 22, 1, -19 },
  { 4160, 21, 19, 22, 0, -19 },
  { 4210, 20, 19, 22, 1, -19 },
  { 4258, 20, 26, 22, 1, -19 },
  { 4323, 17, 19, 22, 2, -19 },
  { 4364, 15, 33, 22, 3, -26 },
  { 4426, 5, 34, 22, 8, -26 },
  { 4448, 15, 33, 22, 3, -26 },
  { 4510, 18, 6, 22, 2, -15 },
};

const GFXfont LiberationMono_Bold36pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold36pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold36pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _LIBERATIONMONO_BOLD36PT7B_H_
