#ifndef _LIBERATIONMONO_BOLD39PT7B_H_
#define _LIBERATIONMONO_BOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xE0, 0xF8, 0xFF, 0xE1,
  0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0x7B, 0xE1, 0xEF, 0x87, 0xBE, 0x1E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x38, 0x03, 0x81, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x38, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xE6, 0xFC,
  0x7E, 0x33, 0xF3, 0xE1, 0x8F, 0x9F, 0x0C, 0x78, 0xFC, 0x60, 0x03, 0xF3,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x0C, 0xFC, 0x00, 0x63, 0xF1, 0x83, 0x0F, 0xFC, 0x18,
  0x7D, 0xF0, 0xC3, 0xEF, 0xC6, 0x3F, 0x7F, 0x33, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x1F, 0x00, 0x1C, 0xFF, 0x00, 0x71, 0xFF, 0x01, 0xE7,
  0x8F, 0x03, 0x8F, 0x1E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0xF0, 0x70,
  0x71, 0xC0, 0xF1, 0xE7, 0x01, 0xE3, 0xDE, 0x01, 0xFF, 0x38, 0x03, 0xFC,
  0xE0, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x3F, 0x00, 0x1C, 0xFF, 0x00, 0x7B,
  0xFF, 0x00, 0xE7, 0x9E, 0x03, 0x8E, 0x1C, 0x0F, 0x1C, 0x38, 0x1C, 0x78,
  0x70, 0x70, 0x70, 0xE1, 0xE0, 0xE1, 0xC3, 0x81, 0xE7, 0x8E, 0x03, 0xFF,
  0x3C, 0x03, 0xFC, 0xF0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0x83, 0xFE, 0x0F, 0x0F, 0xFC,
  0x1E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF0, 0xF0, 0x7D, 0xE3, 0xE0, 0x7F,
  0x87, 0xC0, 0xFF, 0x07, 0x80, 0xFC, 0x0F, 0x81, 0xFC, 0x1F, 0x87, 0xFE,
  0x9F, 0xFF, 0xFF, 0x1F, 0xFE, 0x7E, 0x0F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0x7B, 0xDE, 0xF0, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x03, 0x1E, 0x27, 0xB9, 0xCF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFB, 0xE1, 0xE3, 0xE3, 0xC3, 0x81, 0x04, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x1C,
  0x1E, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC,
  0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x79, 0xFF, 0xCF, 0x3F, 0xF9, 0xE7, 0xFF, 0x3C, 0xFF,
  0xE7, 0x9F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xE7,
  0xE0, 0x7C, 0x7E, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFB, 0xF0, 0x3E, 0x7E, 0x07, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE7, 0xF0, 0xFC, 0xFC, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0xFC, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0xDF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7B, 0xE0,
  0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1,
  0xF0, 0x1E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x9F, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFE, 0x1F, 0xDF, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0x9F, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7C, 0x0F, 0x9F, 0x81, 0xE3,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x8F, 0x83, 0xF7, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x0F, 0xBF, 0x01, 0xF3, 0xE0, 0x7E, 0x7E, 0x1F, 0x87,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE0, 0xFC, 0xF8,
  0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x07, 0xC7, 0xE1, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0x83, 0xF3, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x7E, 0xFC, 0x1F, 0xDF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1,
  0xFC, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFE,
  0xF8, 0xFF, 0xDF, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x1E, 0x03,
  0xE7, 0xC0, 0xFC, 0xFC, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F,
  0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x1E,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFE, 0x00, 0x78, 0x3C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x60, 0x70, 0x01,
  0xC3, 0x80, 0x03, 0x0C, 0x1E, 0x7E, 0x70, 0xFD, 0xB9, 0xC7, 0x16, 0x66,
  0x38, 0x79, 0xB8, 0xE1, 0xE7, 0xE7, 0x07, 0x9F, 0x9C, 0x1E, 0x7E, 0x70,
  0x71, 0xF9, 0x81, 0xC7, 0xCE, 0x07, 0x1F, 0x38, 0x1C, 0x6C, 0xE0, 0x71,
  0xB3, 0x83, 0x86, 0xEE, 0x0E, 0x3B, 0x98, 0x38, 0xEE, 0x71, 0xE3, 0x39,
  0xCD, 0x9C, 0x63, 0xF7, 0xE1, 0xC7, 0x0F, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x40, 0x70, 0x03, 0x80, 0xF0, 0x3C, 0x01, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xF8, 0x1F, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF,
  0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03,
  0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xEF, 0x80,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7,
  0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0x8F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1C, 0xFC, 0x01, 0xF7, 0xE0,
  0x3F, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0x87, 0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x7E, 0xF8,
  0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0,
  0x3F, 0x7C, 0x07, 0xEF, 0x81, 0xF9, 0xF0, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF0, 0xFC, 0xFC, 0x0F, 0xBF, 0x01, 0xFF,
  0xE0, 0x18, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xE0, 0x3E, 0x7E, 0x0F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x9E, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xE1,
  0xFB, 0xF1, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00,
  0xF8, 0x07, 0xFF, 0x80, 0xFE, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x3F,
  0x8F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0x9F,
  0x80, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xEF, 0xC0, 0xFE, 0xFE, 0x0F, 0xC7, 0xE0, 0xF8, 0x7F, 0x0F,
  0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFE,
  0xF8, 0x07, 0xEF, 0x80, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0x79, 0xFF, 0xF7, 0x9F, 0xFF,
  0x79, 0xDF, 0xF7, 0xBD, 0xFF, 0x3B, 0xDF, 0xF3, 0xFD, 0xFF, 0x3F, 0x9F,
  0xF3, 0xF9, 0xFF, 0x1F, 0x9F, 0xF1, 0xF1, 0xFF, 0x1F, 0x1F, 0xF0, 0xF1,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0xF7, 0x87, 0xFD, 0xF1, 0xFF, 0x7C, 0x7F, 0xCF, 0x1F, 0xF3, 0xE7, 0xFC,
  0x79, 0xFF, 0x1E, 0x7F, 0xC7, 0xDF, 0xF0, 0xF7, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7E, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7C,
  0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0xC3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0x81, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF8, 0x7E, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3E, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7C, 0x01,
  0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0xC3, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xCF, 0x80,
  0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8,
  0x07, 0xEF, 0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0,
  0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x07,
  0xEF, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xF0, 0x7F, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xDE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x81,
  0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xE0, 0xFC, 0xFE,
  0x3F, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xE3, 0xE0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01,
  0xF8, 0x3F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xFC, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0x3E, 0x1E,
  0x1E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xF8, 0xF1, 0xF9, 0xF1, 0xE3, 0xF3,
  0xE3, 0xEF, 0xE7, 0x87, 0xDF, 0xCF, 0x0F, 0xBB, 0xDE, 0x1F, 0x77, 0xBC,
  0x1F, 0xEF, 0x78, 0x3F, 0xCE, 0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F,
  0x83, 0xF0, 0x1F, 0x03, 0xC0, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x01, 0xF9,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0x9F, 0x80,
  0x7E, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F,
  0x00, 0x7E, 0x7E, 0x00, 0x7D, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xF0,
  0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0,
  0x07, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xF1, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0,
  0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC,
  0x3F, 0xCF, 0xFF, 0x7F, 0x7F, 0xF7, 0xF3, 0xFE, 0x3F, 0x1F, 0x81, 0xF0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0xF9, 0xFF, 0x1F, 0x7F, 0xE3,
  0xFF, 0xFE, 0x7F, 0x0F, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF,
  0x80, 0x7D, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xF0, 0xFC, 0xFF, 0xFF, 0x9F,
  0x7F, 0xE3, 0xE7, 0xF8, 0x7C, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xF0, 0xFC, 0xFC, 0x0F, 0xDF, 0x01, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xC7,
  0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x3E, 0x3F, 0x1F, 0xF7, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0x8F, 0xF7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0xFF, 0x7F, 0xFF, 0xE7, 0xFE, 0xFC, 0x7F,
  0xDF, 0x83, 0xE3, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xF0, 0xFC, 0x7E, 0x07, 0xC7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x7F, 0x07, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE3, 0xE3, 0xFE, 0x7C, 0x7F, 0xEF, 0x9F,
  0xFF, 0xF7, 0xF0, 0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8,
  0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF,
  0xEF, 0x8F, 0xF9, 0xF0, 0x7C, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF9, 0xF0,
  0x3F, 0x7E, 0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F,
  0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0xF9, 0xFF, 0x3E, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xFF, 0xFB,
  0xFF, 0xCF, 0xFE, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x3E,
  0xFC, 0x0F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1,
  0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0x3E, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC7,
  0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE1,
  0xE7, 0x9F, 0x3F, 0xBD, 0xFD, 0xFD, 0xF9, 0xF9, 0xFF, 0x8F, 0x8F, 0xFC,
  0x7C, 0x3F, 0xE3, 0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3,
  0xFE, 0x1E, 0x1F, 0xF0, 0xF0, 0xFF, 0x87, 0x87, 0xFC, 0x3C, 0x3F, 0xE1,
  0xE1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xFE, 0x1E, 0x1F,
  0xF0, 0xF0, 0xFF, 0x87, 0x87, 0x80, 0xF8, 0x7C, 0x3E, 0x7F, 0xCF, 0xBF,
  0xFB, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF,
  0xC0, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0x7F, 0x0F,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xF8,
  0x7C, 0x1F, 0x3F, 0xC3, 0xEF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE1, 0xFD, 0xF8,
  0x1F, 0xBF, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBF, 0x03, 0xF7, 0xE0,
  0x7E, 0xFE, 0x1F, 0xDF, 0xFF, 0xF3, 0xEF, 0xFC, 0x7C, 0xFF, 0x0F, 0x8F,
  0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0xE3, 0xFE,
  0xFC, 0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xF1, 0xFE, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x7F, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFB, 0xF0, 0xFC, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7,
  0xE0, 0x7C, 0xF8, 0x07, 0xDF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x07, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x7E,
  0xFC, 0x3F, 0xBF, 0xFF, 0xE7, 0xFE, 0xFD, 0xFF, 0x3F, 0x3F, 0x8F, 0xC0,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7E,
  0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x07,
  0xE0, 0x7C, 0x1F, 0x01, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x03,
  0xCF, 0x07, 0x87, 0x9E, 0x1F, 0x0F, 0x3E, 0x3E, 0x1E, 0x3C, 0x7E, 0x3C,
  0x79, 0xFC, 0xF8, 0xF3, 0xF9, 0xE1, 0xE7, 0x7B, 0xC3, 0xCE, 0xF7, 0x87,
  0xBC, 0xEF, 0x07, 0x71, 0xDE, 0x0E, 0xE3, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x7C,
  0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0xFC,
  0x07, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0x7E, 0x01, 0xF1, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x3F, 0x0F, 0x80,
  0xFC, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFB, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x3D, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0xFF,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFC,
};

const GFXglyph LiberationMono_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 26, 23, 9, -26 },
  { 21, 14, 12, 23, 5, -28 },
  { 42, 21, 26, 23, 1, -26 },
  { 111, 21, 32, 23, 1, -29 },
  { 195, 23, 26, 23, 0, -26 },
  { 270, 23, 26, 23, 0, -26 },
  { 345, 5, 12, 23, 9, -28 },
  { 353, 11, 36, 23, 7, -28 },
  { 403, 11, 36, 23, 6, -28 },
  { 453, 15, 14, 23, 4, -28 },
  { 480, 19, 20, 23, 2, -23 },
  { 528, 9, 13, 23, 5, -6 },
  { 543, 11, 5, 23, 6, -12 },
  { 550, 5, 6, 23, 9, -6 },
  { 554, 20, 28, 23, 2, -28 },
  { 624, 19, 26, 23, 2, -26 },
  { 686, 19, 26, 23, 3, -26 },
  { 748, 19, 26, 23, 2, -26 },
  { 810, 19, 26, 23, 2, -26 },
  { 872, 21, 26, 23, 1, -26 },
  { 941, 19, 26, 23, 2, -26 },
  { 1003, 19, 26, 23, 2, -26 },
  { 1065, 19, 26, 23, 2, -26 },
  { 1127, 19, 26, 23, 2, -26 },
  { 1189, 19, 26, 23, 2, -26 },
  { 1251, 5, 21, 23, 9, -21 },
  { 1265, 9, 28, 23, 6, -21 },
  { 1297, 19, 21, 23, 2, -23 },
  { 1347, 19, 14, 23, 2, -20 },
  { 1381, 19, 21, 23, 2, -23 },
  { 1431, 20, 26, 23, 1, -26 },
  { 1496, 22, 33, 23, 1, -28 },
  { 1587, 23, 26, 23, 0, -26 },
  { 1662, 20, 26, 23, 3, -26 },
  { 1727, 20, 26, 23, 2, -26 },
  { 1792, 19, 26, 23, 3, -26 },
  { 1854, 19, 26, 23, 3, -26 },
  { 1916, 18, 26, 23, 3, -26 },
  { 1975, 19, 26, 23, 2, -26 },
  { 2037, 18, 26, 23, 3, -26 },
  { 2096, 17, 26, 23, 3, -26 },
  { 2152, 17, 26, 23, 2, -26 },
  { 2208, 20, 26, 23, 3, -26 },
  { 2273, 17, 26, 23, 4, -26 },
  { 2329, 20, 26, 23, 2, -26 },
  { 2394, 18, 26, 23, 3, -26 },
  { 2453, 21, 26, 23, 1, -26 },
  { 2522, 19, 26, 23, 3, -26 },
  { 2584, 21, 34, 23, 1, -26 },
  { 2674, 20, 26, 23, 3, -26 },
  { 2739, 21, 26, 23, 1, -26 },
  { 2808, 21, 26, 23, 1, -26 },
  { 2877, 19, 26, 23, 2, -26 },
  { 2939, 23, 26, 23, 0, -26 },
  { 3014, 23, 26, 23, 0, -26 },
  { 3089, 23, 26, 23, 0, -26 },
  { 3164, 23, 26, 23, 0, -26 },
  { 3239, 20, 26, 23, 2, -26 },
  { 3304, 12, 36, 23, 7, -28 },
  { 3358, 20, 28, 23, 2, -28 },
  { 3428, 11, 36, 23, 5, -28 },
  { 3478, 21, 17, 23, 1, -26 },
  { 3523, 23, 2, 23, 0, 2 },
  { 3529, 9, 5, 23, 7, -28 },
  { 3535, 20, 21, 23, 2, -21 },
  { 3588, 19, 28, 23, 3, -28 },
  { 3655, 19, 21, 23, 2, -21 },
  { 3705, 19, 28, 23, 2, -28 },
  { 3772, 20, 21, 23, 2, -21 },
  { 3825, 19, 28, 23, 2, -28 },
  { 3892, 19, 29, 23, 2, -21 },
  { 3961, 18, 28, 23, 3, -28 },
  { 4024, 20, 28, 23, 2, -28 },
  { 4094, 14, 36, 23, 2, -28 },
  { 4157, 19, 28, 23, 3, -28 },
  { 4224, 20, 28, 23, 2, -28 },
  { 4294, 21, 21, 23, 1, -21 },
  { 4350, 18, 21, 23, 3, -21 },
  { 4398, 20, 21, 23, 2, -21 },
  { 4451, 19, 29, 23, 3, -21 },
  { 4520, 19, 29, 23, 2, -21 },
  { 4589, 17, 21, 23, 4, -21 },
  { 4634, 19, 21, 23, 2, -21 },
  { 4684, 17, 26, 23, 3, -26 },
  { 4740, 18, 21, 23, 3, -21 },
  { 4788, 22, 21, 23, 1, -21 },
  { 4846, 23, 21, 23, 0, -21 },
  { 4907, 21, 21, 23, 1, -21 },
  { 4963, 22, 29, 23, 1, -21 },
  { 5043, 18, 21, 23, 3, -21 },
  { 5091, 16, 36, 23, 4, -28 },
  { 5163, 5, 37, 23, 9, -28 },
  { 5187, 17, 36, 23, 3, -28 },
  { 5264, 20, 6, 23, 2, -16 },
};

const GFXfont LiberationMono_Bold39pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold39pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold39pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _LIBERATIONMONO_BOLD39PT7B_H_
