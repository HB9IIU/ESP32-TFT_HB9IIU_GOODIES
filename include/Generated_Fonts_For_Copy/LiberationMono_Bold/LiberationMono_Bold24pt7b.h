#ifndef _LIBERATIONMONO_BOLD24PT7B_H_
#define _LIBERATIONMONO_BOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x0F, 0xFF, 0xE7, 0x73, 0xB9,
  0xDC, 0xEE, 0x37, 0x1B, 0x8C, 0x0C, 0x60, 0x63, 0x06, 0x19, 0xFF, 0xFF,
  0xFF, 0x8C, 0x60, 0x43, 0x06, 0x18, 0x30, 0x87, 0xFF, 0xBF, 0xFC, 0x43,
  0x06, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0x60, 0x02, 0x00, 0x10, 0x07, 0xF0,
  0xFF, 0xC7, 0x2F, 0x79, 0x3B, 0x88, 0x0E, 0x40, 0x3F, 0x00, 0xFE, 0x00,
  0xFC, 0x04, 0xEE, 0x27, 0x71, 0x3F, 0x89, 0xCE, 0x5E, 0x3F, 0xE0, 0xFE,
  0x00, 0x80, 0x04, 0x00, 0x78, 0x1B, 0xF0, 0x6C, 0xE3, 0x31, 0x98, 0xC6,
  0x63, 0x3B, 0x07, 0xD8, 0x1E, 0x60, 0x03, 0x78, 0x1B, 0xF0, 0xEC, 0xC3,
  0x33, 0x18, 0xCC, 0xC3, 0x33, 0x0F, 0xD8, 0x1E, 0x07, 0xC0, 0x3F, 0x81,
  0xCE, 0x06, 0x18, 0x1C, 0xE0, 0x7F, 0x00, 0xF8, 0x0F, 0x86, 0x7F, 0x39,
  0xDC, 0xEE, 0x3B, 0x38, 0x7C, 0xE0, 0xE1, 0xC7, 0xE7, 0xFF, 0xC7, 0xC7,
  0xFF, 0xFF, 0xB0, 0x1C, 0x38, 0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xE1, 0xC1, 0xC3, 0x80, 0xE1,
  0xC7, 0x0E, 0x38, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3C,
  0xE3, 0x9C, 0x73, 0x80, 0x18, 0x0C, 0x36, 0x5F, 0xFF, 0xF1, 0xE1, 0xF9,
  0xCE, 0x22, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF,
  0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x38, 0xE7, 0x9C,
  0x71, 0x8E, 0x30, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xFC,
  0x78, 0xE7, 0x0E, 0x70, 0xFF, 0x07, 0xF6, 0x7F, 0x67, 0xF6, 0x7F, 0x07,
  0x70, 0x77, 0x0F, 0x70, 0xE3, 0x8E, 0x3F, 0xC0, 0xF8, 0x0F, 0x03, 0xE0,
  0xFC, 0x7F, 0x8C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x3F, 0xFF, 0xFF, 0x1F, 0x83, 0xFE, 0x78, 0xE7,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x1F, 0x83, 0xFE, 0x70, 0xEF,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFC, 0x0F, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0xF0, 0x7F, 0x0F, 0x7F, 0xE1, 0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0xE7, 0x06, 0x38, 0x71, 0xC7, 0x0E, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x7F, 0xE7, 0xFE,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x78, 0x7F, 0xE7, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0xF0, 0xF7, 0x0E, 0x7F, 0xC1, 0xF8, 0x0F, 0x83, 0xFE,
  0x38, 0xE7, 0x8F, 0x70, 0x07, 0x00, 0x77, 0xCF, 0xFE, 0xF8, 0xF7, 0x07,
  0x70, 0x77, 0x07, 0x70, 0xF3, 0x8E, 0x1F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFC,
  0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x1F, 0x83, 0xFE, 0x78, 0xE7,
  0x0F, 0x70, 0xF7, 0x0F, 0x78, 0xE3, 0xFC, 0x3F, 0xC7, 0x0E, 0xF0, 0x7F,
  0x07, 0xF0, 0x77, 0x0F, 0x7F, 0xE1, 0xF8, 0x1F, 0x83, 0xFC, 0x79, 0xE7,
  0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x79, 0xF3, 0xFF, 0x1E, 0x70,
  0x0E, 0x70, 0xE7, 0x1E, 0x3F, 0xC1, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x38, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9E, 0x71, 0xC6, 0x38,
  0xE3, 0x00, 0x00, 0x10, 0x07, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x80, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0x00, 0x80, 0x00, 0x1F, 0x83, 0xFE, 0x78,
  0xFF, 0x07, 0xE0, 0x70, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x80, 0xFF, 0x0E,
  0x18, 0xC0, 0x66, 0x75, 0x67, 0xAF, 0x77, 0x73, 0x1B, 0x90, 0xDD, 0x84,
  0xEC, 0x67, 0x63, 0x3B, 0x19, 0x59, 0xDB, 0x7B, 0xD9, 0x9C, 0x60, 0x03,
  0x83, 0x0F, 0xF8, 0x3F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xB0,
  0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x1C, 0x38, 0x70, 0xFF, 0xC3, 0xFF,
  0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0x8F, 0xFC,
  0xE1, 0xEE, 0x1E, 0xE1, 0xEE, 0x1C, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xFF, 0xEF, 0xF8, 0x0F, 0x81, 0xFF,
  0x1E, 0x3C, 0xE0, 0xEF, 0x06, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0xF7, 0x07, 0x3C, 0x78, 0xFF, 0x81, 0xF0, 0xFE,
  0x1F, 0xF3, 0x8F, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0xC7, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF, 0xFF,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xF7, 0xFE, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x0F, 0x83, 0xFC, 0x78, 0xE7, 0x0F, 0xF0,
  0x6F, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xF0, 0x7F, 0x07, 0x70,
  0x77, 0x8F, 0x3F, 0xE0, 0xF8, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFC, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0xFF,
  0xFF, 0x0F, 0xE1, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xF8, 0xFF, 0x1E, 0xF3, 0x8F, 0xF0, 0xF8, 0xE0,
  0xFE, 0x1E, 0xE3, 0xCE, 0x38, 0xE7, 0x8E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0x70, 0xF7, 0x8E, 0x3C, 0xE3, 0xCE, 0x1E, 0xE1, 0xEE, 0x0F, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F,
  0xF8, 0xFF, 0x9F, 0xF9, 0xBF, 0xDB, 0xED, 0xBE, 0xFB, 0xEF, 0x3E, 0xF3,
  0xE7, 0x3E, 0x73, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0xFE, 0x1F,
  0xC3, 0xFC, 0x7F, 0x8F, 0xB9, 0xFF, 0x3F, 0x67, 0xEE, 0xFD, 0xDF, 0x9B,
  0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0x1F, 0x81, 0xFE, 0x1E, 0x38,
  0xE1, 0xEF, 0x07, 0x78, 0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xBC,
  0x1D, 0xE0, 0xE7, 0x0F, 0x3C, 0x70, 0xFF, 0x03, 0xF0, 0xFF, 0x1F, 0xFB,
  0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xFF, 0xDF, 0xE3, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x0F, 0x81, 0xFE, 0x1E, 0x38,
  0xE1, 0xEF, 0x07, 0x78, 0x3B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC,
  0x1D, 0xE0, 0xE7, 0x0F, 0x3C, 0x70, 0xFF, 0x83, 0xF0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E,
  0xE0, 0xFE, 0x0E, 0xE1, 0xEF, 0xFC, 0xFF, 0x0E, 0x78, 0xE3, 0x8E, 0x3C,
  0xE1, 0xEE, 0x1E, 0xE0, 0xFE, 0x0F, 0x0F, 0xC0, 0xFF, 0xC3, 0x87, 0x1E,
  0x1E, 0x78, 0x39, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xE0,
  0x03, 0xFC, 0x0F, 0x70, 0x39, 0xE1, 0xE3, 0xFF, 0x03, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xE3, 0x9F, 0xE1, 0xF8, 0xF0, 0x1D,
  0xC0, 0xF7, 0x03, 0xDE, 0x0E, 0x38, 0x78, 0xE1, 0xE3, 0xC7, 0x07, 0x1C,
  0x1C, 0xF0, 0x73, 0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x07, 0x73, 0x9D, 0xCE,
  0x77, 0x79, 0x9D, 0xEE, 0x77, 0xF9, 0xDB, 0xE3, 0xEF, 0x8F, 0x3E, 0x3C,
  0xF0, 0xF3, 0xC3, 0xC7, 0x0F, 0x1C, 0x70, 0x3D, 0xE1, 0xE3, 0xC7, 0x07,
  0x3C, 0x1E, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x01,
  0xFE, 0x07, 0x38, 0x3C, 0x70, 0xE1, 0xE7, 0x83, 0xBC, 0x0F, 0xF0, 0x3D,
  0xC0, 0xE3, 0x87, 0x8F, 0x1C, 0x1C, 0xF0, 0x7B, 0x80, 0xFC, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x7F, 0xF7, 0xFF, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xC0, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xC0, 0x0F, 0x01, 0xF8, 0x1F,
  0x83, 0x9C, 0x39, 0xC3, 0x0C, 0x70, 0xE6, 0x06, 0xE0, 0x7C, 0x03, 0xFF,
  0xFC, 0xF0, 0xE1, 0xC0, 0x1F, 0x81, 0xFE, 0x1E, 0x78, 0xE1, 0xC0, 0x0E,
  0x0F, 0xF1, 0xFF, 0x8E, 0x1C, 0xF0, 0xE7, 0x8F, 0x3C, 0x78, 0xFD, 0xF3,
  0xC7, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x79, 0xFF, 0xBC, 0x7F,
  0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE3, 0xFC, 0x77, 0x7E,
  0xE7, 0x80, 0x0F, 0x83, 0xFE, 0x78, 0xE7, 0x0F, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x77, 0x0F, 0x78, 0xE3, 0xFC, 0x0F, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF7, 0xFF, 0x79, 0xF7, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F, 0x79, 0xF3, 0xFF, 0x1E, 0x70,
  0x0F, 0x83, 0xFC, 0x78, 0xE7, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x07, 0x07, 0x78, 0xE3, 0xFE, 0x0F, 0x80, 0x07, 0xF0, 0xFF, 0x1E,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x73,
  0xF7, 0x78, 0xF7, 0x0F, 0x70, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0x77,
  0x0F, 0x78, 0xF3, 0xF7, 0x1E, 0x70, 0x07, 0x70, 0xF7, 0x8E, 0x3F, 0xE0,
  0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x79, 0xFF, 0xBC, 0x7F, 0x0F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xE0, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xFF, 0xF7, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE,
  0x1C, 0xE3, 0x8E, 0x70, 0xEE, 0x0F, 0xE0, 0xFF, 0x0F, 0x70, 0xE3, 0x8E,
  0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0xDC, 0xE6, 0xF7, 0xB9,
  0xCD, 0xCE, 0x6E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39,
  0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0x80, 0xE7, 0x9F, 0xFB, 0xC7, 0xF0, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E,
  0x1F, 0x83, 0xFE, 0x78, 0xE7, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x77, 0x0F, 0x78, 0xE3, 0xFE, 0x1F, 0x80, 0xE7, 0x9F, 0xFB, 0xC7,
  0x78, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xC7, 0xFF,
  0xEE, 0xF9, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x73, 0xFF,
  0x79, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x79, 0xF7, 0xFF, 0x1E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xF3, 0xEE, 0xFD, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0x83, 0xFE, 0x70, 0xE7, 0x07,
  0x78, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0x70, 0xF7, 0xFE,
  0x1F, 0x80, 0x18, 0x06, 0x03, 0x83, 0xFF, 0xFF, 0xCE, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xFC, 0x3F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0xCF, 0xFF, 0xF7, 0xCE, 0x70, 0x3D, 0xC0, 0xE7, 0x83, 0x8E, 0x1E, 0x38,
  0x70, 0xF1, 0xC1, 0xCF, 0x07, 0x38, 0x1E, 0xE0, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0x80, 0xE0, 0x0F, 0x80, 0x76, 0x01, 0xD8, 0xC7, 0x63, 0x9D,
  0xDE, 0x67, 0x79, 0x9D, 0xB6, 0x3E, 0xF8, 0xF3, 0xE3, 0xCF, 0x0F, 0x1C,
  0x38, 0x70, 0xF0, 0x73, 0x87, 0x0E, 0x78, 0x73, 0x81, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xF0, 0x1D, 0xC1, 0xCE, 0x1E, 0x38, 0xE1, 0xEE, 0x07, 0x00,
  0x70, 0x3D, 0xC0, 0xE7, 0x83, 0x8E, 0x1E, 0x3C, 0x70, 0x71, 0xC1, 0xCE,
  0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x0F,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xC7, 0xF1, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x78, 0x1F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x3F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x3C, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xFE, 0x3F, 0x00, 0x78, 0x0F, 0xE1, 0xC7, 0x18,
  0x3F, 0x01, 0xE0,
};

const GFXglyph LiberationMono_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 9, 7, 14, 3, -17 },
  { 17, 13, 16, 14, 1, -16 },
  { 43, 13, 20, 14, 1, -18 },
  { 76, 14, 16, 14, 0, -16 },
  { 104, 14, 16, 14, 0, -16 },
  { 132, 3, 7, 14, 6, -17 },
  { 135, 7, 22, 14, 4, -17 },
  { 155, 6, 22, 14, 4, -17 },
  { 172, 9, 9, 14, 3, -17 },
  { 183, 12, 12, 14, 1, -14 },
  { 201, 6, 8, 14, 3, -3 },
  { 207, 7, 2, 14, 4, -8 },
  { 209, 3, 3, 14, 6, -3 },
  { 211, 12, 17, 14, 1, -17 },
  { 237, 12, 16, 14, 1, -16 },
  { 261, 11, 16, 14, 2, -16 },
  { 283, 12, 16, 14, 1, -16 },
  { 307, 12, 16, 14, 1, -16 },
  { 331, 13, 16, 14, 1, -16 },
  { 357, 12, 16, 14, 1, -16 },
  { 381, 12, 16, 14, 1, -16 },
  { 405, 11, 16, 14, 2, -16 },
  { 427, 12, 16, 14, 1, -16 },
  { 451, 12, 16, 14, 1, -16 },
  { 475, 3, 13, 14, 6, -13 },
  { 480, 6, 18, 14, 4, -13 },
  { 494, 12, 13, 14, 1, -14 },
  { 514, 12, 9, 14, 1, -12 },
  { 528, 12, 13, 14, 1, -14 },
  { 548, 12, 16, 14, 1, -16 },
  { 572, 13, 20, 14, 1, -17 },
  { 605, 14, 16, 14, 0, -16 },
  { 633, 12, 16, 14, 2, -16 },
  { 657, 13, 16, 14, 1, -16 },
  { 683, 11, 16, 14, 2, -16 },
  { 705, 11, 16, 14, 2, -16 },
  { 727, 11, 16, 14, 2, -16 },
  { 749, 12, 16, 14, 1, -16 },
  { 773, 11, 16, 14, 2, -16 },
  { 795, 11, 16, 14, 2, -16 },
  { 817, 11, 16, 14, 1, -16 },
  { 839, 12, 16, 14, 2, -16 },
  { 863, 11, 16, 14, 2, -16 },
  { 885, 12, 16, 14, 1, -16 },
  { 909, 11, 16, 14, 2, -16 },
  { 931, 13, 16, 14, 1, -16 },
  { 957, 11, 16, 14, 2, -16 },
  { 979, 13, 21, 14, 1, -16 },
  { 1014, 12, 16, 14, 2, -16 },
  { 1038, 14, 16, 14, 0, -16 },
  { 1066, 13, 16, 14, 1, -16 },
  { 1092, 11, 16, 14, 2, -16 },
  { 1114, 14, 16, 14, 0, -16 },
  { 1142, 14, 16, 14, 0, -16 },
  { 1170, 14, 16, 14, 0, -16 },
  { 1198, 14, 16, 14, 0, -16 },
  { 1226, 12, 16, 14, 1, -16 },
  { 1250, 7, 22, 14, 4, -17 },
  { 1270, 12, 17, 14, 1, -17 },
  { 1296, 7, 22, 14, 3, -17 },
  { 1316, 12, 10, 14, 1, -16 },
  { 1331, 14, 1, 14, 0, 1 },
  { 1333, 6, 3, 14, 4, -17 },
  { 1336, 13, 13, 14, 1, -13 },
  { 1358, 11, 17, 14, 2, -17 },
  { 1382, 12, 13, 14, 1, -13 },
  { 1402, 12, 17, 14, 1, -17 },
  { 1428, 12, 13, 14, 1, -13 },
  { 1448, 12, 17, 14, 1, -17 },
  { 1474, 12, 18, 14, 1, -13 },
  { 1501, 11, 17, 14, 2, -17 },
  { 1525, 12, 17, 14, 1, -17 },
  { 1551, 9, 22, 14, 1, -17 },
  { 1576, 12, 17, 14, 2, -17 },
  { 1602, 12, 17, 14, 1, -17 },
  { 1628, 13, 13, 14, 1, -13 },
  { 1650, 11, 13, 14, 2, -13 },
  { 1668, 12, 13, 14, 1, -13 },
  { 1688, 11, 18, 14, 2, -13 },
  { 1713, 12, 18, 14, 1, -13 },
  { 1740, 11, 13, 14, 2, -13 },
  { 1758, 12, 13, 14, 1, -13 },
  { 1778, 10, 16, 14, 2, -16 },
  { 1798, 11, 13, 14, 2, -13 },
  { 1816, 14, 13, 14, 0, -13 },
  { 1839, 14, 13, 14, 0, -13 },
  { 1862, 13, 13, 14, 1, -13 },
  { 1884, 14, 18, 14, 0, -13 },
  { 1916, 11, 13, 14, 2, -13 },
  { 1934, 10, 22, 14, 2, -17 },
  { 1962, 3, 22, 14, 6, -17 },
  { 1971, 10, 22, 14, 2, -17 },
  { 1999, 12, 5, 14, 1, -11 },
};

const GFXfont LiberationMono_Bold24pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold24pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold24pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _LIBERATIONMONO_BOLD24PT7B_H_
