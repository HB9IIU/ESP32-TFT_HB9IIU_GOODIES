#ifndef _LIBERATIONMONO_BOLD45PT7B_H_
#define _LIBERATIONMONO_BOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00, 0x70,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E,
  0x03, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xF0, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x78, 0x1E, 0x00,
  0x38, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x38, 0x0F, 0x00, 0x1C, 0x07,
  0x00, 0x0E, 0x03, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0x9D, 0xFE, 0x7E, 0x38, 0xFC, 0xFC, 0x71,
  0xF9, 0xF0, 0xE1, 0xE3, 0xF1, 0xC0, 0x07, 0xE3, 0x80, 0x0F, 0xF7, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0x9F, 0xE0, 0x07, 0x0F, 0xC0,
  0x0E, 0x1F, 0x8C, 0x1C, 0x1F, 0xF8, 0x38, 0x3F, 0xF8, 0x70, 0xFF, 0xF8,
  0xE1, 0xFB, 0xF9, 0xCF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x07, 0x87, 0xFC,
  0x00, 0xF1, 0xFF, 0xC0, 0x3C, 0x3C, 0x78, 0x0F, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0xE0, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x78,
  0xF0, 0x1E, 0x0E, 0x3C, 0x03, 0xC3, 0xC7, 0x80, 0x3C, 0x79, 0xE0, 0x07,
  0xFE, 0x78, 0x00, 0x7F, 0xCE, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x00, 0xF1,
  0xF8, 0x00, 0x1C, 0xFF, 0x80, 0x07, 0xBF, 0xF8, 0x01, 0xE7, 0x8F, 0x00,
  0x78, 0xF0, 0xF0, 0x0F, 0x1C, 0x1E, 0x03, 0xC7, 0x83, 0xC0, 0xF0, 0xF0,
  0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x81, 0xC1, 0xE1, 0xE0, 0x3C, 0x3C, 0x3C,
  0x07, 0x8F, 0x0F, 0x00, 0x7F, 0xE3, 0xC0, 0x0F, 0xF8, 0x78, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00,
  0x1E, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7D, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xE0, 0xFF, 0xE0, 0x78, 0x7F, 0xF8, 0x3E, 0x1F, 0xBF, 0x0F, 0x8F,
  0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xF0, 0xF8, 0x3F, 0x7C, 0x3E, 0x07, 0xFE,
  0x0F, 0x80, 0xFF, 0x83, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x83,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xC1,
  0xFE, 0x01, 0xE0, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x80, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x06, 0x3E, 0x33, 0xCF, 0x7B, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x01,
  0xF7, 0xC1, 0xF1, 0xF0, 0xF8, 0xF8, 0x38, 0x38, 0x0C, 0x10, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0,
  0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xCF, 0x9F, 0xFE, 0x7C, 0xFF, 0xF3, 0xE7, 0xFF, 0x9F, 0x3F, 0xFC, 0xF9,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7F, 0x07, 0xF1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0x3F, 0x9F, 0x80, 0xFC, 0x7E, 0x03,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F,
  0x83, 0xFB, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0x80,
  0x7F, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x03,
  0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F,
  0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x01, 0xF7, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFE,
  0x7F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x3F, 0x80, 0xFE, 0x7F,
  0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F,
  0x1F, 0x80, 0x70, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x1F, 0xC0, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x87, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8,
  0x3F, 0x8F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8,
  0xFE, 0x03, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0xFF,
  0x07, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F,
  0x01, 0xFD, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x3F, 0xF3, 0xF0, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE1, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x3F, 0x87, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x38, 0x00,
  0x1E, 0x3C, 0x1E, 0x3F, 0x1C, 0x3F, 0xBB, 0x8E, 0x1F, 0xDC, 0xEE, 0x1E,
  0x7E, 0x77, 0x1E, 0x1F, 0x3B, 0x8E, 0x0F, 0x9D, 0xCF, 0x03, 0x8F, 0xC7,
  0x01, 0xC7, 0xE3, 0x80, 0xE3, 0xF1, 0xC0, 0xF1, 0xF9, 0xE0, 0x78, 0xFC,
  0xF0, 0x3C, 0x7E, 0x78, 0x1C, 0x3F, 0x3C, 0x0E, 0x1F, 0x9E, 0x07, 0x0F,
  0xCF, 0x07, 0x86, 0xE7, 0x83, 0xC7, 0x73, 0xC3, 0xE3, 0xB8, 0xE1, 0xF1,
  0xCE, 0x79, 0xF9, 0xC7, 0x3F, 0xDF, 0xE3, 0x8F, 0xC7, 0xE1, 0xE3, 0xC1,
  0xC0, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x04, 0x07, 0xC0,
  0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xC0,
  0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03,
  0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFC, 0x03, 0xFB,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0xFE, 0x00, 0x60, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x38, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x80, 0xFE, 0x3F,
  0xC1, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF0, 0x7F, 0xCF, 0xC0, 0x7F,
  0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFE, 0xFC,
  0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x1F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xE1, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0xC0, 0x1F,
  0xBF, 0xC0, 0x3F, 0x3F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x1E, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x7F,
  0x8F, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFC,
  0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x80, 0xFF,
  0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFB, 0xC7,
  0xBF, 0xF7, 0x8F, 0x7F, 0xEF, 0x9E, 0xFF, 0xDF, 0x7D, 0xFF, 0x9E, 0xF3,
  0xFF, 0x3D, 0xE7, 0xFE, 0x7B, 0xCF, 0xFC, 0xF7, 0x9F, 0xF8, 0xFE, 0x3F,
  0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFF, 0x87, 0xC3, 0xFF,
  0x0F, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xC0, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xDF, 0x0F, 0xFE, 0xF8, 0x7F, 0xF3, 0xE3, 0xFF, 0x9F, 0x1F,
  0xFE, 0xF8, 0xFF, 0xF3, 0xE7, 0xFF, 0x9F, 0x3F, 0xFC, 0xFD, 0xFF, 0xE3,
  0xEF, 0xFF, 0x1F, 0x3F, 0xF8, 0x7D, 0xFF, 0xC3, 0xEF, 0xFE, 0x1F, 0x7F,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xF0, 0x1F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE,
  0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xC1, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xF8,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF9, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFD, 0xFE, 0x00, 0x7E, 0x7F, 0x80, 0xFF, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7E, 0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x1F, 0x0F, 0xCF, 0xC3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x1F, 0x1F, 0xC7, 0xC3, 0xE3, 0xF8, 0xF8, 0x7C, 0x7F, 0x1F, 0x0F, 0xCF,
  0xF3, 0xE1, 0xFB, 0xFE, 0xFC, 0x1F, 0x7B, 0xDF, 0x03, 0xEF, 0x7B, 0xE0,
  0x7D, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0xC1,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xFB, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7F,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xC0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x80,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x83, 0xF8, 0x7E,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0x3F, 0xFC, 0xFF, 0x1F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x3E, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xFC, 0x3F,
  0x7F, 0xF8, 0xFD, 0xFF, 0xF3, 0xFE, 0x1F, 0xCF, 0xF0, 0x3F, 0xBF, 0x80,
  0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xBF, 0xC0, 0xFE, 0xFF, 0x87,
  0xF3, 0xF7, 0xFF, 0xCF, 0xCF, 0xFE, 0x3F, 0x1F, 0xF0, 0xFC, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xC3, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC,
  0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0xFF, 0xCF,
  0xC7, 0xFF, 0xBF, 0x3F, 0xFE, 0xFC, 0xFE, 0x1F, 0xF7, 0xF0, 0x3F, 0xDF,
  0x80, 0x7F, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x3F,
  0x87, 0xFC, 0xFF, 0xFB, 0xF1, 0xFF, 0xCF, 0xC3, 0xFE, 0x3F, 0x03, 0xF0,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3E,
  0xFE, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xFE, 0x1F, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x7F, 0xCF, 0xCF, 0xFF,
  0x7E, 0x7F, 0xFF, 0xF7, 0xF8, 0xFF, 0xBF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFE, 0xFC, 0x7F, 0xE7, 0xE0, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC7, 0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xF8, 0x7F, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x1F,
  0xF9, 0xF9, 0xFF, 0xEF, 0xDF, 0xFF, 0x7E, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F,
  0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xE0, 0x3F, 0x9F, 0xC0,
  0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFE, 0xFC, 0x01,
  0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE0, 0xF9, 0xE7,
  0xE3, 0xFB, 0xDF, 0xEF, 0xFF, 0xBF, 0xDF, 0xFF, 0xCF, 0xE3, 0xFF, 0x8F,
  0xC7, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8,
  0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87,
  0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F,
  0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE,
  0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xFC, 0x1F, 0x87, 0xE3, 0xFF, 0x3F, 0x3F,
  0xFD, 0xFB, 0xFF, 0xEF, 0xDF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0,
  0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFC, 0x3F, 0x03, 0xF1, 0xFF, 0x0F, 0xCF,
  0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0x87, 0xF3, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F,
  0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0xBF, 0xE1, 0xFC,
  0xFD, 0xFF, 0xF3, 0xF7, 0xFF, 0x8F, 0xCF, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0xFC, 0x3F, 0xE3, 0xF1, 0xFF, 0xCF, 0xCF, 0xFF, 0xBF, 0x3F,
  0x87, 0xFD, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xF8,
  0x07, 0xF7, 0xF0, 0x3F, 0xCF, 0xE1, 0xFF, 0x3F, 0xFE, 0xFC, 0x7F, 0xFB,
  0xF0, 0xFF, 0x8F, 0xC0, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x0F, 0xF7, 0xE3, 0xFF,
  0x7E, 0x7F, 0xF7, 0xEF, 0xFF, 0x7E, 0xFF, 0xF7, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F, 0x3E, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF9, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xF7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x04,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0x3B, 0xF7, 0xFF, 0xDF, 0xBF, 0xFC, 0xFC, 0xFF, 0xC7, 0xE3, 0xFC,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x9F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x3C, 0x3C, 0x1F, 0x07, 0x87, 0xC7,
  0xF1, 0xF0, 0xF8, 0xFE, 0x3E, 0x1F, 0x1F, 0xC7, 0xC3, 0xE7, 0xBC, 0xF8,
  0x3C, 0xF7, 0x9E, 0x07, 0x9E, 0xF3, 0xC0, 0xF7, 0x8F, 0x78, 0x1E, 0xF1,
  0xFF, 0x03, 0xDE, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF1, 0xFC, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80,
  0x0F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 30, 27, 10, -30 },
  { 28, 17, 14, 27, 5, -33 },
  { 58, 25, 30, 27, 1, -30 },
  { 152, 23, 37, 27, 2, -33 },
  { 259, 27, 30, 27, 0, -30 },
  { 361, 26, 30, 27, 1, -30 },
  { 459, 7, 14, 27, 10, -33 },
  { 472, 12, 42, 27, 8, -33 },
  { 535, 12, 42, 27, 7, -33 },
  { 598, 17, 17, 27, 5, -33 },
  { 635, 23, 23, 27, 2, -26 },
  { 702, 10, 15, 27, 6, -7 },
  { 721, 13, 5, 27, 7, -14 },
  { 730, 7, 7, 27, 10, -7 },
  { 737, 23, 33, 27, 2, -33 },
  { 832, 21, 30, 27, 3, -30 },
  { 911, 22, 30, 27, 3, -30 },
  { 994, 21, 30, 27, 3, -30 },
  { 1073, 23, 30, 27, 2, -30 },
  { 1160, 24, 30, 27, 2, -30 },
  { 1250, 23, 30, 27, 2, -30 },
  { 1337, 22, 30, 27, 3, -30 },
  { 1420, 21, 30, 27, 3, -30 },
  { 1499, 23, 30, 27, 2, -30 },
  { 1586, 22, 30, 27, 2, -30 },
  { 1669, 7, 24, 27, 10, -24 },
  { 1690, 11, 32, 27, 7, -24 },
  { 1734, 23, 24, 27, 2, -27 },
  { 1803, 23, 17, 27, 2, -23 },
  { 1852, 23, 24, 27, 2, -27 },
  { 1921, 22, 30, 27, 2, -30 },
  { 2004, 25, 39, 27, 1, -33 },
  { 2126, 27, 30, 27, 0, -30 },
  { 2228, 23, 30, 27, 3, -30 },
  { 2315, 24, 30, 27, 2, -30 },
  { 2405, 22, 30, 27, 3, -30 },
  { 2488, 22, 30, 27, 3, -30 },
  { 2571, 20, 30, 27, 4, -30 },
  { 2646, 23, 30, 27, 2, -30 },
  { 2733, 21, 30, 27, 3, -30 },
  { 2812, 21, 30, 27, 3, -30 },
  { 2891, 20, 30, 27, 2, -30 },
  { 2966, 24, 30, 27, 3, -30 },
  { 3056, 20, 30, 27, 5, -30 },
  { 3131, 23, 30, 27, 2, -30 },
  { 3218, 21, 30, 27, 3, -30 },
  { 3297, 23, 30, 27, 2, -30 },
  { 3384, 22, 30, 27, 3, -30 },
  { 3467, 24, 39, 27, 2, -30 },
  { 3584, 24, 30, 27, 3, -30 },
  { 3674, 25, 30, 27, 1, -30 },
  { 3768, 25, 30, 27, 1, -30 },
  { 3862, 21, 30, 27, 3, -30 },
  { 3941, 27, 30, 27, 0, -30 },
  { 4043, 27, 30, 27, 0, -30 },
  { 4145, 27, 30, 27, 0, -30 },
  { 4247, 27, 30, 27, 0, -30 },
  { 4349, 23, 30, 27, 2, -30 },
  { 4436, 13, 42, 27, 8, -33 },
  { 4505, 23, 33, 27, 2, -33 },
  { 4600, 13, 42, 27, 6, -33 },
  { 4669, 24, 20, 27, 1, -30 },
  { 4729, 27, 2, 27, 0, 3 },
  { 4736, 11, 6, 27, 8, -32 },
  { 4745, 24, 24, 27, 2, -24 },
  { 4817, 22, 33, 27, 3, -33 },
  { 4908, 22, 24, 27, 2, -24 },
  { 4974, 22, 33, 27, 2, -33 },
  { 5065, 23, 24, 27, 2, -24 },
  { 5134, 22, 33, 27, 3, -33 },
  { 5225, 21, 33, 27, 3, -24 },
  { 5312, 21, 33, 27, 3, -33 },
  { 5399, 22, 33, 27, 3, -33 },
  { 5490, 16, 42, 27, 3, -33 },
  { 5574, 22, 33, 27, 4, -33 },
  { 5665, 22, 33, 27, 3, -33 },
  { 5756, 23, 24, 27, 2, -24 },
  { 5825, 21, 24, 27, 3, -24 },
  { 5888, 23, 24, 27, 2, -24 },
  { 5957, 22, 33, 27, 3, -24 },
  { 6048, 22, 33, 27, 2, -24 },
  { 6139, 20, 24, 27, 4, -24 },
  { 6199, 21, 24, 27, 3, -24 },
  { 6262, 19, 30, 27, 4, -30 },
  { 6334, 21, 24, 27, 3, -24 },
  { 6397, 25, 24, 27, 1, -24 },
  { 6472, 27, 24, 27, 0, -24 },
  { 6553, 25, 24, 27, 1, -24 },
  { 6628, 25, 33, 27, 1, -24 },
  { 6732, 21, 24, 27, 3, -24 },
  { 6795, 19, 42, 27, 4, -33 },
  { 6895, 5, 43, 27, 11, -33 },
  { 6922, 19, 42, 27, 4, -33 },
  { 7022, 23, 7, 27, 2, -18 },
};

const GFXfont LiberationMono_Bold45pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold45pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold45pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _LIBERATIONMONO_BOLD45PT7B_H_
