#ifndef _LIBERATIONMONO_BOLD29PT7B_H_
#define _LIBERATIONMONO_BOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x0F, 0xFF, 0xF0, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8E, 0xE3, 0x80, 0x06,
  0x0C, 0x06, 0x1C, 0x06, 0x18, 0x0E, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C,
  0x30, 0x1C, 0x30, 0x18, 0x30, 0x18, 0x30, 0x18, 0x70, 0xFF, 0xFE, 0xFF,
  0xFE, 0x30, 0x60, 0x30, 0x60, 0x30, 0xE0, 0x30, 0xC0, 0x70, 0xC0, 0x60,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x3F, 0xC1, 0xFF, 0xC7, 0xFF, 0xCF, 0x37,
  0xDC, 0x67, 0xB8, 0xC0, 0x79, 0x80, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x33, 0xC0, 0x67, 0xB8, 0xC7, 0xF1, 0x9E, 0xF3, 0x7D, 0xFF,
  0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0x30, 0x00, 0x60, 0x00, 0x3C, 0x03, 0x3F,
  0x03, 0xB9, 0xC3, 0x9C, 0xE1, 0x8E, 0x31, 0x87, 0x19, 0xC3, 0x9C, 0xC1,
  0xCE, 0xC0, 0x7E, 0xE0, 0x1E, 0xEF, 0x80, 0x6F, 0xE0, 0x76, 0x70, 0x77,
  0x18, 0x33, 0x8C, 0x31, 0xC6, 0x38, 0xE3, 0x18, 0x33, 0x98, 0x1F, 0xDC,
  0x07, 0x80, 0x03, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x73, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x07, 0x1F, 0xC3, 0x9E,
  0xF3, 0x8E, 0x39, 0xCF, 0x1F, 0xE7, 0x87, 0xE3, 0xC1, 0xF0, 0xF0, 0xFC,
  0x7F, 0xFF, 0x9F, 0xF7, 0xC3, 0xE0, 0xE0, 0xFF, 0xFE, 0xEE, 0xEE, 0xE0,
  0x0F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x00, 0x0E, 0x01,
  0xC1, 0x39, 0x3F, 0x7F, 0xFE, 0x7F, 0x07, 0xC1, 0xFC, 0x3B, 0xCE, 0x38,
  0x46, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x3C, 0x79, 0xE3, 0xC7, 0x0E,
  0x38, 0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF, 0x03,
  0xFC, 0x0F, 0xF7, 0x3F, 0xDC, 0xFF, 0x73, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xEF, 0x07, 0x9E, 0x3E, 0x7F, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x01, 0xFC, 0x3F, 0xF0, 0xFB, 0xC3, 0x8F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xC7,
  0xFF, 0xBE, 0x1E, 0xF0, 0x7B, 0xC1, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3,
  0xE3, 0xE7, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x07, 0xF8, 0x0F,
  0xC0, 0x1F, 0xE0, 0x01, 0xE0, 0x01, 0xFE, 0x03, 0xDE, 0x07, 0xBE, 0x1F,
  0x7F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x3C, 0x78,
  0x38, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFC, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x03, 0xDE, 0x0F,
  0xBE, 0x3E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0xC3,
  0xFF, 0x1F, 0x1E, 0xF8, 0x7B, 0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xFF, 0xF3,
  0xFF, 0xEF, 0x87, 0xBC, 0x1F, 0xF0, 0x3F, 0xC0, 0xF7, 0x07, 0xDE, 0x1E,
  0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBE, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0x9E, 0x3E, 0x3F, 0xF0, 0x3F, 0x07, 0xFF, 0x3E, 0x1E, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xC1, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0x87, 0xFF, 0x3E, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC,
  0x1F, 0xF8, 0xFF, 0xFF, 0xF7, 0xFB, 0xC7, 0xCF, 0x00, 0x78, 0x01, 0xEF,
  0x07, 0xBE, 0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xF7, 0x9E, 0x71, 0xCE, 0x38, 0xC0, 0x00, 0x02, 0x00,
  0x3C, 0x03, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x70, 0x00,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0,
  0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0x80, 0x07, 0x00, 0x7E, 0x03, 0xFC, 0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0x1F,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE1, 0xEF,
  0x81, 0xFE, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1C, 0x3C, 0x38, 0x0C,
  0x30, 0x06, 0x63, 0xDE, 0x67, 0xDE, 0xC6, 0x7B, 0xCC, 0x33, 0xCC, 0x33,
  0xDC, 0x33, 0xD8, 0x33, 0xD8, 0x73, 0xD8, 0x63, 0xD8, 0x63, 0xD8, 0x66,
  0xD8, 0xE6, 0xDC, 0xE6, 0xCF, 0xBC, 0x67, 0x38, 0x60, 0x00, 0x70, 0x08,
  0x38, 0x3C, 0x1F, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0x77, 0x80, 0x7B, 0xC0, 0x3C, 0xE0, 0x1C, 0x78, 0x1E,
  0x3C, 0x0F, 0x0E, 0x07, 0x87, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0xBC, 0x1E,
  0x7F, 0xF8, 0xFF, 0xC1, 0xFF, 0xF3, 0xC1, 0xF7, 0x81, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x1E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0x80, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0x78, 0x1C, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x0C, 0x78, 0x1E, 0x78, 0x1E, 0x7E, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x7E, 0xF0, 0x7B, 0xC1, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x03, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x9E,
  0x1F, 0x3F, 0xFE, 0x3F, 0xF0, 0x1F, 0x80, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x9F, 0x3F,
  0xF0, 0xFF, 0x03, 0xF0, 0xF0, 0x3F, 0xE0, 0xFB, 0xC3, 0xE7, 0x87, 0x8F,
  0x1F, 0x1E, 0x7C, 0x3C, 0xF0, 0x7B, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0x9E, 0x1E, 0x3E, 0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0x7D,
  0xE0, 0x7B, 0xC0, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xFE, 0xE7, 0xFD, 0xCD, 0xFF, 0xBB,
  0xFF, 0x77, 0xF7, 0xEF, 0xEF, 0x9F, 0xDF, 0x3F, 0xBE, 0x7F, 0x3C, 0xFE,
  0x71, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x38, 0xF8,
  0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xB8, 0xFD, 0xE7,
  0xE7, 0x3F, 0xB9, 0xFD, 0xEF, 0xE7, 0x7F, 0x3B, 0xF9, 0xFF, 0xC7, 0xFE,
  0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3E, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xE3, 0xE7, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x3E,
  0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xEF,
  0xFF, 0x3F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7C, 0x7C,
  0x78, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x7C,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7,
  0x83, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3E, 0x78, 0x3C,
  0xF0, 0x7D, 0xE0, 0x7B, 0xC0, 0xF8, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC,
  0x78, 0x7C, 0xF8, 0x3E, 0xF8, 0x1E, 0x78, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xEF, 0x07,
  0xBE, 0x3E, 0x7F, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0xF8, 0x07, 0xBC, 0x03,
  0xDE, 0x03, 0xEF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xF7, 0x80,
  0x3B, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x7B,
  0x8E, 0x3D, 0xE7, 0x9C, 0xF3, 0xCE, 0x7B, 0xE7, 0x3D, 0xF3, 0x8E, 0xFF,
  0xC7, 0x6F, 0xE3, 0xF7, 0xE1, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x1E,
  0x3E, 0x0F, 0x0F, 0x07, 0x87, 0x80, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x87,
  0x83, 0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0x79, 0xE0,
  0x78, 0xF0, 0x7C, 0x3C, 0x3C, 0x1F, 0x3C, 0x07, 0xBE, 0x01, 0xE0, 0xF8,
  0x07, 0xBC, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0,
  0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x3B, 0x80,
  0x77, 0x01, 0xCF, 0x03, 0x8E, 0x0F, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0xE0,
  0x39, 0xC0, 0x77, 0x00, 0xFE, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0xF0, 0xF0,
  0x70, 0x70, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x78, 0x78, 0x78,
  0x00, 0x3C, 0x0F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C,
  0x78, 0x7C, 0x78, 0xFC, 0x7F, 0xFF, 0x3F, 0xBF, 0x1F, 0x1F, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x8F, 0x7F, 0x3F, 0xFE,
  0xFC, 0xFB, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x7F, 0xF3, 0xEF, 0xFF, 0xBD, 0xFC, 0xF3, 0xE0, 0x0F,
  0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xFC, 0x1E, 0xF8, 0xF9, 0xFF, 0xC3,
  0xFE, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x3C, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x7D, 0xE0, 0xF7, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xF1, 0xF3, 0xFF,
  0xCF, 0xEF, 0x0F, 0x3C, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7,
  0x81, 0xCF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0xF7, 0xC3, 0xC7, 0xFF, 0x87, 0xFE, 0x03, 0xF0, 0x03, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC7, 0xC0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1F,
  0x3C, 0xFE, 0xF7, 0xFF, 0xFE, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0xFD, 0xFF, 0xF3,
  0xFB, 0xC7, 0x8F, 0x00, 0x3C, 0x01, 0xEF, 0x87, 0x9F, 0xFE, 0x3F, 0xF0,
  0x7F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF,
  0x8F, 0x7F, 0x3F, 0xFE, 0xFC, 0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0xF7,
  0xFD, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xFF, 0xBF,
  0xCF, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x0F, 0xBC, 0x1E, 0x78, 0x78, 0xF1, 0xE1, 0xE7, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE1, 0xF3,
  0xC1, 0xE7, 0x83, 0xEF, 0x03, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0x3D, 0xDE, 0xFF, 0xFF,
  0xFF, 0x9E, 0x7F, 0x3C, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F,
  0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1,
  0xC7, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0x1E, 0xF8, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1,
  0xE7, 0x83, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D,
  0xE0, 0x7B, 0xC1, 0xF7, 0xC7, 0xC7, 0xFF, 0x07, 0xFE, 0x03, 0xF0, 0xF3,
  0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0x3E, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0xFB, 0xFF, 0xEF,
  0x7F, 0x3C, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x0F, 0x3C, 0xFE, 0xF3, 0xFF, 0xDF, 0x1F, 0x78, 0x3D, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x7C,
  0x7C, 0xFF, 0xF3, 0xFF, 0xC3, 0xCF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xF1, 0xFF, 0x7F, 0xF7, 0xFF, 0xE0, 0xFC,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x3C, 0x1E,
  0xF0, 0x3B, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x07,
  0xF8, 0x0F, 0xF0, 0x79, 0xFF, 0xE7, 0xFF, 0x07, 0xF0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xC3, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xF1, 0xFF, 0xFF, 0xBF, 0xBC, 0xF8, 0xE0, 0x78, 0x07, 0xBC, 0x07, 0x9E,
  0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x70, 0x3C, 0x78,
  0x1E, 0x3C, 0x07, 0x9C, 0x03, 0xDE, 0x00, 0xEF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0xE0, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x77, 0x1C, 0x7B, 0x8F, 0x39, 0xC7, 0x9C, 0xE7, 0xCE, 0x33, 0xE7,
  0x1D, 0xBB, 0x8F, 0xDD, 0xC7, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x78,
  0x78, 0x38, 0x3C, 0xF8, 0x1E, 0x78, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1E,
  0xF0, 0x1E, 0xF8, 0x3C, 0x78, 0x7C, 0x3C, 0x78, 0x3E, 0xF0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0xFF,
  0x1F, 0xF1, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0xFC, 0x0F, 0x00, 0xFC, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xF0, 0xFF,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x03, 0xF0, 0x7C, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0xFC, 0x00, 0x3E, 0x01, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x07, 0xC0,
};

const GFXglyph LiberationMono_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 19, 17, 7, -19 },
  { 11, 10, 9, 17, 4, -21 },
  { 23, 16, 19, 17, 1, -19 },
  { 61, 15, 23, 17, 1, -21 },
  { 105, 17, 19, 17, 0, -19 },
  { 146, 17, 19, 17, 0, -19 },
  { 187, 4, 9, 17, 7, -21 },
  { 192, 8, 27, 17, 5, -21 },
  { 219, 9, 27, 17, 4, -21 },
  { 250, 11, 11, 17, 3, -21 },
  { 266, 15, 15, 17, 1, -17 },
  { 295, 7, 9, 17, 4, -4 },
  { 303, 8, 3, 17, 5, -9 },
  { 306, 4, 4, 17, 7, -4 },
  { 308, 15, 21, 17, 1, -21 },
  { 348, 14, 19, 17, 2, -19 },
  { 382, 14, 19, 17, 2, -19 },
  { 416, 14, 19, 17, 2, -19 },
  { 450, 15, 19, 17, 1, -19 },
  { 486, 16, 19, 17, 1, -19 },
  { 524, 15, 19, 17, 1, -19 },
  { 560, 14, 19, 17, 2, -19 },
  { 594, 13, 19, 17, 2, -19 },
  { 625, 14, 19, 17, 2, -19 },
  { 659, 14, 19, 17, 2, -19 },
  { 693, 4, 16, 17, 7, -16 },
  { 701, 6, 21, 17, 5, -16 },
  { 717, 15, 15, 17, 1, -17 },
  { 746, 15, 11, 17, 1, -15 },
  { 767, 15, 15, 17, 1, -17 },
  { 796, 15, 19, 17, 1, -19 },
  { 832, 16, 25, 17, 1, -21 },
  { 882, 17, 19, 17, 0, -19 },
  { 923, 15, 19, 17, 2, -19 },
  { 959, 16, 19, 17, 1, -19 },
  { 997, 14, 19, 17, 2, -19 },
  { 1031, 14, 19, 17, 2, -19 },
  { 1065, 14, 19, 17, 2, -19 },
  { 1099, 15, 19, 17, 1, -19 },
  { 1135, 13, 19, 17, 2, -19 },
  { 1166, 13, 19, 17, 2, -19 },
  { 1197, 13, 19, 17, 1, -19 },
  { 1228, 15, 19, 17, 2, -19 },
  { 1264, 13, 19, 17, 3, -19 },
  { 1295, 15, 19, 17, 1, -19 },
  { 1331, 13, 19, 17, 2, -19 },
  { 1362, 15, 19, 17, 1, -19 },
  { 1398, 14, 19, 17, 2, -19 },
  { 1432, 16, 25, 17, 1, -19 },
  { 1482, 15, 19, 17, 2, -19 },
  { 1518, 16, 19, 17, 1, -19 },
  { 1556, 16, 19, 17, 1, -19 },
  { 1594, 14, 19, 17, 2, -19 },
  { 1628, 17, 19, 17, 0, -19 },
  { 1669, 17, 19, 17, 0, -19 },
  { 1710, 17, 19, 17, 0, -19 },
  { 1751, 17, 19, 17, 0, -19 },
  { 1792, 15, 19, 17, 1, -19 },
  { 1828, 9, 27, 17, 5, -21 },
  { 1859, 15, 21, 17, 1, -21 },
  { 1899, 8, 27, 17, 4, -21 },
  { 1926, 15, 13, 17, 1, -19 },
  { 1951, 17, 1, 17, 0, 2 },
  { 1954, 7, 4, 17, 5, -21 },
  { 1958, 16, 16, 17, 1, -16 },
  { 1990, 14, 21, 17, 2, -21 },
  { 2027, 14, 16, 17, 2, -16 },
  { 2055, 14, 21, 17, 1, -21 },
  { 2092, 15, 16, 17, 1, -16 },
  { 2122, 14, 21, 17, 2, -21 },
  { 2159, 14, 22, 17, 2, -16 },
  { 2198, 14, 21, 17, 2, -21 },
  { 2235, 14, 21, 17, 2, -21 },
  { 2272, 10, 27, 17, 2, -21 },
  { 2306, 15, 21, 17, 2, -21 },
  { 2346, 14, 21, 17, 2, -21 },
  { 2383, 15, 16, 17, 1, -16 },
  { 2413, 14, 16, 17, 2, -16 },
  { 2441, 15, 16, 17, 1, -16 },
  { 2471, 14, 22, 17, 2, -16 },
  { 2510, 14, 22, 17, 1, -16 },
  { 2549, 12, 16, 17, 3, -16 },
  { 2573, 14, 16, 17, 2, -16 },
  { 2601, 13, 20, 17, 2, -20 },
  { 2634, 13, 15, 17, 2, -15 },
  { 2659, 17, 16, 17, 0, -16 },
  { 2693, 17, 16, 17, 0, -16 },
  { 2727, 16, 16, 17, 1, -16 },
  { 2759, 16, 22, 17, 1, -16 },
  { 2803, 13, 16, 17, 2, -16 },
  { 2829, 12, 27, 17, 3, -21 },
  { 2870, 4, 27, 17, 7, -21 },
  { 2884, 12, 27, 17, 3, -21 },
  { 2925, 15, 5, 17, 1, -12 },
};

const GFXfont LiberationMono_Bold29pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold29pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold29pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _LIBERATIONMONO_BOLD29PT7B_H_
