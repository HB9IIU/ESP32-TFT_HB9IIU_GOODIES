#ifndef _LIBERATIONMONO_BOLD22PT7B_H_
#define _LIBERATIONMONO_BOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xE7, 0xE6, 0xC6, 0xC6, 0xC6,
  0xC6, 0xC6, 0x08, 0x41, 0x8C, 0x18, 0xCF, 0xFF, 0xFF, 0xF3, 0x18, 0x31,
  0x83, 0x18, 0xFF, 0xEF, 0xFE, 0x63, 0x06, 0x30, 0x63, 0x04, 0x20, 0x04,
  0x07, 0xF1, 0xFF, 0x7A, 0xFE, 0x4F, 0xE8, 0x1F, 0x80, 0xFE, 0x05, 0xE0,
  0x9F, 0x91, 0xF2, 0x3F, 0x4E, 0xFF, 0x87, 0xE0, 0x20, 0x04, 0x00, 0x78,
  0x36, 0x61, 0x33, 0x19, 0x99, 0x8C, 0xD8, 0x66, 0xC1, 0xEC, 0x00, 0xDE,
  0x05, 0x98, 0x6C, 0xC6, 0x66, 0x63, 0x33, 0x19, 0xB0, 0x78, 0x0F, 0x80,
  0xFE, 0x06, 0x30, 0x31, 0x81, 0xB8, 0x0F, 0x80, 0xF0, 0xCF, 0xCE, 0xE7,
  0x67, 0x1F, 0x38, 0x78, 0xE3, 0xC7, 0xFF, 0x9F, 0x1C, 0xFF, 0xFF, 0xD8,
  0x1C, 0xE7, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0x71, 0xC7, 0x0E, 0x1C, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C,
  0x18, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE3, 0x87, 0x00, 0x0C,
  0x06, 0x1B, 0x4F, 0xF1, 0xC1, 0xF1, 0xDC, 0x44, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x0F, 0xFF, 0xFF, 0xC3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x7B, 0x9C,
  0xCE, 0x63, 0x00, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x38, 0x6E, 0x0F,
  0xDD, 0xFB, 0xBF, 0x77, 0xE0, 0xFC, 0x1D, 0xC3, 0x38, 0xE3, 0xF8, 0x3E,
  0x00, 0x07, 0x03, 0xE3, 0xFC, 0x73, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFE, 0xFF, 0xC0, 0x1F, 0x0F, 0xF9,
  0xC7, 0x38, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x38, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x0F, 0xF9, 0xC7, 0x70, 0x70, 0x0E,
  0x03, 0x83, 0xE0, 0x7C, 0x01, 0xE0, 0x1F, 0x83, 0xF8, 0xF7, 0xFC, 0x3F,
  0x00, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xDC, 0x1D, 0xC3, 0x9C, 0x31, 0xC6,
  0x1C, 0xE1, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0xCF,
  0xF9, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0x1F, 0xF3, 0x8F, 0x00, 0xE0, 0x1F,
  0x83, 0xB8, 0xF7, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xF9, 0xE7, 0x38, 0x77,
  0x01, 0xCF, 0x3F, 0xF7, 0x8F, 0xF0, 0xEE, 0x1D, 0xC3, 0xB8, 0xF3, 0xFC,
  0x3E, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0x0F,
  0xF9, 0xC7, 0x38, 0x77, 0x0E, 0xE3, 0x8F, 0xE1, 0xFC, 0x71, 0xFC, 0x1F,
  0x83, 0xF8, 0xF7, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0xEE,
  0x0F, 0xC1, 0xDC, 0x7B, 0xFF, 0x3E, 0xE0, 0x1D, 0x87, 0x38, 0xE7, 0xF8,
  0x3E, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x38, 0xE3, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0x8E, 0x71, 0xC6, 0x18, 0x00, 0x20, 0x1C, 0x1F, 0x0F,
  0x87, 0xC1, 0xC0, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0x80, 0x10,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xC0, 0x38, 0x1F, 0x1F, 0x0F, 0x83,
  0xC0, 0x40, 0x00, 0x1F, 0x8F, 0xF9, 0xC7, 0xF0, 0x7E, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xC3, 0x04, 0x08, 0x40, 0x26, 0x75, 0x36, 0x6D, 0x23, 0x6B, 0x1B,
  0x58, 0xDE, 0xC6, 0xF6, 0x26, 0xB1, 0x25, 0x99, 0x2C, 0xD9, 0x3B, 0x8C,
  0x00, 0x30, 0x20, 0xC3, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0x60, 0x1B,
  0x81, 0xDC, 0x0E, 0x60, 0x63, 0x87, 0x1C, 0x3F, 0xE1, 0xFF, 0x9C, 0x1C,
  0xE0, 0xE7, 0x03, 0xF0, 0x1C, 0xFF, 0x8F, 0xFC, 0xF1, 0xEF, 0x0E, 0xF0,
  0xEF, 0x1C, 0xFF, 0x8F, 0xFC, 0xF0, 0xEF, 0x07, 0xF0, 0x7F, 0x0F, 0xFF,
  0xEF, 0xFC, 0x1F, 0x03, 0xFC, 0x71, 0xEF, 0x0E, 0xE0, 0xCE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x06, 0xF0, 0xE7, 0x9E, 0x3F, 0xC1, 0xF0, 0xFF,
  0x1F, 0xF3, 0xCF, 0x78, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC7, 0xF8, 0xEF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3F, 0xF7, 0xFE, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F, 0x07, 0xF1,
  0xC7, 0x78, 0xFE, 0x0D, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xFC, 0x1F, 0xC3,
  0xB8, 0x73, 0xFE, 0x3F, 0x00, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xC0, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xF8, 0x7F, 0x1D, 0xCF, 0x7F, 0x87,
  0xC0, 0xF0, 0xFF, 0x1E, 0xF3, 0xCF, 0x38, 0xF7, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x8F, 0x38, 0xF3, 0xCF, 0x1E, 0xF0, 0xEF, 0x0F, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xFF, 0xFF, 0xF0, 0xF1, 0xFE, 0x3F, 0xE7, 0xEC, 0xFD, 0xB7, 0xB6,
  0xF7, 0xDE, 0x73, 0xCE, 0x79, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0,
  0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF, 0xD9, 0xFB, 0xBF, 0x77, 0xE6,
  0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xC0, 0x1F, 0x07, 0xF9, 0xC7,
  0x78, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xB8,
  0xE3, 0xFC, 0x3E, 0x00, 0xFF, 0x9F, 0xFB, 0xC7, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x7F, 0xFE, 0xFF, 0x9E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00,
  0x1F, 0x03, 0xFC, 0x71, 0xCF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xF0, 0xE7, 0x1C, 0x7F, 0xC1, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3F, 0x01, 0xF0, 0xFF, 0x8F, 0xFE, 0xF0, 0xEF, 0x0E, 0xF0,
  0xEF, 0x0E, 0xFF, 0xCF, 0xF0, 0xF3, 0x8F, 0x3C, 0xF1, 0xCF, 0x1E, 0xF0,
  0xEF, 0x0F, 0x0F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x80, 0x1F, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xF7, 0x83, 0xDC, 0x1C, 0xF0, 0xE3, 0xFE, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1D,
  0xC7, 0xB8, 0xE7, 0xFC, 0x3E, 0x00, 0xE0, 0x3B, 0x83, 0xDC, 0x1C, 0xE0,
  0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x76,
  0x73, 0x3B, 0x99, 0xDC, 0xCF, 0xFE, 0x7D, 0xF1, 0xEF, 0x8F, 0x7C, 0x79,
  0xC3, 0x8E, 0x1C, 0x70, 0x70, 0x73, 0xC7, 0x8E, 0x38, 0x3B, 0x81, 0xFC,
  0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0xEE, 0x0F, 0x38, 0x71, 0xC7,
  0x07, 0x78, 0x1C, 0xF0, 0x3B, 0x83, 0x8E, 0x3C, 0x71, 0xC1, 0xDC, 0x0F,
  0xE0, 0x3E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x7F, 0xEF, 0xFC, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80,
  0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x3F, 0xFC, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xFF, 0xFC, 0x0F, 0x00, 0xF8, 0x0D, 0x81, 0xDC, 0x18, 0xC3,
  0x8C, 0x30, 0xE3, 0x06, 0x70, 0x76, 0x03, 0xFF, 0xF8, 0xE3, 0x86, 0x1F,
  0x03, 0xF8, 0x71, 0xC7, 0x1C, 0x01, 0xC3, 0xFC, 0x7F, 0xCF, 0x1C, 0xE1,
  0xCE, 0x3C, 0x7E, 0xF3, 0xCF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x78,
  0xFF, 0x9E, 0x7B, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xF3,
  0x9F, 0xF3, 0x3C, 0x1F, 0x07, 0xF9, 0xC7, 0x38, 0x7E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x73, 0xCE, 0xFD, 0xDC, 0x7F, 0x8F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0x1E, 0xE3, 0xDF, 0xB9, 0xE7, 0x1F, 0x07, 0xF1, 0xC7, 0x78, 0x7E,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0E, 0x1C, 0xFF, 0x0F, 0x80, 0x07,
  0xE3, 0xFC, 0x70, 0x0E, 0x0F, 0xFF, 0xFF, 0xC7, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0xEF, 0xFD,
  0xC7, 0xB8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0x70, 0xEE, 0x3D, 0xFF,
  0x9E, 0x70, 0x0E, 0xE1, 0xDE, 0x71, 0xFE, 0x1F, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xEF, 0x3F, 0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x3F, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x00, 0x7F, 0x7F, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFE, 0xFC,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1D, 0xC7, 0x39, 0xC7, 0x70, 0xFC,
  0x1F, 0xC3, 0xF8, 0x73, 0x8E, 0x71, 0xC7, 0x38, 0xF7, 0x0E, 0x7F, 0x0F,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x3F, 0xFF, 0xFF, 0xDC, 0xDF, 0xBF, 0xB9,
  0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0x73, 0xCE, 0x79, 0xCF, 0x39, 0xE7,
  0x30, 0xE7, 0x8D, 0xF9, 0xE7, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87,
  0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x70, 0x1F, 0x0F, 0xF9, 0xC7, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x38, 0xFF, 0x0F, 0x80, 0x67,
  0x8F, 0xF9, 0xE7, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEF,
  0x3D, 0xFF, 0x3B, 0xC7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x3C,
  0xEF, 0xDD, 0xC7, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF1, 0xEE,
  0x3D, 0xFB, 0x9E, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xE7,
  0xFB, 0xF7, 0xC1, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x1F, 0x8F, 0xF9, 0xC3, 0xB8, 0x07, 0x80, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0xEE, 0x1D, 0xFF, 0x0F, 0xC0, 0x38, 0x1C, 0x0E, 0x1F, 0xFF,
  0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFC, 0x7E,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xF1,
  0xEE, 0x7D, 0xFB, 0x9E, 0x70, 0x70, 0x7B, 0x83, 0x9C, 0x1C, 0x71, 0xE3,
  0x8E, 0x1C, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x0F,
  0x00, 0xE0, 0x1F, 0x01, 0xD8, 0x0E, 0xCE, 0x66, 0x73, 0x33, 0x99, 0xB6,
  0xCF, 0xB6, 0x3D, 0xF1, 0xC7, 0x0E, 0x38, 0x71, 0xC0, 0xE0, 0xE7, 0x1C,
  0x39, 0xC3, 0xB8, 0x1F, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x3B, 0x87, 0x1C,
  0x71, 0xEE, 0x0E, 0x70, 0x7B, 0x83, 0x9C, 0x1C, 0x71, 0xC3, 0x8E, 0x0E,
  0x70, 0x73, 0x03, 0xB8, 0x0D, 0xC0, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x07, 0xC0, 0x38, 0x00, 0x7F, 0xCF, 0xF8, 0x0F, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0x8F, 0xC7, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x78, 0x3C,
  0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0xF0, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x07, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0xC1, 0xE1, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x9F, 0x8F, 0x80, 0x78, 0x1F, 0xC6, 0x1F,
  0x81, 0xE0,
};

const GFXglyph LiberationMono_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 14, 13, 5, -14 },
  { 7, 8, 7, 13, 3, -16 },
  { 14, 12, 14, 13, 1, -14 },
  { 35, 11, 17, 13, 1, -15 },
  { 59, 13, 14, 13, 0, -14 },
  { 82, 13, 14, 13, 0, -14 },
  { 105, 3, 7, 13, 5, -16 },
  { 108, 6, 21, 13, 4, -16 },
  { 124, 7, 21, 13, 3, -16 },
  { 143, 9, 8, 13, 2, -16 },
  { 152, 11, 10, 13, 1, -12 },
  { 166, 5, 7, 13, 3, -3 },
  { 171, 7, 2, 13, 3, -7 },
  { 173, 3, 3, 13, 5, -3 },
  { 175, 11, 16, 13, 1, -16 },
  { 197, 11, 14, 13, 1, -14 },
  { 217, 11, 14, 13, 1, -14 },
  { 237, 11, 14, 13, 1, -14 },
  { 257, 11, 14, 13, 1, -14 },
  { 277, 12, 14, 13, 1, -14 },
  { 298, 11, 14, 13, 1, -14 },
  { 318, 11, 14, 13, 1, -14 },
  { 338, 11, 14, 13, 1, -14 },
  { 358, 11, 14, 13, 1, -14 },
  { 378, 11, 14, 13, 1, -14 },
  { 398, 3, 12, 13, 5, -12 },
  { 403, 6, 16, 13, 3, -12 },
  { 415, 11, 12, 13, 1, -13 },
  { 432, 11, 7, 13, 1, -10 },
  { 442, 11, 12, 13, 1, -13 },
  { 459, 11, 14, 13, 1, -14 },
  { 479, 13, 19, 13, 0, -16 },
  { 510, 13, 14, 13, 0, -14 },
  { 533, 12, 14, 13, 1, -14 },
  { 554, 12, 14, 13, 1, -14 },
  { 575, 11, 14, 13, 1, -14 },
  { 595, 11, 14, 13, 1, -14 },
  { 615, 10, 14, 13, 2, -14 },
  { 633, 11, 14, 13, 1, -14 },
  { 653, 11, 14, 13, 1, -14 },
  { 673, 10, 14, 13, 2, -14 },
  { 691, 10, 14, 13, 1, -14 },
  { 709, 12, 14, 13, 1, -14 },
  { 730, 10, 14, 13, 2, -14 },
  { 748, 11, 14, 13, 1, -14 },
  { 768, 11, 14, 13, 1, -14 },
  { 788, 11, 14, 13, 1, -14 },
  { 808, 11, 14, 13, 1, -14 },
  { 828, 12, 19, 13, 1, -14 },
  { 857, 12, 14, 13, 1, -14 },
  { 878, 13, 14, 13, 0, -14 },
  { 901, 12, 14, 13, 1, -14 },
  { 922, 11, 14, 13, 1, -14 },
  { 942, 13, 14, 13, 0, -14 },
  { 965, 13, 14, 13, 0, -14 },
  { 988, 13, 14, 13, 0, -14 },
  { 1011, 13, 14, 13, 0, -14 },
  { 1034, 11, 14, 13, 1, -14 },
  { 1054, 6, 21, 13, 4, -16 },
  { 1070, 11, 16, 13, 1, -16 },
  { 1092, 6, 21, 13, 3, -16 },
  { 1108, 12, 10, 13, 0, -14 },
  { 1123, 13, 1, 13, 0, 1 },
  { 1125, 5, 3, 13, 4, -16 },
  { 1127, 12, 12, 13, 1, -12 },
  { 1145, 11, 16, 13, 1, -16 },
  { 1167, 11, 12, 13, 1, -12 },
  { 1184, 11, 16, 13, 1, -16 },
  { 1206, 11, 12, 13, 1, -12 },
  { 1223, 11, 16, 13, 1, -16 },
  { 1245, 11, 17, 13, 1, -12 },
  { 1269, 10, 16, 13, 2, -16 },
  { 1289, 11, 16, 13, 1, -16 },
  { 1311, 8, 21, 13, 1, -16 },
  { 1332, 11, 16, 13, 2, -16 },
  { 1354, 11, 16, 13, 1, -16 },
  { 1376, 11, 12, 13, 1, -12 },
  { 1393, 11, 12, 13, 1, -12 },
  { 1410, 11, 12, 13, 1, -12 },
  { 1427, 11, 17, 13, 1, -12 },
  { 1451, 11, 17, 13, 1, -12 },
  { 1475, 10, 12, 13, 2, -12 },
  { 1490, 11, 12, 13, 1, -12 },
  { 1507, 9, 15, 13, 2, -15 },
  { 1524, 11, 12, 13, 1, -12 },
  { 1541, 13, 12, 13, 0, -12 },
  { 1561, 13, 12, 13, 0, -12 },
  { 1581, 12, 12, 13, 1, -12 },
  { 1599, 13, 17, 13, 0, -12 },
  { 1627, 11, 12, 13, 1, -12 },
  { 1644, 9, 21, 13, 2, -16 },
  { 1668, 3, 21, 13, 5, -16 },
  { 1676, 9, 21, 13, 2, -16 },
  { 1700, 11, 4, 13, 1, -9 },
};

const GFXfont LiberationMono_Bold22pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold22pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold22pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _LIBERATIONMONO_BOLD22PT7B_H_
