#ifndef _LIBERATIONMONO_BOLD14PT7B_H_
#define _LIBERATIONMONO_BOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xDC, 0xE7, 0x20, 0x12, 0x12, 0x7F, 0x24, 0x24,
  0xFF, 0x24, 0x4C, 0x48, 0x08, 0x3E, 0x6B, 0x68, 0x68, 0x3C, 0x0B, 0x0B,
  0x4B, 0x7E, 0x08, 0x63, 0x92, 0x94, 0x9C, 0x6F, 0x15, 0x2D, 0x65, 0x47,
  0x3C, 0x24, 0x24, 0x38, 0x73, 0xDA, 0xCE, 0xCE, 0x7B, 0xFF, 0x36, 0x66,
  0x4C, 0xCC, 0x46, 0x66, 0x30, 0xC6, 0x63, 0x33, 0x33, 0x33, 0x66, 0xC0,
  0x11, 0x77, 0x8E, 0x48, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x00, 0x7B,
  0x40, 0xF0, 0xF0, 0x06, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0xC1, 0x00,
  0x79, 0x9B, 0x17, 0xBF, 0x78, 0xF1, 0x66, 0x78, 0x18, 0x73, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0xFE, 0x79, 0x98, 0x30, 0x61, 0xC7, 0x18, 0x60, 0xFE,
  0x79, 0x98, 0x30, 0x63, 0x81, 0x81, 0xE6, 0x7C, 0x0E, 0x0E, 0x1E, 0x36,
  0x66, 0x46, 0xFF, 0x06, 0x06, 0xFD, 0x83, 0x07, 0xCC, 0xC0, 0xC1, 0xE6,
  0x78, 0x78, 0x9B, 0x07, 0xEC, 0xD8, 0xF1, 0xA6, 0x38, 0xFC, 0x30, 0x86,
  0x30, 0xC3, 0x18, 0x60, 0x79, 0x9B, 0x36, 0x63, 0x99, 0xB1, 0xE6, 0x7C,
  0x79, 0x9B, 0x36, 0x3C, 0xEE, 0x83, 0x66, 0x78, 0xF0, 0x3C, 0x66, 0x00,
  0x06, 0x64, 0xC0, 0x02, 0x39, 0x84, 0x06, 0x03, 0x80, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x80, 0xC0, 0x60, 0x31, 0x8C, 0x20, 0x00, 0x3C, 0x66, 0x63,
  0x06, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x1C, 0x22, 0x41, 0x5B, 0xB5, 0xA5,
  0xA5, 0xAD, 0xB6, 0x40, 0x62, 0x3C, 0x1C, 0x1C, 0x3C, 0x36, 0x26, 0x7E,
  0x63, 0x43, 0xC3, 0xFD, 0x9B, 0x1E, 0x6F, 0x98, 0xF1, 0xE3, 0xFC, 0x79,
  0x9B, 0x1E, 0x0C, 0x18, 0x31, 0xE6, 0x78, 0xF9, 0x9B, 0x1E, 0x3C, 0x78,
  0xF1, 0xE6, 0xF8, 0xFF, 0x83, 0x06, 0x0F, 0xD8, 0x30, 0x60, 0xFE, 0xFF,
  0x83, 0x06, 0x0F, 0xD8, 0x30, 0x60, 0xC0, 0x79, 0x9B, 0x16, 0x0D, 0xF8,
  0xF1, 0xE3, 0x78, 0xCF, 0x3C, 0xF3, 0xFF, 0x3C, 0xF3, 0xCC, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x3C, 0x30, 0xC3, 0x0C, 0x3C, 0xF3, 0x78,
  0xC7, 0x9B, 0x67, 0x8F, 0x9B, 0x33, 0x66, 0xC6, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xFE, 0xCF, 0x9F, 0xBD, 0x7B, 0xF6, 0xED, 0xC3, 0x86,
  0xC7, 0x9E, 0x7D, 0xF7, 0x5D, 0xF3, 0xCC, 0x3C, 0x66, 0x63, 0x63, 0xE3,
  0x63, 0x63, 0x66, 0x3C, 0xFD, 0x8F, 0x1E, 0x7F, 0xD8, 0x30, 0x60, 0xC0,
  0x3C, 0x66, 0x63, 0x63, 0xE3, 0x63, 0x63, 0x66, 0x3C, 0x18, 0x0C, 0x07,
  0xFD, 0x8F, 0x1E, 0x3F, 0xDB, 0x33, 0x67, 0xC6, 0x3C, 0x66, 0x63, 0x70,
  0x3E, 0x07, 0xC3, 0x63, 0x3E, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0x66, 0x78, 0xC3, 0x63,
  0x63, 0x66, 0x36, 0x34, 0x3C, 0x1C, 0x18, 0xC1, 0xC3, 0xC3, 0x5B, 0x5B,
  0x5F, 0x56, 0x76, 0x66, 0x63, 0x66, 0x3C, 0x1C, 0x18, 0x3C, 0x36, 0x66,
  0xC3, 0xC3, 0x63, 0x66, 0x36, 0x3C, 0x18, 0x18, 0x18, 0x18, 0xFE, 0x18,
  0x60, 0xC3, 0x0E, 0x18, 0x60, 0xFE, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0x81, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x0C, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xF0, 0x18, 0x3C, 0x24, 0x66, 0x62, 0x43, 0xFF,
  0x63, 0x79, 0x98, 0x33, 0xEC, 0xD9, 0xBD, 0x80, 0xC1, 0x83, 0x07, 0xEC,
  0xD8, 0xF1, 0xE3, 0xCD, 0xF8, 0x79, 0x9B, 0x06, 0x0C, 0x19, 0x9E, 0x00,
  0x0C, 0x30, 0xDF, 0xCF, 0x3C, 0xF3, 0xCD, 0xD0, 0x79, 0x9B, 0x1F, 0xFC,
  0x18, 0x9E, 0x00, 0x3E, 0x60, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x77, 0x9F, 0x1E, 0x3C, 0x79, 0xDD, 0x83, 0xCC, 0xF0, 0xC1, 0x83, 0x07,
  0xEC, 0xD8, 0xF1, 0xE3, 0xC7, 0x8C, 0x30, 0x00, 0x03, 0x83, 0x06, 0x0C,
  0x18, 0x31, 0xFC, 0x18, 0x00, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x00,
  0xC1, 0x83, 0x06, 0x6D, 0x9E, 0x3E, 0x6C, 0xCD, 0x8C, 0x70, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x31, 0xFC, 0xF7, 0x5B, 0x5B, 0x5B, 0x5B, 0x5B,
  0x5B, 0xFD, 0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0x80, 0x79, 0x9B, 0x1E, 0x3C,
  0x79, 0x9E, 0x00, 0xFD, 0x9B, 0x1E, 0x3C, 0x79, 0xBF, 0x60, 0xC1, 0x80,
  0x77, 0x3C, 0xF3, 0xCF, 0x37, 0xC3, 0x0C, 0x30, 0xDD, 0x46, 0x18, 0x61,
  0x86, 0x00, 0x79, 0x9B, 0x83, 0xE0, 0xF8, 0x9F, 0x00, 0x21, 0x8F, 0xD8,
  0x61, 0x86, 0x18, 0x3C, 0xCF, 0x3C, 0xF3, 0xCF, 0x37, 0x40, 0xC3, 0x63,
  0x66, 0x26, 0x34, 0x3C, 0x1C, 0xC1, 0xC1, 0x5B, 0x5B, 0x56, 0x66, 0x66,
  0x63, 0x66, 0x34, 0x18, 0x3C, 0x26, 0x63, 0xC3, 0x63, 0x66, 0x36, 0x34,
  0x1C, 0x18, 0x18, 0x18, 0x70, 0xFC, 0x71, 0x8C, 0x63, 0x8F, 0xC0, 0x3C,
  0xC3, 0x0C, 0x30, 0xCC, 0x0C, 0x30, 0xC3, 0x0C, 0x3C, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x41, 0x86, 0x18, 0x60, 0xC6, 0x18, 0x61, 0x84, 0xF0, 0xE2,
  0x3C,
};

const GFXglyph LiberationMono_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 5, 4, 8, 2, -10 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 8, 11, 8, 0, -10 },
  { 27, 8, 9, 8, 0, -9 },
  { 36, 8, 9, 8, 0, -9 },
  { 45, 2, 4, 8, 3, -10 },
  { 46, 4, 13, 8, 2, -10 },
  { 53, 4, 13, 8, 2, -10 },
  { 60, 6, 5, 8, 1, -10 },
  { 64, 7, 7, 8, 1, -8 },
  { 71, 3, 4, 8, 2, -2 },
  { 73, 4, 1, 8, 2, -4 },
  { 74, 2, 2, 8, 3, -2 },
  { 75, 7, 10, 8, 1, -10 },
  { 84, 7, 9, 8, 1, -9 },
  { 92, 7, 9, 8, 1, -9 },
  { 100, 7, 9, 8, 1, -9 },
  { 108, 7, 9, 8, 1, -9 },
  { 116, 8, 9, 8, 0, -9 },
  { 125, 7, 9, 8, 1, -9 },
  { 133, 7, 9, 8, 1, -9 },
  { 141, 6, 9, 8, 1, -9 },
  { 148, 7, 9, 8, 1, -9 },
  { 156, 7, 9, 8, 1, -9 },
  { 164, 2, 7, 8, 3, -7 },
  { 166, 4, 9, 8, 2, -7 },
  { 171, 7, 7, 8, 1, -8 },
  { 178, 7, 4, 8, 1, -6 },
  { 182, 7, 7, 8, 1, -8 },
  { 189, 8, 9, 8, 0, -9 },
  { 198, 8, 12, 8, 0, -10 },
  { 210, 8, 9, 8, 0, -9 },
  { 219, 7, 9, 8, 1, -9 },
  { 227, 7, 9, 8, 1, -9 },
  { 235, 7, 9, 8, 1, -9 },
  { 243, 7, 9, 8, 1, -9 },
  { 251, 7, 9, 8, 1, -9 },
  { 259, 7, 9, 8, 1, -9 },
  { 267, 6, 9, 8, 1, -9 },
  { 274, 6, 9, 8, 1, -9 },
  { 281, 6, 9, 8, 1, -9 },
  { 288, 7, 9, 8, 1, -9 },
  { 296, 7, 9, 8, 1, -9 },
  { 304, 7, 9, 8, 1, -9 },
  { 312, 6, 9, 8, 1, -9 },
  { 319, 8, 9, 8, 0, -9 },
  { 328, 7, 9, 8, 1, -9 },
  { 336, 8, 12, 8, 0, -9 },
  { 348, 7, 9, 8, 1, -9 },
  { 356, 8, 9, 8, 0, -9 },
  { 365, 8, 9, 8, 0, -9 },
  { 374, 7, 9, 8, 1, -9 },
  { 382, 8, 9, 8, 0, -9 },
  { 391, 8, 9, 8, 0, -9 },
  { 400, 8, 9, 8, 0, -9 },
  { 409, 8, 9, 8, 0, -9 },
  { 418, 7, 9, 8, 1, -9 },
  { 426, 4, 13, 8, 3, -10 },
  { 433, 7, 10, 8, 1, -10 },
  { 442, 4, 13, 8, 2, -10 },
  { 449, 8, 6, 8, 0, -9 },
  { 455, 8, 1, 8, 0, 1 },
  { 456, 4, 2, 8, 2, -10 },
  { 457, 7, 7, 8, 1, -7 },
  { 464, 7, 10, 8, 1, -10 },
  { 473, 7, 7, 8, 1, -7 },
  { 480, 6, 10, 8, 1, -10 },
  { 488, 7, 7, 8, 1, -7 },
  { 495, 7, 10, 8, 1, -10 },
  { 504, 7, 10, 8, 1, -7 },
  { 513, 7, 10, 8, 1, -10 },
  { 522, 7, 10, 8, 1, -10 },
  { 531, 5, 13, 8, 1, -10 },
  { 540, 7, 10, 8, 1, -10 },
  { 549, 7, 10, 8, 1, -10 },
  { 558, 8, 7, 8, 0, -7 },
  { 565, 7, 7, 8, 1, -7 },
  { 572, 7, 7, 8, 1, -7 },
  { 579, 7, 10, 8, 1, -7 },
  { 588, 6, 10, 8, 1, -7 },
  { 596, 6, 7, 8, 1, -7 },
  { 602, 7, 7, 8, 1, -7 },
  { 609, 6, 9, 8, 1, -9 },
  { 616, 6, 7, 8, 1, -7 },
  { 622, 8, 7, 8, 0, -7 },
  { 629, 8, 7, 8, 0, -7 },
  { 636, 8, 7, 8, 0, -7 },
  { 643, 8, 10, 8, 0, -7 },
  { 653, 6, 7, 8, 1, -7 },
  { 659, 6, 13, 8, 1, -10 },
  { 669, 2, 13, 8, 3, -10 },
  { 673, 6, 13, 8, 1, -10 },
  { 683, 7, 2, 8, 1, -6 },
};

const GFXfont LiberationMono_Bold14pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold14pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _LIBERATIONMONO_BOLD14PT7B_H_
