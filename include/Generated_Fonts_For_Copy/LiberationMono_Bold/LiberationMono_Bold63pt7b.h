#ifndef _LIBERATIONMONO_BOLD63PT7B_H_
#define _LIBERATIONMONO_BOLD63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE,
  0x7B, 0xFF, 0x87, 0xFC, 0x3C, 0x7F, 0xC3, 0xFC, 0x1E, 0x1F, 0xF1, 0xFE,
  0x0F, 0x0F, 0xF8, 0xFF, 0x07, 0x83, 0xFC, 0x7F, 0x83, 0xC1, 0xFE, 0x3F,
  0xC1, 0xE0, 0xF0, 0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x07,
  0xFE, 0x3C, 0x00, 0x01, 0xFF, 0xDE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0x3F, 0xF8, 0x00, 0x07, 0x87,
  0xFE, 0x00, 0x03, 0xC1, 0xFF, 0x00, 0x01, 0xE0, 0x7F, 0x83, 0x80, 0xF0,
  0x3F, 0xFF, 0xC0, 0x78, 0x1F, 0xFF, 0xF0, 0x3C, 0x0F, 0xF7, 0xF8, 0x1E,
  0x07, 0xFB, 0xFC, 0x0F, 0x03, 0xFD, 0xFF, 0x07, 0x83, 0xFE, 0x7F, 0xC3,
  0xC3, 0xFF, 0x3F, 0xF9, 0xE7, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xC3, 0xFF, 0xE0, 0x00, 0x3E, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x7E,
  0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0xF8, 0x01,
  0xF0, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x0F, 0x80, 0x0F, 0xC0,
  0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x8F, 0x80,
  0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x03, 0xFF, 0xE1, 0xF0, 0x00, 0x07, 0xFF,
  0x0F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0x8F, 0xFF, 0xC0, 0x00, 0x7E, 0x3F, 0xFF,
  0x00, 0x03, 0xF1, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0x7E,
  0x1F, 0x03, 0xE0, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x3F,
  0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x83, 0xF0, 0x01,
  0xF8, 0x7E, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x7C, 0x00, 0x07, 0xFF, 0x83,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0x8F, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0x7F, 0x01, 0xF8, 0x1F, 0xF3, 0xFC,
  0x0F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xF0, 0x7F,
  0x81, 0xFE, 0x7F, 0x03, 0xF8, 0x07, 0xFB, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF,
  0x80, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x80,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x20, 0x7E, 0x04, 0x78, 0x7E, 0x1C, 0x7E, 0x7E, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x1F, 0xE7, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xFC, 0x1F,
  0x81, 0xF0, 0x07, 0x00, 0xE0, 0x01, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFB,
  0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0xFC, 0x7F, 0xFF, 0xC3,
  0xF1, 0xFF, 0xFF, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F, 0x1F, 0xFF, 0xF0, 0xFC,
  0x7F, 0xFF, 0xC3, 0xF1, 0xFF, 0xFF, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFB, 0xFC, 0x00, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xCF, 0xF0, 0x03, 0xFE,
  0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x1F,
  0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x07,
  0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xF8, 0x1F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xCF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFE,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFC,
  0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00,
  0x7F, 0x9F, 0xF0, 0x01, 0xC0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x03,
  0xFC, 0x3F, 0xFC, 0x0F, 0xF3, 0xFF, 0xFC, 0x3F, 0xDF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0xBF, 0xF8,
  0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFC,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF9,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF1, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xCF,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xEF, 0xF8, 0x0F, 0xFF, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x03, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0,
  0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x03,
  0xC1, 0xF0, 0x3F, 0xC7, 0xBC, 0x1E, 0x07, 0xFE, 0x79, 0xE3, 0xE0, 0xFF,
  0xEF, 0x9E, 0x3C, 0x1F, 0x8F, 0xF1, 0xE3, 0xC1, 0xF0, 0x7F, 0x1E, 0x3C,
  0x3E, 0x03, 0xF1, 0xE7, 0xC3, 0xE0, 0x3F, 0x1E, 0x78, 0x7C, 0x03, 0xF1,
  0xF7, 0x87, 0xC0, 0x3E, 0x0F, 0x78, 0x78, 0x03, 0xE0, 0xF7, 0x8F, 0x80,
  0x3E, 0x0F, 0x78, 0xF8, 0x03, 0xE0, 0xF7, 0x8F, 0x80, 0x3E, 0x1F, 0xF8,
  0xF8, 0x03, 0xE1, 0xEF, 0x8F, 0x00, 0x3C, 0x1E, 0xF8, 0xF0, 0x07, 0xC1,
  0xEF, 0x8F, 0x00, 0x7C, 0x1E, 0xF8, 0xF0, 0x07, 0xC1, 0xEF, 0x8F, 0x00,
  0x7C, 0x1E, 0xF8, 0xF0, 0x07, 0x81, 0xEF, 0x8F, 0x00, 0xF8, 0x3C, 0x78,
  0xF8, 0x0F, 0x83, 0xC7, 0x8F, 0x81, 0xF8, 0x3C, 0x78, 0xF8, 0x1F, 0x87,
  0x87, 0x8F, 0x83, 0xB8, 0x78, 0x78, 0x7C, 0x7B, 0x8F, 0x87, 0xC7, 0xFF,
  0x3F, 0xF0, 0x3C, 0x3F, 0xE3, 0xFE, 0x03, 0xC1, 0xFC, 0x1F, 0xC0, 0x3E,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x08, 0x00, 0xFC, 0x00,
  0x01, 0xC0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0x3F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x00,
  0xFE, 0x1F, 0xF8, 0x00, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1C, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xF9,
  0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x03,
  0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x7F,
  0xF3, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC7, 0xFC, 0x00,
  0x3F, 0xC7, 0xFE, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xDF,
  0xF0, 0x3F, 0xFF, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F,
  0xE3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x38, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x0F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xFC, 0x3F,
  0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE1, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xF0, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF3,
  0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFD, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC,
  0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xFE, 0x3F, 0x7F, 0xFE, 0x7E,
  0x7E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E,
  0x7E, 0x7F, 0xFE, 0x3F, 0x7C, 0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F,
  0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xBF, 0x80, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFB,
  0xFC, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xDF, 0xC0, 0xFF, 0xFF, 0x7F,
  0x83, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xF3, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0,
  0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xF0, 0xFE, 0x3F,
  0xFF, 0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xF3, 0xFF, 0xFC, 0x1F, 0xCF, 0xFF,
  0xF0, 0x7F, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x03, 0xFB, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0,
  0x1F, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F,
  0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF,
  0x8F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF,
  0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3E, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x3C,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD,
  0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0xC0, 0x3F,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xFF, 0x1F,
  0xE0, 0x7F, 0x9F, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0xF9, 0xFC, 0x03, 0xF9,
  0xFF, 0xE7, 0xF0, 0x0F, 0xEF, 0xDF, 0x9F, 0xC0, 0x3F, 0xBF, 0x3F, 0x7F,
  0x00, 0xFE, 0xFC, 0xFD, 0xFC, 0x03, 0xFB, 0xF3, 0xF7, 0xF0, 0x0F, 0xFF,
  0x8F, 0xDF, 0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xFF, 0xDF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFF, 0xF0, 0x1F, 0xE3, 0xFF, 0xF0, 0x3F, 0xCF, 0xFF, 0xF0, 0x7F,
  0xBF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF,
  0x80, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF0,
  0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01,
  0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0xFF,
  0x9F, 0xF8, 0x03, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF9,
  0xFF, 0x7F, 0xFF, 0xE3, 0xFE, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0xFF, 0x0F,
  0xF8, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x7F,
  0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xF8, 0x7F, 0x81, 0xFF,
  0xF8, 0xFF, 0x07, 0xFF, 0xF9, 0xFE, 0x1F, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF,
  0xF7, 0xF8, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xE7, 0xFE, 0x00,
  0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD,
  0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x1F,
  0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0xF7, 0xF8, 0x7F,
  0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x9F, 0xE0, 0x7F, 0xFE, 0x3F, 0xC0, 0x7F,
  0xF8, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFE, 0x3F, 0xC3, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xFB,
  0xFC, 0xFF, 0xFF, 0xEF, 0xF3, 0xFF, 0x87, 0xFF, 0xDF, 0xF8, 0x07, 0xFF,
  0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xCF,
  0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0xFB, 0xFC, 0x7F, 0xFF, 0xEF, 0xF0, 0xFF,
  0xFF, 0x7F, 0xC3, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0x87, 0xFC, 0x03, 0xF8,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFE,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0xFE, 0x03, 0xFE, 0x0F, 0xFF, 0x0F, 0xF8, 0xFF, 0xFE, 0x3F,
  0xE7, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xC3, 0xFF, 0xBF, 0xFC, 0x03, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xEC, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF,
  0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFB, 0xFE,
  0x00, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xF1,
  0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x3F,
  0x9F, 0xF0, 0xFF, 0x8F, 0xEF, 0xFC, 0x7F, 0xF3, 0xFB, 0xFF, 0x9F, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xF3, 0xFB, 0x9F, 0xEF, 0xF8, 0x7F, 0xC3,
  0xFB, 0xFC, 0x1F, 0xE0, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0xBF, 0xC1, 0xFE,
  0x0F, 0xEF, 0xF0, 0x7F, 0x83, 0xFB, 0xFC, 0x1F, 0xE0, 0xFE, 0xFE, 0x07,
  0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8,
  0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0,
  0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x0F, 0xFE, 0x0F, 0xF8, 0xFF, 0xFE, 0x3F, 0xE7, 0xFF, 0xFC, 0xFF,
  0xBF, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xC3, 0xFF, 0xBF, 0xFC,
  0x03, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0x07,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00,
  0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0xFF,
  0xC7, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xEF, 0xFF, 0xFC,
  0x3F, 0xCF, 0xFF, 0xF0, 0x7F, 0x8F, 0xFF, 0xC0, 0xFF, 0x0F, 0xFE, 0x01,
  0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xF8, 0x1F,
  0xFF, 0x8F, 0xF0, 0x7F, 0xFF, 0x9F, 0xE1, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF,
  0xFF, 0x7F, 0x8F, 0xFE, 0x1F, 0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF1,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0x87,
  0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xE3, 0xFC, 0x07,
  0xFF, 0x87, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0xC7, 0xFF, 0xF7, 0xF9, 0xFF, 0xFE, 0xFF,
  0x3F, 0xFF, 0xDF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x38,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xE0,
  0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x06, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x01,
  0xFF, 0xDF, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xEF, 0xF3, 0xFF, 0xFE, 0x7F,
  0x9F, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0x1F, 0xE1, 0xFF, 0xF0, 0xFF, 0x07,
  0xFE, 0x07, 0xF8, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0xE0, 0x7E,
  0x0F, 0xC1, 0xFF, 0x87, 0xF0, 0x7E, 0x0F, 0xFC, 0x3F, 0x83, 0xF0, 0x7F,
  0xE1, 0xFC, 0x1F, 0xC7, 0xFF, 0x8F, 0xE0, 0xFE, 0x3E, 0xFC, 0x7E, 0x03,
  0xF1, 0xF3, 0xE3, 0xF0, 0x1F, 0x9F, 0x9F, 0x1F, 0x80, 0xFC, 0xF8, 0xFD,
  0xFC, 0x07, 0xE7, 0xC3, 0xEF, 0xE0, 0x3F, 0x7E, 0x1F, 0x7E, 0x01, 0xFB,
  0xE0, 0xFF, 0xF0, 0x07, 0xDF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xF0,
};

const GFXglyph LiberationMono_Bold63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 9, 42, 38, 14, -42 },
  { 49, 22, 19, 38, 8, -46 },
  { 102, 34, 42, 38, 2, -42 },
  { 281, 33, 52, 38, 2, -47 },
  { 496, 38, 44, 38, 0, -43 },
  { 705, 37, 44, 38, 1, -43 },
  { 909, 8, 19, 38, 15, -46 },
  { 928, 17, 59, 38, 11, -46 },
  { 1054, 18, 59, 38, 9, -46 },
  { 1187, 24, 23, 38, 7, -46 },
  { 1256, 32, 33, 38, 3, -37 },
  { 1388, 15, 20, 38, 8, -9 },
  { 1426, 18, 8, 38, 10, -20 },
  { 1444, 9, 9, 38, 14, -9 },
  { 1455, 32, 47, 38, 3, -46 },
  { 1643, 30, 44, 38, 4, -43 },
  { 1808, 31, 42, 38, 4, -42 },
  { 1971, 30, 43, 38, 4, -43 },
  { 2133, 32, 44, 38, 3, -43 },
  { 2309, 34, 42, 38, 2, -42 },
  { 2488, 32, 43, 38, 3, -42 },
  { 2660, 30, 44, 38, 4, -43 },
  { 2825, 30, 42, 38, 4, -42 },
  { 2983, 31, 44, 38, 3, -43 },
  { 3154, 31, 44, 38, 3, -43 },
  { 3325, 9, 33, 38, 14, -33 },
  { 3363, 15, 44, 38, 10, -33 },
  { 3446, 32, 34, 38, 3, -38 },
  { 3582, 32, 24, 38, 3, -33 },
  { 3678, 32, 34, 38, 3, -38 },
  { 3814, 32, 43, 38, 2, -43 },
  { 3986, 36, 55, 38, 1, -46 },
  { 4234, 38, 42, 38, 0, -42 },
  { 4434, 32, 42, 38, 4, -42 },
  { 4602, 34, 44, 38, 2, -43 },
  { 4789, 31, 42, 38, 4, -42 },
  { 4952, 31, 42, 38, 4, -42 },
  { 5115, 29, 42, 38, 5, -42 },
  { 5268, 33, 44, 38, 2, -43 },
  { 5450, 30, 42, 38, 4, -42 },
  { 5608, 28, 42, 38, 5, -42 },
  { 5755, 28, 43, 38, 3, -42 },
  { 5906, 34, 42, 38, 4, -42 },
  { 6085, 29, 42, 38, 6, -42 },
  { 6238, 32, 42, 38, 3, -42 },
  { 6406, 30, 42, 38, 4, -42 },
  { 6564, 34, 44, 38, 2, -43 },
  { 6751, 31, 42, 38, 4, -42 },
  { 6914, 34, 55, 38, 2, -43 },
  { 7148, 34, 42, 38, 4, -42 },
  { 7327, 35, 44, 38, 1, -43 },
  { 7520, 34, 42, 38, 2, -42 },
  { 7699, 30, 43, 38, 4, -42 },
  { 7861, 38, 42, 38, 0, -42 },
  { 8061, 38, 42, 38, 0, -42 },
  { 8261, 38, 42, 38, 0, -42 },
  { 8461, 38, 42, 38, 0, -42 },
  { 8661, 32, 42, 38, 3, -42 },
  { 8829, 19, 59, 38, 11, -46 },
  { 8970, 32, 47, 38, 3, -46 },
  { 9158, 18, 59, 38, 8, -46 },
  { 9291, 34, 28, 38, 1, -43 },
  { 9410, 38, 3, 38, 0, 4 },
  { 9425, 15, 8, 38, 11, -44 },
  { 9440, 33, 35, 38, 3, -34 },
  { 9585, 31, 47, 38, 4, -46 },
  { 9768, 31, 35, 38, 3, -34 },
  { 9904, 31, 47, 38, 3, -46 },
  { 10087, 32, 35, 38, 3, -34 },
  { 10227, 31, 47, 38, 4, -47 },
  { 10410, 30, 47, 38, 4, -34 },
  { 10587, 30, 46, 38, 4, -46 },
  { 10760, 31, 46, 38, 4, -46 },
  { 10939, 23, 59, 38, 4, -46 },
  { 11109, 31, 46, 38, 5, -46 },
  { 11288, 31, 46, 38, 4, -46 },
  { 11467, 34, 34, 38, 2, -34 },
  { 11612, 30, 34, 38, 4, -34 },
  { 11740, 32, 35, 38, 3, -34 },
  { 11880, 31, 47, 38, 4, -34 },
  { 12063, 31, 47, 38, 3, -34 },
  { 12246, 27, 34, 38, 6, -34 },
  { 12361, 30, 35, 38, 4, -34 },
  { 12493, 27, 43, 38, 5, -42 },
  { 12639, 29, 34, 38, 4, -33 },
  { 12763, 36, 33, 38, 1, -33 },
  { 12912, 37, 33, 38, 0, -33 },
  { 13065, 35, 33, 38, 1, -33 },
  { 13210, 36, 46, 38, 1, -33 },
  { 13417, 29, 33, 38, 4, -33 },
  { 13537, 26, 59, 38, 6, -46 },
  { 13729, 8, 60, 38, 15, -46 },
  { 13789, 26, 59, 38, 6, -46 },
  { 13981, 32, 10, 38, 3, -26 },
};

const GFXfont LiberationMono_Bold63pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold63pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold63pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _LIBERATIONMONO_BOLD63PT7B_H_
