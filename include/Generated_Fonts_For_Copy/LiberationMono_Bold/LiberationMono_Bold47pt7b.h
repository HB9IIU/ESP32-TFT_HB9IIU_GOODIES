#ifndef _LIBERATIONMONO_BOLD47PT7B_H_
#define _LIBERATIONMONO_BOLD47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7,
  0xE0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x07,
  0xDF, 0x03, 0xEF, 0x81, 0xF3, 0xC0, 0xF8, 0x00, 0x78, 0x0E, 0x00, 0x1C,
  0x07, 0x80, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00,
  0x3C, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03,
  0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0E, 0x03, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xF0, 0x1C, 0x00, 0x3C, 0x07,
  0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0x19, 0xFE, 0x7E, 0x18, 0xFE, 0x7E, 0x18, 0x7F, 0x7E, 0x18, 0x38,
  0x7E, 0x18, 0x00, 0x7F, 0x18, 0x00, 0x7F, 0x98, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x18, 0xFF, 0x00, 0x18, 0x3F, 0x00, 0x18, 0x3F,
  0x1C, 0x18, 0x3F, 0xFC, 0x18, 0x3F, 0xFC, 0x18, 0x3F, 0xFE, 0x18, 0x3F,
  0x7F, 0x98, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x03, 0xE3, 0xFE, 0x00,
  0x3C, 0x7F, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0xF0, 0xF8, 0x78, 0x0F, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x78, 0x0F, 0x07, 0x8F, 0x00, 0xF0, 0x78, 0xF0, 0x0F, 0x87, 0x9E, 0x00,
  0x78, 0xF3, 0xC0, 0x07, 0xFF, 0x7C, 0x00, 0x3F, 0xE7, 0x80, 0x00, 0xF8,
  0xF1, 0xF8, 0x00, 0x1E, 0x7F, 0xC0, 0x01, 0xEF, 0xFE, 0x00, 0x3C, 0xF1,
  0xE0, 0x07, 0x9F, 0x0F, 0x00, 0x79, 0xE0, 0xF0, 0x0F, 0x1E, 0x0F, 0x01,
  0xE1, 0xE0, 0xF0, 0x1E, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0xF0, 0x0F, 0x1E, 0x1E, 0x00, 0xFF, 0xE3,
  0xC0, 0x07, 0xFC, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xC1, 0xFF, 0xC0,
  0x78, 0x3F, 0xFC, 0x1F, 0x0F, 0xCF, 0x83, 0xE3, 0xF1, 0xF8, 0x7C, 0x7E,
  0x1F, 0x9F, 0x0F, 0x81, 0xFB, 0xE1, 0xF0, 0x3F, 0xFC, 0x3E, 0x03, 0xFF,
  0x07, 0xC0, 0x3F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x83, 0xFC,
  0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x1F,
  0xC0, 0xFE, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7,
  0xDF, 0x79, 0xE0, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x61, 0xE1, 0x9F, 0x79, 0xE7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0x3E, 0x0F, 0xCF, 0xC3, 0xE1,
  0xF0, 0x78, 0x38, 0x04, 0x08, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0xFC, 0xFE, 0x01,
  0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x8F, 0x9F, 0xBF, 0x1F, 0x3F, 0x7E, 0x3E, 0x7F, 0xFC, 0x7C, 0xFD,
  0xF8, 0xF9, 0xFB, 0xF1, 0xF3, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0xC0, 0x1F, 0xBF, 0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xBF, 0x80, 0xFC, 0x7F, 0x01, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0x7E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x7F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x83, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF8,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x0F, 0xCF, 0xFE, 0x1F, 0xBF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0x83, 0xFD, 0xFE, 0x03, 0xFB,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x3F, 0x01, 0xFC, 0x7F, 0x07, 0xF8, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x00,
  0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFE, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFB, 0xF0, 0xFF, 0xCF, 0xC0, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x7E, 0xFE, 0x03, 0xF9, 0xFC, 0x3F,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0xC1, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC1, 0xF0, 0x07, 0xC0, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x8F,
  0x07, 0xCF, 0xE3, 0x83, 0xFB, 0xBD, 0xE1, 0xFE, 0xE7, 0x70, 0xF1, 0xB9,
  0xDC, 0x78, 0x3E, 0x77, 0x1E, 0x0F, 0x9F, 0xC7, 0x03, 0xC7, 0xF3, 0xC0,
  0xF1, 0xF8, 0xF0, 0x3C, 0x7E, 0x38, 0x0F, 0x1F, 0x8E, 0x03, 0x87, 0xE7,
  0x80, 0xE1, 0xF9, 0xE0, 0x38, 0x7E, 0x78, 0x1E, 0x1F, 0x9E, 0x07, 0x87,
  0xE7, 0x81, 0xE3, 0xB8, 0xE0, 0xF0, 0xEE, 0x38, 0x3C, 0x3B, 0xCF, 0x1B,
  0x1C, 0x71, 0xFE, 0xFF, 0x1C, 0x7F, 0x3F, 0x87, 0x8F, 0x87, 0x80, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x01, 0xE0, 0x00, 0xC0,
  0x3C, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xF1, 0xFE, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x18, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0x83, 0xF8, 0x01, 0xFD, 0xFC,
  0x00, 0xFC, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xF0, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0x3F, 0x80, 0xFF, 0x7F,
  0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFE,
  0xFE, 0x03, 0xF9, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x60, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0xE1, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x7F, 0x03, 0xF9, 0xFC, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x87,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF3, 0xF8, 0x0F, 0xF1,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0xCF,
  0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFB, 0xC3, 0xFF, 0xFB, 0xC3, 0xDF, 0xFB, 0xE3,
  0xDF, 0xFB, 0xE7, 0xDF, 0xF9, 0xE7, 0xDF, 0xF9, 0xF7, 0x9F, 0xF9, 0xF7,
  0x9F, 0xF9, 0xF7, 0x9F, 0xF8, 0xFF, 0x9F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF,
  0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0x7F, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFB, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0x7C,
  0x3F, 0xFD, 0xF8, 0xFF, 0xF3, 0xE3, 0xFF, 0xCF, 0x8F, 0xFF, 0x3F, 0x3F,
  0xFC, 0x7C, 0xFF, 0xF1, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF, 0x0F, 0xBF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7D, 0xFF, 0xC1, 0xF7, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0,
  0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x81, 0xFE,
  0x1F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xC0, 0x7F,
  0xBF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x0F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F,
  0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x1F, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3E,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC7, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0x9F, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F,
  0x03, 0xF9, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x7F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0xF8, 0x7E, 0x3E, 0x1F, 0x87, 0xE3, 0xE1,
  0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xFC, 0x7C, 0x3F, 0x3F, 0xCF,
  0xC3, 0xF3, 0xFC, 0xFC, 0x1F, 0x3F, 0xEF, 0xC1, 0xF7, 0xFE, 0xF8, 0x1F,
  0x7D, 0xEF, 0x81, 0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xFF, 0x81, 0xFF, 0x9F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7F, 0x00, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE1, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0xFF, 0x0F, 0xC0, 0xFF, 0x87, 0xF0, 0xFF, 0xC3, 0xFF,
  0xF7, 0xFC, 0xFF, 0xF1, 0xFE, 0x3F, 0xF0, 0xFF, 0x07, 0xE0, 0x1F, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x3F, 0x03, 0xF9, 0xFF, 0x87, 0xF7, 0xFF, 0x8F, 0xFF,
  0xFF, 0x9F, 0xF8, 0x7F, 0x3F, 0xE0, 0x7F, 0x7F, 0x80, 0xFE, 0xFE, 0x00,
  0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF7, 0xF8, 0x0F, 0xEF, 0xF8, 0x1F, 0xDF,
  0xF8, 0x7F, 0x3F, 0xFF, 0xFE, 0x7F, 0x7F, 0xF8, 0xFE, 0x7F, 0xE1, 0xFC,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0x87, 0xF9, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0x7E, 0x3F, 0x87, 0xF8,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0xF3, 0xF8, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF,
  0xE7, 0xF8, 0xFF, 0xDF, 0xE0, 0x7F, 0xBF, 0x80, 0xFF, 0x7F, 0x00, 0xFE,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFC,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xE7, 0xF8,
  0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0x7F, 0x0F, 0xFC, 0x7E, 0x07, 0xE0,
  0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x7E, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x1F, 0xF9, 0xFC,
  0x7F, 0xFB, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0xCF, 0xE0, 0x7F, 0x9F,
  0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80,
  0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xFC, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x1F, 0xE7, 0xF8, 0x7F, 0xC7, 0xFF, 0xDF, 0x87, 0xFF, 0xBF,
  0x07, 0xFE, 0x7E, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE1, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0x1F, 0xE1, 0xFE, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x0F, 0xE3, 0xFF, 0x3F, 0x9F, 0xFE, 0xFE, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFA, 0x03, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F, 0x83,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF9, 0xFC,
  0x03, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7F, 0x9F, 0x80, 0xFE, 0x3F, 0x81, 0xF8, 0x3F, 0x83,
  0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x3F,
  0x00, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFC, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF1, 0xF0, 0x7C, 0xF3, 0xF8, 0xFE, 0xF7, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0x3F, 0xFC, 0x7F, 0x1F, 0xFC, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xFC, 0x0F, 0xC3, 0xF0, 0xFF, 0x8F, 0xC7, 0xFF,
  0x3F, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x1F, 0x81, 0xFC, 0xFF, 0xC3, 0xFB, 0xFF,
  0xC7, 0xFF, 0xFF, 0xCF, 0xFC, 0x3F, 0x9F, 0xF0, 0x3F, 0xBF, 0xC0, 0x7F,
  0x7F, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xFC, 0x07, 0xF7, 0xFC,
  0x0F, 0xEF, 0xFC, 0x3F, 0x9F, 0xFF, 0xFF, 0x3F, 0xBF, 0xFC, 0x7F, 0x3F,
  0xF0, 0xFE, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x7E,
  0x0F, 0xF8, 0xFC, 0x7F, 0xFB, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x7F, 0xEF,
  0xF0, 0x3F, 0xDF, 0xC0, 0x7F, 0xBF, 0x80, 0x7F, 0x7E, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFE, 0x01,
  0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x0F, 0xF3, 0xFC, 0x7F, 0xE7, 0xFF, 0xFF,
  0xC7, 0xFF, 0xBF, 0x87, 0xFE, 0x7F, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x0F,
  0x9F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0x7F, 0x01, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x10, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0x7F, 0xDF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xCF, 0xCF,
  0xFE, 0x3F, 0x0F, 0xF0, 0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xE1, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x0F, 0x03, 0xE3, 0xE1, 0xF8, 0x3E, 0x3E, 0x1F, 0x87, 0xC3, 0xE1,
  0xF8, 0x7C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE3, 0xFC, 0x7C, 0x3E, 0x3F, 0xC7,
  0xC1, 0xE3, 0xFE, 0x7C, 0x1E, 0x79, 0xE7, 0x81, 0xF7, 0x9E, 0xF8, 0x1F,
  0x79, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF7,
  0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xF0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xFC,
};

const GFXglyph LiberationMono_Bold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 31, 28, 11, -31 },
  { 25, 17, 14, 28, 6, -34 },
  { 55, 26, 31, 28, 1, -31 },
  { 156, 24, 38, 28, 2, -34 },
  { 270, 28, 31, 28, 0, -31 },
  { 379, 27, 31, 28, 1, -31 },
  { 484, 6, 14, 28, 11, -34 },
  { 495, 13, 44, 28, 8, -34 },
  { 567, 13, 44, 28, 7, -34 },
  { 639, 18, 17, 28, 5, -34 },
  { 678, 24, 23, 28, 2, -27 },
  { 747, 11, 15, 28, 6, -7 },
  { 768, 14, 6, 28, 7, -15 },
  { 779, 6, 7, 28, 11, -7 },
  { 785, 24, 34, 28, 2, -34 },
  { 887, 23, 31, 28, 3, -31 },
  { 977, 23, 31, 28, 3, -31 },
  { 1067, 22, 31, 28, 3, -31 },
  { 1153, 24, 31, 28, 2, -31 },
  { 1246, 25, 31, 28, 2, -31 },
  { 1343, 24, 31, 28, 2, -31 },
  { 1436, 23, 31, 28, 3, -31 },
  { 1526, 22, 31, 28, 3, -31 },
  { 1612, 24, 31, 28, 2, -31 },
  { 1705, 22, 31, 28, 3, -31 },
  { 1791, 6, 25, 28, 11, -25 },
  { 1810, 12, 33, 28, 7, -25 },
  { 1860, 24, 25, 28, 2, -28 },
  { 1935, 24, 17, 28, 2, -24 },
  { 1986, 24, 25, 28, 2, -28 },
  { 2061, 24, 31, 28, 2, -31 },
  { 2154, 26, 40, 28, 1, -34 },
  { 2284, 28, 31, 28, 0, -31 },
  { 2393, 24, 31, 28, 3, -31 },
  { 2486, 25, 31, 28, 2, -31 },
  { 2583, 23, 31, 28, 3, -31 },
  { 2673, 23, 31, 28, 3, -31 },
  { 2763, 21, 31, 28, 4, -31 },
  { 2845, 24, 31, 28, 2, -31 },
  { 2938, 22, 31, 28, 3, -31 },
  { 3024, 21, 31, 28, 4, -31 },
  { 3106, 21, 31, 28, 2, -31 },
  { 3188, 25, 31, 28, 3, -31 },
  { 3285, 21, 31, 28, 5, -31 },
  { 3367, 24, 31, 28, 2, -31 },
  { 3460, 22, 31, 28, 3, -31 },
  { 3546, 25, 31, 28, 2, -31 },
  { 3643, 23, 31, 28, 3, -31 },
  { 3733, 25, 40, 28, 2, -31 },
  { 3858, 25, 31, 28, 3, -31 },
  { 3955, 26, 31, 28, 1, -31 },
  { 4056, 26, 31, 28, 1, -31 },
  { 4157, 22, 31, 28, 3, -31 },
  { 4243, 28, 31, 28, 0, -31 },
  { 4352, 28, 31, 28, 0, -31 },
  { 4461, 28, 31, 28, 0, -31 },
  { 4570, 28, 31, 28, 0, -31 },
  { 4679, 24, 31, 28, 2, -31 },
  { 4772, 13, 44, 28, 9, -34 },
  { 4844, 24, 34, 28, 2, -34 },
  { 4946, 14, 44, 28, 6, -34 },
  { 5023, 25, 21, 28, 1, -31 },
  { 5089, 28, 2, 28, 0, 3 },
  { 5096, 12, 6, 28, 8, -33 },
  { 5105, 25, 25, 28, 2, -25 },
  { 5184, 23, 34, 28, 3, -34 },
  { 5282, 22, 25, 28, 3, -25 },
  { 5351, 23, 34, 28, 2, -34 },
  { 5449, 24, 25, 28, 2, -25 },
  { 5524, 23, 34, 28, 3, -34 },
  { 5622, 23, 35, 28, 3, -25 },
  { 5723, 22, 34, 28, 3, -34 },
  { 5817, 23, 34, 28, 3, -34 },
  { 5915, 17, 44, 28, 3, -34 },
  { 6009, 23, 34, 28, 4, -34 },
  { 6107, 23, 34, 28, 3, -34 },
  { 6205, 24, 25, 28, 2, -25 },
  { 6280, 22, 25, 28, 3, -25 },
  { 6349, 24, 25, 28, 2, -25 },
  { 6424, 23, 35, 28, 3, -25 },
  { 6525, 23, 35, 28, 2, -25 },
  { 6626, 20, 25, 28, 5, -25 },
  { 6689, 22, 25, 28, 3, -25 },
  { 6758, 20, 31, 28, 4, -31 },
  { 6836, 22, 25, 28, 3, -25 },
  { 6905, 26, 25, 28, 1, -25 },
  { 6987, 28, 25, 28, 0, -25 },
  { 7075, 26, 25, 28, 1, -25 },
  { 7157, 26, 35, 28, 1, -25 },
  { 7271, 22, 25, 28, 3, -25 },
  { 7340, 20, 44, 28, 4, -34 },
  { 7450, 6, 44, 28, 11, -34 },
  { 7483, 20, 44, 28, 4, -34 },
  { 7593, 24, 7, 28, 2, -19 },
};

const GFXfont LiberationMono_Bold47pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold47pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold47pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _LIBERATIONMONO_BOLD47PT7B_H_
