#ifndef _LIBERATIONMONO_BOLD37PT7B_H_
#define _LIBERATIONMONO_BOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC,
  0x3C, 0x01, 0xC1, 0xC0, 0x18, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x18, 0x03,
  0x83, 0x80, 0x38, 0x38, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x70, 0x70, 0x06, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0xE0, 0xE0,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xC1, 0xC0, 0x1C, 0x1C,
  0x01, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x38, 0x03, 0x83,
  0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x67, 0xE7, 0xC6, 0x3E, 0x7C, 0x63, 0xC7,
  0xC6, 0x00, 0x3F, 0x60, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x63, 0xE0, 0x06, 0x1F, 0x38, 0x61,
  0xFF, 0x86, 0x1F, 0x7C, 0x61, 0xF7, 0xE6, 0x3E, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0x00, 0x39, 0xFE, 0x01, 0xC7, 0x3C, 0x0E, 0x38, 0x70,
  0x78, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x0E, 0x1C, 0x78, 0x38, 0x71, 0xC0,
  0xE1, 0xCE, 0x01, 0xCF, 0x70, 0x07, 0xF9, 0xC0, 0x07, 0xCE, 0x00, 0x00,
  0x73, 0xF0, 0x03, 0xDF, 0xE0, 0x0E, 0xF3, 0xC0, 0x73, 0x87, 0x03, 0xCE,
  0x1C, 0x0E, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C,
  0x70, 0x1C, 0xF3, 0x80, 0x7F, 0x9E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1E,
  0x00, 0x70, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0xBF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x3C, 0x3F, 0xE0, 0xF0, 0xFB, 0xC3, 0xC7, 0xCF,
  0x9E, 0x1E, 0x1E, 0x78, 0xF8, 0x3D, 0xE3, 0xE0, 0xFF, 0x07, 0x81, 0xFC,
  0x1E, 0x03, 0xF0, 0x7E, 0x1F, 0xF4, 0xFF, 0xFF, 0xF1, 0xFF, 0xCF, 0xC1,
  0xFC, 0x0F, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x07, 0xC0, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x11,
  0xE2, 0x77, 0xBF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0xC0, 0x7F, 0x83,
  0xCF, 0x1F, 0x3E, 0x38, 0x70, 0x21, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x9E, 0x7F, 0xE7, 0x9F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x9E,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x81, 0xFD, 0xF0, 0x3F,
  0x3E, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0xBF,
  0x03, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80,
  0x3C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8,
  0x3C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0xDF,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x0F, 0x9F,
  0x03, 0xE7, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0xFC, 0x3E, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xFC, 0xFC, 0x7E, 0x3F, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F,
  0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0x7E, 0x1F, 0x8F, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBF, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0x7C, 0x3F, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE7, 0xC0,
  0xF9, 0xF0, 0x7C, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F,
  0x87, 0x87, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFC,
  0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0x87, 0x80, 0xE0, 0x1C, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0x67, 0x07, 0x3F, 0x71, 0xFB, 0xB6, 0x38, 0xB3, 0x63, 0x8F, 0x3E,
  0x70, 0x73, 0xE7, 0x07, 0x3E, 0x60, 0x73, 0xCE, 0x0E, 0x3C, 0xE0, 0xE3,
  0xCE, 0x0E, 0x3C, 0xE0, 0xE3, 0xCE, 0x0E, 0x3C, 0xE1, 0xC7, 0xCE, 0x1C,
  0x6E, 0xE1, 0xC6, 0xE7, 0x3C, 0xEE, 0x7E, 0x7C, 0x63, 0xC7, 0x87, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x08, 0x1C, 0x01, 0xC0, 0xE0, 0x78, 0x07,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01,
  0xF3, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xC1, 0xFD, 0xF8, 0x1F,
  0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x83, 0xF3, 0xFF, 0xFC,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xBF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x8F, 0xE7, 0xE0, 0x3E, 0x7E, 0x03,
  0xF7, 0xC0, 0x18, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1C, 0x7E,
  0x01, 0xF7, 0xE0, 0x3F, 0x3F, 0x03, 0xE3, 0xF8, 0x7E, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xC3, 0xF9, 0xF8, 0x3F, 0xBF, 0x03, 0xF7,
  0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x07, 0xDF,
  0x81, 0xFB, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xF0, 0xFC, 0xFC, 0x0F, 0x9F, 0x81, 0xFB, 0xE0, 0x18, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xDF, 0x0F, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0xC3, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xE0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x38, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7E, 0x3F, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E,
  0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xE7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1D, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0xFF, 0xF7, 0x3F, 0xFD, 0xEE, 0xFF, 0x7B, 0xBF, 0xDF, 0xEF, 0xF3, 0xFB,
  0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0xC7, 0xCF, 0xF1, 0xE3, 0xFC, 0x78, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFE, 0xF1, 0xFF,
  0xBE, 0x7F, 0xE7, 0x9F, 0xF9, 0xE7, 0xFE, 0x7D, 0xFF, 0x8F, 0x7F, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C,
  0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xC1, 0xFD, 0xF8, 0x0F, 0xBF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x3F, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xE0,
  0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xF8,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xF7, 0xF0, 0x7F,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F,
  0xDF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F,
  0x9F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x07,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x03, 0xEF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x79,
  0xE0, 0x01, 0xE7, 0xC0, 0x07, 0x9F, 0x1E, 0x1E, 0x7C, 0x78, 0xF8, 0xF1,
  0xF3, 0xE3, 0xCF, 0xCF, 0x8F, 0x3F, 0x3C, 0x3C, 0xFE, 0xF0, 0xF7, 0xFB,
  0xC3, 0xDF, 0xEF, 0x0F, 0xFB, 0xBC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xF8,
  0x3E, 0x03, 0xC0, 0xF0, 0x7E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x3F,
  0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xCF, 0x80, 0x3F, 0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x3F,
  0x03, 0xF0, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00,
  0xFD, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x03, 0xE0,
  0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7B,
  0xC0, 0x07, 0x9E, 0x00, 0xF9, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x38, 0x07, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x1F, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC1, 0xFC, 0xFC, 0x7F, 0x8F,
  0xFD, 0xFC, 0xFF, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF1, 0xF0,
  0xFB, 0xFE, 0x7F, 0xFF, 0xBF, 0x8F, 0xDF, 0x83, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7D, 0xFC, 0x7E, 0xFF, 0xFE,
  0x7D, 0xFE, 0x3E, 0x3E, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xF8, 0x7E, 0x7C, 0x0F, 0x9F, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0x3E, 0x1F, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x3F, 0x1F, 0xEF, 0xCF, 0xFF,
  0xF7, 0xE3, 0xFD, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xF7, 0xC1, 0xFD, 0xF8, 0xFF, 0x3F, 0xF7, 0xC7, 0xF9,
  0xF0, 0xF8, 0x7C, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x7E,
  0x7C, 0x0F, 0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x3F, 0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0x7C, 0xFC, 0x7F, 0x7E, 0x0F,
  0xDF, 0x03, 0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF8,
  0x3F, 0x7F, 0x1F, 0xCF, 0xFD, 0xF1, 0xFE, 0x7C, 0x3F, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF3, 0xC0, 0x7D, 0xF8, 0x3E, 0x3F, 0x1F, 0x8F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF1, 0xF8, 0xF9, 0xFE, 0x7D,
  0xFF, 0xBF, 0xFF, 0xDF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE8,
  0x1F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x87, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE3, 0xF0,
  0xF8, 0xF8, 0x3E, 0x7C, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xEF, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0x83,
  0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFC, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF3, 0xC3, 0xCF, 0x7E, 0x7E, 0xF7, 0xEF, 0xEF, 0xDF,
  0x9F, 0xF8, 0xF8, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8,
  0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF,
  0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F,
  0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0x7E, 0x1E, 0x3F, 0xC7, 0x9F, 0xF9,
  0xEF, 0xFE, 0x7F, 0x0F, 0xDF, 0x83, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7,
  0xC0, 0xFD, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBF,
  0x01, 0xF3, 0xE0, 0x7C, 0x7E, 0x1F, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03,
  0xFC, 0x00, 0xF8, 0xF8, 0x7D, 0xFF, 0x3F, 0xFF, 0x9F, 0xC7, 0xEF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xFE, 0x3F, 0x7F, 0xFF, 0x3E, 0xFF, 0x9F, 0x1F, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x87, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xF8, 0xFF, 0x7C,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFD,
  0xF0, 0x7F, 0x7E, 0x3F, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x3E, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF, 0xFB, 0xFF, 0xFB,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0x3E, 0x7C, 0x07, 0x9F, 0x01, 0xE7, 0xC0,
  0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x0F, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xBF, 0x03,
  0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB,
  0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC,
  0x0F, 0xBF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7E, 0x7F, 0x77, 0x9F, 0xFD,
  0xE3, 0xFE, 0x78, 0x7F, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00,
  0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x79,
  0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9E, 0x1F, 0x1E, 0x38, 0xFC, 0x78, 0xF3,
  0xF1, 0xC3, 0xCF, 0xEF, 0x0F, 0x7B, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x3B,
  0xC1, 0xFC, 0xFF, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xF7, 0xE0, 0x7E, 0x3E, 0x07,
  0xC1, 0xF0, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0xFD, 0xF0, 0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0x3F, 0x07, 0xC3,
  0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x01, 0xF7, 0xE0, 0x0F,
  0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xE3, 0xC0,
  0x1F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xE0,
};

const GFXglyph LiberationMono_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 24, 22, 8, -24 },
  { 19, 13, 11, 22, 5, -27 },
  { 37, 20, 24, 22, 1, -24 },
  { 97, 20, 29, 22, 1, -26 },
  { 170, 22, 24, 22, 0, -24 },
  { 236, 22, 24, 22, 0, -24 },
  { 302, 5, 11, 22, 9, -27 },
  { 309, 11, 35, 22, 6, -27 },
  { 358, 10, 35, 22, 6, -27 },
  { 402, 14, 14, 22, 4, -27 },
  { 427, 18, 18, 22, 2, -21 },
  { 468, 8, 12, 22, 5, -6 },
  { 480, 10, 4, 22, 6, -12 },
  { 485, 6, 6, 22, 8, -6 },
  { 490, 19, 27, 22, 2, -27 },
  { 555, 18, 24, 22, 2, -24 },
  { 609, 19, 24, 22, 2, -24 },
  { 666, 18, 24, 22, 2, -24 },
  { 720, 18, 24, 22, 2, -24 },
  { 774, 20, 24, 22, 1, -24 },
  { 834, 18, 24, 22, 2, -24 },
  { 888, 18, 24, 22, 2, -24 },
  { 942, 18, 24, 22, 2, -24 },
  { 996, 18, 24, 22, 2, -24 },
  { 1050, 18, 24, 22, 2, -24 },
  { 1104, 6, 20, 22, 8, -20 },
  { 1119, 9, 26, 22, 6, -20 },
  { 1149, 18, 20, 22, 2, -22 },
  { 1194, 18, 14, 22, 2, -19 },
  { 1226, 18, 20, 22, 2, -22 },
  { 1271, 19, 24, 22, 1, -24 },
  { 1328, 20, 32, 22, 1, -27 },
  { 1408, 22, 24, 22, 0, -24 },
  { 1474, 19, 24, 22, 2, -24 },
  { 1531, 20, 24, 22, 1, -24 },
  { 1591, 19, 24, 22, 2, -24 },
  { 1648, 19, 24, 22, 2, -24 },
  { 1705, 17, 24, 22, 3, -24 },
  { 1756, 19, 24, 22, 1, -24 },
  { 1813, 18, 24, 22, 2, -24 },
  { 1867, 16, 24, 22, 3, -24 },
  { 1915, 16, 24, 22, 2, -24 },
  { 1963, 20, 24, 22, 2, -24 },
  { 2023, 16, 24, 22, 4, -24 },
  { 2071, 18, 24, 22, 2, -24 },
  { 2125, 18, 24, 22, 2, -24 },
  { 2179, 20, 24, 22, 1, -24 },
  { 2239, 19, 24, 22, 2, -24 },
  { 2296, 20, 31, 22, 1, -24 },
  { 2374, 20, 24, 22, 2, -24 },
  { 2434, 20, 24, 22, 1, -24 },
  { 2494, 20, 24, 22, 1, -24 },
  { 2554, 18, 24, 22, 2, -24 },
  { 2608, 22, 24, 22, 0, -24 },
  { 2674, 22, 24, 22, 0, -24 },
  { 2740, 22, 24, 22, 0, -24 },
  { 2806, 22, 24, 22, 0, -24 },
  { 2872, 19, 24, 22, 2, -24 },
  { 2929, 11, 35, 22, 7, -27 },
  { 2978, 19, 27, 22, 2, -27 },
  { 3043, 10, 35, 22, 5, -27 },
  { 3087, 20, 16, 22, 1, -24 },
  { 3127, 22, 2, 22, 0, 2 },
  { 3133, 9, 5, 22, 6, -26 },
  { 3139, 19, 20, 22, 2, -20 },
  { 3187, 17, 27, 22, 3, -27 },
  { 3245, 18, 20, 22, 2, -20 },
  { 3290, 18, 27, 22, 2, -27 },
  { 3351, 18, 20, 22, 2, -20 },
  { 3396, 18, 27, 22, 2, -27 },
  { 3457, 18, 28, 22, 2, -20 },
  { 3520, 17, 27, 22, 3, -27 },
  { 3578, 19, 27, 22, 2, -27 },
  { 3643, 14, 35, 22, 2, -27 },
  { 3705, 18, 27, 22, 3, -27 },
  { 3766, 19, 27, 22, 2, -27 },
  { 3831, 20, 20, 22, 1, -20 },
  { 3881, 18, 20, 22, 2, -20 },
  { 3926, 19, 20, 22, 2, -20 },
  { 3974, 17, 28, 22, 3, -20 },
  { 4034, 18, 28, 22, 2, -20 },
  { 4097, 16, 20, 22, 4, -20 },
  { 4137, 18, 20, 22, 2, -20 },
  { 4182, 16, 25, 22, 3, -25 },
  { 4232, 18, 20, 22, 2, -20 },
  { 4277, 21, 20, 22, 1, -20 },
  { 4330, 22, 20, 22, 0, -20 },
  { 4385, 20, 20, 22, 1, -20 },
  { 4435, 21, 28, 22, 1, -20 },
  { 4509, 17, 20, 22, 2, -20 },
  { 4552, 16, 35, 22, 3, -27 },
  { 4622, 4, 35, 22, 9, -27 },
  { 4640, 16, 35, 22, 3, -27 },
  { 4710, 18, 6, 22, 2, -15 },
};

const GFXfont LiberationMono_Bold37pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold37pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold37pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _LIBERATIONMONO_BOLD37PT7B_H_
