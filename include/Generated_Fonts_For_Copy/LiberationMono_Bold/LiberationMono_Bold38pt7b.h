#ifndef _LIBERATIONMONO_BOLD38PT7B_H_
#define _LIBERATIONMONO_BOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xF0, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x01, 0xC1, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x38, 0x18, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x87, 0x03, 0x80, 0x38, 0x18, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0xE0,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x18, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7E, 0x67,
  0xE7, 0xC6, 0x3F, 0x7C, 0x61, 0xC7, 0xC6, 0x00, 0x3F, 0x60, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x06, 0xFE, 0x00,
  0x63, 0xF0, 0x06, 0x1F, 0x18, 0x61, 0xFF, 0x86, 0x0F, 0x7C, 0x61, 0xF7,
  0xC6, 0x1F, 0x7F, 0x63, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1F, 0x00,
  0x38, 0xFF, 0x00, 0xF1, 0xFF, 0x01, 0xC7, 0x8E, 0x07, 0x0E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x38, 0x38, 0x78, 0xE0, 0x70, 0xF3, 0xC0, 0xE1, 0xC7, 0x01,
  0xE3, 0x9C, 0x01, 0xFF, 0x70, 0x03, 0xFD, 0xE0, 0x01, 0xF3, 0x9F, 0x00,
  0x0E, 0x7F, 0x00, 0x3D, 0xFF, 0x00, 0x73, 0x8E, 0x01, 0xCF, 0x1E, 0x07,
  0x9C, 0x1C, 0x0E, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xF0, 0xF1, 0xE1, 0xC0,
  0xE3, 0x87, 0x01, 0xFF, 0x1C, 0x01, 0xFC, 0x78, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x9F, 0x80,
  0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0x87,
  0xFE, 0x0E, 0x0F, 0xBC, 0x3C, 0x3E, 0x7C, 0x78, 0x78, 0x7D, 0xF1, 0xF0,
  0x7F, 0xC3, 0xE0, 0x7F, 0x83, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC3,
  0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFE, 0x7F, 0x07, 0xF0, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xBC, 0xE0, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xFC,
  0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x02, 0x1C,
  0x67, 0xBB, 0xDF, 0xFF, 0xBF, 0xFF, 0x8F, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFB, 0xC3, 0xE3, 0xC3, 0xC7, 0x01, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x8F, 0x8F, 0xC7,
  0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xE1, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xFC,
  0x07, 0xDF, 0x80, 0xFB, 0xE7, 0x9F, 0xFC, 0xF3, 0xFF, 0x9E, 0x7F, 0xF3,
  0xCF, 0xFE, 0x79, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3F, 0x07, 0xE3, 0xE1, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x03, 0x87, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF0,
  0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xE1,
  0xFD, 0xF8, 0x1F, 0xBE, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03,
  0xF7, 0xE0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF,
  0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1E,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xE1, 0xFC, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xE7, 0xE1, 0xFC, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xE3,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x9F, 0x83, 0xE7, 0xFC, 0x7D, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFE, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0x7C, 0x07, 0xEF,
  0x80, 0xFD, 0xF0, 0x1F, 0x9F, 0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x0F, 0xC7, 0xC1, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xFF, 0x1F, 0x83, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xE1, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x3F, 0x3F, 0x0F, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0x87, 0xFD, 0xF0, 0x3E, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xF0,
  0x3F, 0x3E, 0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0xE0, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01,
  0xC6, 0x0F, 0x36, 0x70, 0xFB, 0xB3, 0x8E, 0x7D, 0xD8, 0xE1, 0xEF, 0xC6,
  0x0E, 0x3E, 0x70, 0x71, 0xF3, 0x83, 0x8F, 0x98, 0x1C, 0x79, 0xC0, 0xE3,
  0xCE, 0x07, 0x1E, 0x70, 0x71, 0xF3, 0x83, 0x8F, 0x9C, 0x1C, 0x7C, 0xE0,
  0xE3, 0x77, 0x0F, 0x1B, 0x98, 0x79, 0xDC, 0xE6, 0xCC, 0x67, 0xE7, 0xC3,
  0x1E, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x08, 0x0E, 0x00,
  0xE0, 0x3C, 0x1E, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0x3E,
  0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3E, 0x03, 0xF7, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7E, 0x1F, 0x81,
  0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x30, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0xC3, 0xF0, 0x0F, 0xDF, 0x80, 0x7C, 0x7E,
  0x07, 0xE3, 0xF8, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xC3, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0x7E, 0x07, 0xEF, 0xC3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0x7E,
  0x7E, 0x03, 0xE7, 0xE0, 0x38, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xF7, 0xC3, 0xFF, 0x7C, 0x3F, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x3F,
  0x87, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFC, 0x00,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x38, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0x83, 0xF7, 0xE3, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x07, 0xEF, 0x80, 0xFC, 0xF8,
  0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0xFE,
  0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x8F, 0x81,
  0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xF0, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0x7F, 0xB8, 0xEF, 0xF7, 0xBD,
  0xFE, 0xF7, 0xBF, 0xDE, 0xE7, 0xF9, 0xDC, 0xFF, 0x3B, 0x9F, 0xE7, 0xF3,
  0xFC, 0xFC, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xE0, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFB, 0xC3, 0xFE,
  0xF0, 0xFF, 0xBE, 0x3F, 0xE7, 0x8F, 0xF9, 0xF3, 0xFE, 0x7C, 0xFF, 0x8F,
  0x3F, 0xE3, 0xEF, 0xF8, 0x7B, 0xFE, 0x1E, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x8F,
  0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF3,
  0xE0, 0x7E, 0x3F, 0x8F, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF8,
  0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xF7,
  0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00,
  0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x0F, 0xC3, 0xF8, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F,
  0xCF, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0xF8, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F,
  0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E,
  0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFB,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xE7, 0xF0, 0x3F, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x3F,
  0x7E, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7,
  0x80, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x3C, 0x3E, 0x7C,
  0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF1, 0xF1, 0xE1, 0xE7, 0xF3, 0xC3, 0xCF,
  0xEF, 0x87, 0xDF, 0xDF, 0x0F, 0xFB, 0xBE, 0x1F, 0xF7, 0xF8, 0x1F, 0xEF,
  0xF0, 0x3F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x7E, 0x00, 0xFC, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xFC, 0x1F, 0x80,
  0xF8, 0x3E, 0x01, 0xF8, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xEF,
  0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7C,
  0xFC, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0xC1,
  0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x1E, 0x78, 0x01,
  0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xE1, 0xF0, 0x7E, 0x1F, 0x87, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xE0,
  0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC,
  0x3F, 0x8F, 0xFF, 0x7F, 0x7F, 0xE7, 0xF3, 0xFC, 0x7F, 0x1F, 0x83, 0xE0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0xFB, 0xFE, 0x3E, 0xFF, 0xCF, 0xFF,
  0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC1, 0xFB, 0xF8, 0x7E, 0xFF, 0xFF, 0x3E, 0xFF, 0xCF, 0x9F,
  0xE3, 0xE3, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xF0, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x01, 0xFB, 0xF0, 0x3E, 0x7F, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x3F, 0x1F, 0x1F,
  0xE7, 0xCF, 0xFD, 0xF7, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F,
  0xFF, 0xCF, 0xFD, 0xF1, 0xFE, 0x7C, 0x3F, 0x1F, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0x87, 0xC7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x00,
  0xF7, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x7F, 0x0F,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xE3, 0xFE, 0x7C, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF7, 0xF1, 0xFE, 0xFC, 0x1F, 0xDF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0, 0x7F, 0x7F, 0x1F, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFB, 0xF0, 0x7C, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF1,
  0xE0, 0x3E, 0x7E, 0x0F, 0xC7, 0xE3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00,
  0x3F, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0xF9, 0xFF, 0x7D, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xE0, 0x7E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0xF8, 0x1F, 0x9F, 0x03, 0xE3,
  0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0xFC, 0x07,
  0xDF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x7E, 0x0F,
  0x87, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF8, 0xF8, 0x1F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3F, 0x7C, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF3, 0xC3, 0xCF, 0x7E, 0x7E, 0xF7, 0xFF, 0xFF, 0xCF, 0xCF,
  0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8,
  0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F,
  0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xFF, 0x8F, 0x8F, 0xF8,
  0xF8, 0xFF, 0x8F, 0x8F, 0xF8, 0xF8, 0xF0, 0x7C, 0x3E, 0x1F, 0x3F, 0xC7,
  0xDF, 0xF9, 0xFF, 0xFF, 0x7F, 0x0F, 0xDF, 0x81, 0xF7, 0xE0, 0x7D, 0xF0,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7E, 0x1F, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xF8, 0xF8, 0x3E,
  0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFC, 0xFE, 0x1F, 0xBF, 0x07, 0xEF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFE, 0x1F, 0xBF,
  0xFF, 0xEF, 0xBF, 0xF3, 0xE7, 0xF8, 0xF8, 0xF8, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF,
  0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C, 0x7F, 0x9F,
  0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFE,
  0x7E, 0x0F, 0xDF, 0x01, 0xF7, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00,
  0x3D, 0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x07, 0xFC, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F, 0xFF, 0xDF, 0xFD, 0xF3,
  0xFE, 0x7C, 0x7F, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x0F, 0x07, 0x9E, 0x1F, 0x1F, 0x3C, 0x3E, 0x3C, 0x3C,
  0x7C, 0x78, 0x79, 0xFC, 0xF0, 0xF3, 0xF9, 0xE1, 0xE7, 0x73, 0xC3, 0xDE,
  0xE7, 0x87, 0xBD, 0xFE, 0x07, 0x71, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xF0, 0x3E,
  0x00, 0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0x81,
  0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3E,
  0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x00,
};

const GFXglyph LiberationMono_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 25, 23, 9, -25 },
  { 17, 13, 12, 23, 5, -28 },
  { 37, 21, 25, 23, 1, -25 },
  { 103, 20, 30, 23, 1, -27 },
  { 178, 23, 25, 23, 0, -25 },
  { 250, 23, 25, 23, 0, -25 },
  { 322, 5, 12, 23, 9, -28 },
  { 330, 11, 36, 23, 6, -28 },
  { 380, 10, 36, 23, 6, -28 },
  { 425, 15, 14, 23, 4, -28 },
  { 452, 19, 20, 23, 2, -23 },
  { 500, 9, 12, 23, 5, -6 },
  { 514, 11, 5, 23, 6, -12 },
  { 521, 5, 6, 23, 9, -6 },
  { 525, 19, 28, 23, 2, -28 },
  { 592, 19, 25, 23, 2, -25 },
  { 652, 18, 25, 23, 3, -25 },
  { 709, 19, 25, 23, 2, -25 },
  { 769, 19, 25, 23, 2, -25 },
  { 829, 21, 25, 23, 1, -25 },
  { 895, 19, 25, 23, 2, -25 },
  { 955, 19, 25, 23, 2, -25 },
  { 1015, 18, 25, 23, 2, -25 },
  { 1072, 19, 25, 23, 2, -25 },
  { 1132, 19, 25, 23, 2, -25 },
  { 1192, 5, 21, 23, 9, -21 },
  { 1206, 9, 27, 23, 6, -21 },
  { 1237, 19, 21, 23, 2, -23 },
  { 1287, 19, 14, 23, 2, -20 },
  { 1321, 19, 21, 23, 2, -23 },
  { 1371, 20, 25, 23, 1, -25 },
  { 1434, 21, 33, 23, 1, -28 },
  { 1521, 23, 25, 23, 0, -25 },
  { 1593, 19, 25, 23, 3, -25 },
  { 1653, 21, 25, 23, 1, -25 },
  { 1719, 19, 25, 23, 2, -25 },
  { 1779, 18, 25, 23, 3, -25 },
  { 1836, 18, 25, 23, 3, -25 },
  { 1893, 20, 25, 23, 1, -25 },
  { 1956, 17, 25, 23, 3, -25 },
  { 2010, 17, 25, 23, 3, -25 },
  { 2064, 17, 25, 23, 2, -25 },
  { 2118, 20, 25, 23, 3, -25 },
  { 2181, 17, 25, 23, 4, -25 },
  { 2235, 19, 25, 23, 2, -25 },
  { 2295, 18, 25, 23, 2, -25 },
  { 2352, 20, 25, 23, 1, -25 },
  { 2415, 18, 25, 23, 3, -25 },
  { 2472, 21, 32, 23, 1, -25 },
  { 2556, 20, 25, 23, 3, -25 },
  { 2619, 21, 25, 23, 1, -25 },
  { 2685, 21, 25, 23, 1, -25 },
  { 2751, 18, 25, 23, 2, -25 },
  { 2808, 23, 25, 23, 0, -25 },
  { 2880, 23, 25, 23, 0, -25 },
  { 2952, 23, 25, 23, 0, -25 },
  { 3024, 23, 25, 23, 0, -25 },
  { 3096, 19, 25, 23, 2, -25 },
  { 3156, 11, 36, 23, 7, -28 },
  { 3206, 19, 28, 23, 2, -28 },
  { 3273, 11, 36, 23, 5, -28 },
  { 3323, 20, 17, 23, 1, -25 },
  { 3366, 23, 2, 23, 0, 2 },
  { 3372, 10, 5, 23, 6, -27 },
  { 3379, 20, 21, 23, 2, -21 },
  { 3432, 18, 28, 23, 3, -28 },
  { 3495, 19, 21, 23, 2, -21 },
  { 3545, 18, 28, 23, 2, -28 },
  { 3608, 19, 21, 23, 2, -21 },
  { 3658, 19, 28, 23, 2, -28 },
  { 3725, 19, 29, 23, 2, -21 },
  { 3794, 17, 28, 23, 3, -28 },
  { 3854, 19, 28, 23, 2, -28 },
  { 3921, 14, 36, 23, 2, -28 },
  { 3984, 19, 28, 23, 3, -28 },
  { 4051, 19, 28, 23, 2, -28 },
  { 4118, 20, 21, 23, 1, -21 },
  { 4171, 18, 21, 23, 2, -21 },
  { 4219, 19, 21, 23, 2, -21 },
  { 4269, 18, 29, 23, 3, -21 },
  { 4335, 18, 29, 23, 2, -21 },
  { 4401, 16, 21, 23, 4, -21 },
  { 4443, 18, 21, 23, 2, -21 },
  { 4491, 16, 26, 23, 3, -26 },
  { 4543, 18, 20, 23, 2, -20 },
  { 4588, 21, 21, 23, 1, -21 },
  { 4644, 23, 21, 23, 0, -21 },
  { 4705, 21, 21, 23, 1, -21 },
  { 4761, 21, 29, 23, 1, -21 },
  { 4838, 17, 21, 23, 3, -21 },
  { 4883, 15, 36, 23, 4, -28 },
  { 4951, 5, 36, 23, 9, -28 },
  { 4974, 16, 36, 23, 3, -28 },
  { 5046, 19, 6, 23, 2, -16 },
};

const GFXfont LiberationMono_Bold38pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold38pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold38pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _LIBERATIONMONO_BOLD38PT7B_H_
