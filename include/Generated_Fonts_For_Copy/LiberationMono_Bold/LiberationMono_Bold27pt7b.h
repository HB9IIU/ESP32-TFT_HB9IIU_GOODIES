#ifndef _LIBERATIONMONO_BOLD27PT7B_H_
#define _LIBERATIONMONO_BOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x00, 0xFF, 0xFF, 0xF3, 0xFC,
  0xFF, 0x3D, 0xC7, 0x71, 0xDC, 0x77, 0x1D, 0x86, 0x06, 0x18, 0x38, 0x60,
  0xC3, 0x03, 0x0C, 0xFF, 0xFF, 0xFF, 0xF1, 0x86, 0x06, 0x18, 0x18, 0x60,
  0x61, 0x8F, 0xFF, 0xFF, 0xFF, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x30,
  0x61, 0x81, 0x86, 0x00, 0x03, 0x00, 0x0C, 0x00, 0xFE, 0x0F, 0xFC, 0x7F,
  0xF9, 0xED, 0xE7, 0x33, 0xDC, 0xC0, 0x7B, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x0C, 0xF6, 0x31, 0xFC, 0xC7, 0xFB, 0x3D, 0xFF, 0xF3,
  0xFF, 0x83, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x06, 0x7E, 0x0C, 0xE6,
  0x1C, 0xC6, 0x18, 0xC7, 0x30, 0xC7, 0x70, 0xE6, 0x60, 0x7E, 0xC0, 0x3D,
  0xC0, 0x01, 0xBE, 0x03, 0x7F, 0x07, 0x67, 0x06, 0x63, 0x0C, 0x63, 0x1C,
  0x63, 0x38, 0x67, 0x30, 0x7E, 0x60, 0x3E, 0x07, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0x78, 0x1C, 0x30, 0x0C, 0x70, 0x0F, 0xE0, 0x0F, 0x80, 0x3F,
  0x0E, 0x7F, 0x0C, 0x73, 0x9C, 0xF1, 0xDC, 0xF1, 0xF8, 0xF0, 0xF8, 0x78,
  0x7C, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0x87, 0xFF, 0xF7, 0x77, 0x76, 0x1E,
  0x78, 0xF3, 0xC7, 0x8E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xE3, 0xC7, 0x87, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0x78,
  0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0xF0,
  0x0E, 0x03, 0x04, 0xCF, 0xFF, 0xFF, 0xC7, 0x83, 0xF1, 0xEE, 0x73, 0x88,
  0x40, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x3E, 0x78, 0xF1, 0xC3, 0x8E, 0x1C, 0x30, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xF1, 0xEF, 0x0F, 0x78, 0x3B, 0x81, 0xDC,
  0xEF, 0xE7, 0x7F, 0x3B, 0xF8, 0x1F, 0xC0, 0xEF, 0x07, 0x78, 0x7B, 0xE3,
  0xCF, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0xE1, 0xFF,
  0x0F, 0x78, 0x63, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x83, 0xFF, 0x1F, 0xFD, 0xE1, 0xEF, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E,
  0x1E, 0x70, 0x38, 0x00, 0xE0, 0x07, 0x81, 0xFC, 0x07, 0xC0, 0x1F, 0xC0,
  0x07, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0xDF, 0xFE, 0x3F, 0xF0,
  0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3B,
  0xC1, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xC3, 0xCE, 0x0F, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x3F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xBE, 0x1F, 0xFC,
  0x7F, 0xF9, 0xE1, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xC0, 0xF7, 0x87,
  0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1,
  0xEF, 0x07, 0x78, 0x03, 0x9F, 0x1D, 0xFC, 0xFF, 0xF7, 0xC7, 0xBC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x78, 0x79,
  0xE1, 0xE7, 0x87, 0x8F, 0xFC, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x3E, 0x78, 0x7B, 0xC0, 0xE7, 0x03, 0x9E,
  0x1F, 0x78, 0x7D, 0xFF, 0xF3, 0xFF, 0x87, 0xCE, 0x00, 0x39, 0xC1, 0xE7,
  0x8F, 0x0F, 0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE3, 0xC7, 0x8E, 0x3C, 0x70, 0xE1, 0x87, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x1F, 0xC3, 0xFE, 0x7F, 0xC3, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF0, 0x03, 0xC0, 0x0F, 0x01, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0xF8,
  0x03, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F,
  0xC0, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x07,
  0xC0, 0x1F, 0xE0, 0x70, 0xE1, 0x80, 0xC7, 0x00, 0xCC, 0x77, 0x91, 0xEF,
  0x66, 0x7A, 0xCC, 0x67, 0xB0, 0xCF, 0x61, 0x9C, 0xC3, 0x39, 0x86, 0x73,
  0x18, 0xA6, 0x33, 0x6C, 0x66, 0xD9, 0xCD, 0xBE, 0xF3, 0x39, 0xC3, 0x00,
  0x07, 0x01, 0x07, 0x0F, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78,
  0x1E, 0x38, 0x1C, 0x38, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE,
  0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFF, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x3F, 0xF8, 0xFF, 0x83,
  0xFF, 0xCF, 0x07, 0xBC, 0x0E, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xBF, 0xFE,
  0xFF, 0xF3, 0xFF, 0x80, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78,
  0x3F, 0xC0, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x1D, 0xE0, 0xF7, 0xC7, 0xCF, 0xFE, 0x1F, 0xF0, 0x1F, 0x00,
  0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7B, 0xC7,
  0xDF, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0xBC, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0xFE, 0xFF, 0xF7, 0xFF, 0xBC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F,
  0x1E, 0x78, 0x7B, 0xC0, 0xCF, 0x00, 0x3C, 0x00, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0xC3, 0xCF, 0xFF, 0x1F, 0xF0,
  0x3F, 0x00, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x70, 0x77, 0x8F, 0x78, 0xF7, 0xFF, 0x3F, 0xE0, 0xF8, 0xF0,
  0x7F, 0xC3, 0xEF, 0x0F, 0x3C, 0x78, 0xF3, 0xC3, 0xDF, 0x0F, 0x78, 0x3F,
  0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3E, 0xF0, 0xF3, 0xE3, 0xC7, 0x8F,
  0x0F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0xFF, 0xB3, 0xFE, 0xED, 0xFB, 0xF7,
  0xEF, 0xDF, 0x9F, 0x7E, 0x79, 0xF9, 0xE7, 0xE3, 0x9F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC7, 0xEE, 0x7E, 0xE7, 0xEE, 0x7E, 0x77, 0xE7, 0x7E, 0x7F,
  0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0x0F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0xC7, 0x8F,
  0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xE1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE1, 0xF7,
  0xC7, 0x8F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E,
  0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC,
  0x3C, 0xF0, 0xF1, 0xE3, 0xC7, 0xCF, 0x0F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC0,
  0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1, 0xF7, 0x81, 0xEF, 0x00,
  0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0xF7,
  0x00, 0xEF, 0x03, 0xDF, 0x07, 0x9F, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xCF, 0xFC, 0x7F, 0xE0, 0xFC,
  0x00, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1E, 0x3C,
  0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E,
  0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x71,
  0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x7B, 0xEE, 0x3F, 0xEE, 0x3F,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x1C, 0x3C, 0x1C,
  0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E,
  0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x87,
  0x0E, 0x1C, 0x70, 0x39, 0xC0, 0xEE, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xE1,
  0xC3, 0x87, 0x0F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC3, 0xC7, 0x80, 0x07, 0x80,
  0x0F, 0x07, 0xFE, 0x1F, 0xFC, 0x78, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0xCF,
  0xC7, 0xFF, 0xEF, 0xE7, 0xCF, 0x8F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x79, 0xE3, 0xFF, 0x9F, 0xFE, 0xF8, 0xF7, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xF7, 0xFF,
  0xBF, 0xF9, 0xE7, 0x80, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78,
  0x39, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x83, 0xDF,
  0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x8F, 0x9C, 0xFE, 0xEF, 0xFF, 0x78, 0xFB, 0xC3, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xEF, 0x0F, 0x78, 0xFB, 0xFD,
  0xCF, 0xEE, 0x3E, 0x70, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x78,
  0x3B, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1E,
  0x0F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC7, 0xFE,
  0x3C, 0x01, 0xE0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x1E, 0x7B, 0xFB, 0xDF, 0xFF, 0xF1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xF1, 0xF7,
  0xFF, 0xBF, 0xBC, 0xF9, 0xE0, 0x0F, 0x00, 0x77, 0x87, 0x9F, 0xFC, 0xFF,
  0xC1, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x79,
  0xE3, 0xDF, 0xDF, 0xFE, 0xF8, 0xF7, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x81, 0xC0,
  0xE0, 0x00, 0x03, 0xFD, 0xFE, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1F, 0xFF,
  0xFF, 0x7E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x3F, 0xC3, 0xDE, 0x3C, 0xF3, 0xC7, 0xBC, 0x3D, 0xC1, 0xFE, 0x0F, 0xF8,
  0x7D, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE7, 0x87, 0xBC, 0x1F, 0xE0, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEE, 0x3B, 0xFD,
  0xFF, 0xFF, 0xFD, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xE3,
  0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xC0,
  0xE3, 0xC7, 0x3F, 0x3B, 0xFD, 0xF1, 0xEF, 0x07, 0x78, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xE0, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9E, 0x1E, 0x78, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x3F, 0xF8,
  0xFF, 0xC0, 0xFC, 0x00, 0xF3, 0xC7, 0xBF, 0x3F, 0xFD, 0xF1, 0xEF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xEF,
  0xFF, 0x7F, 0xF3, 0xCF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xEE, 0xF1, 0xF7, 0x87, 0xF8,
  0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xDE, 0x1E, 0xF1, 0xF7, 0xFF,
  0x9F, 0xDC, 0x7C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0xE3, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x1F,
  0x83, 0xFF, 0x1F, 0xFD, 0xE0, 0xEF, 0x00, 0x7C, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0xEF, 0xFF, 0x3F, 0xF0, 0xFE, 0x00,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1F, 0xF1, 0xFF, 0x07, 0xF0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xF7, 0x7F,
  0x73, 0xE7, 0x70, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0xE0, 0x07,
  0x60, 0x07, 0x70, 0x06, 0x71, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE,
  0x37, 0xEE, 0x37, 0x6C, 0x36, 0x6C, 0x36, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0xF0, 0x3C, 0xF0, 0xF0, 0xF1, 0xC1, 0xE7, 0x81, 0xFE, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x73, 0x81, 0xE7,
  0x87, 0x87, 0x8F, 0x07, 0xBC, 0x0F, 0x00, 0x78, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E,
  0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE3, 0xFC, 0x7F, 0x8F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x81, 0xF0, 0x7C, 0x0E, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0x1F, 0xE1, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x3F, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x8F,
  0xF0, 0xFF, 0x0F, 0xE0, 0x3C, 0x03, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0x00,
  0xF8,
};

const GFXglyph LiberationMono_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 18, 16, 6, -18 },
  { 10, 10, 8, 16, 3, -20 },
  { 20, 14, 18, 16, 1, -18 },
  { 52, 14, 22, 16, 1, -20 },
  { 91, 16, 18, 16, 0, -18 },
  { 127, 16, 18, 16, 0, -18 },
  { 163, 4, 8, 16, 6, -20 },
  { 167, 7, 26, 16, 5, -20 },
  { 190, 8, 26, 16, 4, -20 },
  { 216, 10, 10, 16, 3, -20 },
  { 229, 14, 13, 16, 1, -15 },
  { 252, 7, 9, 16, 3, -4 },
  { 260, 8, 3, 16, 4, -9 },
  { 263, 4, 4, 16, 6, -4 },
  { 265, 14, 20, 16, 1, -20 },
  { 300, 13, 18, 16, 2, -18 },
  { 330, 13, 18, 16, 2, -18 },
  { 360, 13, 18, 16, 2, -18 },
  { 390, 14, 18, 16, 1, -18 },
  { 422, 14, 18, 16, 1, -18 },
  { 454, 14, 18, 16, 1, -18 },
  { 486, 13, 18, 16, 2, -18 },
  { 516, 12, 18, 16, 2, -18 },
  { 543, 14, 18, 16, 1, -18 },
  { 575, 14, 18, 16, 1, -18 },
  { 607, 4, 15, 16, 6, -15 },
  { 615, 7, 20, 16, 4, -15 },
  { 633, 14, 14, 16, 1, -16 },
  { 658, 14, 9, 16, 1, -13 },
  { 674, 14, 14, 16, 1, -16 },
  { 699, 14, 18, 16, 1, -18 },
  { 731, 15, 24, 16, 1, -20 },
  { 776, 16, 18, 16, 0, -18 },
  { 812, 14, 18, 16, 2, -18 },
  { 844, 14, 18, 16, 1, -18 },
  { 876, 13, 18, 16, 2, -18 },
  { 906, 13, 18, 16, 2, -18 },
  { 936, 13, 18, 16, 2, -18 },
  { 966, 14, 18, 16, 1, -18 },
  { 998, 12, 18, 16, 2, -18 },
  { 1025, 12, 18, 16, 2, -18 },
  { 1052, 12, 18, 16, 1, -18 },
  { 1079, 14, 18, 16, 2, -18 },
  { 1111, 12, 18, 16, 3, -18 },
  { 1138, 14, 18, 16, 1, -18 },
  { 1170, 12, 18, 16, 2, -18 },
  { 1197, 14, 18, 16, 1, -18 },
  { 1229, 13, 18, 16, 2, -18 },
  { 1259, 14, 24, 16, 1, -18 },
  { 1301, 14, 18, 16, 2, -18 },
  { 1333, 15, 18, 16, 0, -18 },
  { 1367, 14, 18, 16, 1, -18 },
  { 1399, 13, 18, 16, 2, -18 },
  { 1429, 16, 18, 16, 0, -18 },
  { 1465, 16, 18, 16, 0, -18 },
  { 1501, 16, 18, 16, 0, -18 },
  { 1537, 16, 18, 16, 0, -18 },
  { 1573, 14, 18, 16, 1, -18 },
  { 1605, 8, 26, 16, 5, -20 },
  { 1631, 14, 20, 16, 1, -20 },
  { 1666, 8, 26, 16, 3, -20 },
  { 1692, 14, 12, 16, 1, -18 },
  { 1713, 16, 1, 16, 0, 2 },
  { 1715, 6, 4, 16, 5, -20 },
  { 1718, 15, 15, 16, 1, -15 },
  { 1747, 13, 20, 16, 2, -20 },
  { 1780, 14, 15, 16, 1, -15 },
  { 1807, 13, 20, 16, 1, -20 },
  { 1840, 14, 15, 16, 1, -15 },
  { 1867, 13, 20, 16, 2, -20 },
  { 1900, 13, 21, 16, 2, -15 },
  { 1935, 13, 20, 16, 2, -20 },
  { 1968, 13, 20, 16, 2, -20 },
  { 2001, 9, 26, 16, 2, -20 },
  { 2031, 13, 20, 16, 2, -20 },
  { 2064, 13, 20, 16, 2, -20 },
  { 2097, 14, 15, 16, 1, -15 },
  { 2124, 13, 15, 16, 2, -15 },
  { 2149, 14, 15, 16, 1, -15 },
  { 2176, 13, 21, 16, 2, -15 },
  { 2211, 13, 21, 16, 1, -15 },
  { 2246, 11, 15, 16, 3, -15 },
  { 2267, 13, 15, 16, 2, -15 },
  { 2292, 12, 19, 16, 2, -19 },
  { 2321, 12, 14, 16, 2, -14 },
  { 2342, 16, 15, 16, 0, -15 },
  { 2372, 16, 15, 16, 0, -15 },
  { 2402, 15, 15, 16, 1, -15 },
  { 2431, 16, 21, 16, 0, -15 },
  { 2473, 12, 15, 16, 2, -15 },
  { 2496, 11, 26, 16, 3, -20 },
  { 2532, 4, 26, 16, 6, -20 },
  { 2545, 12, 26, 16, 2, -20 },
  { 2584, 14, 5, 16, 1, -11 },
};

const GFXfont LiberationMono_Bold27pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold27pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold27pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _LIBERATIONMONO_BOLD27PT7B_H_
