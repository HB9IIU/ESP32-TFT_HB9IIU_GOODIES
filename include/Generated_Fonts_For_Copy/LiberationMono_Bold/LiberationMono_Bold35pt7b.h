#ifndef _LIBERATIONMONO_BOLD35PT7B_H_
#define _LIBERATIONMONO_BOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xF7, 0x8F,
  0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0x03, 0x83,
  0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0x81, 0x80, 0x30, 0x70, 0x0E, 0x0E,
  0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xC1, 0xC0, 0x38, 0x38,
  0x07, 0x07, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC3, 0x03, 0x00, 0x60, 0x60, 0x1C, 0x1C, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x0C, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x93, 0xF3, 0xE2, 0x3E,
  0x7C, 0x43, 0x8F, 0x88, 0x01, 0xF9, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x02, 0xFE, 0x00, 0x47, 0xC7, 0x08, 0x7F,
  0xE1, 0x0F, 0xBC, 0x21, 0xF7, 0xE4, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x3E, 0x00, 0x73, 0xFC, 0x07, 0x1C, 0xE0, 0x71, 0xC3, 0x83, 0x8E, 0x1C,
  0x38, 0x70, 0xE3, 0x83, 0x87, 0x3C, 0x1C, 0x39, 0xC0, 0xE1, 0xDC, 0x03,
  0x9D, 0xC0, 0x1F, 0xEE, 0x00, 0x7C, 0xE7, 0xC0, 0x0E, 0xFF, 0x00, 0x77,
  0x38, 0x07, 0x70, 0xE0, 0x73, 0x87, 0x03, 0x9C, 0x38, 0x38, 0xE1, 0xC3,
  0x87, 0x0E, 0x38, 0x38, 0x71, 0xC0, 0xE7, 0x1C, 0x07, 0xF9, 0xC0, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x1E, 0x00,
  0xF0, 0x70, 0x07, 0x83, 0x80, 0x3C, 0x3C, 0x00, 0xE3, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x83, 0xC3, 0xFE, 0x1E, 0x3E,
  0xF0, 0xF1, 0xE3, 0xCF, 0x0F, 0x0F, 0x78, 0xF8, 0x7F, 0x87, 0xC1, 0xFC,
  0x1E, 0x07, 0xC0, 0xF8, 0x7F, 0xD3, 0xFF, 0xFF, 0x8F, 0xFC, 0xFC, 0x3F,
  0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFD, 0xCE, 0x73, 0x9C, 0x07, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x1E, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F,
  0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x2F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEF, 0x1E, 0x3C, 0x71,
  0xC1, 0x04, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xFB, 0xE0,
  0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0xE7, 0xFE, 0x73, 0xFF, 0x39, 0xFF,
  0x9C, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0x3E, 0x0F,
  0x9F, 0x8F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0x9F, 0x03, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF,
  0xEF, 0xC3, 0xF7, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xFF, 0xE7, 0xFF,
  0xF0, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xF7, 0xC0, 0x3C, 0xF8,
  0x07, 0x9F, 0x01, 0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x83, 0xC1, 0xF0,
  0xF0, 0x3E, 0x1E, 0x07, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF3, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xC7, 0xF7, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3,
  0xE0, 0x79, 0xE0, 0x01, 0xF0, 0x00, 0xF9, 0xF8, 0x7D, 0xFF, 0x3F, 0xFF,
  0xDF, 0xFF, 0xEF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x78,
  0x0F, 0xBE, 0x07, 0xCF, 0x87, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x3E, 0xF8, 0x3E, 0x7C, 0x1F, 0x1F, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xEF, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0x7C, 0x3F, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x3C, 0x0F, 0x9F, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x7C, 0x78,
  0x78, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0x00,
  0xFE, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF8, 0xFF, 0xFE, 0x7E, 0x0F, 0xDF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xC0, 0x3C, 0x1C, 0x0E, 0x01, 0xC1, 0x80, 0x1C, 0x70,
  0x01, 0x8C, 0x00, 0x33, 0x87, 0xBF, 0x61, 0xF7, 0x6C, 0x73, 0xCF, 0x9C,
  0x39, 0xF3, 0x07, 0x3C, 0xE0, 0xE7, 0x9C, 0x1C, 0xF3, 0x83, 0x1E, 0x60,
  0xE3, 0xCC, 0x1C, 0x79, 0x83, 0x8F, 0x30, 0x73, 0xE7, 0x1C, 0x6C, 0xE6,
  0x9D, 0xCF, 0x9F, 0x18, 0xE3, 0xC3, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x20, 0xE0, 0x0E, 0x0F, 0x07, 0x80, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0xBE, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xF0, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x18, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x1C, 0x7C, 0x03, 0xEF, 0xC0, 0xF8, 0xFC,
  0x3F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xF8, 0x7F, 0x3E, 0x07,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x07, 0xEF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3F, 0x0F, 0x9F, 0x83, 0xF7, 0xC0, 0x71, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03, 0xDF, 0x80, 0xF3, 0xF0, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x80, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xBC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xFB, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x01,
  0xF8, 0x00, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F,
  0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F,
  0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xBF, 0x07, 0xE3, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0x7C,
  0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF8, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0xC3, 0xFE, 0xE3, 0xFF, 0x71, 0xDF, 0xB8, 0xEF, 0xDE, 0x77, 0xEF, 0x7B,
  0xF3, 0xB9, 0xF9, 0xDC, 0xFC, 0xEE, 0x7E, 0x7F, 0x3F, 0x1F, 0x1F, 0x8F,
  0x8F, 0xC7, 0xC7, 0xE1, 0xE3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xEF, 0x1F, 0xF7,
  0x8F, 0xFD, 0xE7, 0xFE, 0xF3, 0xFF, 0x79, 0xFF, 0x9E, 0xFF, 0xCF, 0x7F,
  0xE3, 0xFF, 0xF1, 0xEF, 0xF8, 0xF7, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7E, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0xC1, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8,
  0x1F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x81, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0,
  0x3E, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0xC1,
  0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0x81, 0xF9, 0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x0F, 0xDF, 0x03, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0xCF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0,
  0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0x3F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x8F, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xC0, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xDE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE1, 0xC3, 0xCF,
  0x1F, 0x1E, 0x7C, 0xF8, 0xF3, 0xE7, 0xCF, 0x8F, 0x3E, 0x78, 0x7B, 0xFB,
  0xC3, 0xDD, 0xDE, 0x1E, 0xEE, 0xF0, 0xF7, 0x77, 0x87, 0xFB, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x7C,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC1, 0xF0, 0x7E, 0x07, 0xC3, 0xE0,
  0x3E, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F,
  0x9F, 0x80, 0xFC, 0x7C, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x38,
  0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xC1, 0xF3, 0xE0,
  0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x87, 0xF3, 0xFF, 0xBF, 0x7F, 0xCF,
  0xC7, 0xC1, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF1, 0xF0, 0x79, 0xFE, 0x3D, 0xFF,
  0x9F, 0x87, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0,
  0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB,
  0xF0, 0xFB, 0xEF, 0xFD, 0xF3, 0xFC, 0xF8, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x01, 0xFF, 0x80,
  0xFB, 0xE0, 0xF9, 0xF8, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x1F, 0x1E, 0x3F, 0xCF, 0x3F, 0xF7, 0x9F, 0x8F, 0xDF,
  0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F,
  0x7C, 0x07, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0xC1, 0xF3, 0xE1, 0xF9, 0xFF,
  0xBC, 0x7F, 0x9F, 0x0F, 0x8F, 0x80, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xC3, 0xE7, 0xC0, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7D,
  0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xC7, 0xF7,
  0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0xFD, 0xF8, 0xFE, 0x7F,
  0xFF, 0x1F, 0xEF, 0x87, 0xC7, 0xC0, 0x03, 0xE0, 0x01, 0xF7, 0xC1, 0xF3,
  0xF0, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0xF8, 0xF9, 0xFE, 0x7D, 0xFF, 0xBE, 0xFF, 0xDF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xEF, 0xFF, 0x7F,
  0xF3, 0xFF, 0x0F, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0xF8, 0x3E, 0x7C,
  0x3E, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3E, 0x3E, 0x1F, 0x1F, 0x8F, 0x87,
  0xC7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0x87, 0x9E, 0xF9, 0xFB,
  0xFF, 0xFF, 0x7C, 0xF9, 0xFF, 0x9F, 0x1F, 0xE3, 0xE3, 0xFC, 0x3C, 0x7F,
  0x87, 0x0F, 0xF0, 0xE1, 0xFE, 0x1C, 0x3F, 0xC3, 0x87, 0xF8, 0x70, 0xFF,
  0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x0F, 0xF0, 0xE1, 0xFE,
  0x1C, 0x3C, 0xF8, 0x7C, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0x7F, 0xEF, 0xE1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xC3, 0xEF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFD, 0xF8,
  0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xF8, 0xF8, 0x7C, 0xFF,
  0x1E, 0xFF, 0xCF, 0xC3, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0,
  0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xFB,
  0xE0, 0xFD, 0xF8, 0xFC, 0xF7, 0xFE, 0x7B, 0xFE, 0x3C, 0x7C, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x8F, 0x9F, 0xE7, 0xDF, 0xFB, 0xCF, 0x87, 0xEF, 0xC1,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE,
  0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xE0, 0xF9, 0xF0, 0xFC, 0xFF, 0xDE,
  0x3F, 0xCF, 0x07, 0xC7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x7E, 0xF3, 0xFD,
  0xF7, 0xFB, 0xFF, 0xF7, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xF7, 0x00, 0xFF, 0xC0, 0x7D,
  0xF0, 0x3C, 0xFF, 0xFE, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF,
  0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F,
  0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xE1, 0xF9, 0xF9,
  0xFC, 0xFF, 0xDE, 0x3F, 0xCF, 0x0F, 0xC7, 0x80, 0xF8, 0x03, 0xFF, 0x00,
  0x7D, 0xE0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0xDF,
  0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0,
  0x01, 0xE7, 0x87, 0x0F, 0x3C, 0x7C, 0x79, 0xE3, 0xE3, 0xCF, 0x1F, 0x1C,
  0x39, 0xDC, 0xE1, 0xCE, 0xEF, 0x0F, 0x77, 0x78, 0x7F, 0xBB, 0xC3, 0xF8,
  0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x00, 0x7C, 0x07, 0xCF, 0x81, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F,
  0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xE0, 0x3E, 0x3E,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03,
  0xFF, 0x00, 0x7D, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0x78,
  0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x3F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x1F, 0x00, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0x80, 0x7E, 0x00, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xF8,
};

const GFXglyph LiberationMono_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 23, 21, 8, -23 },
  { 16, 13, 11, 21, 4, -25 },
  { 34, 19, 23, 21, 1, -23 },
  { 89, 19, 28, 21, 1, -25 },
  { 156, 21, 23, 21, 0, -23 },
  { 217, 21, 23, 21, 0, -23 },
  { 278, 5, 11, 21, 8, -25 },
  { 285, 10, 32, 21, 6, -25 },
  { 325, 10, 32, 21, 5, -25 },
  { 365, 13, 13, 21, 4, -25 },
  { 387, 17, 18, 21, 2, -21 },
  { 426, 9, 11, 21, 4, -5 },
  { 439, 9, 4, 21, 6, -11 },
  { 444, 5, 5, 21, 8, -5 },
  { 448, 17, 25, 21, 2, -25 },
  { 502, 17, 23, 21, 2, -23 },
  { 551, 18, 23, 21, 2, -23 },
  { 603, 17, 23, 21, 2, -23 },
  { 652, 17, 23, 21, 2, -23 },
  { 701, 19, 23, 21, 1, -23 },
  { 756, 17, 23, 21, 2, -23 },
  { 805, 17, 23, 21, 2, -23 },
  { 854, 17, 23, 21, 2, -23 },
  { 903, 17, 23, 21, 2, -23 },
  { 952, 17, 23, 21, 2, -23 },
  { 1001, 5, 18, 21, 8, -18 },
  { 1013, 8, 24, 21, 6, -18 },
  { 1037, 17, 19, 21, 2, -21 },
  { 1078, 17, 13, 21, 2, -18 },
  { 1106, 17, 19, 21, 2, -21 },
  { 1147, 18, 23, 21, 1, -23 },
  { 1199, 19, 30, 21, 1, -25 },
  { 1271, 21, 23, 21, 0, -23 },
  { 1332, 18, 23, 21, 2, -23 },
  { 1384, 19, 23, 21, 1, -23 },
  { 1439, 18, 23, 21, 2, -23 },
  { 1491, 18, 23, 21, 2, -23 },
  { 1543, 16, 23, 21, 3, -23 },
  { 1589, 18, 23, 21, 1, -23 },
  { 1641, 17, 23, 21, 2, -23 },
  { 1690, 15, 23, 21, 3, -23 },
  { 1734, 15, 23, 21, 2, -23 },
  { 1778, 19, 23, 21, 2, -23 },
  { 1833, 15, 23, 21, 4, -23 },
  { 1877, 17, 23, 21, 2, -23 },
  { 1926, 17, 23, 21, 2, -23 },
  { 1975, 19, 23, 21, 1, -23 },
  { 2030, 18, 23, 21, 2, -23 },
  { 2082, 19, 30, 21, 1, -23 },
  { 2154, 19, 23, 21, 2, -23 },
  { 2209, 19, 23, 21, 1, -23 },
  { 2264, 19, 23, 21, 1, -23 },
  { 2319, 17, 23, 21, 2, -23 },
  { 2368, 21, 23, 21, 0, -23 },
  { 2429, 21, 23, 21, 0, -23 },
  { 2490, 21, 23, 21, 0, -23 },
  { 2551, 21, 23, 21, 0, -23 },
  { 2612, 18, 23, 21, 1, -23 },
  { 2664, 11, 32, 21, 6, -25 },
  { 2708, 17, 25, 21, 2, -25 },
  { 2762, 11, 32, 21, 4, -25 },
  { 2806, 19, 15, 21, 1, -23 },
  { 2842, 21, 2, 21, 0, 2 },
  { 2848, 9, 5, 21, 6, -25 },
  { 2854, 18, 18, 21, 2, -18 },
  { 2895, 17, 25, 21, 2, -25 },
  { 2949, 17, 18, 21, 2, -18 },
  { 2988, 17, 25, 21, 2, -25 },
  { 3042, 17, 18, 21, 2, -18 },
  { 3081, 17, 25, 21, 2, -25 },
  { 3135, 17, 25, 21, 2, -18 },
  { 3189, 17, 25, 21, 2, -25 },
  { 3243, 18, 25, 21, 2, -25 },
  { 3300, 13, 32, 21, 2, -25 },
  { 3352, 17, 25, 21, 3, -25 },
  { 3406, 18, 25, 21, 2, -25 },
  { 3463, 19, 18, 21, 1, -18 },
  { 3506, 17, 18, 21, 2, -18 },
  { 3545, 17, 18, 21, 2, -18 },
  { 3584, 17, 25, 21, 2, -18 },
  { 3638, 17, 25, 21, 2, -18 },
  { 3692, 15, 18, 21, 3, -18 },
  { 3726, 17, 18, 21, 2, -18 },
  { 3765, 15, 23, 21, 3, -23 },
  { 3809, 17, 18, 21, 2, -18 },
  { 3848, 19, 18, 21, 1, -18 },
  { 3891, 21, 18, 21, 0, -18 },
  { 3939, 19, 18, 21, 1, -18 },
  { 3982, 19, 25, 21, 1, -18 },
  { 4042, 16, 18, 21, 2, -18 },
  { 4078, 15, 32, 21, 3, -25 },
  { 4138, 5, 33, 21, 8, -25 },
  { 4159, 15, 32, 21, 3, -25 },
  { 4219, 17, 6, 21, 2, -15 },
};

const GFXfont LiberationMono_Bold35pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold35pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold35pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _LIBERATIONMONO_BOLD35PT7B_H_
