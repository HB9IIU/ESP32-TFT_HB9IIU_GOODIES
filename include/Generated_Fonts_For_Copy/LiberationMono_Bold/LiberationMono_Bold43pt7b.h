#ifndef _LIBERATIONMONO_BOLD43PT7B_H_
#define _LIBERATIONMONO_BOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFB, 0xEF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78,
  0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0x80, 0xE0,
  0x03, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x07, 0x03, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xCC, 0xFE, 0x3E,
  0x18, 0xFC, 0xFC, 0x30, 0xF9, 0xF8, 0x61, 0xE3, 0xF0, 0xC0, 0x03, 0xF1,
  0x80, 0x07, 0xF3, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0x8F,
  0xE0, 0x03, 0x0F, 0xC7, 0x06, 0x0F, 0xBE, 0x0C, 0x1F, 0x7E, 0x18, 0x7E,
  0xFC, 0x30, 0xFC, 0xFE, 0x67, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x0F, 0x0F, 0xF0, 0x03, 0xC7,
  0xFE, 0x01, 0xE3, 0xE7, 0xC0, 0xF0, 0xF0, 0xF0, 0x38, 0x3C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x0F, 0x03, 0xC3, 0xC3, 0x80, 0xF0, 0xF1, 0xE0, 0x3C, 0x3C,
  0xF0, 0x07, 0x9E, 0x78, 0x01, 0xFF, 0x9E, 0x00, 0x3F, 0xCF, 0x00, 0x07,
  0xE7, 0x80, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0xF7, 0xFC, 0x00, 0x79, 0xFF,
  0x80, 0x1C, 0xF1, 0xE0, 0x0F, 0x3C, 0x3C, 0x07, 0x8F, 0x0F, 0x01, 0xC3,
  0x83, 0xC0, 0xF0, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x3C, 0x0F, 0x0F, 0x0E,
  0x03, 0xC7, 0x87, 0x80, 0x7F, 0xE3, 0xC0, 0x0F, 0xF0, 0xE0, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x00, 0xF3, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0x81, 0xFF, 0x81,
  0xE0, 0xFF, 0xF0, 0xF8, 0x7E, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x07, 0xC1,
  0xF7, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x0F, 0xF8, 0x1F, 0x01, 0xFE, 0x07,
  0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF1, 0xFC, 0x0F, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xBE, 0x79, 0xE7, 0x9E, 0x78, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6, 0x7B, 0xDE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xE0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7C,
  0x7C, 0x3E, 0x3C, 0x38, 0x08, 0x10, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xC3,
  0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0xF8, 0xF3, 0xFF, 0xC7, 0x9F, 0xFE, 0x3C, 0xFF, 0xF1, 0xE7,
  0xFF, 0x8F, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0xFE, 0x1F, 0xC7, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFC, 0x1F, 0xE7, 0xE0, 0x3F, 0xBF, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xE7,
  0xF0, 0x3F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB,
  0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xE3,
  0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF9, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC,
  0x01, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE,
  0x7E, 0x07, 0xEF, 0xC0, 0x38, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7E,
  0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C,
  0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xF1, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xC1,
  0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F,
  0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0xC1, 0xFE, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xC3, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0xC3, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFD, 0xF8, 0x1F, 0x8F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF1, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xFC, 0x3F, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8,
  0x7E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x78, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0x38, 0x3C, 0x7E, 0x38, 0x7E, 0x6E, 0x70, 0xFF, 0xE7,
  0x71, 0xE3, 0xE7, 0x71, 0xC1, 0xE7, 0xE3, 0xC1, 0xE7, 0xE3, 0x81, 0xC7,
  0xE7, 0x81, 0xC7, 0xE7, 0x81, 0xC7, 0xE7, 0x01, 0xC7, 0xE7, 0x03, 0xC7,
  0xE7, 0x03, 0x87, 0xE7, 0x03, 0x87, 0xE7, 0x03, 0x86, 0xE7, 0x07, 0x8E,
  0xE7, 0x07, 0x8E, 0xE7, 0x0F, 0x8E, 0xE7, 0x9D, 0x9C, 0x73, 0xFD, 0xFC,
  0x73, 0xF9, 0xF8, 0x70, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x10, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xC0, 0x7E, 0x3F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x01,
  0xC7, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x9F, 0xF0, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x0F, 0xF3, 0xF0, 0x3F, 0xDF, 0x80, 0xFE,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03,
  0xFB, 0xF0, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F,
  0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0x7E, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x70, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0xC3,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80,
  0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x07,
  0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF7, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0x7F, 0xEF, 0x3D, 0xFF,
  0xBC, 0xF7, 0xFE, 0xF3, 0xDF, 0xFB, 0xFE, 0x7F, 0xE7, 0xF9, 0xFF, 0x9F,
  0xE7, 0xFE, 0x7F, 0x9F, 0xF9, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x8F, 0xC7,
  0xFE, 0x3F, 0x1F, 0xF8, 0x78, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xBE, 0x1F, 0xFB, 0xE1, 0xFF, 0xBE, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F,
  0xF9, 0xF1, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xFF, 0x87, 0xDF, 0xF8, 0x7D,
  0xFF, 0x87, 0xDF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF9, 0xFC, 0x0F, 0xE7,
  0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xC0, 0xFE, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0x8F, 0xE0, 0x7F, 0x1F, 0xE1, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0x3F, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0xCF, 0xC0, 0x7F, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFC,
  0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x3F, 0xCF, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF9, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x0F, 0xDF, 0xE0, 0x7F, 0xBF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7E, 0xFF, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x7E, 0x7E, 0x1E, 0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xF1,
  0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x9F, 0xE7, 0xC3, 0xE7,
  0xF9, 0xF0, 0xF9, 0xFE, 0xF8, 0x1E, 0xFF, 0xBE, 0x07, 0xFC, 0xFF, 0x81,
  0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x7F, 0x00, 0x3F, 0x8F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC,
  0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xCF,
  0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xFB,
  0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x03,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF8,
  0x00, 0x78, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x0F, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xF1, 0xFC, 0x1F,
  0xE3, 0xF8, 0x7F, 0xC3, 0xFF, 0xEF, 0xF7, 0xFF, 0x9F, 0xE7, 0xFE, 0x3F,
  0xC3, 0xF0, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x07, 0xE7, 0xFC, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF, 0xCF,
  0xF8, 0xFE, 0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF8, 0x3F,
  0xBF, 0xE3, 0xF9, 0xFF, 0xFF, 0xCF, 0xDF, 0xFC, 0x7E, 0x7F, 0xC3, 0xF0,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xF8, 0x7F, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8,
  0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xF8,
  0xFF, 0xBF, 0x83, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF8, 0x3F, 0xDF,
  0xE3, 0xFE, 0x7F, 0xFB, 0xF1, 0xFF, 0xDF, 0x87, 0xFC, 0xFC, 0x1F, 0x87,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x87, 0xF1, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0xFC,
  0x00, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x03, 0xE3, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF1, 0xFF, 0x1F,
  0x3F, 0xF9, 0xF7, 0xFF, 0xDF, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1,
  0xFF, 0x3F, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x3F,
  0x7E, 0x07, 0xF7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x0F, 0xCF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x87, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0x3F, 0x07, 0xF1,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0xBF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x87, 0xE0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E,
  0x03, 0xFB, 0xF0, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF0, 0xF8, 0xF7, 0xF3,
  0xF9, 0xEF, 0xEF, 0xF3, 0xFF, 0xDF, 0xF7, 0xE7, 0xF3, 0xEF, 0x8F, 0xC7,
  0xDF, 0x1F, 0x8F, 0xBE, 0x3E, 0x1F, 0x7C, 0x7C, 0x3E, 0xF0, 0x78, 0x7D,
  0xE0, 0xF0, 0xFB, 0xC1, 0xE1, 0xF7, 0x83, 0xC3, 0xEF, 0x07, 0x87, 0xDE,
  0x0F, 0x0F, 0xBC, 0x1E, 0x1F, 0x78, 0x3C, 0x3E, 0xF0, 0x78, 0x7D, 0xE0,
  0xF0, 0xFB, 0xC1, 0xE1, 0xF7, 0x83, 0xC3, 0xEF, 0x07, 0x87, 0xDE, 0x0F,
  0x0F, 0x80, 0xFC, 0x3F, 0x0F, 0xCF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0x87, 0xF1, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x3E, 0x07, 0xE7, 0xFC, 0x3F, 0x7F, 0xF1,
  0xFF, 0xFF, 0xCF, 0xF8, 0xFE, 0x7F, 0x83, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0,
  0x7E, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFE, 0x03,
  0xF7, 0xF0, 0x3F, 0xBF, 0xE3, 0xF9, 0xFF, 0xFF, 0xCF, 0xDF, 0xFC, 0x7E,
  0x7F, 0xC3, 0xF0, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E,
  0x7F, 0xFB, 0xF7, 0xF8, 0xFF, 0xBF, 0x83, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x7E, 0x03,
  0xFB, 0xF8, 0x3F, 0xDF, 0xE3, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xDF, 0x8F,
  0xFC, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFD, 0xF3, 0xFF, 0xBF,
  0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0x07, 0xE7,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xF7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x21, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xBF, 0x7F, 0xFB, 0xF3, 0xFF,
  0x3F, 0x1F, 0xC3, 0xF0, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC1, 0xE0, 0xF1,
  0xF0, 0xF8, 0x3C, 0x3C, 0x3F, 0x0F, 0x0F, 0x0F, 0xC7, 0xC3, 0xC7, 0xF1,
  0xF0, 0xF9, 0xFE, 0x7C, 0x3E, 0x77, 0x9E, 0x0F, 0xBC, 0xE7, 0x81, 0xEF,
  0x3D, 0xE0, 0x7B, 0xCF, 0x78, 0x1F, 0xE3, 0xDE, 0x07, 0xF8, 0x7F, 0x81,
  0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x01,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x00,
};

const GFXglyph LiberationMono_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 28, 26, 10, -28 },
  { 22, 16, 13, 26, 5, -31 },
  { 48, 24, 28, 26, 1, -28 },
  { 132, 23, 35, 26, 1, -31 },
  { 233, 26, 28, 26, 0, -28 },
  { 324, 26, 28, 26, 0, -28 },
  { 415, 6, 13, 26, 10, -31 },
  { 425, 12, 40, 26, 7, -31 },
  { 485, 13, 40, 26, 6, -31 },
  { 550, 16, 16, 26, 5, -31 },
  { 582, 22, 23, 26, 2, -26 },
  { 646, 11, 14, 26, 5, -6 },
  { 666, 12, 5, 26, 7, -14 },
  { 674, 6, 6, 26, 10, -6 },
  { 679, 22, 31, 26, 2, -31 },
  { 765, 21, 28, 26, 2, -28 },
  { 839, 21, 28, 26, 3, -28 },
  { 913, 20, 28, 26, 3, -28 },
  { 983, 22, 28, 26, 2, -28 },
  { 1060, 24, 28, 26, 1, -28 },
  { 1144, 22, 28, 26, 2, -28 },
  { 1221, 20, 28, 26, 3, -28 },
  { 1291, 20, 28, 26, 3, -28 },
  { 1361, 22, 28, 26, 2, -28 },
  { 1438, 21, 28, 26, 2, -28 },
  { 1512, 6, 23, 26, 10, -23 },
  { 1530, 10, 31, 26, 7, -23 },
  { 1569, 22, 23, 26, 2, -26 },
  { 1633, 22, 16, 26, 2, -22 },
  { 1677, 22, 23, 26, 2, -26 },
  { 1741, 21, 28, 26, 2, -28 },
  { 1815, 24, 37, 26, 1, -31 },
  { 1926, 26, 28, 26, 0, -28 },
  { 2017, 22, 28, 26, 3, -28 },
  { 2094, 23, 28, 26, 2, -28 },
  { 2175, 21, 28, 26, 3, -28 },
  { 2249, 21, 28, 26, 3, -28 },
  { 2323, 20, 28, 26, 3, -28 },
  { 2393, 22, 28, 26, 2, -28 },
  { 2470, 20, 28, 26, 3, -28 },
  { 2540, 20, 28, 26, 3, -28 },
  { 2610, 19, 28, 26, 2, -28 },
  { 2677, 23, 28, 26, 3, -28 },
  { 2758, 20, 28, 26, 4, -28 },
  { 2828, 22, 28, 26, 2, -28 },
  { 2905, 20, 28, 26, 3, -28 },
  { 2975, 22, 28, 26, 2, -28 },
  { 3052, 21, 28, 26, 3, -28 },
  { 3126, 23, 36, 26, 2, -28 },
  { 3230, 23, 28, 26, 3, -28 },
  { 3311, 23, 28, 26, 1, -28 },
  { 3392, 24, 28, 26, 1, -28 },
  { 3476, 20, 28, 26, 3, -28 },
  { 3546, 26, 28, 26, 0, -28 },
  { 3637, 26, 28, 26, 0, -28 },
  { 3728, 26, 28, 26, 0, -28 },
  { 3819, 26, 28, 26, 0, -28 },
  { 3910, 22, 28, 26, 2, -28 },
  { 3987, 12, 40, 26, 8, -31 },
  { 4047, 22, 31, 26, 2, -31 },
  { 4133, 13, 40, 26, 5, -31 },
  { 4198, 23, 19, 26, 1, -28 },
  { 4253, 26, 2, 26, 0, 3 },
  { 4260, 11, 6, 26, 7, -31 },
  { 4269, 23, 23, 26, 2, -23 },
  { 4336, 21, 31, 26, 3, -31 },
  { 4418, 21, 23, 26, 2, -23 },
  { 4479, 21, 31, 26, 2, -31 },
  { 4561, 22, 23, 26, 2, -23 },
  { 4625, 22, 31, 26, 2, -31 },
  { 4711, 20, 32, 26, 3, -23 },
  { 4791, 20, 31, 26, 3, -31 },
  { 4869, 22, 31, 26, 2, -31 },
  { 4955, 16, 40, 26, 2, -31 },
  { 5035, 21, 31, 26, 4, -31 },
  { 5117, 22, 31, 26, 2, -31 },
  { 5203, 23, 23, 26, 1, -23 },
  { 5270, 20, 23, 26, 3, -23 },
  { 5328, 22, 23, 26, 2, -23 },
  { 5392, 21, 32, 26, 3, -23 },
  { 5476, 21, 32, 26, 2, -23 },
  { 5560, 19, 23, 26, 4, -23 },
  { 5615, 20, 23, 26, 3, -23 },
  { 5673, 19, 29, 26, 3, -29 },
  { 5742, 20, 23, 26, 3, -23 },
  { 5800, 24, 23, 26, 1, -23 },
  { 5869, 26, 23, 26, 0, -23 },
  { 5944, 24, 23, 26, 1, -23 },
  { 6013, 24, 32, 26, 1, -23 },
  { 6109, 20, 23, 26, 3, -23 },
  { 6167, 18, 40, 26, 4, -31 },
  { 6257, 6, 41, 26, 10, -31 },
  { 6288, 18, 40, 26, 4, -31 },
  { 6378, 22, 7, 26, 2, -18 },
};

const GFXfont LiberationMono_Bold43pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold43pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold43pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _LIBERATIONMONO_BOLD43PT7B_H_
