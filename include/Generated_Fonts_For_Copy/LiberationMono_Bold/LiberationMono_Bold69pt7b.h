#ifndef _LIBERATIONMONO_BOLD69PT7B_H_
#define _LIBERATIONMONO_BOLD69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF,
  0xFB, 0xFE, 0xFF, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8,
  0x0F, 0xFB, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x7F,
  0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFE,
  0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xE3, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xC7, 0xBF, 0xFC, 0x1F, 0xF8, 0x3C,
  0x7F, 0xF0, 0xFF, 0x81, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0x07, 0xFC, 0x3F,
  0xE0, 0x78, 0x3F, 0xF1, 0xFF, 0x03, 0xC0, 0xFF, 0x8F, 0xF8, 0x1E, 0x07,
  0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x0F, 0xFC,
  0x3C, 0x00, 0x00, 0x7F, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x79, 0xFF, 0xF0, 0x00, 0x03, 0xC1, 0xFF, 0x80, 0x00,
  0x1E, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x1F, 0xF0, 0x38, 0x07, 0x80, 0xFF,
  0xBF, 0xC0, 0x3C, 0x07, 0xFF, 0xFF, 0x01, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F,
  0x01, 0xFF, 0x7F, 0xC0, 0x78, 0x0F, 0xFB, 0xFF, 0x03, 0xC0, 0xFF, 0x8F,
  0xFC, 0x1E, 0x0F, 0xFC, 0x7F, 0xF8, 0xF1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x87, 0xFF, 0xFC, 0x00, 0x1F, 0x83, 0xF8,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x83,
  0xF0, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x8F, 0xE1, 0xF8, 0x00, 0x1F, 0xFF, 0xF1, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0x8F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x7E,
  0x00, 0x1F, 0x87, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x3F, 0x83, 0xF0, 0x00, 0x7F,
  0xFF, 0xC1, 0xF8, 0x00, 0x1F, 0xFF, 0xC1, 0xF8, 0x00, 0x07, 0xFF, 0xE1,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xF7, 0xF8, 0x07,
  0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0x9F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xCF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x04, 0x07, 0xE0, 0x21, 0xE0, 0xFC, 0x3C, 0x3F, 0x9F, 0x9F, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF,
  0x00, 0xFF, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x3E,
  0x03, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x10, 0x04, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0x0F, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x0F,
  0xE1, 0xFF, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0x80, 0x1F, 0xFC,
  0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x03, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE1, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE1, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x03, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE3,
  0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFE, 0x3F, 0xF8, 0x03,
  0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE1, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xFC, 0x7F, 0xFE, 0x03, 0xFF, 0x3F, 0xFF, 0xC0, 0xFF,
  0xDF, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0xFF,
  0xEF, 0xFF, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xF0,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xC7,
  0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF,
  0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF, 0xE1,
  0xFF, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0x87, 0xFC,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x0F,
  0x07, 0xC0, 0x3F, 0xC7, 0xDF, 0x0F, 0x80, 0xFF, 0xCF, 0xBE, 0x1F, 0x03,
  0xFF, 0xDF, 0x3C, 0x7C, 0x0F, 0xC7, 0xBC, 0x78, 0xF8, 0x3F, 0x07, 0xF8,
  0xF9, 0xF0, 0x7C, 0x07, 0xF1, 0xF3, 0xC1, 0xF0, 0x0F, 0xE3, 0xE7, 0x83,
  0xE0, 0x1F, 0xC7, 0xDF, 0x0F, 0x80, 0x3F, 0x07, 0xBE, 0x1F, 0x00, 0x7E,
  0x0F, 0x7C, 0x3E, 0x00, 0xFC, 0x1E, 0xF8, 0xFC, 0x01, 0xF8, 0x3D, 0xE1,
  0xF0, 0x03, 0xF0, 0x7B, 0xC3, 0xE0, 0x07, 0xC0, 0xF7, 0x87, 0xC0, 0x0F,
  0x81, 0xEF, 0x0F, 0x80, 0x1F, 0x07, 0xFE, 0x3F, 0x00, 0x3E, 0x0F, 0xFC,
  0x7E, 0x00, 0xFC, 0x1F, 0xF8, 0xFC, 0x01, 0xF0, 0x3F, 0xF1, 0xF8, 0x03,
  0xE0, 0x7B, 0xE3, 0xF0, 0x07, 0xC0, 0xF3, 0xC7, 0xE0, 0x0F, 0x81, 0xE7,
  0x8F, 0xC0, 0x3F, 0x07, 0xCF, 0x0F, 0x80, 0x7E, 0x0F, 0x9E, 0x1F, 0x00,
  0xFC, 0x1E, 0x3E, 0x3E, 0x03, 0xF0, 0x3C, 0x7C, 0x7C, 0x0F, 0xE0, 0xF8,
  0xF8, 0xFC, 0x1D, 0xC1, 0xE1, 0xF0, 0xF8, 0x7B, 0xC7, 0xC1, 0xE1, 0xFF,
  0xE7, 0xFF, 0x03, 0xE1, 0xFF, 0x8F, 0xFC, 0x07, 0xC1, 0xFE, 0x0F, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x08, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xF8, 0xFF,
  0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xC0,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0xE0, 0x00, 0x38,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xE7, 0xFE, 0x00,
  0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x07, 0xFE, 0x3F,
  0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x80, 0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xF3,
  0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F,
  0xFB, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0x80,
  0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07,
  0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF3, 0xFF, 0x80,
  0x03, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x70, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xC0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xF1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xFE, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF, 0xF8, 0x1F, 0xBF, 0xFF, 0xFF,
  0x03, 0xF7, 0xFF, 0xF7, 0xE0, 0xFE, 0xFF, 0xFE, 0xFE, 0x1F, 0xDF, 0xFF,
  0xDF, 0xC3, 0xF3, 0xFF, 0xFB, 0xF8, 0xFE, 0x7F, 0xFF, 0x3F, 0x9F, 0xCF,
  0xFF, 0xE7, 0xF3, 0xF9, 0xFF, 0xFC, 0xFE, 0x7E, 0x3F, 0xFF, 0x9F, 0xCF,
  0xC7, 0xFF, 0xF1, 0xFB, 0xF8, 0xFF, 0xFE, 0x3F, 0x7F, 0x1F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF,
  0x3F, 0xC1, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF,
  0x1F, 0xE1, 0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF,
  0x0F, 0xF1, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0xFF,
  0x07, 0xF9, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0xFF,
  0x03, 0xFC, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x1F,
  0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFC,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x01, 0xFF,
  0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x1F, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F,
  0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8,
  0x3F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xFF, 0x8F, 0xF0,
  0x1F, 0xE7, 0xFF, 0xC7, 0xF8, 0x0F, 0xF3, 0xFF, 0xE3, 0xFC, 0x07, 0xF9,
  0xFB, 0xF9, 0xFC, 0x03, 0xFC, 0xFD, 0xFD, 0xFE, 0x01, 0xFE, 0xFE, 0xFE,
  0xFF, 0x00, 0x7F, 0x7F, 0x3F, 0x7F, 0x80, 0x3F, 0xBF, 0x1F, 0xFF, 0xC0,
  0x1F, 0xDF, 0x8F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xFF,
  0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFB, 0x7F, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x1F, 0xFF, 0xE0,
  0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xCF, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F,
  0xFB, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x03,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xBF,
  0xFE, 0x03, 0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0xCF, 0xFB, 0xFF, 0xFF, 0xC7,
  0xFD, 0xFF, 0xFF, 0xE3, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF, 0xE0,
  0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xE3, 0xFE, 0x07, 0xFF,
  0xFC, 0xFF, 0x83, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xE3,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF,
  0xF3, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xF3, 0xFE, 0x0F, 0xFF, 0xFE, 0xFF,
  0x87, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xFE, 0xFF, 0x83,
  0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0x83, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xF8, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0xE0, 0x0F,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07,
  0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xE7,
  0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0xFF,
  0x03, 0xFE, 0x3F, 0x8F, 0xFC, 0x3F, 0xF9, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF,
  0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xF9, 0xFF, 0x9F, 0xEE,
  0x3F, 0xCF, 0xF8, 0x7F, 0xE1, 0xFF, 0x7F, 0x83, 0xFF, 0x07, 0xFB, 0xFC,
  0x0F, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFC, 0x0F,
  0xF7, 0xF8, 0x1F, 0xE0, 0x7F, 0xBF, 0x80, 0xFF, 0x03, 0xFD, 0xFC, 0x07,
  0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFF, 0x7F, 0x01, 0xFE, 0x07, 0xFB,
  0xF8, 0x0F, 0xF0, 0x3F, 0xDF, 0xC0, 0x7F, 0x81, 0xFE, 0xFE, 0x03, 0xFC,
  0x0F, 0xF7, 0xF0, 0x1F, 0xE0, 0x7F, 0xBF, 0x80, 0xFF, 0x03, 0xFD, 0xFC,
  0x07, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFF, 0x7F, 0x01, 0xFE, 0x07,
  0xFB, 0xF8, 0x0F, 0xF0, 0x3F, 0xDF, 0xC0, 0x7F, 0x81, 0xFE, 0xFE, 0x03,
  0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xE0, 0x7F, 0xBF, 0x80, 0xFF, 0x03, 0xFD,
  0xFC, 0x07, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xC0, 0xFF, 0x7F, 0x01, 0xFE,
  0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0x3F, 0xDF, 0xC0, 0x7F, 0x81, 0xFE, 0xFE,
  0x03, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x3F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xC1, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xF8,
  0x1F, 0xF1, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0xFF,
  0xE3, 0xFE, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF8, 0x0F,
  0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x7F, 0xF7,
  0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xBF, 0xFF, 0xFC, 0x7F, 0xCF, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF, 0xFC,
  0x1F, 0xF0, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF,
  0x0F, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x8F, 0xFC, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE,
  0x01, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xCF, 0xF8,
  0x0F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xE7, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0xEF, 0xFB, 0xFC,
  0x01, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFE, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFE, 0x3F, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFF,
  0x07, 0xF0, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x1F, 0xC1, 0xFF, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFF, 0xF0, 0xFE, 0x03, 0xF8, 0xFD, 0xF8, 0x7F, 0x01, 0xFC,
  0x7E, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x1F,
  0x9F, 0xC0, 0x3F, 0x9F, 0x8F, 0xCF, 0xE0, 0x1F, 0xCF, 0xC3, 0xF7, 0xF0,
  0x07, 0xEF, 0xC1, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0xFD, 0xFC, 0x01, 0xFB,
  0xF0, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF,
  0xBF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x05, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
};

const GFXglyph LiberationMono_Bold69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 10, 45, 41, 16, -45 },
  { 58, 25, 21, 41, 8, -50 },
  { 124, 37, 45, 41, 2, -45 },
  { 333, 37, 57, 41, 2, -51 },
  { 597, 41, 47, 41, 0, -46 },
  { 838, 40, 47, 41, 1, -46 },
  { 1073, 9, 21, 41, 16, -50 },
  { 1097, 19, 64, 41, 12, -50 },
  { 1249, 20, 64, 41, 10, -50 },
  { 1409, 27, 26, 41, 7, -50 },
  { 1497, 35, 36, 41, 3, -41 },
  { 1655, 16, 22, 41, 9, -10 },
  { 1699, 19, 8, 41, 11, -22 },
  { 1718, 10, 10, 41, 16, -10 },
  { 1731, 35, 51, 41, 3, -50 },
  { 1955, 33, 47, 41, 4, -46 },
  { 2149, 33, 45, 41, 5, -45 },
  { 2335, 33, 46, 41, 4, -46 },
  { 2525, 35, 47, 41, 3, -46 },
  { 2731, 37, 45, 41, 2, -45 },
  { 2940, 35, 46, 41, 3, -45 },
  { 3142, 34, 47, 41, 4, -46 },
  { 3342, 33, 45, 41, 4, -45 },
  { 3528, 34, 47, 41, 4, -46 },
  { 3728, 33, 47, 41, 4, -46 },
  { 3922, 10, 36, 41, 16, -36 },
  { 3967, 16, 48, 41, 11, -36 },
  { 4063, 35, 37, 41, 3, -41 },
  { 4225, 35, 26, 41, 3, -36 },
  { 4339, 35, 37, 41, 3, -41 },
  { 4501, 36, 46, 41, 2, -46 },
  { 4708, 39, 60, 41, 1, -50 },
  { 5001, 41, 45, 41, 0, -45 },
  { 5232, 35, 45, 41, 5, -45 },
  { 5429, 36, 47, 41, 3, -46 },
  { 5641, 34, 45, 41, 5, -45 },
  { 5833, 34, 45, 41, 5, -45 },
  { 6025, 31, 45, 41, 6, -45 },
  { 6200, 35, 47, 41, 3, -46 },
  { 6406, 32, 45, 41, 5, -45 },
  { 6586, 31, 45, 41, 5, -45 },
  { 6761, 31, 46, 41, 3, -45 },
  { 6940, 36, 45, 41, 5, -45 },
  { 7143, 31, 45, 41, 7, -45 },
  { 7318, 35, 45, 41, 3, -45 },
  { 7515, 32, 45, 41, 5, -45 },
  { 7695, 37, 47, 41, 2, -46 },
  { 7913, 33, 45, 41, 5, -45 },
  { 8099, 37, 60, 41, 2, -46 },
  { 8377, 36, 45, 41, 5, -45 },
  { 8580, 38, 47, 41, 1, -46 },
  { 8804, 37, 45, 41, 2, -45 },
  { 9013, 33, 46, 41, 4, -45 },
  { 9203, 41, 45, 41, 0, -45 },
  { 9434, 41, 45, 41, 0, -45 },
  { 9665, 41, 45, 41, 0, -45 },
  { 9896, 41, 45, 41, 0, -45 },
  { 10127, 35, 45, 41, 3, -45 },
  { 10324, 20, 64, 41, 13, -50 },
  { 10484, 35, 51, 41, 3, -50 },
  { 10708, 20, 64, 41, 9, -50 },
  { 10868, 37, 30, 41, 2, -47 },
  { 11007, 42, 3, 41, 0, 4 },
  { 11023, 17, 9, 41, 12, -49 },
  { 11043, 36, 38, 41, 4, -37 },
  { 11214, 33, 51, 41, 5, -50 },
  { 11425, 33, 38, 41, 4, -37 },
  { 11582, 34, 51, 41, 3, -50 },
  { 11799, 35, 38, 41, 3, -37 },
  { 11966, 34, 51, 41, 4, -51 },
  { 12183, 34, 51, 41, 4, -37 },
  { 12400, 32, 50, 41, 5, -50 },
  { 12600, 35, 50, 41, 4, -50 },
  { 12819, 25, 64, 41, 4, -50 },
  { 13019, 33, 50, 41, 6, -50 },
  { 13226, 35, 50, 41, 4, -50 },
  { 13445, 37, 37, 41, 2, -37 },
  { 13617, 32, 37, 41, 5, -37 },
  { 13765, 35, 38, 41, 3, -37 },
  { 13932, 33, 51, 41, 5, -37 },
  { 14143, 34, 51, 41, 3, -37 },
  { 14360, 29, 37, 41, 7, -37 },
  { 14495, 33, 38, 41, 4, -37 },
  { 14652, 30, 47, 41, 5, -46 },
  { 14829, 32, 37, 41, 5, -36 },
  { 14977, 39, 36, 41, 1, -36 },
  { 15153, 41, 36, 41, 0, -36 },
  { 15338, 38, 36, 41, 2, -36 },
  { 15509, 39, 50, 41, 1, -36 },
  { 15753, 31, 36, 41, 5, -36 },
  { 15893, 28, 64, 41, 7, -50 },
  { 16117, 9, 65, 41, 16, -50 },
  { 16191, 29, 64, 41, 6, -50 },
  { 16423, 35, 11, 41, 3, -28 },
};

const GFXfont LiberationMono_Bold69pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold69pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold69pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _LIBERATIONMONO_BOLD69PT7B_H_
