#ifndef _LIBERATIONMONO_BOLD15PT7B_H_
#define _LIBERATIONMONO_BOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x24, 0x90, 0xFC, 0xDE, 0xF7, 0xBD, 0x80, 0x11, 0x09, 0x04,
  0x8F, 0xF2, 0x21, 0x33, 0xFC, 0x48, 0x64, 0x22, 0x00, 0x08, 0x3E, 0x6B,
  0x68, 0x68, 0x3C, 0x0B, 0x0B, 0x09, 0x6B, 0x3E, 0x08, 0x71, 0x49, 0xA4,
  0x92, 0x87, 0x80, 0x78, 0x52, 0x49, 0x64, 0xA3, 0x80, 0x1C, 0x1B, 0x09,
  0x87, 0xC3, 0x83, 0xCB, 0x6D, 0x9C, 0xC6, 0x3E, 0xC0, 0x49, 0x24, 0x66,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0x66, 0x66, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x66, 0x25, 0x7E, 0xED, 0x28, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00,
  0x6D, 0x68, 0xF8, 0xFC, 0x06, 0x0C, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x61,
  0x83, 0x00, 0x38, 0x8B, 0x1E, 0x3D, 0x7A, 0xF1, 0xE3, 0x44, 0x70, 0x18,
  0x73, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFC, 0x7D, 0x8C, 0x18, 0x70,
  0xE3, 0x8E, 0x30, 0xE1, 0xFC, 0x7D, 0x8C, 0x18, 0x33, 0x80, 0xC1, 0x83,
  0xC6, 0xF8, 0x0C, 0x1C, 0x3C, 0x6C, 0x4C, 0xCC, 0xFF, 0x0C, 0x0C, 0x0C,
  0xFF, 0x83, 0x07, 0xEC, 0x60, 0xC1, 0x83, 0xC6, 0xF8, 0x3C, 0xCF, 0x06,
  0xEE, 0x78, 0xF1, 0xE3, 0x66, 0x78, 0xFE, 0x0C, 0x30, 0xC1, 0x87, 0x0C,
  0x18, 0x30, 0xE0, 0x7D, 0x8F, 0x1E, 0x33, 0x98, 0xF1, 0xE3, 0xC6, 0xF8,
  0x79, 0x9B, 0x1E, 0x3C, 0x79, 0xDD, 0x83, 0xCC, 0xF0, 0xFC, 0x00, 0x3F,
  0x33, 0x00, 0x00, 0x36, 0x64, 0x40, 0x02, 0x19, 0xC4, 0x07, 0x01, 0x80,
  0x80, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x70, 0x11, 0xCC, 0x20,
  0x00, 0x7D, 0x8F, 0x18, 0x31, 0xC3, 0x0C, 0x00, 0x30, 0x60, 0x1E, 0x11,
  0x90, 0x4B, 0xD5, 0x6D, 0x16, 0x93, 0x49, 0xA5, 0x2D, 0x90, 0x0C, 0x61,
  0xC0, 0x1C, 0x0E, 0x0D, 0x86, 0xC3, 0x63, 0x19, 0xFC, 0xC6, 0xC1, 0xE0,
  0xC0, 0xFC, 0xC6, 0xC6, 0xC6, 0xF8, 0xC6, 0xC7, 0xC7, 0xC6, 0xFC, 0x3C,
  0xE6, 0xC6, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0x66, 0x3C, 0xF9, 0x9B, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xCD, 0xF0, 0xFF, 0x83, 0x06, 0x0F, 0xF8, 0x30,
  0x60, 0xC1, 0xFC, 0xFF, 0x83, 0x06, 0x0F, 0xF8, 0x30, 0x60, 0xC1, 0x80,
  0x7D, 0xCF, 0x1E, 0x0C, 0x1B, 0xF1, 0xE3, 0x66, 0x78, 0xC7, 0x8F, 0x1E,
  0x3F, 0xF8, 0xF1, 0xE3, 0xC7, 0x8C, 0xFE, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x39, 0xFC, 0x3C, 0x30, 0xC3, 0x0C, 0x30, 0xF3, 0xCD, 0xE0, 0xC6,
  0xCE, 0xCC, 0xD8, 0xF8, 0xF8, 0xFC, 0xCC, 0xC6, 0xC7, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0xF0, 0xC7, 0xDF, 0xBD, 0x5A, 0xB7, 0x64, 0xC1,
  0x83, 0x04, 0xE7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCF, 0x9C, 0x7D,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xF8, 0xFD, 0x8F, 0x1E, 0x3C,
  0x7F, 0xB0, 0x60, 0xC1, 0x80, 0x7C, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6,
  0xC6, 0xC6, 0x7C, 0x18, 0x18, 0x0F, 0xFC, 0xC6, 0xC6, 0xC6, 0xFC, 0xCC,
  0xCC, 0xC6, 0xC6, 0xC7, 0x3E, 0x31, 0x98, 0xCC, 0x07, 0xE0, 0xF8, 0x0D,
  0x86, 0x63, 0x1F, 0x00, 0xFF, 0x8E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x00, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCE,
  0xF8, 0xC1, 0xB1, 0x98, 0xCC, 0x63, 0x61, 0xB0, 0xD8, 0x28, 0x1C, 0x0E,
  0x00, 0xC1, 0xE0, 0xF0, 0x69, 0x25, 0xD3, 0xF9, 0xDC, 0xEE, 0x77, 0x31,
  0x80, 0x63, 0x31, 0x8D, 0x83, 0x81, 0xC0, 0xE0, 0xD8, 0x6C, 0x63, 0x71,
  0xC0, 0xC3, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x00, 0xFE, 0x1C, 0x30, 0xC3, 0x86, 0x1C, 0x30, 0xC1, 0xFC, 0xFC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xC1, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04,
  0x0C, 0x0C, 0x18, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x1C, 0x14,
  0x36, 0x26, 0x62, 0x63, 0x41, 0xFF, 0x80, 0xCC, 0x78, 0x6C, 0xCC, 0x7E,
  0xCE, 0xCE, 0xCE, 0x77, 0xC1, 0x83, 0x06, 0xEE, 0x78, 0xF1, 0xE3, 0xC7,
  0xCF, 0x70, 0x3D, 0xCF, 0x1E, 0x0C, 0x18, 0xF9, 0xBE, 0x06, 0x0C, 0x1B,
  0xBC, 0xF8, 0xF1, 0xE3, 0xC7, 0x9D, 0xD8, 0x7D, 0x8F, 0x1F, 0xFC, 0x18,
  0x39, 0xBE, 0x1E, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0x77, 0xDF, 0x1E, 0x3C, 0x78, 0xFB, 0xBB, 0x07, 0xCD, 0xF0, 0xC1, 0x83,
  0x06, 0xEE, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x18, 0x00, 0x03, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x33, 0xF8, 0x18, 0x00, 0xF1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0xF8, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC, 0xD8, 0xF8, 0xF8, 0xCC,
  0xCE, 0xC6, 0x78, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x33, 0xF8,
  0x5B, 0x6D, 0x49, 0x49, 0x49, 0x49, 0x49, 0x49, 0xDD, 0xCF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0x7D, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xBE, 0xDD, 0xCF,
  0x1E, 0x3C, 0x78, 0xF9, 0xEE, 0xC1, 0x83, 0x00, 0x77, 0x9F, 0x1E, 0x3C,
  0x78, 0xF3, 0xBB, 0x06, 0x0C, 0x18, 0x6E, 0xE1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x7D, 0x8F, 0x03, 0xC3, 0xE0, 0xF1, 0xBE, 0x20, 0x43, 0xF3, 0x06,
  0x0C, 0x18, 0x30, 0x30, 0x7C, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFB, 0xBB,
  0xE3, 0xB1, 0x98, 0xC6, 0xC3, 0x61, 0xB0, 0x70, 0x38, 0xC1, 0xE0, 0xF2,
  0x4B, 0xA5, 0x52, 0xB9, 0xDC, 0xC6, 0x63, 0x3B, 0x8D, 0x83, 0x81, 0xC1,
  0xB1, 0xDC, 0xC6, 0xE3, 0xB1, 0x98, 0xC6, 0x43, 0x60, 0xB0, 0x50, 0x38,
  0x18, 0x0C, 0x1C, 0x00, 0xFE, 0x18, 0x61, 0xC3, 0x0C, 0x38, 0x7F, 0x1E,
  0x60, 0xC1, 0x83, 0x06, 0x38, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x03, 0xC0,
  0xFF, 0xFC, 0xF0, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x8C, 0x18, 0x30, 0x60,
  0xC1, 0x9E, 0x00, 0xF0, 0x3C,
};

const GFXglyph LiberationMono_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 5, 5, 9, 2, -11 },
  { 9, 9, 10, 9, 0, -10 },
  { 21, 8, 12, 9, 0, -11 },
  { 33, 9, 10, 9, 0, -10 },
  { 45, 9, 10, 9, 0, -10 },
  { 57, 3, 5, 9, 3, -11 },
  { 59, 4, 14, 9, 3, -11 },
  { 66, 4, 14, 9, 2, -11 },
  { 73, 5, 6, 9, 2, -11 },
  { 77, 7, 7, 9, 1, -9 },
  { 84, 3, 5, 9, 2, -2 },
  { 86, 5, 1, 9, 2, -5 },
  { 87, 3, 2, 9, 3, -2 },
  { 88, 7, 11, 9, 1, -11 },
  { 98, 7, 10, 9, 1, -10 },
  { 107, 7, 10, 9, 1, -10 },
  { 116, 7, 10, 9, 1, -10 },
  { 125, 7, 10, 9, 1, -10 },
  { 134, 8, 10, 9, 1, -10 },
  { 144, 7, 10, 9, 1, -10 },
  { 153, 7, 10, 9, 1, -10 },
  { 162, 7, 10, 9, 1, -10 },
  { 171, 7, 10, 9, 1, -10 },
  { 180, 7, 10, 9, 1, -10 },
  { 189, 3, 8, 9, 3, -8 },
  { 192, 4, 11, 9, 2, -8 },
  { 198, 7, 7, 9, 1, -9 },
  { 205, 7, 5, 9, 1, -8 },
  { 210, 7, 7, 9, 1, -9 },
  { 217, 7, 10, 9, 1, -10 },
  { 226, 9, 13, 9, 0, -11 },
  { 241, 9, 10, 9, 0, -10 },
  { 253, 8, 10, 9, 1, -10 },
  { 263, 8, 10, 9, 1, -10 },
  { 273, 7, 10, 9, 1, -10 },
  { 282, 7, 10, 9, 1, -10 },
  { 291, 7, 10, 9, 1, -10 },
  { 300, 7, 10, 9, 1, -10 },
  { 309, 7, 10, 9, 1, -10 },
  { 318, 7, 10, 9, 1, -10 },
  { 327, 6, 10, 9, 1, -10 },
  { 335, 8, 10, 9, 1, -10 },
  { 345, 6, 10, 9, 2, -10 },
  { 353, 7, 10, 9, 1, -10 },
  { 362, 7, 10, 9, 1, -10 },
  { 371, 7, 10, 9, 1, -10 },
  { 380, 7, 10, 9, 1, -10 },
  { 389, 8, 13, 9, 1, -10 },
  { 402, 8, 10, 9, 1, -10 },
  { 412, 9, 10, 9, 0, -10 },
  { 424, 9, 10, 9, 0, -10 },
  { 436, 7, 10, 9, 1, -10 },
  { 445, 9, 10, 9, 0, -10 },
  { 457, 9, 10, 9, 0, -10 },
  { 469, 9, 10, 9, 0, -10 },
  { 481, 9, 10, 9, 0, -10 },
  { 493, 7, 10, 9, 1, -10 },
  { 502, 4, 14, 9, 3, -11 },
  { 509, 7, 11, 9, 1, -11 },
  { 519, 4, 14, 9, 2, -11 },
  { 526, 8, 7, 9, 0, -10 },
  { 533, 9, 1, 9, 0, 1 },
  { 535, 3, 2, 9, 3, -11 },
  { 536, 8, 8, 9, 1, -8 },
  { 544, 7, 11, 9, 1, -11 },
  { 554, 7, 8, 9, 1, -8 },
  { 561, 7, 11, 9, 1, -11 },
  { 571, 7, 8, 9, 1, -8 },
  { 578, 7, 11, 9, 1, -11 },
  { 588, 7, 11, 9, 1, -8 },
  { 598, 7, 11, 9, 1, -11 },
  { 608, 7, 11, 9, 1, -11 },
  { 618, 5, 14, 9, 1, -11 },
  { 627, 8, 11, 9, 1, -11 },
  { 638, 7, 11, 9, 1, -11 },
  { 648, 8, 8, 9, 0, -8 },
  { 656, 7, 8, 9, 1, -8 },
  { 663, 7, 8, 9, 1, -8 },
  { 670, 7, 11, 9, 1, -8 },
  { 680, 7, 11, 9, 1, -8 },
  { 690, 7, 8, 9, 1, -8 },
  { 697, 7, 8, 9, 1, -8 },
  { 704, 7, 10, 9, 1, -10 },
  { 713, 7, 8, 9, 1, -8 },
  { 720, 9, 8, 9, 0, -8 },
  { 729, 9, 8, 9, 0, -8 },
  { 738, 9, 8, 9, 0, -8 },
  { 747, 9, 11, 9, 0, -8 },
  { 760, 7, 8, 9, 1, -8 },
  { 767, 7, 14, 9, 1, -11 },
  { 780, 1, 14, 9, 4, -11 },
  { 782, 7, 14, 9, 1, -11 },
  { 795, 7, 2, 9, 1, -7 },
};

const GFXfont LiberationMono_Bold15pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold15pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold15pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _LIBERATIONMONO_BOLD15PT7B_H_
