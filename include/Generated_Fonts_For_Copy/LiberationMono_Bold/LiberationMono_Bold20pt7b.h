#ifndef _LIBERATIONMONO_BOLD20PT7B_H_
#define _LIBERATIONMONO_BOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xCF, 0xC0, 0xE7, 0x66, 0x66, 0x66, 0x66, 0x66, 0x18,
  0x84, 0x61, 0x1B, 0xFF, 0x31, 0x0C, 0x42, 0x30, 0x8C, 0xFF, 0xD8, 0x84,
  0x61, 0x18, 0x46, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0xB7, 0xED, 0xFB, 0x07,
  0xE0, 0x7E, 0x0F, 0xC3, 0x3C, 0xCF, 0xB7, 0x7F, 0xCF, 0xC0, 0xC0, 0x30,
  0x78, 0x6C, 0x84, 0xCC, 0xCC, 0xD8, 0xCD, 0x0C, 0xB0, 0x77, 0xE0, 0xD3,
  0x0B, 0x31, 0xB3, 0x33, 0x32, 0x13, 0x60, 0xE0, 0x0F, 0x01, 0xF8, 0x19,
  0x81, 0x98, 0x1B, 0x81, 0xE0, 0x3C, 0x66, 0xEE, 0xE6, 0xCE, 0x3C, 0xE3,
  0xC7, 0xFF, 0x3E, 0x70, 0xFF, 0xF0, 0x1C, 0xE3, 0x9C, 0x71, 0x86, 0x38,
  0xE3, 0x8E, 0x38, 0x61, 0x87, 0x1C, 0x38, 0xE1, 0xC0, 0xE1, 0xC7, 0x0E,
  0x38, 0x61, 0x87, 0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x71, 0xCE, 0x00,
  0x18, 0x18, 0x7E, 0xFF, 0x3C, 0x66, 0x24, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x76, 0xEC, 0xC8, 0xFF,
  0xF0, 0xFC, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x1E, 0x1F, 0xE7,
  0x3B, 0x87, 0xE1, 0xFB, 0x7E, 0xDF, 0x87, 0xE1, 0xF8, 0x67, 0x39, 0xFC,
  0x1E, 0x00, 0x0E, 0x07, 0x8F, 0xE3, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0x1F, 0xEE, 0x38, 0x07,
  0x03, 0x80, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0x1F, 0xEE, 0x3C, 0x07, 0x03, 0x87, 0xC1, 0xF0, 0x0F, 0x01, 0xC0,
  0x7E, 0x1F, 0xFE, 0x3F, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0x6E, 0x3B, 0x9C,
  0xE6, 0x3B, 0x0E, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0x7F, 0x9F,
  0xE6, 0x01, 0x80, 0x6F, 0x1F, 0xEF, 0x3C, 0x07, 0x01, 0xC0, 0x7E, 0x3D,
  0xFE, 0x3E, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x80, 0xEF, 0x3F, 0xEF, 0x3F,
  0x87, 0xE1, 0xD8, 0x77, 0x38, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0x18,
  0x0E, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x00, 0x3F, 0x1F, 0xEF, 0x3F, 0x87, 0x73, 0x8F, 0xC3, 0xF9, 0x87, 0xE1,
  0xF8, 0x7E, 0x1D, 0xFE, 0x3F, 0x00, 0x3E, 0x1F, 0xEF, 0x3B, 0x86, 0xE1,
  0xF8, 0x7F, 0x3D, 0xFF, 0x3D, 0xC0, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0xFC,
  0x00, 0xFC, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x3B, 0x9C, 0xC6, 0x60, 0x00,
  0x40, 0xF1, 0xFB, 0xF0, 0xE0, 0x38, 0x0F, 0xC0, 0x7E, 0x03, 0xC0, 0x10,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x3C, 0x07,
  0xE0, 0x3F, 0x01, 0xC0, 0x70, 0xFD, 0xF8, 0xF0, 0x20, 0x00, 0x3F, 0x1F,
  0xEE, 0x1F, 0x87, 0x01, 0xC0, 0xE0, 0xF0, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x00, 0x0F, 0x81, 0x8C, 0x30, 0x62, 0x02, 0x66, 0xE4, 0x9A,
  0x59, 0xB5, 0x9B, 0xD1, 0xBD, 0x1A, 0xD1, 0x25, 0x12, 0x5B, 0x64, 0xCC,
  0x60, 0x02, 0x04, 0x30, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8,
  0x19, 0x83, 0x9C, 0x39, 0xC3, 0x9C, 0x7F, 0xE7, 0xFE, 0x70, 0xEE, 0x07,
  0xE0, 0x70, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0xEE, 0x19, 0xFE, 0x3F, 0xE7,
  0x0E, 0xE0, 0xFC, 0x1F, 0x87, 0x7F, 0xEF, 0xF8, 0x1F, 0x1F, 0xE7, 0x1F,
  0x87, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x37, 0x1D, 0xFE, 0x1F,
  0x00, 0xFE, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x3B, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0,
  0x3F, 0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x00, 0x1F, 0x1F, 0xE7, 0x3B, 0x87, 0xE0, 0x38, 0x0E, 0x7F, 0x9F,
  0xE1, 0xF8, 0x77, 0x1D, 0xFE, 0x1F, 0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x1F, 0x8F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xE3, 0xF1,
  0xDC, 0xEF, 0xE3, 0xE0, 0xE1, 0xDC, 0x7B, 0x8E, 0x73, 0x8E, 0xE1, 0xF8,
  0x3F, 0x87, 0xF8, 0xF7, 0x1C, 0x73, 0x8E, 0x70, 0xEE, 0x1E, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF,
  0xF8, 0xE1, 0xFC, 0xFF, 0x3F, 0xCF, 0xDA, 0xF7, 0xBD, 0xEF, 0x7B, 0xCC,
  0xF3, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xF1, 0xFC, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFF, 0x7E, 0xDF, 0xBF, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xC0, 0x1E,
  0x1F, 0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x77,
  0x39, 0xFE, 0x1E, 0x00, 0xFF, 0x3F, 0xEE, 0x1F, 0x87, 0xE1, 0xF8, 0x7F,
  0xFB, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x1F, 0xE7,
  0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE,
  0x3F, 0x03, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0xFF, 0x1F, 0xFB, 0x87, 0x70,
  0xEE, 0x1D, 0xC3, 0xBF, 0xE7, 0xF8, 0xE7, 0x1C, 0x73, 0x8E, 0x70, 0xEE,
  0x1E, 0x1F, 0x87, 0xF9, 0xC7, 0xB8, 0x77, 0x00, 0x7E, 0x07, 0xF0, 0x1F,
  0x00, 0xFC, 0x0D, 0xC3, 0x9F, 0xE1, 0xF8, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x77, 0x39, 0xFE, 0x3E, 0x00, 0xE0, 0x76, 0x06, 0x70, 0xE7, 0x0E, 0x30,
  0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x66, 0x66, 0x66, 0x6F, 0x66,
  0xF6, 0x7F, 0x63, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC0, 0x70, 0xE7, 0x0E,
  0x39, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x83, 0x9C,
  0x39, 0xC7, 0x0E, 0xE0, 0x70, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x9C, 0x19,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x7F, 0xDF, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38,
  0x1C, 0x0F, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x6C, 0x0C,
  0xC3, 0x98, 0x61, 0x8C, 0x33, 0x07, 0x60, 0x60, 0xFF, 0xF0, 0xE1, 0x86,
  0x3E, 0x0F, 0xE1, 0xCE, 0x01, 0xC3, 0xF8, 0xFF, 0x38, 0xE7, 0x1C, 0xE7,
  0x9F, 0xBD, 0xE7, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x3F, 0xEF,
  0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xFF, 0xEE, 0xF0, 0x1E,
  0x1F, 0xE7, 0x3B, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0x73, 0x9F, 0xE1,
  0xE0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x3D, 0xDF, 0xFF, 0x3F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x1E, 0x1F, 0xE7, 0x1B,
  0x87, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x71, 0xDF, 0xE1, 0xF0, 0x0F, 0xC7,
  0xF1, 0xC0, 0x60, 0xFF, 0xFF, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x3D, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0x73, 0xDF, 0xF3, 0xDC, 0x07, 0x73, 0x9F, 0xE3, 0xF0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0x3B, 0xEF, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F,
  0xFF, 0xFC, 0x06, 0x0C, 0x00, 0x07, 0xEF, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x0F, 0xFF, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x3E, 0x3B, 0x39, 0xB8, 0xFC, 0x7E, 0x3B, 0x99, 0xCC, 0x76, 0x1F, 0x0E,
  0x7E, 0x1F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFC, 0xD9, 0xBF, 0xFC, 0xEF, 0x33,
  0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCC, 0xE7, 0x3B, 0xEF,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x1F,
  0x1F, 0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE1,
  0xE0, 0xEF, 0x3B, 0xEF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3,
  0xFF, 0xEE, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x3D, 0xDF, 0xFF, 0x3F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0xEF, 0xF7, 0xFE, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x00, 0x3F, 0x1F, 0xE6, 0x19, 0x80, 0x7C, 0x0F, 0xE0,
  0x7C, 0x07, 0xE1, 0xDF, 0xE3, 0xF0, 0x30, 0x30, 0x70, 0xFF, 0xFF, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0x77, 0xDC, 0xE0, 0x67,
  0x0E, 0x70, 0xE3, 0x0C, 0x39, 0xC3, 0x9C, 0x19, 0x81, 0xF8, 0x1F, 0x00,
  0xF0, 0x0F, 0x00, 0xC0, 0x3E, 0x07, 0x60, 0x66, 0x66, 0x66, 0x66, 0xF6,
  0x6F, 0x66, 0x96, 0x79, 0xC3, 0x9C, 0x30, 0xC0, 0x70, 0xE3, 0x9C, 0x39,
  0xC1, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x39, 0xC3, 0x0C, 0x70,
  0xE0, 0x60, 0x67, 0x0E, 0x70, 0xE3, 0x0C, 0x39, 0xC1, 0x9C, 0x19, 0x81,
  0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x07, 0xC0, 0x78, 0x00,
  0x7F, 0x9F, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x3F,
  0xFF, 0xFC, 0x1F, 0x3F, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF0, 0xF0,
  0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F, 0x0F,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFC, 0xF8, 0x70, 0x3F, 0x18,
  0xFC, 0x0E,
};

const GFXglyph LiberationMono_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 13, 12, 5, -13 },
  { 5, 8, 6, 12, 2, -15 },
  { 11, 10, 13, 12, 1, -13 },
  { 28, 10, 16, 12, 1, -14 },
  { 48, 12, 13, 12, 0, -13 },
  { 68, 12, 13, 12, 0, -13 },
  { 88, 2, 6, 12, 5, -15 },
  { 90, 6, 19, 12, 3, -15 },
  { 105, 6, 19, 12, 3, -15 },
  { 120, 8, 7, 12, 2, -15 },
  { 127, 10, 10, 12, 1, -12 },
  { 140, 4, 6, 12, 3, -3 },
  { 143, 6, 2, 12, 3, -6 },
  { 145, 2, 3, 12, 5, -3 },
  { 146, 10, 15, 12, 1, -15 },
  { 165, 10, 13, 12, 1, -13 },
  { 182, 10, 13, 12, 1, -13 },
  { 199, 10, 13, 12, 1, -13 },
  { 216, 10, 13, 12, 1, -13 },
  { 233, 10, 13, 12, 1, -13 },
  { 250, 10, 13, 12, 1, -13 },
  { 267, 10, 13, 12, 1, -13 },
  { 284, 10, 13, 12, 1, -13 },
  { 301, 10, 13, 12, 1, -13 },
  { 318, 10, 13, 12, 1, -13 },
  { 335, 2, 11, 12, 5, -11 },
  { 338, 5, 14, 12, 3, -11 },
  { 347, 10, 10, 12, 1, -12 },
  { 360, 10, 7, 12, 1, -10 },
  { 369, 10, 10, 12, 1, -12 },
  { 382, 10, 13, 12, 1, -13 },
  { 399, 12, 18, 12, 0, -15 },
  { 426, 12, 13, 12, 0, -13 },
  { 446, 11, 13, 12, 1, -13 },
  { 464, 10, 13, 12, 1, -13 },
  { 481, 10, 13, 12, 1, -13 },
  { 498, 10, 13, 12, 1, -13 },
  { 515, 9, 13, 12, 2, -13 },
  { 530, 10, 13, 12, 1, -13 },
  { 547, 10, 13, 12, 1, -13 },
  { 564, 8, 13, 12, 2, -13 },
  { 577, 9, 13, 12, 1, -13 },
  { 592, 11, 13, 12, 1, -13 },
  { 610, 9, 13, 12, 2, -13 },
  { 625, 10, 13, 12, 1, -13 },
  { 642, 10, 13, 12, 1, -13 },
  { 659, 10, 13, 12, 1, -13 },
  { 676, 10, 13, 12, 1, -13 },
  { 693, 10, 17, 12, 1, -13 },
  { 715, 11, 13, 12, 1, -13 },
  { 733, 11, 13, 12, 0, -13 },
  { 751, 10, 13, 12, 1, -13 },
  { 768, 10, 13, 12, 1, -13 },
  { 785, 12, 13, 12, 0, -13 },
  { 805, 12, 13, 12, 0, -13 },
  { 825, 12, 13, 12, 0, -13 },
  { 845, 12, 13, 12, 0, -13 },
  { 865, 10, 13, 12, 1, -13 },
  { 882, 6, 19, 12, 4, -15 },
  { 897, 10, 15, 12, 1, -15 },
  { 916, 6, 19, 12, 2, -15 },
  { 931, 11, 9, 12, 0, -13 },
  { 944, 12, 1, 12, 0, 1 },
  { 946, 5, 3, 12, 3, -15 },
  { 948, 11, 11, 12, 1, -11 },
  { 964, 10, 15, 12, 1, -15 },
  { 983, 10, 11, 12, 1, -11 },
  { 997, 10, 15, 12, 1, -15 },
  { 1016, 10, 11, 12, 1, -11 },
  { 1030, 10, 15, 12, 1, -15 },
  { 1049, 10, 15, 12, 1, -11 },
  { 1068, 10, 15, 12, 1, -15 },
  { 1087, 10, 15, 12, 1, -15 },
  { 1106, 7, 19, 12, 1, -15 },
  { 1123, 9, 15, 12, 2, -15 },
  { 1140, 10, 15, 12, 1, -15 },
  { 1159, 10, 11, 12, 1, -11 },
  { 1173, 10, 11, 12, 1, -11 },
  { 1187, 10, 11, 12, 1, -11 },
  { 1201, 10, 15, 12, 1, -11 },
  { 1220, 10, 15, 12, 1, -11 },
  { 1239, 9, 11, 12, 2, -11 },
  { 1252, 10, 11, 12, 1, -11 },
  { 1266, 8, 14, 12, 2, -14 },
  { 1280, 10, 11, 12, 1, -11 },
  { 1294, 12, 11, 12, 0, -11 },
  { 1311, 12, 11, 12, 0, -11 },
  { 1328, 12, 11, 12, 0, -11 },
  { 1345, 12, 15, 12, 0, -11 },
  { 1368, 10, 11, 12, 1, -11 },
  { 1382, 8, 19, 12, 2, -15 },
  { 1401, 2, 19, 12, 5, -15 },
  { 1406, 8, 19, 12, 2, -15 },
  { 1425, 10, 4, 12, 1, -9 },
};

const GFXfont LiberationMono_Bold20pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold20pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _LIBERATIONMONO_BOLD20PT7B_H_
