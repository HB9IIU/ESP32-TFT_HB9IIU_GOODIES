#ifndef _LIBERATIONMONO_BOLD62PT7B_H_
#define _LIBERATIONMONO_BOLD62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF,
  0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0x7E, 0x03, 0xF9, 0xF8,
  0x0F, 0xE7, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x73, 0xFF, 0x07, 0xFC, 0x38, 0x7F, 0xC3, 0xFC, 0x1C, 0x1F,
  0xE1, 0xFE, 0x0E, 0x0F, 0xF8, 0xFE, 0x07, 0x03, 0xFC, 0x7F, 0x03, 0x81,
  0xC0, 0x3F, 0xC1, 0xC0, 0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x0F, 0xF8, 0x70,
  0x00, 0x07, 0xFF, 0xB8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1C, 0x7F, 0xF0, 0x00, 0x0E, 0x0F, 0xF8, 0x00,
  0x07, 0x03, 0xFC, 0x00, 0x03, 0x80, 0xFF, 0x07, 0x01, 0xC0, 0x7F, 0xFF,
  0x80, 0xE0, 0x3F, 0xFF, 0xC0, 0x70, 0x1F, 0xEF, 0xF0, 0x38, 0x0F, 0xF7,
  0xF8, 0x1C, 0x07, 0xFB, 0xFE, 0x0E, 0x07, 0xF8, 0xFF, 0x87, 0x07, 0xFC,
  0x7F, 0xF3, 0x8F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x0F,
  0xFF, 0x80, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0x00,
  0xF8, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x81,
  0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x3F, 0x00, 0x7E, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x3E, 0x1F, 0x00, 0x0F,
  0x83, 0xF1, 0xF0, 0x00, 0x7E, 0x3F, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0xF8,
  0x00, 0x0F, 0xFF, 0x8F, 0x80, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x00, 0x7F,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x03, 0xE3, 0xFF, 0xE0, 0x00, 0x3F,
  0x3F, 0xFF, 0x80, 0x03, 0xF1, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x83, 0xF0,
  0x01, 0xF0, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x7C, 0x00, 0xF8, 0x3E,
  0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x01,
  0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0xFC, 0x3F, 0x00,
  0x1F, 0x8F, 0xC1, 0xF0, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x03, 0xFF, 0xE1,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0xFF, 0xF8, 0x03, 0xF8,
  0x1F, 0xFF, 0xC0, 0x3F, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0xEF, 0xE0,
  0x7F, 0x07, 0xFC, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0x7E, 0x0F, 0xF0,
  0x7F, 0x8F, 0xE0, 0xFF, 0x03, 0xFC, 0xFE, 0x0F, 0xE0, 0x1F, 0xEF, 0xC0,
  0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0xFF,
  0xBF, 0xDF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x7E,
  0x0C, 0x78, 0x7E, 0x3C, 0x7E, 0x7C, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC7,
  0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF0, 0x07, 0x01,
  0xC0, 0x02, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x7F, 0x1F,
  0xEF, 0xF1, 0xFC, 0x7F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF, 0x1F, 0xC7, 0xFF,
  0xFC, 0x7F, 0x1F, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF,
  0x1F, 0xC7, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xDF,
  0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF1, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC7, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x80, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x0F,
  0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x1F, 0xE7, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC7, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x07,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xC7, 0xFC, 0x00, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0xFF, 0x1F, 0xFF, 0x03, 0xFC, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xCF, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFD, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x01, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0x80,
  0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x03,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xCF, 0xF0,
  0x1F, 0xFE, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x01, 0xFE, 0x7F, 0xC0,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F,
  0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x0F, 0x80, 0x7C,
  0x3C, 0x07, 0xF9, 0xF7, 0x87, 0x81, 0xFF, 0xBC, 0xF1, 0xF0, 0x7F, 0xF7,
  0x9E, 0x3C, 0x1F, 0x8E, 0xF1, 0xE7, 0x83, 0xE0, 0xFE, 0x3D, 0xF0, 0xF8,
  0x1F, 0xC7, 0xBC, 0x1E, 0x01, 0xF0, 0xF7, 0x87, 0xC0, 0x3E, 0x1E, 0xF0,
  0xF0, 0x07, 0xC3, 0xDE, 0x3E, 0x00, 0xF8, 0x7B, 0xC7, 0xC0, 0x1F, 0x0F,
  0x78, 0xF8, 0x03, 0xC1, 0xFF, 0x1F, 0x00, 0xF8, 0x3F, 0xE3, 0xC0, 0x1F,
  0x07, 0xF8, 0x78, 0x03, 0xE0, 0xFF, 0x1F, 0x00, 0x7C, 0x1F, 0xE3, 0xE0,
  0x0F, 0x03, 0xBC, 0x7C, 0x01, 0xE0, 0xF7, 0x8F, 0x80, 0x7C, 0x1E, 0xF9,
  0xF0, 0x0F, 0x83, 0xDF, 0x1E, 0x01, 0xF0, 0x79, 0xE3, 0xC0, 0x7E, 0x1E,
  0x3C, 0x7C, 0x0F, 0xC3, 0xC7, 0x8F, 0x83, 0xF0, 0xF8, 0xF1, 0xF8, 0xFF,
  0x1E, 0x1E, 0x1F, 0xFC, 0xFF, 0x83, 0xE3, 0xFF, 0x1F, 0xF0, 0x3C, 0x3F,
  0xC3, 0xFC, 0x07, 0x81, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x10,
  0x03, 0xE0, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x0F, 0xC3,
  0xFE, 0x00, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x81, 0xFF, 0x80,
  0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF,
  0x80, 0x7F, 0xF1, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0,
  0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x01, 0xFF,
  0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xF1,
  0xFF, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0,
  0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0,
  0x01, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7F, 0xC0,
  0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x07, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x07,
  0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x03,
  0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x01,
  0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC,
  0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xF9, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0xFC,
  0x0F, 0xFF, 0xFD, 0xF8, 0x1F, 0x7F, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0xE0,
  0xFD, 0xFF, 0xFF, 0xE1, 0xFB, 0xFF, 0xEF, 0xC3, 0xFF, 0xFF, 0xDF, 0x8F,
  0xDF, 0xFF, 0xBF, 0x1F, 0xBF, 0xFF, 0x7F, 0x3F, 0x7F, 0xFE, 0x7E, 0x7E,
  0xFF, 0xFC, 0xFD, 0xF9, 0xFF, 0xF9, 0xFB, 0xF3, 0xFF, 0xF1, 0xF7, 0xE7,
  0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0x8F, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFC, 0x7F, 0xFE, 0x1F, 0xF0, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0x7F, 0x03,
  0xFF, 0xF9, 0xFC, 0x1F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0x7F, 0x87, 0xFF,
  0xF9, 0xFC, 0x3F, 0xFF, 0xCF, 0xE1, 0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0xF1,
  0xFC, 0x7F, 0xFF, 0x8F, 0xE3, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0xE1, 0xFC,
  0xFF, 0xFF, 0x0F, 0xF3, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xC1, 0xFC, 0xFF,
  0xFE, 0x07, 0xF7, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0x81, 0xFD, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x8F, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x3F, 0xFE, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x7F, 0xF7, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF,
  0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x0F, 0xFE,
  0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00,
  0x1F, 0xF7, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xFC, 0x1F,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x01, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x87, 0xF8,
  0x7F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0xFE,
  0x07, 0xF0, 0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0xF1, 0xFC, 0x0F, 0xF3, 0xFF, 0xCF, 0xE0, 0x3F, 0xBF, 0x7E, 0x7F, 0x01,
  0xFD, 0xFB, 0xF3, 0xF8, 0x0F, 0xEF, 0xDF, 0xBF, 0x80, 0x7F, 0x7E, 0x7F,
  0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00,
  0x1F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xFF, 0xBF, 0xFD,
  0xFF, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x7F,
  0xFE, 0x0F, 0xFB, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xE1, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xBF, 0xF8, 0x03, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x80, 0x3F, 0xEF, 0xFF, 0x01, 0xFF, 0xBF,
  0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0x8F, 0xF9,
  0xFF, 0xFC, 0x3F, 0xE7, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x7F,
  0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0x81, 0xFF, 0x03, 0xFF, 0xC7, 0xFC, 0x1F, 0xFF, 0x9F, 0xF0, 0xFF,
  0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE1,
  0xFF, 0xF3, 0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFD, 0xFF, 0x80, 0x7F, 0xF3, 0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0x7F, 0xC1,
  0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0x83, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xE0, 0xFF, 0x80, 0x0F, 0xF1, 0xFF, 0x80, 0x3F, 0xE1,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x40, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x7F, 0xC3, 0xFF, 0xFD, 0xFF, 0x1F,
  0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0xDF, 0xF8,
  0x0F, 0xFF, 0x7F, 0xC0, 0x1F, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x03,
  0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF,
  0xF1, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0x87, 0xFC,
  0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0xFF, 0x9F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFC,
  0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0xC7, 0xFF, 0xE3, 0xFE, 0x7F, 0xFF, 0x9F,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xB0, 0x07, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x7E, 0x3F, 0xC1, 0xFF, 0x3F, 0xBF, 0xF1, 0xFF, 0x9F, 0xDF, 0xF9, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFC, 0x7F, 0xE3, 0xFB, 0xFE, 0x3F, 0xE1,
  0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0x83, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0,
  0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xFC,
  0x3F, 0xC3, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xCF, 0xF3, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x1F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0xF8,
  0x3F, 0xE7, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0x87, 0xFF, 0x3F, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xEF, 0xFE, 0x00, 0xFF, 0xBF, 0xFC, 0x07, 0xFE, 0xFF, 0xF8,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFB, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF,
  0xF0, 0xFF, 0x9F, 0xFF, 0x83, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x7F, 0xC3, 0xFF, 0xFD,
  0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7,
  0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFD, 0xFF, 0x07, 0xFF,
  0xE7, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0xC7, 0xFF, 0xF7, 0xF9, 0xFF, 0xFE,
  0xFF, 0x3F, 0xFF, 0xDF, 0xEF, 0xE0, 0x0B, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0xFF, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFB, 0xFC,
  0x00, 0x3E, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x40, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0x9F, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF, 0x3F, 0xE1, 0xFF, 0xF0,
  0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xC1,
  0xFF, 0x07, 0xF0, 0x7E, 0x0F, 0xFC, 0x3F, 0x03, 0xF0, 0xFF, 0xE1, 0xF8,
  0x1F, 0x87, 0xDF, 0x0F, 0xC0, 0xFE, 0x3E, 0xF8, 0xFE, 0x07, 0xF3, 0xF7,
  0xE7, 0xF0, 0x1F, 0x9F, 0x9F, 0x3F, 0x00, 0xFC, 0xF8, 0xF9, 0xF8, 0x07,
  0xEF, 0xC7, 0xEF, 0xC0, 0x3F, 0x7E, 0x1F, 0x7E, 0x01, 0xFB, 0xE0, 0xFB,
  0xF0, 0x0F, 0xDF, 0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC7,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
};

const GFXglyph LiberationMono_Bold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 9, 41, 37, 14, -41 },
  { 48, 22, 19, 37, 8, -45 },
  { 101, 33, 41, 37, 2, -41 },
  { 271, 33, 51, 37, 2, -46 },
  { 482, 37, 43, 37, 0, -42 },
  { 681, 36, 43, 37, 1, -42 },
  { 875, 9, 19, 37, 14, -45 },
  { 897, 18, 58, 37, 10, -45 },
  { 1028, 18, 58, 37, 9, -45 },
  { 1159, 24, 23, 37, 7, -45 },
  { 1228, 31, 31, 37, 3, -36 },
  { 1349, 14, 20, 37, 8, -9 },
  { 1384, 17, 7, 37, 10, -20 },
  { 1399, 9, 9, 37, 14, -9 },
  { 1410, 31, 46, 37, 3, -45 },
  { 1589, 30, 43, 37, 4, -42 },
  { 1751, 31, 41, 37, 4, -41 },
  { 1910, 30, 42, 37, 4, -42 },
  { 2068, 31, 43, 37, 3, -42 },
  { 2235, 33, 41, 37, 2, -41 },
  { 2405, 31, 42, 37, 3, -41 },
  { 2568, 30, 43, 37, 4, -42 },
  { 2730, 29, 41, 37, 4, -41 },
  { 2879, 31, 43, 37, 3, -42 },
  { 3046, 30, 43, 37, 3, -42 },
  { 3208, 9, 33, 37, 14, -33 },
  { 3246, 15, 44, 37, 10, -33 },
  { 3329, 31, 33, 37, 3, -37 },
  { 3457, 31, 23, 37, 3, -32 },
  { 3547, 31, 33, 37, 3, -37 },
  { 3675, 32, 42, 37, 2, -42 },
  { 3843, 35, 54, 37, 1, -45 },
  { 4080, 37, 41, 37, 0, -41 },
  { 4270, 32, 41, 37, 4, -41 },
  { 4434, 33, 43, 37, 2, -42 },
  { 4612, 31, 41, 37, 4, -41 },
  { 4771, 31, 41, 37, 4, -41 },
  { 4930, 28, 41, 37, 5, -41 },
  { 5074, 32, 43, 37, 2, -42 },
  { 5246, 29, 41, 37, 4, -41 },
  { 5395, 27, 41, 37, 5, -41 },
  { 5534, 28, 42, 37, 3, -41 },
  { 5681, 33, 41, 37, 4, -41 },
  { 5851, 28, 41, 37, 6, -41 },
  { 5995, 31, 41, 37, 3, -41 },
  { 6154, 29, 41, 37, 4, -41 },
  { 6303, 33, 43, 37, 2, -42 },
  { 6481, 31, 41, 37, 4, -41 },
  { 6640, 33, 54, 37, 2, -42 },
  { 6863, 33, 41, 37, 4, -41 },
  { 7033, 34, 43, 37, 1, -42 },
  { 7216, 33, 41, 37, 2, -41 },
  { 7386, 29, 42, 37, 4, -41 },
  { 7539, 37, 41, 37, 0, -41 },
  { 7729, 37, 41, 37, 0, -41 },
  { 7919, 37, 41, 37, 0, -41 },
  { 8109, 37, 41, 37, 0, -41 },
  { 8299, 31, 41, 37, 3, -41 },
  { 8458, 19, 58, 37, 11, -45 },
  { 8596, 32, 46, 37, 3, -45 },
  { 8780, 18, 58, 37, 8, -45 },
  { 8911, 34, 27, 37, 1, -43 },
  { 9026, 37, 3, 37, 0, 4 },
  { 9040, 16, 8, 37, 10, -44 },
  { 9056, 33, 35, 37, 3, -34 },
  { 9201, 30, 46, 37, 4, -45 },
  { 9374, 31, 35, 37, 3, -34 },
  { 9510, 30, 46, 37, 3, -45 },
  { 9683, 31, 35, 37, 3, -34 },
  { 9819, 30, 46, 37, 4, -46 },
  { 9992, 30, 47, 37, 4, -34 },
  { 10169, 29, 45, 37, 4, -45 },
  { 10333, 31, 45, 37, 4, -45 },
  { 10508, 22, 58, 37, 4, -45 },
  { 10668, 30, 45, 37, 5, -45 },
  { 10837, 31, 45, 37, 4, -45 },
  { 11012, 33, 34, 37, 2, -34 },
  { 11153, 29, 34, 37, 4, -34 },
  { 11277, 31, 35, 37, 3, -34 },
  { 11413, 30, 47, 37, 4, -34 },
  { 11590, 30, 47, 37, 3, -34 },
  { 11767, 27, 34, 37, 6, -34 },
  { 11882, 29, 35, 37, 4, -34 },
  { 12009, 26, 43, 37, 5, -42 },
  { 12149, 29, 34, 37, 4, -33 },
  { 12273, 35, 33, 37, 1, -33 },
  { 12418, 37, 33, 37, 0, -33 },
  { 12571, 35, 33, 37, 1, -33 },
  { 12716, 35, 46, 37, 1, -33 },
  { 12918, 29, 33, 37, 4, -33 },
  { 13038, 26, 58, 37, 6, -45 },
  { 13227, 8, 59, 37, 15, -45 },
  { 13286, 25, 58, 37, 6, -45 },
  { 13468, 31, 10, 37, 3, -25 },
};

const GFXfont LiberationMono_Bold62pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold62pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold62pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _LIBERATIONMONO_BOLD62PT7B_H_
