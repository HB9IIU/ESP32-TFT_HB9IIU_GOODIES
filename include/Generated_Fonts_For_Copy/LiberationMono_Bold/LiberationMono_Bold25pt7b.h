#ifndef _LIBERATIONMONO_BOLD25PT7B_H_
#define _LIBERATIONMONO_BOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0x0C, 0x30, 0x61, 0x03, 0x19, 0xFF, 0xFF, 0xFF,
  0x8C, 0x30, 0x63, 0x02, 0x18, 0x30, 0xC7, 0xFF, 0xFF, 0xFE, 0x63, 0x02,
  0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x02, 0x00, 0x10, 0x07, 0xF0, 0xFF,
  0xC7, 0xFF, 0x79, 0x7B, 0xC9, 0xEE, 0x40, 0x7F, 0x01, 0xFF, 0x03, 0xFC,
  0x05, 0xF0, 0x23, 0xF1, 0x1F, 0xC9, 0xEF, 0xFF, 0x7F, 0xF0, 0xFE, 0x00,
  0x80, 0x04, 0x00, 0x7C, 0x0C, 0xF8, 0x33, 0x18, 0xE6, 0x31, 0x8C, 0x66,
  0x18, 0xD8, 0x1F, 0x70, 0x3E, 0xC0, 0x03, 0x7C, 0x0E, 0xF8, 0x1B, 0x18,
  0x66, 0x31, 0x8C, 0x63, 0x18, 0xCC, 0x1F, 0x30, 0x3E, 0x07, 0xC0, 0x1F,
  0xC0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x0E,
  0x7F, 0x18, 0xE7, 0x73, 0x8E, 0xE7, 0x0F, 0x8E, 0x0F, 0x0E, 0x3F, 0x1F,
  0xFF, 0x8F, 0x87, 0xFF, 0xFF, 0xFF, 0x1E, 0x38, 0xF1, 0xC7, 0x8E, 0x1C,
  0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xE1, 0xC3,
  0xC3, 0x87, 0x80, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x0E, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0x00,
  0x1C, 0x0E, 0x37, 0x7F, 0xFF, 0xF9, 0xF1, 0xDD, 0xEE, 0x22, 0x00, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0xE3, 0x9C,
  0x71, 0x86, 0x38, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x0F, 0x81, 0xFF, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x38, 0x3B, 0xDD,
  0xDE, 0xEF, 0xF7, 0x7F, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x8F, 0x1F, 0xF0,
  0xFF, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x3F, 0x0F, 0xF0, 0xF7, 0x0C, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xE1, 0xE0,
  0x07, 0x00, 0x78, 0x1F, 0x80, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0xE0,
  0xFF, 0x8F, 0xBF, 0xF8, 0xFF, 0x83, 0xF8, 0x01, 0xE0, 0x1F, 0x01, 0xF8,
  0x0D, 0xC0, 0xEE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xE7, 0x07, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFC, 0xE0, 0x07, 0x00, 0x3B, 0xE1, 0xFF, 0x8F, 0xFE, 0x78, 0xF0,
  0x03, 0xC0, 0x1F, 0xE0, 0xF7, 0x8F, 0x3F, 0xF8, 0xFF, 0x83, 0xF0, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0x1E, 0xE0, 0x0E, 0xF8, 0xFF, 0xCF, 0xFE, 0xF1,
  0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF1, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xF1, 0xE7, 0x07, 0x3C, 0x78, 0xFF, 0x81, 0xF0, 0x3F, 0xE3,
  0xC7, 0xBC, 0x1F, 0xE0, 0xFF, 0x8F, 0xBF, 0xF8, 0xFF, 0x83, 0xF8, 0x1F,
  0x81, 0xFF, 0x1F, 0xF8, 0xF1, 0xEF, 0x07, 0x78, 0x39, 0xE3, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFB, 0x80, 0x1C, 0xE1, 0xE7, 0x8F, 0x3F, 0xF0, 0xFF, 0x03,
  0xF0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x38, 0xE3, 0x8E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xCE, 0x79, 0xC7, 0x18, 0xE3, 0x00, 0x00, 0x18, 0x07,
  0xC1, 0xFE, 0x7F, 0xCF, 0xF0, 0x7E, 0x03, 0x80, 0x1F, 0x80, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x07,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0xE0, 0x3F, 0x07,
  0xF9, 0xFF, 0x3F, 0xC1, 0xF0, 0x0C, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x1F,
  0xFD, 0xE1, 0xFF, 0x07, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xC0,
  0x7F, 0x83, 0x87, 0x1C, 0x0C, 0x67, 0x7B, 0x3F, 0xEC, 0xCE, 0xB6, 0x32,
  0x98, 0xCA, 0x63, 0x3B, 0x0C, 0xAC, 0x32, 0xB0, 0x8A, 0xC6, 0x6D, 0xB9,
  0xB7, 0xBC, 0xCE, 0xE1, 0x80, 0x07, 0x02, 0x0F, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x1C,
  0x0E, 0x38, 0x1C, 0x70, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0x83, 0xCE,
  0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFE, 0xFF, 0xEE, 0x1E, 0xE0,
  0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF,
  0x07, 0xF8, 0x3B, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xE0,
  0xF7, 0x8F, 0xBF, 0xF8, 0xFF, 0x81, 0xF8, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE,
  0x3E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC,
  0xF1, 0xEF, 0x07, 0x78, 0x03, 0xC0, 0x1E, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC,
  0x1F, 0xE0, 0xF7, 0x87, 0xBF, 0xFC, 0xFF, 0xC1, 0xF8, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1D, 0xC3, 0xF8, 0x77, 0x9E, 0xFF,
  0xCF, 0xF0, 0xF8, 0xE0, 0xF7, 0x0F, 0xB8, 0x79, 0xC7, 0x8E, 0x78, 0x77,
  0x83, 0xB8, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3D, 0xE1, 0xC7, 0x8E, 0x1E,
  0x70, 0xF3, 0x83, 0xDC, 0x1F, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xDF, 0xFE,
  0xFF, 0xB6, 0xFD, 0xB7, 0xEF, 0xBF, 0x3D, 0xF9, 0xCF, 0xCE, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7D, 0xCF,
  0xF9, 0xFF, 0x3F, 0x77, 0xEE, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0xC7,
  0xF8, 0x7F, 0x0F, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x8F,
  0x3F, 0xF8, 0xFF, 0x81, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x8E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xF7, 0x8F, 0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0xFE,
  0x03, 0xF0, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x0F,
  0x70, 0x7B, 0x83, 0xDF, 0xFC, 0xFF, 0xC7, 0xFC, 0x38, 0xF1, 0xC7, 0x8E,
  0x1E, 0x70, 0xF3, 0x83, 0xDC, 0x0F, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9E,
  0x1E, 0x78, 0x3D, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xF0,
  0x03, 0xFC, 0x07, 0x78, 0x3D, 0xFF, 0xF3, 0xFF, 0x83, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x1F, 0xFF, 0xDF, 0xF1, 0xF8, 0xF0, 0x1E,
  0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x87, 0x0F, 0x1E, 0x0E,
  0x38, 0x1C, 0x70, 0x3D, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0xFE, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7B, 0x80, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0xEE, 0x76, 0xDC, 0x6D, 0xB0, 0xDB,
  0x61, 0xF7, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x3C,
  0xF0, 0x70, 0xF1, 0xE0, 0xF7, 0x80, 0xEE, 0x01, 0xFC, 0x01, 0xF0, 0x01,
  0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x83, 0xC7, 0x87, 0x07,
  0x1E, 0x0F, 0x78, 0x0F, 0xF0, 0x1E, 0xF0, 0x78, 0xE0, 0xE1, 0xE3, 0xC1,
  0xCF, 0x03, 0xDE, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0x80, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x7C, 0x07, 0x60, 0x3B, 0x83, 0x9C, 0x1C, 0x71, 0xC3, 0x8E,
  0x0E, 0x60, 0x77, 0x01, 0xB8, 0x0E, 0xFF, 0xFE, 0xF1, 0xE1, 0xC3, 0x1F,
  0x81, 0xFE, 0x1E, 0x78, 0xF1, 0xC0, 0x0F, 0x00, 0x78, 0x7F, 0xCF, 0xFE,
  0x78, 0xF7, 0x87, 0xBC, 0x3D, 0xE2, 0xE7, 0xF7, 0x9E, 0x1C, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8E, 0xFC, 0xF9, 0xEF, 0x0E, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xEF, 0x9E, 0xEF, 0xCE,
  0x78, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xE7, 0x07, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x83, 0x9E, 0x1C, 0xF1, 0xE3, 0xFE, 0x07, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1E, 0x73, 0xF7, 0x79, 0xF7, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x9F,
  0x3F, 0x71, 0xE7, 0x0F, 0x81, 0xFF, 0x1E, 0x38, 0xE0, 0xEF, 0x07, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x1E, 0xF1, 0xE3, 0xFE,
  0x07, 0xC0, 0x03, 0xF8, 0x7F, 0xC3, 0x80, 0x1C, 0x0F, 0xFF, 0x7F, 0xF8,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0xF7, 0xFF, 0xF1,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x1F, 0x7F, 0xF3, 0xCF, 0x00, 0xEF, 0x0E, 0xF1, 0xE7, 0xFC, 0x1F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x79, 0xDF, 0xFF, 0xFF, 0xCF,
  0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0x3F, 0xCF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0xFF, 0xBF, 0xC7,
  0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0x1E, 0xF3, 0xCF,
  0x78, 0xF7, 0x0F, 0xE0, 0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x3C, 0xF1, 0xCF,
  0x1E, 0xF0, 0xEF, 0x0F, 0x3F, 0x81, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xCE, 0x76,
  0xF7, 0xF9, 0xEF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7,
  0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9C, 0xE7, 0x9D, 0xFF,
  0xFF, 0xFC, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xE0, 0xEF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDC, 0x1C, 0xF1,
  0xE3, 0xFE, 0x07, 0xC0, 0xE7, 0x8E, 0xFC, 0xF9, 0xEF, 0x0E, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xEF, 0x9E, 0xEF, 0xCE,
  0x78, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x73, 0xF7,
  0x79, 0xF7, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0x70, 0xF7, 0x9F, 0x3F, 0x71, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x73, 0xEE, 0xFD, 0xDF, 0xBF, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0xC3,
  0xFE, 0x78, 0xF7, 0x07, 0x70, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xF0,
  0x07, 0xF0, 0x77, 0x07, 0x3F, 0xE1, 0xFC, 0x18, 0x03, 0x00, 0xE0, 0x7F,
  0xEF, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0x00, 0xFF, 0x0F, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0xCF, 0xFF, 0x77,
  0xCE, 0x70, 0x1C, 0xE0, 0x79, 0xE0, 0xF1, 0xC1, 0xC3, 0x87, 0x87, 0x8F,
  0x07, 0x1C, 0x0E, 0x38, 0x1E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x33, 0x1C, 0x67,
  0x39, 0xCE, 0x73, 0x9D, 0xF7, 0x3B, 0x6E, 0x76, 0xD8, 0x7D, 0xB0, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x00, 0xF0, 0x7B, 0xC7, 0x8E, 0x38,
  0x7B, 0xC1, 0xDC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0xEE, 0x0E,
  0x78, 0xF1, 0xE7, 0x07, 0x78, 0x3C, 0x70, 0x1C, 0xF0, 0x79, 0xE0, 0xF1,
  0xC1, 0xC3, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0F, 0x38, 0x0E, 0xE0, 0x1D,
  0xC0, 0x1B, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xE1, 0xFC, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x83, 0xE0, 0x7C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1F, 0xC1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0x81, 0xF0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF1,
  0xFC, 0x3F, 0x00, 0x7C, 0x07, 0xF8, 0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0x00,
};

const GFXglyph LiberationMono_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 16, 15, 6, -16 },
  { 7, 9, 8, 15, 3, -18 },
  { 16, 13, 16, 15, 1, -16 },
  { 42, 13, 20, 15, 1, -18 },
  { 75, 15, 16, 15, 0, -16 },
  { 105, 15, 16, 15, 0, -16 },
  { 135, 3, 8, 15, 6, -18 },
  { 138, 7, 23, 15, 4, -18 },
  { 159, 7, 23, 15, 4, -18 },
  { 180, 9, 9, 15, 3, -18 },
  { 191, 13, 13, 15, 1, -15 },
  { 213, 6, 8, 15, 3, -4 },
  { 219, 7, 2, 15, 4, -8 },
  { 221, 3, 4, 15, 6, -4 },
  { 223, 13, 18, 15, 1, -18 },
  { 253, 13, 16, 15, 1, -16 },
  { 279, 12, 16, 15, 2, -16 },
  { 303, 13, 16, 15, 1, -16 },
  { 329, 13, 16, 15, 1, -16 },
  { 355, 13, 16, 15, 1, -16 },
  { 381, 13, 16, 15, 1, -16 },
  { 407, 12, 16, 15, 2, -16 },
  { 431, 11, 16, 15, 2, -16 },
  { 453, 13, 16, 15, 1, -16 },
  { 479, 13, 16, 15, 1, -16 },
  { 505, 3, 14, 15, 6, -14 },
  { 511, 6, 18, 15, 4, -14 },
  { 525, 13, 13, 15, 1, -15 },
  { 547, 13, 9, 15, 1, -13 },
  { 562, 13, 13, 15, 1, -15 },
  { 584, 13, 16, 15, 1, -16 },
  { 610, 14, 21, 15, 1, -18 },
  { 647, 15, 16, 15, 0, -16 },
  { 677, 12, 16, 15, 2, -16 },
  { 701, 13, 16, 15, 1, -16 },
  { 727, 12, 16, 15, 2, -16 },
  { 751, 12, 16, 15, 2, -16 },
  { 775, 12, 16, 15, 2, -16 },
  { 799, 13, 16, 15, 1, -16 },
  { 825, 11, 16, 15, 2, -16 },
  { 847, 11, 16, 15, 2, -16 },
  { 869, 11, 16, 15, 1, -16 },
  { 891, 13, 16, 15, 2, -16 },
  { 917, 11, 16, 15, 3, -16 },
  { 939, 13, 16, 15, 1, -16 },
  { 965, 11, 16, 15, 2, -16 },
  { 987, 13, 16, 15, 1, -16 },
  { 1013, 12, 16, 15, 2, -16 },
  { 1037, 13, 21, 15, 1, -16 },
  { 1072, 13, 16, 15, 2, -16 },
  { 1098, 14, 16, 15, 0, -16 },
  { 1126, 13, 16, 15, 1, -16 },
  { 1152, 11, 16, 15, 2, -16 },
  { 1174, 15, 16, 15, 0, -16 },
  { 1204, 15, 16, 15, 0, -16 },
  { 1234, 15, 16, 15, 0, -16 },
  { 1264, 15, 16, 15, 0, -16 },
  { 1294, 13, 16, 15, 1, -16 },
  { 1320, 7, 23, 15, 5, -18 },
  { 1341, 13, 18, 15, 1, -18 },
  { 1371, 7, 23, 15, 3, -18 },
  { 1392, 13, 11, 15, 1, -16 },
  { 1410, 15, 1, 15, 0, 2 },
  { 1412, 6, 4, 15, 4, -19 },
  { 1415, 13, 14, 15, 1, -14 },
  { 1438, 12, 18, 15, 2, -18 },
  { 1465, 13, 14, 15, 1, -14 },
  { 1488, 12, 18, 15, 1, -18 },
  { 1515, 13, 14, 15, 1, -14 },
  { 1538, 13, 18, 15, 1, -18 },
  { 1568, 12, 19, 15, 2, -14 },
  { 1597, 11, 18, 15, 2, -18 },
  { 1622, 13, 18, 15, 1, -18 },
  { 1652, 10, 23, 15, 1, -18 },
  { 1681, 12, 18, 15, 2, -18 },
  { 1708, 13, 18, 15, 1, -18 },
  { 1738, 13, 14, 15, 1, -14 },
  { 1761, 11, 14, 15, 2, -14 },
  { 1781, 13, 14, 15, 1, -14 },
  { 1804, 12, 19, 15, 2, -14 },
  { 1833, 12, 19, 15, 1, -14 },
  { 1862, 11, 14, 15, 2, -14 },
  { 1882, 12, 14, 15, 1, -14 },
  { 1903, 11, 17, 15, 2, -17 },
  { 1927, 11, 13, 15, 2, -13 },
  { 1945, 15, 14, 15, 0, -14 },
  { 1972, 15, 14, 15, 0, -14 },
  { 1999, 13, 14, 15, 1, -14 },
  { 2022, 15, 19, 15, 0, -14 },
  { 2058, 11, 14, 15, 2, -14 },
  { 2078, 11, 23, 15, 2, -18 },
  { 2110, 3, 24, 15, 6, -18 },
  { 2119, 11, 23, 15, 2, -18 },
  { 2151, 13, 5, 15, 1, -11 },
};

const GFXfont LiberationMono_Bold25pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold25pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold25pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _LIBERATIONMONO_BOLD25PT7B_H_
