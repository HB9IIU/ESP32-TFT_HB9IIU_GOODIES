#ifndef _LIBERATIONMONO_BOLD40PT7B_H_
#define _LIBERATIONMONO_BOLD40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xF7, 0x87, 0xDE, 0x1E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x38,
  0x1C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x70, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x03,
  0x81, 0xC0, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xCD, 0xFC, 0x7E, 0x31, 0xF1, 0xF0, 0xC7, 0xE7, 0xC3, 0x0E,
  0x1F, 0x8C, 0x00, 0x3F, 0xB0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0C,
  0x7E, 0x00, 0x30, 0xF8, 0xE0, 0xC3, 0xEF, 0xC3, 0x0F, 0x9F, 0x0C, 0x3E,
  0x7F, 0x31, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x00,
  0x1E, 0x7F, 0xC0, 0x3C, 0x7F, 0xC0, 0x38, 0xF1, 0xE0, 0x70, 0xF1, 0xE0,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE0, 0xE3, 0xC0, 0xF1, 0xE7,
  0x80, 0xF1, 0xE7, 0x00, 0x7F, 0xCF, 0x00, 0x3F, 0xDE, 0x00, 0x1F, 0x1C,
  0x00, 0x00, 0x38, 0xF8, 0x00, 0x7B, 0xFE, 0x00, 0x73, 0xFE, 0x00, 0xE7,
  0x8F, 0x01, 0xE7, 0x0F, 0x03, 0xC7, 0x07, 0x03, 0x87, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x07, 0x0F, 0x0E, 0x07, 0x8F, 0x1C, 0x03, 0xFE, 0x3C, 0x03,
  0xFC, 0x38, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0x83,
  0xC0, 0x07, 0x87, 0xC0, 0x07, 0xCF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x3F, 0xF8,
  0x78, 0x7E, 0x7C, 0x78, 0x7C, 0x7C, 0xF8, 0x78, 0x3E, 0xF0, 0xF8, 0x1F,
  0xF0, 0xF8, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x7C, 0x07, 0xF0, 0x7E, 0x1F,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0x7F, 0x07, 0xF8, 0x1F, 0xFF, 0xFF,
  0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x07, 0xE0, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0xFC, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC6, 0x7B, 0xDE, 0x7F,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E,
  0x7C, 0x3E, 0x7C, 0x1C, 0x38, 0x08, 0x10, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x87, 0xE1,
  0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xCF, 0x3F, 0xFC, 0xF3,
  0xFF, 0xCF, 0x3F, 0xFC, 0xF3, 0xFF, 0xCF, 0x3F, 0xFC, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC3, 0xF0, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x81, 0xFD, 0xF0, 0x3E,
  0x3E, 0x07, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x0F, 0xE7,
  0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7E, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x1F, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x7D, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x0F, 0xF7, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xE7, 0xE0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0x8F, 0xC3, 0xE0, 0x7E, 0x7E, 0x03, 0x87, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC7, 0xE0, 0x7D, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0,
  0xFE, 0xFE, 0x07, 0xE7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C,
  0x03, 0xF7, 0xE0, 0x3F, 0x3E, 0x07, 0xE3, 0xF0, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7,
  0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xC0, 0x3E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xF0,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x0F, 0xC7,
  0xE0, 0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E,
  0xFC, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xBE, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE3, 0xC0,
  0x7E, 0x7E, 0x07, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE3, 0xF8, 0x7F, 0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7C, 0x3C, 0x03, 0xC0, 0x38, 0x0E, 0x00,
  0x70, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x1E, 0x76, 0x70, 0xFD, 0xDD,
  0xC7, 0x1F, 0x77, 0x38, 0x7D, 0xD8, 0xE0, 0xE3, 0xE7, 0x03, 0x8F, 0x9C,
  0x0E, 0x3E, 0x70, 0x38, 0xF9, 0xC1, 0xE3, 0xE7, 0x07, 0x0F, 0xB8, 0x1C,
  0x7E, 0xE0, 0x71, 0xFB, 0x81, 0xC7, 0xEE, 0x0F, 0x1B, 0x9C, 0x3C, 0x6E,
  0x71, 0xE3, 0xB9, 0xC7, 0xCC, 0xE3, 0xF3, 0xE1, 0x87, 0x8F, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x40, 0x70, 0x01, 0x81, 0xE0, 0x1E,
  0x03, 0xC1, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC1, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8,
  0x0F, 0xCF, 0x80, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xF8, 0xFE, 0x3F, 0x03, 0xF3,
  0xF8, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0x87, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0E, 0x3F, 0x00, 0x7E, 0xFC, 0x03,
  0xE7, 0xE0, 0x3F, 0x1F, 0xC3, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x83, 0xF9, 0xF0, 0x3F, 0xBE, 0x03, 0xF7, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xEF, 0x81, 0xFD, 0xF0, 0x7F, 0x3F, 0xFF, 0xE7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7,
  0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x38, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xE0,
  0x1F, 0x7E, 0x01, 0xF3, 0xF8, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x1F, 0xC0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xCF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7E,
  0x1F, 0x9F, 0xC7, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x3E, 0x03, 0xF9, 0xF0, 0x3F, 0x8F,
  0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x1F, 0xC0, 0xF8, 0xFC,
  0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x7E, 0x07, 0xE3, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x7F, 0x0F, 0x81, 0xFC, 0x7C, 0x07, 0xE3, 0xE0,
  0x3F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xF7, 0xC0, 0x1F, 0xC0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xF7, 0x8E, 0xFF, 0x79, 0xEF, 0xF7, 0x9E, 0xFF, 0x79, 0xEF, 0xF3, 0xDC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0xFF, 0x1F,
  0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF0, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xF7, 0x87, 0xFD, 0xF1,
  0xFF, 0x3C, 0x7F, 0xEF, 0x9F, 0xFB, 0xE7, 0xFE, 0x79, 0xFF, 0x9F, 0x7F,
  0xE3, 0xDF, 0xF8, 0xFB, 0xFE, 0x3E, 0xFF, 0x87, 0xBF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7C, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0xFE,
  0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7C,
  0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x03,
  0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0x80, 0xFE, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03,
  0xF7, 0xC0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF8, 0x7E, 0x07, 0xC1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0x81, 0xFC, 0x7C, 0x07, 0xE3, 0xE0,
  0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF1,
  0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF7,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xF9, 0xFC, 0x0F, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x3C, 0x3E, 0x7C, 0x3C, 0x3E, 0x3C, 0x7E, 0x3E, 0x3C, 0x7E, 0x3C,
  0x3E, 0x7E, 0x7C, 0x3E, 0xFF, 0x7C, 0x3E, 0xFF, 0x7C, 0x3E, 0xFF, 0x7C,
  0x3E, 0xFF, 0x7C, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8,
  0x1F, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0,
  0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF8,
  0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00,
  0x1F, 0xF8, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xC0, 0x7E, 0x3F, 0x03, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xE0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x1F, 0xC7, 0xF1, 0xFE, 0x1F, 0xFF, 0xFE, 0xFF, 0xE7, 0xF3, 0xFE, 0x3F,
  0x87, 0xC0, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0xF9, 0xFF,
  0x1F, 0x7F, 0xF3, 0xFF, 0xFF, 0x7F, 0x8F, 0xEF, 0xE0, 0xFD, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7E,
  0xFF, 0x1F, 0xDF, 0x7F, 0xF3, 0xEF, 0xFE, 0x7C, 0xFF, 0x8F, 0x87, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x0F,
  0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x1F, 0x1F, 0xF3, 0xE7, 0xFF, 0x7C, 0xFF, 0xFF, 0xBF, 0x8F, 0xF7,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFB, 0xF0, 0x7F, 0x7F, 0x1F, 0xE7, 0xFF, 0x7C, 0xFF, 0xEF, 0x8F,
  0xF9, 0xF0, 0x7C, 0x3E, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xF0,
  0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE3, 0xF0, 0xFF, 0xBF, 0x1F, 0xFB, 0xF3, 0xFF, 0xFF, 0x3F, 0x0F,
  0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C,
  0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0xF9, 0xFF,
  0x1F, 0x7F, 0xF3, 0xEF, 0xFF, 0x7F, 0x87, 0xEF, 0xE0, 0xFD, 0xF8, 0x0F,
  0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xF8, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFD, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xF7,
  0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xF0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF1, 0xE1, 0xE3, 0xCF, 0xCF, 0xCF, 0xFF, 0x7F, 0xBF, 0x3F, 0x3E,
  0xFC, 0xFC, 0x7B, 0xE1, 0xF1, 0xEF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8,
  0x78, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78,
  0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F,
  0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0x7F, 0xE1,
  0xE1, 0xF0, 0xF8, 0x7E, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xEF,
  0xF0, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E,
  0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0xF8, 0x7C, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xCF,
  0xF1, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xDF, 0xE3, 0xFB, 0xEF, 0xFE, 0x7D,
  0xFF, 0xCF, 0x9F, 0xF1, 0xF0, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC3, 0xE3, 0xFE, 0x7C, 0xFF, 0xEF, 0x9F, 0xFD, 0xF7,
  0xF1, 0xFE, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF, 0x9F,
  0xFD, 0xF1, 0xFF, 0x3E, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x3F, 0xFE, 0x7F, 0xFF, 0x7F, 0xEF, 0xBF, 0xF7, 0xFE,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E,
  0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x38, 0x03, 0xE7, 0xE0, 0x7E, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xFD,
  0xF7, 0xFF, 0x7D, 0xFF, 0x9F, 0x1F, 0xC7, 0xC0, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xF8, 0x07,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x3E, 0x00, 0x7C,
  0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x3C, 0x1E, 0x7C, 0x3C, 0x3E, 0x7C, 0x7E, 0x3E, 0x3C, 0x7E, 0x3C,
  0x3C, 0x7E, 0x3C, 0x3C, 0xFE, 0x3C, 0x3C, 0xFF, 0x3C, 0x3C, 0xFF, 0x3C,
  0x3C, 0xE7, 0x7C, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x07,
  0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x3F, 0x00, 0x7D, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF3, 0xF0, 0x0F,
  0x87, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x01,
  0xFB, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x0F,
  0x9F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x07,
  0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF1,
  0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xF0, 0x01, 0xFC,
};

const GFXglyph LiberationMono_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 26, 24, 9, -26 },
  { 21, 14, 12, 24, 5, -29 },
  { 42, 22, 26, 24, 1, -26 },
  { 114, 22, 32, 24, 1, -29 },
  { 202, 24, 26, 24, 0, -26 },
  { 280, 24, 26, 24, 0, -26 },
  { 358, 6, 12, 24, 9, -29 },
  { 367, 11, 37, 24, 7, -29 },
  { 418, 11, 37, 24, 6, -29 },
  { 469, 16, 15, 24, 4, -29 },
  { 499, 20, 20, 24, 2, -23 },
  { 549, 10, 13, 24, 5, -6 },
  { 566, 12, 5, 24, 6, -13 },
  { 574, 6, 6, 24, 9, -6 },
  { 579, 20, 29, 24, 2, -29 },
  { 652, 20, 26, 24, 2, -26 },
  { 717, 19, 26, 24, 3, -26 },
  { 779, 20, 26, 24, 2, -26 },
  { 844, 20, 26, 24, 2, -26 },
  { 909, 22, 26, 24, 1, -26 },
  { 981, 20, 26, 24, 2, -26 },
  { 1046, 20, 26, 24, 2, -26 },
  { 1111, 18, 26, 24, 3, -26 },
  { 1170, 20, 26, 24, 2, -26 },
  { 1235, 20, 26, 24, 2, -26 },
  { 1300, 6, 22, 24, 9, -22 },
  { 1317, 10, 29, 24, 6, -22 },
  { 1354, 20, 22, 24, 2, -24 },
  { 1409, 20, 15, 24, 2, -21 },
  { 1447, 20, 22, 24, 2, -24 },
  { 1502, 21, 26, 24, 1, -26 },
  { 1571, 22, 34, 24, 1, -29 },
  { 1665, 24, 26, 24, 0, -26 },
  { 1743, 20, 26, 24, 3, -26 },
  { 1808, 21, 26, 24, 2, -26 },
  { 1877, 19, 26, 24, 3, -26 },
  { 1939, 19, 26, 24, 3, -26 },
  { 2001, 19, 26, 24, 3, -26 },
  { 2063, 20, 26, 24, 2, -26 },
  { 2128, 18, 26, 24, 3, -26 },
  { 2187, 18, 26, 24, 3, -26 },
  { 2246, 18, 26, 24, 2, -26 },
  { 2305, 21, 26, 24, 3, -26 },
  { 2374, 18, 26, 24, 4, -26 },
  { 2433, 20, 26, 24, 2, -26 },
  { 2498, 18, 26, 24, 3, -26 },
  { 2557, 22, 26, 24, 1, -26 },
  { 2629, 19, 26, 24, 3, -26 },
  { 2691, 22, 34, 24, 1, -26 },
  { 2785, 21, 26, 24, 3, -26 },
  { 2854, 22, 26, 24, 1, -26 },
  { 2926, 22, 26, 24, 1, -26 },
  { 2998, 18, 26, 24, 3, -26 },
  { 3057, 24, 26, 24, 0, -26 },
  { 3135, 24, 26, 24, 0, -26 },
  { 3213, 24, 26, 24, 0, -26 },
  { 3291, 24, 26, 24, 0, -26 },
  { 3369, 20, 26, 24, 2, -26 },
  { 3434, 12, 37, 24, 7, -29 },
  { 3490, 20, 29, 24, 2, -29 },
  { 3563, 12, 37, 24, 5, -29 },
  { 3619, 21, 17, 24, 1, -26 },
  { 3664, 24, 2, 24, 0, 2 },
  { 3670, 10, 5, 24, 7, -28 },
  { 3677, 21, 22, 24, 2, -22 },
  { 3735, 19, 29, 24, 3, -29 },
  { 3804, 20, 22, 24, 2, -22 },
  { 3859, 19, 29, 24, 2, -29 },
  { 3928, 20, 22, 24, 2, -22 },
  { 3983, 20, 29, 24, 2, -29 },
  { 4056, 20, 30, 24, 2, -22 },
  { 4131, 19, 29, 24, 3, -29 },
  { 4200, 20, 29, 24, 2, -29 },
  { 4273, 15, 37, 24, 2, -29 },
  { 4343, 20, 29, 24, 3, -29 },
  { 4416, 20, 29, 24, 2, -29 },
  { 4489, 22, 22, 24, 1, -22 },
  { 4550, 19, 22, 24, 3, -22 },
  { 4603, 20, 22, 24, 2, -22 },
  { 4658, 19, 30, 24, 3, -22 },
  { 4730, 19, 30, 24, 2, -22 },
  { 4802, 17, 22, 24, 4, -22 },
  { 4849, 20, 22, 24, 2, -22 },
  { 4904, 17, 28, 24, 3, -28 },
  { 4964, 18, 21, 24, 3, -21 },
  { 5012, 22, 22, 24, 1, -22 },
  { 5073, 24, 22, 24, 0, -22 },
  { 5139, 22, 22, 24, 1, -22 },
  { 5200, 22, 30, 24, 1, -22 },
  { 5283, 18, 22, 24, 3, -22 },
  { 5333, 16, 37, 24, 4, -29 },
  { 5407, 6, 38, 24, 9, -29 },
  { 5436, 16, 37, 24, 4, -29 },
  { 5510, 20, 6, 24, 2, -16 },
};

const GFXfont LiberationMono_Bold40pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold40pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold40pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _LIBERATIONMONO_BOLD40PT7B_H_
