#ifndef _LIBERATIONMONO_BOLD8PT7B_H_
#define _LIBERATIONMONO_BOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xB6, 0x80, 0x57, 0xD5, 0xE6, 0x00, 0x23, 0x98, 0x6B, 0x38,
  0x80, 0xD7, 0x0C, 0xD9, 0x80, 0x73, 0x15, 0x6F, 0x80, 0xE0, 0x4B, 0x48,
  0x93, 0x95, 0x56, 0x5E, 0x80, 0x22, 0xF2, 0x60, 0xE0, 0x80, 0x11, 0x22,
  0x44, 0x75, 0xF5, 0x70, 0xC9, 0x2E, 0x71, 0x24, 0xF0, 0x71, 0x31, 0x70,
  0x32, 0x95, 0xF1, 0x00, 0x76, 0x51, 0x70, 0x76, 0xD5, 0x70, 0xE5, 0x28,
  0x75, 0x7D, 0x70, 0x7D, 0x71, 0x70, 0x90, 0x41, 0x80, 0x07, 0xC3, 0x00,
  0xF0, 0xF0, 0x87, 0x16, 0x00, 0x71, 0x20, 0x20, 0x75, 0x77, 0xBE, 0xC9,
  0xC0, 0x62, 0x95, 0xE8, 0x80, 0xEA, 0xEB, 0xE0, 0x76, 0x21, 0xB7, 0x00,
  0xF6, 0xDE, 0xF3, 0xCE, 0xF3, 0xC8, 0x7C, 0xBD, 0x70, 0xB7, 0xDA, 0xE9,
  0x2E, 0x31, 0x1D, 0x70, 0xAC, 0xCA, 0xA0, 0x92, 0x4E, 0xDD, 0xBB, 0x90,
  0xBF, 0xFA, 0x76, 0xA7, 0xA7, 0x00, 0xF7, 0xC8, 0x76, 0xA7, 0xA7, 0x10,
  0x40, 0xEB, 0xEA, 0xA0, 0x76, 0x1C, 0x37, 0x00, 0xF9, 0x08, 0x42, 0x00,
  0xDD, 0xD5, 0x70, 0x9A, 0x94, 0xE2, 0x00, 0x8D, 0x6C, 0xA5, 0x00, 0x53,
  0x08, 0xAD, 0x00, 0xD2, 0x88, 0x42, 0x00, 0x73, 0x24, 0xF0, 0xFB, 0x6D,
  0xB7, 0x04, 0x22, 0x11, 0xD5, 0x57, 0x23, 0x15, 0x20, 0xF8, 0xC0, 0x71,
  0xB4, 0xF0, 0x93, 0xDB, 0xC0, 0x7C, 0xC7, 0x11, 0x7D, 0xD7, 0x7F, 0xC7,
  0x36, 0xF6, 0x66, 0x7D, 0x57, 0x56, 0x93, 0xDB, 0x40, 0x20, 0x62, 0x2F,
  0x21, 0x92, 0x4E, 0x88, 0xAC, 0xEA, 0x62, 0x22, 0x2F, 0xF5, 0x6B, 0x50,
  0xF6, 0xD0, 0x7D, 0xD7, 0xF6, 0xF9, 0x00, 0x7D, 0xD7, 0x11, 0xF2, 0x40,
  0x76, 0x17, 0x9E, 0x4E, 0xB6, 0xF0, 0xD2, 0x94, 0x40, 0x8D, 0x54, 0xA0,
  0x51, 0x1C, 0xA0, 0xD2, 0x94, 0x42, 0x20, 0xEA, 0x70, 0x69, 0x6C, 0x93,
  0xFF, 0xC9, 0x34, 0x96, 0xF0,
};

const GFXglyph LiberationMono_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 5, 5, 2, -5 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 5, 7, 5, 0, -6 },
  { 13, 5, 5, 5, 0, -5 },
  { 17, 5, 5, 5, 0, -5 },
  { 21, 1, 3, 5, 2, -6 },
  { 22, 3, 8, 5, 1, -6 },
  { 25, 2, 8, 5, 1, -6 },
  { 27, 3, 3, 5, 1, -6 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 2, 2, 5, 1, -1 },
  { 32, 3, 1, 5, 1, -3 },
  { 33, 1, 1, 5, 2, -1 },
  { 34, 4, 6, 5, 0, -6 },
  { 37, 4, 5, 5, 0, -5 },
  { 40, 3, 5, 5, 1, -5 },
  { 42, 4, 5, 5, 0, -5 },
  { 45, 4, 5, 5, 0, -5 },
  { 48, 5, 5, 5, 0, -5 },
  { 52, 4, 5, 5, 0, -5 },
  { 55, 4, 5, 5, 0, -5 },
  { 58, 3, 5, 5, 1, -5 },
  { 60, 4, 5, 5, 0, -5 },
  { 63, 4, 5, 5, 0, -5 },
  { 66, 1, 4, 5, 2, -4 },
  { 67, 2, 5, 5, 1, -4 },
  { 69, 4, 5, 5, 0, -5 },
  { 72, 4, 3, 5, 0, -4 },
  { 74, 4, 5, 5, 0, -5 },
  { 77, 4, 5, 5, 0, -5 },
  { 80, 5, 7, 5, 0, -6 },
  { 85, 5, 5, 5, 0, -5 },
  { 89, 4, 5, 5, 1, -5 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 3, 5, 5, 1, -5 },
  { 98, 3, 5, 5, 1, -5 },
  { 100, 3, 5, 5, 1, -5 },
  { 102, 4, 5, 5, 0, -5 },
  { 105, 3, 5, 5, 1, -5 },
  { 107, 3, 5, 5, 1, -5 },
  { 109, 4, 5, 5, 0, -5 },
  { 112, 4, 5, 5, 1, -5 },
  { 115, 3, 5, 5, 1, -5 },
  { 117, 4, 5, 5, 0, -5 },
  { 120, 3, 5, 5, 1, -5 },
  { 122, 5, 5, 5, 0, -5 },
  { 126, 3, 5, 5, 1, -5 },
  { 128, 5, 7, 5, 0, -5 },
  { 133, 4, 5, 5, 1, -5 },
  { 136, 5, 5, 5, 0, -5 },
  { 140, 5, 5, 5, 0, -5 },
  { 144, 4, 5, 5, 0, -5 },
  { 147, 5, 5, 5, 0, -5 },
  { 151, 5, 5, 5, 0, -5 },
  { 155, 5, 5, 5, 0, -5 },
  { 159, 5, 5, 5, 0, -5 },
  { 163, 4, 5, 5, 0, -5 },
  { 166, 3, 8, 5, 1, -6 },
  { 169, 4, 6, 5, 0, -6 },
  { 172, 2, 8, 5, 1, -6 },
  { 174, 5, 4, 5, 0, -6 },
  { 177, 5, 1, 5, 0, 0 },
  { 178, 2, 1, 5, 1, -6 },
  { 179, 5, 4, 5, 0, -4 },
  { 182, 3, 6, 5, 1, -6 },
  { 185, 4, 4, 5, 0, -4 },
  { 187, 4, 6, 5, 0, -6 },
  { 190, 4, 4, 5, 0, -4 },
  { 192, 4, 6, 5, 0, -6 },
  { 195, 4, 6, 5, 0, -4 },
  { 198, 3, 6, 5, 1, -6 },
  { 201, 4, 6, 5, 0, -6 },
  { 204, 3, 8, 5, 0, -6 },
  { 207, 4, 6, 5, 1, -6 },
  { 210, 4, 6, 5, 0, -6 },
  { 213, 5, 4, 5, 0, -4 },
  { 216, 3, 4, 5, 1, -4 },
  { 218, 4, 4, 5, 0, -4 },
  { 220, 3, 6, 5, 1, -4 },
  { 223, 4, 6, 5, 0, -4 },
  { 226, 3, 4, 5, 1, -4 },
  { 228, 4, 4, 5, 0, -4 },
  { 230, 3, 5, 5, 1, -5 },
  { 232, 3, 4, 5, 1, -4 },
  { 234, 5, 4, 5, 0, -4 },
  { 237, 5, 4, 5, 0, -4 },
  { 240, 5, 4, 5, 0, -4 },
  { 243, 5, 6, 5, 0, -4 },
  { 247, 3, 4, 5, 1, -4 },
  { 249, 3, 8, 5, 1, -6 },
  { 252, 1, 8, 5, 2, -6 },
  { 253, 3, 8, 5, 1, -6 },
  { 256, 4, 1, 5, 0, -3 },
};

const GFXfont LiberationMono_Bold8pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold8pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _LIBERATIONMONO_BOLD8PT7B_H_
