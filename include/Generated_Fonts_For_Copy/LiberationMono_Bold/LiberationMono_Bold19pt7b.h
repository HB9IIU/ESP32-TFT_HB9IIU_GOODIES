#ifndef _LIBERATIONMONO_BOLD19PT7B_H_
#define _LIBERATIONMONO_BOLD19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x63, 0xFE, 0xE7, 0xCF, 0x9B, 0x36, 0x6C, 0xC0,
  0x11, 0x84, 0x41, 0x13, 0xFF, 0x23, 0x08, 0xC2, 0x20, 0x88, 0xFF, 0x91,
  0x84, 0x61, 0x10, 0x44, 0x00, 0x08, 0x0F, 0x87, 0xFB, 0xAE, 0xE9, 0xBA,
  0x07, 0xC0, 0xFC, 0x0B, 0x82, 0x7C, 0x9F, 0xA7, 0x7F, 0x8F, 0xC0, 0x80,
  0x20, 0x70, 0x7B, 0x1B, 0x22, 0x64, 0xCD, 0xB0, 0xE4, 0x01, 0x80, 0x6E,
  0x0B, 0x23, 0x64, 0xCC, 0x91, 0x96, 0x1C, 0x0F, 0x03, 0xF0, 0xE6, 0x18,
  0xC1, 0xF0, 0x3C, 0x0F, 0x33, 0x66, 0xE6, 0xDC, 0xF3, 0x8E, 0x3F, 0xF3,
  0xE6, 0xED, 0xB6, 0xC0, 0x18, 0xE3, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0x61, 0x87, 0x0C, 0x38, 0x60, 0xE3, 0x1C, 0x63, 0x9C, 0xE3, 0x18,
  0xC6, 0x73, 0x9C, 0xCE, 0x67, 0x00, 0x18, 0x31, 0xFF, 0xF3, 0xCD, 0x89,
  0x00, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x39, 0x9C, 0xC6, 0x20, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x00, 0x3E, 0x3F, 0x98, 0xFC, 0x7E, 0x1F, 0x6F, 0xB7, 0xC3,
  0xE1, 0xF1, 0xD8, 0xEF, 0xE1, 0xE0, 0x0E, 0x07, 0x8F, 0xE3, 0xB8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x3E,
  0x3F, 0xB8, 0xE0, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x38, 0x38, 0x18, 0x1F,
  0xFF, 0xF8, 0x3E, 0x3F, 0xF8, 0xE0, 0x70, 0x38, 0xF8, 0x7C, 0x07, 0x01,
  0x80, 0xF8, 0xFF, 0xF3, 0xE0, 0x07, 0x03, 0xC1, 0xF0, 0x6C, 0x33, 0x1C,
  0xC6, 0x33, 0x0C, 0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0xBF,
  0xD8, 0x0C, 0x07, 0xE7, 0xFF, 0x8E, 0x03, 0x01, 0x80, 0xF8, 0xEF, 0xE3,
  0xE0, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x07, 0x7B, 0xFF, 0xC7, 0xE1, 0xB0,
  0xDC, 0xE7, 0xF1, 0xE0, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30,
  0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0x3E, 0x3F, 0xF8, 0xFC, 0x76,
  0x39, 0xF9, 0xFD, 0xC7, 0xE1, 0xF0, 0xF8, 0xEF, 0xF3, 0xE0, 0x3E, 0x3F,
  0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0xFF, 0x3D, 0x81, 0xF8, 0xCF, 0xE3,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x73, 0x9C, 0x00, 0x00, 0x0E, 0x73, 0x19,
  0x8C, 0x00, 0x00, 0x83, 0xDF, 0xDF, 0x0C, 0x07, 0xC1, 0xFC, 0x0F, 0x00,
  0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0xC0, 0x7C, 0x1F, 0xC1,
  0xF0, 0x08, 0x7D, 0xFD, 0xF0, 0xC0, 0x00, 0x3E, 0x3F, 0xF8, 0xF8, 0x30,
  0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x81, 0xC0, 0x0F, 0x02,
  0x10, 0x81, 0x30, 0x34, 0x6A, 0x93, 0x56, 0x6E, 0x89, 0xD1, 0x3A, 0x27,
  0x4D, 0xA9, 0xA5, 0xD8, 0x80, 0x08, 0x21, 0x8C, 0x1F, 0x00, 0x0E, 0x01,
  0xE0, 0x7C, 0x0D, 0x81, 0xB8, 0x73, 0x0E, 0x61, 0x8E, 0x7F, 0xCF, 0xF9,
  0x83, 0xF0, 0x7E, 0x06, 0xFF, 0x3F, 0xEE, 0x3B, 0x8E, 0xE3, 0xBF, 0xCF,
  0xFB, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFE, 0xFF, 0x00, 0x1E, 0x1F, 0xEF,
  0x3B, 0x86, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x77, 0x39, 0xFE,
  0x1E, 0x00, 0xFE, 0x3F, 0xCE, 0x3B, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xB8, 0xEE, 0x3B, 0xFC, 0xFE, 0x00, 0xFF, 0xBF, 0xEE, 0x03, 0x80,
  0xE0, 0x3F, 0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x3E, 0x3F, 0xBC, 0xFC, 0x3E, 0x07, 0x03, 0xBF, 0xDF, 0xE1, 0xF0,
  0xDC, 0x6F, 0xF1, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0xFF, 0xFF, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0x1F, 0x1F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xE3, 0xE7, 0x7F, 0x3C, 0xE1,
  0xF8, 0xEE, 0x73, 0x9C, 0xEE, 0x3F, 0x0F, 0xE3, 0xF8, 0xE7, 0x39, 0xCE,
  0x3B, 0x8F, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE3, 0xF9, 0xFC, 0xBE, 0x7F, 0x7E, 0xBF,
  0x7F, 0xBB, 0xDD, 0xE6, 0xF0, 0x78, 0x3C, 0x18, 0xF1, 0xF8, 0xFC, 0x7B,
  0x3F, 0x9F, 0xCF, 0xB7, 0xDB, 0xED, 0xF3, 0xF9, 0xFC, 0xFE, 0x38, 0x3E,
  0x1F, 0xCE, 0x3B, 0x86, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x6E,
  0x39, 0xFC, 0x3E, 0x00, 0xFF, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0xEF,
  0xFB, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x3E, 0x1F, 0xCE,
  0x3B, 0x86, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x6E, 0x39, 0xFC,
  0x3E, 0x03, 0x00, 0xE0, 0x1F, 0x03, 0xC0, 0xFF, 0x3F, 0xEE, 0x3F, 0x87,
  0xE1, 0xF8, 0xEF, 0xFB, 0xF8, 0xE7, 0x39, 0xCE, 0x3B, 0x8F, 0xE1, 0xC0,
  0x1F, 0x07, 0xF9, 0xC7, 0x38, 0x67, 0x00, 0x7C, 0x07, 0xF0, 0x1E, 0x00,
  0xFC, 0x1D, 0xC3, 0xBF, 0xE1, 0xF8, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xD8, 0xEF,
  0xE3, 0xE0, 0xE0, 0xEC, 0x1D, 0xC3, 0xB8, 0x63, 0x1C, 0x63, 0x8E, 0x60,
  0xDC, 0x1B, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0xC0, 0x7C, 0x0F, 0x81,
  0xB0, 0x36, 0x6E, 0xDD, 0xDB, 0xB3, 0x7E, 0x6B, 0xCF, 0x78, 0xE7, 0x1C,
  0xE3, 0x1C, 0x70, 0xEE, 0x38, 0xE6, 0x0D, 0xC1, 0xF0, 0x1C, 0x03, 0x80,
  0xF8, 0x1F, 0x87, 0x70, 0xC7, 0x38, 0x6E, 0x0E, 0xE0, 0xEE, 0x1D, 0xC7,
  0x1C, 0xC3, 0xB8, 0x36, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x7F, 0x9F, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0xFF, 0xF0, 0x0E, 0x03, 0x60, 0x6C, 0x1C, 0xC3, 0x18,
  0x63, 0x98, 0x33, 0x06, 0xFF, 0xE0, 0xE1, 0x86, 0x3E, 0x1F, 0xC6, 0x30,
  0x0E, 0x3F, 0xBF, 0xEE, 0x3B, 0x9E, 0xFF, 0xDE, 0x70, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xEF, 0x3F, 0xEF, 0x3B, 0x86, 0xE1, 0xB8, 0x6E, 0x1B, 0xCE,
  0xFF, 0xBB, 0xC0, 0x3E, 0x3F, 0xD8, 0xFC, 0x0E, 0x07, 0x03, 0x87, 0xC7,
  0x7F, 0x1F, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0xBB, 0xFF, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0xF9, 0xCC, 0x3E, 0x3F, 0xB8, 0xFC, 0x3F,
  0xFF, 0xFF, 0x81, 0xC3, 0x7F, 0x9F, 0x00, 0x0F, 0x8F, 0xC6, 0x07, 0x0F,
  0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x3D,
  0xBF, 0xDC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE7, 0x7F, 0x9E, 0xC0, 0x6C,
  0x77, 0xF1, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xF7, 0xFF, 0xCF, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0x0E, 0x1C, 0x00, 0x07, 0xEF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0xFD, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x76, 0x33,
  0x31, 0xB0, 0xF8, 0x7E, 0x33, 0x98, 0xCC, 0x76, 0x1C, 0x7C, 0x1F, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xFF, 0xFF, 0xF0, 0xFB, 0xBE, 0xFD, 0xDF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF,
  0x33, 0xCC, 0xF3, 0x30, 0xEF, 0x7F, 0xFC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xC0, 0x3E, 0x1F, 0xEE, 0x3B, 0x86, 0xE1, 0xF8, 0x7E,
  0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0xEF, 0x3F, 0xEF, 0x3B, 0x86, 0xE1, 0xB8,
  0x6E, 0x1B, 0xCE, 0xFF, 0xBB, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x39,
  0xBF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0x9D, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0xCF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x3E, 0x3F, 0x98, 0xEE, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0x7F, 0x9F,
  0x80, 0x18, 0x0C, 0x0E, 0x1F, 0xEF, 0xF1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0xF1, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0x7F, 0xBC, 0xC0, 0xE0, 0xEE, 0x19, 0xC7, 0x18, 0xE3, 0x98, 0x77,
  0x06, 0xE0, 0xD8, 0x1F, 0x01, 0xC0, 0xC0, 0x78, 0x0D, 0x99, 0xB7, 0x36,
  0xE6, 0xD7, 0x9E, 0xF3, 0xCE, 0x39, 0xC6, 0x38, 0x70, 0xC6, 0x38, 0xEE,
  0x0F, 0x80, 0xE0, 0x1E, 0x07, 0xC1, 0xDC, 0x31, 0xCE, 0x1C, 0x60, 0xEE,
  0x19, 0xC7, 0x18, 0xE3, 0x98, 0x37, 0x06, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x06, 0x07, 0xC0, 0xF0, 0x00, 0x7F, 0xBF, 0xC1, 0xC1, 0xC1, 0xC0,
  0xC0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0x3F, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x70, 0xE0, 0xF0, 0x70, 0x30, 0x30, 0x30, 0x30, 0x38, 0x3F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xF8, 0x18, 0x18, 0x18,
  0x18, 0x1C, 0x1C, 0x0F, 0x0F, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0xF8,
  0xF0, 0x70, 0x7F, 0x38, 0xFC, 0x1E,
};

const GFXglyph LiberationMono_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 7, 6, 11, 2, -14 },
  { 12, 10, 13, 11, 1, -13 },
  { 29, 10, 16, 11, 1, -14 },
  { 49, 11, 13, 11, 0, -13 },
  { 67, 11, 13, 11, 0, -13 },
  { 85, 3, 6, 11, 4, -14 },
  { 88, 6, 18, 11, 3, -14 },
  { 102, 5, 18, 11, 3, -14 },
  { 114, 7, 7, 11, 2, -14 },
  { 121, 9, 10, 11, 1, -11 },
  { 133, 5, 6, 11, 2, -3 },
  { 137, 5, 2, 11, 3, -6 },
  { 139, 3, 3, 11, 4, -3 },
  { 141, 10, 14, 11, 1, -14 },
  { 159, 9, 13, 11, 1, -13 },
  { 174, 10, 13, 11, 1, -13 },
  { 191, 9, 13, 11, 1, -13 },
  { 206, 9, 13, 11, 1, -13 },
  { 221, 10, 13, 11, 1, -13 },
  { 238, 9, 13, 11, 1, -13 },
  { 253, 9, 13, 11, 1, -13 },
  { 268, 9, 13, 11, 1, -13 },
  { 283, 9, 13, 11, 1, -13 },
  { 298, 9, 13, 11, 1, -13 },
  { 313, 3, 10, 11, 4, -10 },
  { 317, 5, 13, 11, 3, -10 },
  { 326, 9, 9, 11, 1, -11 },
  { 337, 9, 6, 11, 1, -9 },
  { 344, 9, 9, 11, 1, -11 },
  { 355, 9, 13, 11, 1, -13 },
  { 370, 11, 17, 11, 0, -14 },
  { 394, 11, 13, 11, 0, -13 },
  { 412, 10, 13, 11, 1, -13 },
  { 429, 10, 13, 11, 1, -13 },
  { 446, 10, 13, 11, 1, -13 },
  { 463, 10, 13, 11, 1, -13 },
  { 480, 8, 13, 11, 2, -13 },
  { 493, 9, 13, 11, 1, -13 },
  { 508, 9, 13, 11, 1, -13 },
  { 523, 9, 13, 11, 1, -13 },
  { 538, 8, 13, 11, 1, -13 },
  { 551, 10, 13, 11, 1, -13 },
  { 568, 8, 13, 11, 2, -13 },
  { 581, 9, 13, 11, 1, -13 },
  { 596, 9, 13, 11, 1, -13 },
  { 611, 10, 13, 11, 1, -13 },
  { 628, 10, 13, 11, 1, -13 },
  { 645, 10, 17, 11, 1, -13 },
  { 667, 10, 13, 11, 1, -13 },
  { 684, 11, 13, 11, 0, -13 },
  { 702, 10, 13, 11, 1, -13 },
  { 719, 9, 13, 11, 1, -13 },
  { 734, 11, 13, 11, 0, -13 },
  { 752, 11, 13, 11, 0, -13 },
  { 770, 11, 13, 11, 0, -13 },
  { 788, 11, 13, 11, 0, -13 },
  { 806, 10, 13, 11, 1, -13 },
  { 823, 6, 18, 11, 3, -14 },
  { 837, 10, 14, 11, 1, -14 },
  { 855, 6, 18, 11, 2, -14 },
  { 869, 11, 8, 11, 0, -13 },
  { 880, 11, 1, 11, 0, 1 },
  { 882, 5, 3, 11, 3, -14 },
  { 884, 10, 10, 11, 1, -10 },
  { 897, 10, 14, 11, 1, -14 },
  { 915, 9, 10, 11, 1, -10 },
  { 927, 9, 14, 11, 1, -14 },
  { 943, 9, 10, 11, 1, -10 },
  { 955, 9, 14, 11, 1, -14 },
  { 971, 9, 14, 11, 1, -10 },
  { 987, 9, 14, 11, 1, -14 },
  { 1003, 10, 14, 11, 1, -14 },
  { 1021, 7, 18, 11, 1, -14 },
  { 1037, 9, 14, 11, 2, -14 },
  { 1053, 10, 14, 11, 1, -14 },
  { 1071, 10, 10, 11, 1, -10 },
  { 1084, 9, 10, 11, 1, -10 },
  { 1096, 10, 10, 11, 1, -10 },
  { 1109, 10, 14, 11, 1, -10 },
  { 1127, 9, 14, 11, 1, -10 },
  { 1143, 8, 10, 11, 2, -10 },
  { 1153, 9, 10, 11, 1, -10 },
  { 1165, 9, 13, 11, 1, -13 },
  { 1180, 9, 10, 11, 1, -10 },
  { 1192, 11, 10, 11, 0, -10 },
  { 1206, 11, 10, 11, 0, -10 },
  { 1220, 11, 10, 11, 0, -10 },
  { 1234, 11, 14, 11, 0, -10 },
  { 1254, 9, 10, 11, 1, -10 },
  { 1266, 8, 18, 11, 2, -14 },
  { 1284, 3, 18, 11, 4, -14 },
  { 1291, 8, 18, 11, 2, -14 },
  { 1309, 10, 4, 11, 1, -8 },
};

const GFXfont LiberationMono_Bold19pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold19pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _LIBERATIONMONO_BOLD19PT7B_H_
