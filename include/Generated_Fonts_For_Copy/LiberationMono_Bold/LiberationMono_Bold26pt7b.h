#ifndef _LIBERATIONMONO_BOLD26PT7B_H_
#define _LIBERATIONMONO_BOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0x00, 0xFF, 0xF0, 0xF3, 0xF9,
  0xFC, 0xFC, 0x7E, 0x3F, 0x1D, 0x8E, 0xC7, 0x04, 0x30, 0x30, 0xC0, 0xC3,
  0x03, 0x0C, 0xFF, 0xFF, 0xFF, 0xF1, 0x86, 0x06, 0x18, 0x18, 0x60, 0xC3,
  0x0F, 0xFF, 0xBF, 0xFE, 0x30, 0xC0, 0xC3, 0x06, 0x18, 0x18, 0x60, 0x61,
  0x80, 0x03, 0x00, 0x0C, 0x01, 0xFC, 0x0F, 0xFC, 0x7F, 0xF9, 0xCD, 0xEF,
  0x33, 0x9E, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0x39,
  0x8C, 0xFF, 0x33, 0xFE, 0xCE, 0x7F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0xC0,
  0x03, 0x00, 0x3C, 0x0E, 0x7E, 0x0C, 0xE6, 0x18, 0xC6, 0x30, 0xC6, 0x70,
  0xC6, 0x60, 0xE6, 0xC0, 0x7F, 0xC0, 0x3D, 0xBC, 0x03, 0x7E, 0x07, 0x66,
  0x06, 0xE7, 0x0C, 0xE7, 0x18, 0xE7, 0x18, 0x66, 0x30, 0x7E, 0x60, 0x3C,
  0x07, 0xC0, 0x0F, 0xE0, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0,
  0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0x1C, 0x7F, 0x1C, 0x73, 0x9C, 0xF3, 0xF8,
  0xE1, 0xF8, 0xF0, 0xF0, 0x70, 0xFD, 0x7F, 0xFF, 0x1F, 0x8F, 0xFE, 0xEE,
  0xEE, 0xEE, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C,
  0x1E, 0x0E, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0xCF, 0x1C, 0x78, 0x0C,
  0x03, 0x0C, 0xCB, 0xFE, 0xFF, 0xC7, 0x83, 0xE1, 0xDC, 0x73, 0x88, 0x80,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0xF3,
  0x9E, 0x71, 0xC6, 0x38, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x87,
  0xB8, 0x3D, 0xC1, 0xFE, 0xE7, 0xF7, 0x3F, 0xBB, 0xDC, 0x1E, 0xE0, 0xF7,
  0x87, 0xBC, 0x78, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0x07, 0x00, 0x78, 0x0F,
  0xC1, 0xFE, 0x0F, 0x70, 0x63, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0x87, 0xFE, 0xFF, 0xEF, 0x0F, 0xE0, 0xF0, 0x0F, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF1, 0xFF, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0xFC, 0x07, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0x7F, 0x07, 0xFC,
  0x3D, 0xFF, 0xE7, 0xFE, 0x0F, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x8E,
  0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xF0, 0x07, 0x80, 0x3B, 0xE1, 0xFF, 0xCF,
  0xFE, 0x78, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x7F, 0x07, 0xBC, 0x7D, 0xFF,
  0xC7, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x8E, 0xF0, 0xFE,
  0x00, 0xE7, 0x8F, 0xFE, 0xFF, 0xEF, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xF7,
  0x0F, 0x7F, 0xE3, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0xC1, 0xFF, 0x9F,
  0xFC, 0xF1, 0xF7, 0x07, 0xBC, 0x3D, 0xE3, 0xC7, 0xFC, 0x0F, 0xC1, 0xFF,
  0x9E, 0x1F, 0xE0, 0xFF, 0x07, 0xBC, 0x3D, 0xFF, 0xE7, 0xFE, 0x0F, 0xC0,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xEF,
  0x1F, 0x7F, 0xF9, 0xFF, 0xC7, 0xDE, 0x00, 0xF7, 0x07, 0x3C, 0x79, 0xFF,
  0x87, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3C,
  0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x39, 0xE7, 0x1C, 0x63,
  0x80, 0x00, 0x08, 0x03, 0xC0, 0x7E, 0x1F, 0xE7, 0xF8, 0x7F, 0x03, 0xC0,
  0x1E, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0x80, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xFC, 0x01, 0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0xCF, 0xF1, 0xFC, 0x0F, 0x00,
  0x60, 0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFE, 0xF0, 0xFF, 0x07, 0xF8, 0x3C,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0x87, 0x0C,
  0x06, 0x60, 0x19, 0x9C, 0xBC, 0xFE, 0xF3, 0x3B, 0xD8, 0x6E, 0x61, 0xB9,
  0x8C, 0xE6, 0x33, 0x90, 0xCE, 0x63, 0x39, 0x9D, 0xB7, 0xFE, 0xCE, 0x73,
  0x80, 0x06, 0x01, 0x0E, 0x1C, 0x3F, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x1E, 0x70, 0x1C,
  0x70, 0x1C, 0x78, 0x3C, 0x38, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x78,
  0x1C, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xFF, 0x87, 0xFF, 0x3F, 0xFD,
  0xC1, 0xEE, 0x0F, 0x70, 0x7B, 0x83, 0xDF, 0xFC, 0xFF, 0x87, 0xFF, 0xB8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x0F,
  0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0x1E, 0x78, 0x7B, 0xC0, 0xCF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0E, 0x78, 0x3D, 0xF1, 0xE3,
  0xFF, 0x07, 0xFC, 0x0F, 0xC0, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xEE,
  0x0F, 0x70, 0x7B, 0x81, 0xDC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC1,
  0xEE, 0x0F, 0x70, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFC, 0xFF, 0xE7,
  0xFF, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xF7, 0x87, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x77, 0x83,
  0xBE, 0x3C, 0xFF, 0xE3, 0xFE, 0x0F, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF7, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xE3, 0xFC, 0x0F,
  0x80, 0xE0, 0x7B, 0x83, 0xCE, 0x1E, 0x38, 0xF8, 0xE3, 0xC3, 0x9E, 0x0E,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3C, 0xF0, 0xE1, 0xE3,
  0x87, 0x8E, 0x0F, 0x38, 0x3E, 0xE0, 0x78, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F,
  0xF9, 0xBF, 0xCD, 0xF6, 0x6F, 0xBF, 0x7D, 0xF3, 0xEF, 0x9F, 0x3C, 0xF9,
  0xE7, 0xCE, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x18, 0xF0,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE,
  0x7E, 0x77, 0xE7, 0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xF0, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x3E, 0xF0, 0x7B, 0xC0, 0xEF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x79,
  0xE3, 0xE7, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD,
  0xC1, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xDC, 0x1E, 0xFF, 0xF7, 0xFF, 0x3F,
  0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x3E, 0xF0, 0x7B, 0xC0, 0xEF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x79, 0xE3, 0xE7,
  0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xFF, 0x01, 0xFC,
  0x03, 0xF0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x3C, 0xE0, 0x7B, 0x81,
  0xEE, 0x07, 0xB8, 0x3C, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x38, 0xF0, 0xE1,
  0xE3, 0x87, 0x8E, 0x0F, 0x38, 0x3E, 0xE0, 0x78, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x01, 0xEF, 0x07, 0xDF, 0xFF,
  0x1F, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1E, 0xFF, 0xE7, 0xFC, 0x1F, 0x80,
  0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xE0, 0x0F,
  0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x73, 0x8E, 0x73, 0xCE,
  0x73, 0xDC, 0x73, 0xDC, 0x77, 0xDC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C,
  0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x1C, 0x38, 0x78, 0x1E, 0x78, 0x3C,
  0x3C, 0x38, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x78, 0x3C, 0x78,
  0x3C, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C,
  0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF,
  0x0F, 0x80, 0x3E, 0x01, 0xDC, 0x07, 0x70, 0x38, 0xE0, 0xE3, 0x83, 0x07,
  0x1C, 0x1C, 0x70, 0x33, 0x80, 0xEE, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xF0,
  0xE0, 0xE0, 0xE0, 0x0F, 0x80, 0xFF, 0x87, 0x8F, 0x1E, 0x3C, 0x00, 0xF0,
  0x03, 0xC1, 0xFF, 0x1F, 0xFC, 0x78, 0xF3, 0xC3, 0xCF, 0x0F, 0x1C, 0x7C,
  0x7F, 0x7C, 0xF8, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x7C, 0xEF, 0xEF, 0x9E, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0xFF, 0x0F, 0xF9, 0xEE, 0xFE, 0xE7, 0x80, 0x0F, 0xC1, 0xFF,
  0x0E, 0x3C, 0xF0, 0xF7, 0x07, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x83, 0xDE, 0x1E, 0x79, 0xE3, 0xFE, 0x07, 0xE0, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x8F, 0x3C, 0xFF, 0xEF, 0x1F, 0x70, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEF, 0x0F, 0x78, 0xF9,
  0xFF, 0xC7, 0x9E, 0x0F, 0xC1, 0xFF, 0x1E, 0x3C, 0xF0, 0xF7, 0x03, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x0E, 0xF0, 0xE3, 0xFF,
  0x07, 0xE0, 0x03, 0xF8, 0x3F, 0xC3, 0xC0, 0x1C, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3E, 0x77, 0xF7,
  0xF9, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x9F, 0x7F, 0x73, 0xE7, 0x00, 0xFF, 0x0F, 0x79, 0xE7, 0xFC,
  0x1F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x3C, 0xEF,
  0xEE, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x0F,
  0xF3, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xEF, 0xF1, 0xF8, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7B, 0xC7, 0x9E, 0x38,
  0xF3, 0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x79, 0xE3, 0xCF, 0x1E,
  0x3C, 0xF0, 0xE7, 0x87, 0xBC, 0x1E, 0x3F, 0x80, 0xFE, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83,
  0xFF, 0xFF, 0xFF, 0xC0, 0xEE, 0x73, 0xFF, 0xEF, 0x7B, 0xB9, 0xC7, 0xE7,
  0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9,
  0xC7, 0xE7, 0x1F, 0x9C, 0x70, 0xE3, 0xCE, 0xFE, 0xEF, 0xFF, 0x8F, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0x0F, 0xC1, 0xFF, 0x9E, 0x3C, 0xE0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xDC, 0x1E, 0xF1, 0xE3, 0xFE, 0x07,
  0xE0, 0xE7, 0xCE, 0xFE, 0xF9, 0xEF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x9E, 0xEF, 0xEE, 0x7C, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x79, 0xFB, 0xDE, 0x3E, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDC, 0x1E,
  0xF1, 0xF3, 0xFF, 0x8F, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0xE3, 0xFD, 0xFF, 0xBF, 0xFE, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x87, 0xFE,
  0xF0, 0xEE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x07,
  0xE0, 0x7F, 0x0F, 0x7F, 0xE3, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x0F,
  0xFF, 0xFF, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x1F, 0xE1, 0xFC, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF1, 0xFF,
  0xBF, 0x7E, 0xF7, 0xCF, 0x70, 0x1E, 0xF0, 0x3D, 0xE0, 0x71, 0xC1, 0xE3,
  0xC3, 0x87, 0x87, 0x07, 0x1E, 0x0F, 0x38, 0x0E, 0xF0, 0x1D, 0xE0, 0x3F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0xC0, 0x1D, 0x80,
  0x3B, 0x9C, 0x77, 0x38, 0xEE, 0x79, 0xDC, 0xF3, 0x3B, 0xEE, 0x36, 0xFC,
  0x6C, 0xF8, 0xF9, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x87, 0x00, 0xF0, 0x79,
  0xE1, 0xE3, 0x8F, 0x0F, 0x78, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0xC0, 0x77, 0x83, 0xCE, 0x1E, 0x3C, 0x70, 0x7B, 0xC0, 0xF0, 0x70,
  0x1E, 0xF0, 0x3C, 0xE0, 0x71, 0xC1, 0xE3, 0xC3, 0x83, 0x87, 0x07, 0x9E,
  0x07, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE1, 0xFC, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x7C,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x3E, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x3F, 0xC7, 0xE0,
  0x7C, 0x07, 0xF8, 0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0x00,
};

const GFXglyph LiberationMono_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 17, 16, 6, -17 },
  { 10, 9, 8, 16, 3, -19 },
  { 19, 14, 17, 16, 1, -17 },
  { 49, 14, 21, 16, 1, -19 },
  { 86, 16, 17, 16, 0, -17 },
  { 120, 16, 17, 16, 0, -17 },
  { 154, 4, 8, 16, 6, -19 },
  { 158, 8, 24, 16, 4, -19 },
  { 182, 7, 24, 16, 4, -19 },
  { 203, 10, 10, 16, 3, -19 },
  { 216, 13, 13, 16, 1, -15 },
  { 238, 6, 8, 16, 3, -4 },
  { 244, 7, 3, 16, 4, -8 },
  { 247, 4, 4, 16, 6, -4 },
  { 249, 13, 19, 16, 1, -19 },
  { 280, 13, 17, 16, 1, -17 },
  { 308, 13, 17, 16, 2, -17 },
  { 336, 12, 17, 16, 2, -17 },
  { 362, 13, 17, 16, 1, -17 },
  { 390, 14, 17, 16, 1, -17 },
  { 420, 13, 17, 16, 1, -17 },
  { 448, 12, 17, 16, 2, -17 },
  { 474, 12, 17, 16, 2, -17 },
  { 500, 13, 17, 16, 1, -17 },
  { 528, 13, 17, 16, 1, -17 },
  { 556, 4, 14, 16, 6, -14 },
  { 563, 6, 18, 16, 4, -14 },
  { 577, 13, 14, 16, 1, -16 },
  { 600, 13, 9, 16, 1, -13 },
  { 615, 13, 14, 16, 1, -16 },
  { 638, 13, 17, 16, 1, -17 },
  { 666, 14, 22, 16, 1, -19 },
  { 705, 16, 17, 16, 0, -17 },
  { 739, 13, 17, 16, 2, -17 },
  { 767, 14, 17, 16, 1, -17 },
  { 797, 13, 17, 16, 2, -17 },
  { 825, 13, 17, 16, 2, -17 },
  { 853, 12, 17, 16, 2, -17 },
  { 879, 13, 17, 16, 1, -17 },
  { 907, 12, 17, 16, 2, -17 },
  { 933, 12, 17, 16, 2, -17 },
  { 959, 12, 17, 16, 1, -17 },
  { 985, 14, 17, 16, 2, -17 },
  { 1015, 11, 17, 16, 3, -17 },
  { 1039, 13, 17, 16, 1, -17 },
  { 1067, 12, 17, 16, 2, -17 },
  { 1093, 14, 17, 16, 1, -17 },
  { 1123, 13, 17, 16, 2, -17 },
  { 1151, 14, 22, 16, 1, -17 },
  { 1190, 14, 17, 16, 2, -17 },
  { 1220, 15, 17, 16, 0, -17 },
  { 1252, 14, 17, 16, 1, -17 },
  { 1282, 12, 17, 16, 2, -17 },
  { 1308, 16, 17, 16, 0, -17 },
  { 1342, 16, 17, 16, 0, -17 },
  { 1376, 16, 17, 16, 0, -17 },
  { 1410, 16, 17, 16, 0, -17 },
  { 1444, 13, 17, 16, 1, -17 },
  { 1472, 7, 24, 16, 5, -19 },
  { 1493, 13, 19, 16, 1, -19 },
  { 1524, 8, 24, 16, 3, -19 },
  { 1548, 14, 11, 16, 1, -17 },
  { 1568, 16, 1, 16, 0, 2 },
  { 1570, 7, 5, 16, 4, -20 },
  { 1575, 14, 14, 16, 1, -14 },
  { 1600, 12, 19, 16, 2, -19 },
  { 1629, 13, 14, 16, 1, -14 },
  { 1652, 13, 19, 16, 1, -19 },
  { 1683, 13, 14, 16, 1, -14 },
  { 1706, 13, 19, 16, 1, -19 },
  { 1737, 12, 19, 16, 2, -14 },
  { 1766, 12, 19, 16, 2, -19 },
  { 1795, 14, 19, 16, 1, -19 },
  { 1829, 10, 24, 16, 1, -19 },
  { 1859, 13, 19, 16, 2, -19 },
  { 1890, 14, 19, 16, 1, -19 },
  { 1924, 14, 14, 16, 1, -14 },
  { 1949, 12, 14, 16, 2, -14 },
  { 1970, 13, 14, 16, 1, -14 },
  { 1993, 12, 19, 16, 2, -14 },
  { 2022, 13, 19, 16, 1, -14 },
  { 2053, 11, 14, 16, 3, -14 },
  { 2073, 12, 14, 16, 2, -14 },
  { 2094, 11, 18, 16, 2, -18 },
  { 2119, 12, 14, 16, 2, -14 },
  { 2140, 15, 14, 16, 0, -14 },
  { 2167, 15, 14, 16, 0, -14 },
  { 2194, 14, 14, 16, 1, -14 },
  { 2219, 15, 19, 16, 0, -14 },
  { 2255, 12, 14, 16, 2, -14 },
  { 2276, 11, 24, 16, 2, -19 },
  { 2309, 3, 25, 16, 6, -19 },
  { 2319, 11, 24, 16, 2, -19 },
  { 2352, 13, 5, 16, 1, -11 },
};

const GFXfont LiberationMono_Bold26pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold26pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold26pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _LIBERATIONMONO_BOLD26PT7B_H_
