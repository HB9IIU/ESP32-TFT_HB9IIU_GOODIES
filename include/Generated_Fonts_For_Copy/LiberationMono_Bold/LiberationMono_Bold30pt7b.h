#ifndef _LIBERATIONMONO_BOLD30PT7B_H_
#define _LIBERATIONMONO_BOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF3,
  0xFC, 0xFF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x07,
  0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x1C, 0x0E, 0x1C, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0C, 0x18, 0x0C, 0x38, 0x1C, 0x30, 0x18, 0x30, 0x18, 0x30, 0xFF,
  0xFE, 0xFF, 0xFE, 0x38, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0xE0, 0x30,
  0xE0, 0x70, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7D, 0xBE, 0x79, 0x9E, 0x79, 0x9E, 0x79, 0x80, 0x7D, 0x80, 0x3F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0x9F, 0x71, 0x8F, 0xF1,
  0x8F, 0xF9, 0x8F, 0x7D, 0x9F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x3C, 0x03, 0x9F, 0xC0, 0xCE, 0x70, 0x63,
  0x8C, 0x38, 0xE3, 0x1C, 0x38, 0xC6, 0x0E, 0x33, 0x83, 0x9D, 0xC0, 0x7F,
  0x60, 0x0F, 0x38, 0x00, 0x1C, 0xF0, 0x06, 0xFE, 0x03, 0xB9, 0xC1, 0xCC,
  0x70, 0x63, 0x1C, 0x38, 0xC7, 0x1C, 0x31, 0xC6, 0x0E, 0x73, 0x03, 0xF9,
  0xC0, 0x3C, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x38, 0xF0, 0x0E,
  0x1C, 0x03, 0x8F, 0x00, 0xE7, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE1,
  0xC3, 0xF8, 0x71, 0xEF, 0x1C, 0x71, 0xEF, 0x3C, 0x3F, 0x8F, 0x0F, 0xE3,
  0xC1, 0xF0, 0x78, 0x7F, 0x5F, 0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x60, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xE1, 0xE0,
  0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0xC1, 0xE0,
  0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x46,
  0x27, 0x6E, 0xFF, 0xF3, 0xFC, 0x0F, 0x01, 0xF8, 0x39, 0xC3, 0x9C, 0x10,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x78, 0xF3, 0xC7, 0x8E,
  0x1C, 0x70, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x1E,
  0x1E, 0xF8, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF7, 0xBF, 0xDE, 0xFF,
  0x7B, 0xFD, 0xEF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x1E, 0x78, 0x78,
  0xFF, 0xC3, 0xFE, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0x07, 0xFE,
  0x0F, 0xBC, 0x1C, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x1F, 0xF8, 0x3F, 0xC0, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xE1, 0xF7, 0x81, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x03, 0xF8, 0x07,
  0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xFE, 0x07, 0xBC, 0x0F,
  0x7C, 0x3E, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x78, 0x0E, 0x78,
  0x1E, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x87, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3F, 0xC0, 0x0F, 0x00, 0x3C,
  0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0x87, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xDE, 0x0F, 0x7C, 0x7C, 0xFF, 0xE1, 0xFF, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xDE, 0x1E, 0x3F,
  0xF0, 0x3F, 0x07, 0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x87,
  0xFF, 0x3E, 0x3E, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xE1, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0x3C, 0x00, 0xF0, 0x03, 0xFC, 0x1E,
  0xF8, 0xF9, 0xFF, 0xC3, 0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0x8F, 0x3C, 0x78, 0xE1, 0xC7, 0x0E, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFE,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x7F, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xFF, 0x81, 0xFE, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1E, 0x1C, 0x38, 0x0E, 0x30,
  0x06, 0x70, 0x03, 0x61, 0xDB, 0x67, 0xFB, 0xC6, 0x3B, 0xCE, 0x3B, 0xCC,
  0x3B, 0xDC, 0x33, 0xD8, 0x33, 0xD8, 0x33, 0xD8, 0x73, 0xD8, 0x73, 0xD8,
  0x63, 0xDC, 0xE6, 0xCF, 0xBE, 0xC7, 0x3C, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x04, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xCE, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0x9E, 0x01, 0xEF,
  0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x83, 0xEF,
  0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF,
  0xF7, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0C, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x0E, 0x78, 0x0F,
  0x7C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xBC, 0x0F, 0x78, 0x3E, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x3C, 0x7C, 0x1E, 0x78,
  0x1C, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7C, 0x0F, 0x3E, 0x1F, 0x3F,
  0xFE, 0x1F, 0xFC, 0x07, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x1F, 0x7C, 0x78, 0xFF, 0xE1, 0xFF,
  0x03, 0xF0, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0,
  0xF1, 0xE0, 0xF3, 0xE0, 0xF7, 0xC0, 0xF7, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFD, 0xE0, 0xF9, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xF7, 0xEF, 0xF7, 0xEF, 0xF7,
  0xEF, 0xF3, 0xEF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFE, 0x3F, 0xB8, 0xFE, 0xE3, 0xFF, 0xCF, 0xF7, 0x3F, 0xDC,
  0xFF, 0x7B, 0xFC, 0xEF, 0xF3, 0xFF, 0xC7, 0xFF, 0x1D, 0xFC, 0x7F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E,
  0x78, 0x3E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE1,
  0xFF, 0xF3, 0xFF, 0xF7, 0x83, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E,
  0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x7C, 0xFF, 0xFC,
  0xFF, 0xF0, 0xFF, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0xF8,
  0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0x78, 0x79, 0xFF, 0xE3,
  0xFF, 0x03, 0xF0, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3E,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xEE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0E, 0x70, 0x03, 0x9C,
  0x00, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0xBF,
  0x70, 0xEF, 0xDC, 0x3B, 0xF7, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x1F, 0x3E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x78, 0x07, 0x8F,
  0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x03, 0xEF, 0x01, 0xF3, 0xC0, 0x78, 0x78, 0x3E, 0x1F, 0x0F,
  0x03, 0xC7, 0xC0, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0xC0,
  0xF8, 0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x1C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xF0, 0x78, 0x1C, 0x0E, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xC3, 0xC7, 0xCF,
  0x87, 0x80, 0x0F, 0x07, 0xFE, 0x3F, 0xFC, 0xF8, 0x79, 0xE0, 0xF3, 0xC1,
  0xE7, 0x87, 0xCF, 0x1F, 0x9F, 0xF7, 0xDF, 0xCF, 0x9F, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x7B,
  0xFC, 0xFF, 0xF9, 0xF8, 0xFB, 0xE0, 0xF7, 0xC1, 0xEF, 0x03, 0xDE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1E, 0xF8, 0x3D, 0xF0, 0x7B, 0xF1, 0xF7, 0xFF, 0xCF,
  0x7F, 0x1E, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0xF8,
  0x3F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x03, 0xFE,
  0x0F, 0x7C, 0x7D, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xC7, 0x9F, 0xEF, 0x3F,
  0xFE, 0xF8, 0xFD, 0xE0, 0xFB, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0x78, 0x3E, 0xF0, 0x7D, 0xF1, 0xF9, 0xFE, 0xF3, 0xFD, 0xE1,
  0xF3, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E,
  0x78, 0x1E, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC3, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x7D,
  0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0x00, 0x3C, 0x00, 0xFF, 0x87, 0xDF, 0xFE,
  0x3F, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x1F, 0x3D, 0xFE, 0xF7, 0xFF, 0xF1, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFB, 0xFF,
  0x7F, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xDF,
  0xFB, 0xFE, 0x7F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x07, 0xBC, 0x3C, 0xF1, 0xF3, 0xCF, 0x8F, 0x7C, 0x3D,
  0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3C, 0xF0, 0xF3, 0xE3, 0xC7, 0x8F,
  0x0F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE7, 0x1C, 0xEF, 0xBE, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xC7, 0xF3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xF1, 0xF3, 0xDF,
  0xEF, 0x7F, 0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF1, 0xE1, 0xEF,
  0xF3, 0xDF, 0xE7, 0xE3, 0xEF, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xF7, 0xC1, 0xEF, 0xC7, 0xDE, 0xFF, 0x3D,
  0xFE, 0x78, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x3F, 0xBC, 0xFF, 0x7B, 0xE3, 0xF7, 0x83,
  0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB,
  0xC1, 0xF7, 0xC7, 0xE7, 0xFF, 0xCF, 0xF7, 0x87, 0x8F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xF1, 0xFF, 0x9F,
  0xFD, 0xFE, 0xFE, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xFF, 0xF7,
  0xFF, 0x87, 0xF8, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xFE,
  0xF7, 0xFB, 0xCF, 0xCF, 0x78, 0x07, 0xBC, 0x03, 0xDF, 0x03, 0xE7, 0x81,
  0xE3, 0xC0, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xCE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x71,
  0xE3, 0x9C, 0x78, 0xE7, 0x1E, 0x39, 0xEF, 0x9E, 0x3B, 0xF7, 0x0E, 0xCD,
  0xC3, 0xB3, 0x70, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x87, 0xC1, 0xE1, 0xE0,
  0x78, 0x78, 0xF8, 0x1F, 0x78, 0x3E, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0xF8,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1E, 0x78, 0x3C, 0x7C, 0x3C, 0x3C, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0xFF, 0x1F, 0xF1, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0xFC, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00,
  0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x80,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x8F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x3E, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x7C,
};

const GFXglyph LiberationMono_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 20, 18, 7, -20 },
  { 11, 10, 9, 18, 4, -22 },
  { 23, 16, 20, 18, 1, -20 },
  { 63, 16, 25, 18, 1, -22 },
  { 113, 18, 20, 18, 0, -20 },
  { 158, 18, 20, 18, 0, -20 },
  { 203, 4, 9, 18, 7, -22 },
  { 208, 9, 28, 18, 5, -22 },
  { 240, 9, 28, 18, 4, -22 },
  { 272, 12, 11, 18, 3, -22 },
  { 289, 16, 15, 18, 1, -18 },
  { 319, 7, 10, 18, 4, -4 },
  { 328, 8, 4, 18, 5, -10 },
  { 332, 4, 4, 18, 7, -4 },
  { 334, 16, 22, 18, 1, -22 },
  { 378, 14, 20, 18, 2, -20 },
  { 413, 15, 20, 18, 2, -20 },
  { 451, 14, 20, 18, 2, -20 },
  { 486, 15, 20, 18, 1, -20 },
  { 524, 16, 20, 18, 1, -20 },
  { 564, 14, 20, 18, 2, -20 },
  { 599, 14, 20, 18, 2, -20 },
  { 634, 14, 20, 18, 2, -20 },
  { 669, 14, 20, 18, 2, -20 },
  { 704, 14, 20, 18, 2, -20 },
  { 739, 4, 16, 18, 7, -16 },
  { 747, 7, 22, 18, 5, -16 },
  { 767, 16, 16, 18, 1, -18 },
  { 799, 16, 11, 18, 1, -16 },
  { 821, 16, 16, 18, 1, -18 },
  { 853, 15, 20, 18, 1, -20 },
  { 891, 16, 26, 18, 1, -22 },
  { 943, 18, 20, 18, 0, -20 },
  { 988, 15, 20, 18, 2, -20 },
  { 1026, 16, 20, 18, 1, -20 },
  { 1066, 15, 20, 18, 2, -20 },
  { 1104, 15, 20, 18, 2, -20 },
  { 1142, 14, 20, 18, 2, -20 },
  { 1177, 16, 20, 18, 1, -20 },
  { 1217, 14, 20, 18, 2, -20 },
  { 1252, 14, 20, 18, 2, -20 },
  { 1287, 14, 20, 18, 1, -20 },
  { 1322, 16, 20, 18, 2, -20 },
  { 1362, 13, 20, 18, 3, -20 },
  { 1395, 16, 20, 18, 1, -20 },
  { 1435, 14, 20, 18, 2, -20 },
  { 1470, 16, 20, 18, 1, -20 },
  { 1510, 15, 20, 18, 2, -20 },
  { 1548, 16, 26, 18, 1, -20 },
  { 1600, 16, 20, 18, 2, -20 },
  { 1640, 16, 20, 18, 1, -20 },
  { 1680, 16, 20, 18, 1, -20 },
  { 1720, 14, 20, 18, 2, -20 },
  { 1755, 18, 20, 18, 0, -20 },
  { 1800, 18, 20, 18, 0, -20 },
  { 1845, 18, 20, 18, 0, -20 },
  { 1890, 18, 20, 18, 0, -20 },
  { 1935, 16, 20, 18, 1, -20 },
  { 1975, 9, 28, 18, 5, -22 },
  { 2007, 16, 22, 18, 1, -22 },
  { 2051, 9, 28, 18, 4, -22 },
  { 2083, 16, 13, 18, 1, -20 },
  { 2109, 18, 1, 18, 0, 2 },
  { 2112, 8, 4, 18, 5, -21 },
  { 2116, 15, 16, 18, 2, -16 },
  { 2146, 15, 22, 18, 2, -22 },
  { 2188, 14, 16, 18, 2, -16 },
  { 2216, 15, 22, 18, 1, -22 },
  { 2258, 16, 16, 18, 1, -16 },
  { 2290, 14, 22, 18, 2, -22 },
  { 2329, 14, 22, 18, 2, -16 },
  { 2368, 14, 22, 18, 2, -22 },
  { 2407, 15, 22, 18, 2, -22 },
  { 2449, 11, 28, 18, 2, -22 },
  { 2488, 14, 22, 18, 3, -22 },
  { 2527, 15, 22, 18, 2, -22 },
  { 2569, 16, 16, 18, 1, -16 },
  { 2601, 14, 16, 18, 2, -16 },
  { 2629, 16, 16, 18, 1, -16 },
  { 2661, 15, 22, 18, 2, -16 },
  { 2703, 15, 22, 18, 1, -16 },
  { 2745, 13, 16, 18, 3, -16 },
  { 2771, 14, 16, 18, 2, -16 },
  { 2799, 13, 20, 18, 2, -20 },
  { 2832, 14, 16, 18, 2, -16 },
  { 2860, 17, 16, 18, 0, -16 },
  { 2894, 18, 16, 18, 0, -16 },
  { 2930, 16, 16, 18, 1, -16 },
  { 2962, 16, 22, 18, 1, -16 },
  { 3006, 14, 16, 18, 2, -16 },
  { 3034, 12, 28, 18, 3, -22 },
  { 3076, 4, 29, 18, 7, -22 },
  { 3091, 12, 28, 18, 3, -22 },
  { 3133, 16, 5, 18, 1, -13 },
};

const GFXfont LiberationMono_Bold30pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold30pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold30pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _LIBERATIONMONO_BOLD30PT7B_H_
