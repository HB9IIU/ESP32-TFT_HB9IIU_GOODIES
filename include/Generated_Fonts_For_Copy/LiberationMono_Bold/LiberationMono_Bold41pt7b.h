#ifndef _LIBERATIONMONO_BOLD41PT7B_H_
#define _LIBERATIONMONO_BOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x0F, 0x7C,
  0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE0, 0x00, 0xE0, 0x70,
  0x03, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x3C, 0x0E, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF0, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x83, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x0E, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x81, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xCC, 0xFE, 0x7E, 0x31,
  0xF9, 0xF8, 0xC3, 0xE7, 0xE3, 0x0F, 0x1F, 0x8C, 0x00, 0x3F, 0xB0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0C, 0x7F, 0x00, 0x30, 0xFC, 0x70, 0xC1,
  0xFF, 0xC3, 0x07, 0xDF, 0x0C, 0x1F, 0x7E, 0x30, 0xFC, 0xFC, 0xC7, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x0E, 0x1F, 0xE0,
  0x0E, 0x1F, 0xF8, 0x0F, 0x1E, 0x3C, 0x0F, 0x0F, 0x0E, 0x07, 0x07, 0x87,
  0x07, 0x83, 0xC3, 0x87, 0x81, 0xE1, 0xC3, 0x80, 0xF0, 0xE3, 0xC0, 0x78,
  0x73, 0xC0, 0x1C, 0x79, 0xC0, 0x0F, 0xFD, 0xC0, 0x03, 0xFD, 0xE0, 0x00,
  0xF8, 0xE7, 0xE0, 0x00, 0xE7, 0xF8, 0x00, 0xF7, 0xFE, 0x00, 0xF3, 0xCF,
  0x00, 0x73, 0xC3, 0x80, 0x79, 0xE1, 0xE0, 0x78, 0xF0, 0xF0, 0x38, 0x78,
  0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1C, 0x1C, 0x07, 0x9E, 0x1C, 0x03,
  0xFF, 0x1E, 0x00, 0xFF, 0x0E, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xC3, 0xE0, 0x07, 0xC1, 0xE0, 0x07,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC7, 0xC0, 0x03,
  0xCF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x3F, 0xF8, 0x3C, 0x7E, 0x7C, 0x7C, 0x7C,
  0x3E, 0x78, 0x7C, 0x3F, 0xF8, 0xF8, 0x1F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C,
  0x07, 0xE0, 0x7C, 0x07, 0xF0, 0x7E, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFE, 0x3F, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD,
  0xE0, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x23, 0xC2, 0x7B, 0xCE, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFC, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x1C, 0x3C, 0x04, 0x10,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC7, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x7E,
  0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xCF, 0x1F, 0xFC, 0xF1, 0xFF, 0xCF, 0x1F, 0xFC, 0xF1, 0xFF, 0xCF,
  0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0xFE, 0xF8, 0x0F, 0x8F,
  0x80, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x3F, 0x03,
  0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7D, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0x7F, 0x03, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7D, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80,
  0x7C, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x07, 0xE0, 0x7C, 0x1F, 0x83, 0xE0,
  0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0x0F,
  0xF7, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7F, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x87, 0xE3, 0xF0, 0x3E, 0x7E, 0x03,
  0xC7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x7E, 0x07, 0xDF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x3E, 0x03, 0xF3,
  0xF0, 0x3F, 0x1F, 0x87, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0x0F, 0xE1,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC7, 0xF0, 0x7E,
  0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x07,
  0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xDF, 0x0F, 0xF9, 0xF0, 0x3E,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x3C, 0x03, 0xE7, 0xE0, 0x7E, 0x7F,
  0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0xCF, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0xBF, 0xC1, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFC,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3E, 0x0F,
  0x80, 0xF0, 0x07, 0x03, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x1E, 0x7E,
  0x38, 0xFE, 0xDC, 0xE3, 0xFF, 0x99, 0xC7, 0x9F, 0x33, 0x9E, 0x1E, 0x7E,
  0x38, 0x3C, 0xFC, 0xF0, 0x71, 0xF9, 0xC0, 0xE3, 0xF3, 0x81, 0xC7, 0xE7,
  0x03, 0x8F, 0xCE, 0x07, 0x1F, 0x9C, 0x1C, 0x3F, 0x38, 0x38, 0x6E, 0x70,
  0x71, 0xDC, 0xE1, 0xE3, 0xB9, 0xC3, 0xC7, 0x73, 0xCD, 0x9C, 0xE7, 0xFB,
  0xF8, 0xC7, 0xE7, 0xE1, 0xC7, 0x87, 0x83, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x04, 0x07, 0x80, 0x3C, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x7E,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xC1,
  0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xC0, 0xFE, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x03, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x80,
  0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC3, 0xF9, 0xF8, 0x0F,
  0xDF, 0xC0, 0x3F, 0xFC, 0x01, 0xC7, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x07, 0x3F, 0x00, 0x7F, 0xFC, 0x03, 0xF7, 0xF0,
  0x3F, 0xBF, 0xC3, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC3, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC3, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC,
  0x03, 0x87, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0xC3, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF3,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0xC7, 0xF7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFC, 0x03, 0xFB, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE,
  0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F,
  0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x7E, 0x03, 0xF9, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFF, 0xDE, 0x3F, 0xFE, 0xF1, 0xFF, 0xF7, 0x8F, 0xFF,
  0xBC, 0xF7, 0xFC, 0xF7, 0xBF, 0xE7, 0xBD, 0xFF, 0x3D, 0xCF, 0xF9, 0xEE,
  0x7F, 0xC7, 0xF3, 0xFE, 0x3F, 0x9F, 0xF1, 0xF8, 0xFF, 0x8F, 0xC7, 0xFC,
  0x3E, 0x3F, 0xE1, 0xF1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3E, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xBC, 0x1F, 0xF7, 0xC3, 0xFF, 0xF8, 0x7F, 0xEF,
  0x0F, 0xFD, 0xF1, 0xFF, 0xBE, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xC7,
  0x9F, 0xF8, 0xFB, 0xFF, 0x1F, 0x7F, 0xE1, 0xEF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x3F,
  0x03, 0xF8, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0,
  0x7E, 0x7E, 0x01, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x7F, 0x01,
  0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x03,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x07, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF3, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF8, 0x1F, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFD, 0xFC, 0x3F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E,
  0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0xCF, 0xC7, 0xC3, 0xE7, 0xF3, 0xE1,
  0xF3, 0xF9, 0xE0, 0xFB, 0xFC, 0xF0, 0x7D, 0xEF, 0x78, 0x1E, 0xF7, 0xFC,
  0x0F, 0x7B, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x3F,
  0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFB, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x07, 0xE3,
  0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3E, 0x00,
  0x78, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x3C, 0x0F, 0x01, 0xF0,
  0x3E, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0x80, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8,
  0xFF, 0x87, 0xFF, 0xBF, 0xDF, 0xFC, 0xFF, 0x3F, 0xE1, 0xFC, 0x3F, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x0F,
  0xDF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFE, 0x07, 0xEF, 0xF0, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8, 0xF9,
  0xFF, 0x0F, 0x87, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xF7, 0xC0, 0x3F,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF3, 0xF8,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE3, 0xF1, 0xFF, 0x3F,
  0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x7E,
  0x07, 0xF7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0,
  0x7C, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7E, 0x0F,
  0xC3, 0xE0, 0x3E, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x7F, 0x03, 0xF1, 0xFC,
  0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF,
  0xDF, 0x3F, 0x8F, 0xF7, 0xF0, 0x7F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xF8, 0xFF,
  0x3F, 0xFD, 0xF1, 0xFF, 0xDF, 0x0F, 0xF9, 0xF0, 0x7E, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x1E, 0x03, 0xF3, 0xE0, 0x3F, 0x3F, 0x07, 0xE3, 0xF8,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x1F, 0x1F, 0xF3, 0xE7, 0xFF, 0x7D,
  0xFF, 0xEF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xF7, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFE, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8,
  0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF9, 0xE0, 0xF3, 0xEF, 0xCF, 0xEF, 0xFF, 0xBF,
  0xBF, 0x3F, 0x9F, 0xFC, 0x7C, 0x7F, 0xF1, 0xF1, 0xFF, 0x87, 0xC7, 0xFE,
  0x1F, 0x0F, 0xF8, 0x7C, 0x3F, 0xE1, 0xF0, 0xFF, 0x87, 0xC3, 0xFE, 0x1F,
  0x0F, 0xF8, 0x7C, 0x3F, 0xE1, 0xF0, 0xFF, 0x87, 0xC3, 0xFE, 0x1F, 0x0F,
  0xF8, 0x7C, 0x3F, 0xE1, 0xF0, 0xFF, 0x87, 0xC3, 0xFE, 0x1F, 0x0F, 0xF8,
  0x7C, 0x3F, 0xE1, 0xF0, 0xF0, 0xF8, 0x7E, 0x1F, 0x1F, 0xF3, 0xE7, 0xFF,
  0x7D, 0xFF, 0xEF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7E, 0x3F,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xDF, 0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xF8, 0x7E, 0x0F, 0x8F,
  0xF0, 0xF9, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0x0F, 0xCF, 0xE0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFE, 0x07, 0xEF, 0xF0, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFD, 0xFF,
  0x0F, 0xC7, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF,
  0x7F, 0x0F, 0xF7, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0x7C, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xFD, 0xF7, 0xFF, 0x7D, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3E, 0x07, 0xE7, 0xE0,
  0x3F, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF3,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xE0, 0x3F, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFB, 0xF3, 0xFE, 0x7E, 0x3F, 0x8F,
  0xC0, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00,
  0xFC, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x3C, 0x1E, 0x7C,
  0x3E, 0x1E, 0x7C, 0x3E, 0x1E, 0x3C, 0x7E, 0x1E, 0x3C, 0x7F, 0x3E, 0x3C,
  0x7F, 0x3E, 0x3C, 0xF7, 0x3C, 0x3C, 0xF7, 0x3C, 0x3E, 0xE7, 0xBC, 0x1F,
  0xE7, 0xBC, 0x1F, 0xE3, 0xBC, 0x1F, 0xE3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC1, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x7E,
  0x00, 0xFC, 0xFC, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xF8,
  0x7E, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0,
  0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0xDF,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x0F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x3F, 0x00,
};

const GFXglyph LiberationMono_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 27, 25, 9, -27 },
  { 22, 15, 12, 25, 5, -30 },
  { 45, 22, 27, 25, 1, -27 },
  { 120, 22, 33, 25, 1, -30 },
  { 211, 25, 27, 25, 0, -27 },
  { 296, 24, 27, 25, 0, -27 },
  { 377, 5, 12, 25, 10, -30 },
  { 385, 11, 39, 25, 7, -30 },
  { 439, 12, 39, 25, 6, -30 },
  { 498, 16, 15, 25, 4, -30 },
  { 528, 21, 21, 25, 2, -24 },
  { 584, 10, 13, 25, 5, -6 },
  { 601, 12, 5, 25, 6, -13 },
  { 609, 6, 6, 25, 9, -6 },
  { 614, 21, 30, 25, 2, -30 },
  { 693, 20, 27, 25, 2, -27 },
  { 761, 20, 27, 25, 3, -27 },
  { 829, 20, 27, 25, 2, -27 },
  { 897, 21, 27, 25, 2, -27 },
  { 968, 22, 27, 25, 1, -27 },
  { 1043, 20, 27, 25, 2, -27 },
  { 1111, 20, 27, 25, 2, -27 },
  { 1179, 19, 27, 25, 3, -27 },
  { 1244, 20, 27, 25, 2, -27 },
  { 1312, 20, 27, 25, 2, -27 },
  { 1380, 6, 22, 25, 9, -22 },
  { 1397, 9, 29, 25, 7, -22 },
  { 1430, 21, 22, 25, 2, -25 },
  { 1488, 21, 15, 25, 2, -21 },
  { 1528, 21, 22, 25, 2, -25 },
  { 1586, 21, 27, 25, 1, -27 },
  { 1657, 23, 35, 25, 1, -30 },
  { 1758, 25, 27, 25, 0, -27 },
  { 1843, 21, 27, 25, 3, -27 },
  { 1914, 21, 27, 25, 2, -27 },
  { 1985, 20, 27, 25, 3, -27 },
  { 2053, 20, 27, 25, 3, -27 },
  { 2121, 19, 27, 25, 3, -27 },
  { 2186, 21, 27, 25, 2, -27 },
  { 2257, 19, 27, 25, 3, -27 },
  { 2322, 18, 27, 25, 3, -27 },
  { 2383, 18, 27, 25, 2, -27 },
  { 2444, 22, 27, 25, 3, -27 },
  { 2519, 18, 27, 25, 4, -27 },
  { 2580, 21, 27, 25, 2, -27 },
  { 2651, 19, 27, 25, 3, -27 },
  { 2716, 22, 27, 25, 1, -27 },
  { 2791, 20, 27, 25, 3, -27 },
  { 2859, 22, 35, 25, 1, -27 },
  { 2956, 22, 27, 25, 3, -27 },
  { 3031, 22, 27, 25, 1, -27 },
  { 3106, 22, 27, 25, 1, -27 },
  { 3181, 19, 27, 25, 3, -27 },
  { 3246, 25, 27, 25, 0, -27 },
  { 3331, 25, 27, 25, 0, -27 },
  { 3416, 25, 27, 25, 0, -27 },
  { 3501, 25, 27, 25, 0, -27 },
  { 3586, 21, 27, 25, 2, -27 },
  { 3657, 13, 39, 25, 7, -30 },
  { 3721, 21, 30, 25, 2, -30 },
  { 3800, 12, 39, 25, 5, -30 },
  { 3859, 22, 18, 25, 1, -27 },
  { 3909, 25, 2, 25, 0, 2 },
  { 3916, 10, 6, 25, 7, -30 },
  { 3924, 22, 22, 25, 2, -22 },
  { 3985, 20, 30, 25, 3, -30 },
  { 4060, 20, 22, 25, 2, -22 },
  { 4115, 20, 30, 25, 2, -30 },
  { 4190, 21, 22, 25, 2, -22 },
  { 4248, 20, 30, 25, 2, -30 },
  { 4323, 20, 31, 25, 2, -22 },
  { 4401, 19, 30, 25, 3, -30 },
  { 4473, 21, 30, 25, 2, -30 },
  { 4552, 15, 39, 25, 2, -30 },
  { 4626, 20, 30, 25, 3, -30 },
  { 4701, 21, 30, 25, 2, -30 },
  { 4780, 22, 22, 25, 1, -22 },
  { 4841, 19, 22, 25, 3, -22 },
  { 4894, 21, 22, 25, 2, -22 },
  { 4952, 20, 31, 25, 3, -22 },
  { 5030, 20, 31, 25, 2, -22 },
  { 5108, 18, 22, 25, 4, -22 },
  { 5158, 20, 22, 25, 2, -22 },
  { 5213, 18, 28, 25, 3, -28 },
  { 5276, 19, 22, 25, 3, -22 },
  { 5329, 23, 22, 25, 1, -22 },
  { 5393, 24, 22, 25, 0, -22 },
  { 5459, 23, 22, 25, 1, -22 },
  { 5523, 23, 31, 25, 1, -22 },
  { 5613, 19, 22, 25, 3, -22 },
  { 5666, 17, 39, 25, 4, -30 },
  { 5749, 5, 39, 25, 10, -30 },
  { 5774, 17, 39, 25, 4, -30 },
  { 5857, 21, 7, 25, 2, -17 },
};

const GFXfont LiberationMono_Bold41pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold41pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold41pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _LIBERATIONMONO_BOLD41PT7B_H_
