#ifndef _LIBERATIONMONO_BOLD16PT7B_H_
#define _LIBERATIONMONO_BOLD16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xCF, 0x3C, 0xF2, 0xC8, 0x19, 0x08, 0x84, 0x4F,
  0xF1, 0x21, 0x90, 0x89, 0xFF, 0x26, 0x12, 0x19, 0x00, 0x10, 0x7C, 0xFE,
  0xD7, 0xD0, 0xF8, 0x3E, 0x17, 0x13, 0xD3, 0xFF, 0x7C, 0x10, 0x71, 0xB4,
  0x49, 0x22, 0x58, 0xD4, 0x1E, 0xE1, 0xE8, 0x5B, 0x36, 0xD9, 0xA4, 0x38,
  0x1E, 0x0F, 0x83, 0x20, 0xD8, 0x1C, 0x1E, 0x64, 0x93, 0x3C, 0xC7, 0x1F,
  0xF3, 0xDC, 0xFF, 0xC0, 0x36, 0x6C, 0xCC, 0xCC, 0xCC, 0xCC, 0x66, 0x30,
  0x63, 0x8C, 0x63, 0x8C, 0x63, 0x18, 0xCE, 0x63, 0x39, 0x80, 0x32, 0xDF,
  0xDE, 0x73, 0x64, 0x80, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x76, 0x6C, 0xC0, 0xFF, 0xF0, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x3C, 0x7E, 0xE6, 0xC7, 0xDF, 0xDF, 0xC7,
  0xC7, 0xE6, 0x7E, 0x3C, 0x18, 0x38, 0xF8, 0xD8, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x3C, 0x7E, 0xC6, 0x06, 0x06, 0x1C, 0x38, 0x70, 0xE0,
  0xFF, 0xFF, 0x7C, 0xFE, 0xC7, 0x06, 0x1C, 0x1E, 0x07, 0x03, 0xC7, 0xFE,
  0x7C, 0x0E, 0x1E, 0x16, 0x36, 0x66, 0x46, 0xC6, 0xFF, 0xFF, 0x06, 0x06,
  0xFE, 0xFE, 0xC0, 0xDC, 0xFE, 0xE7, 0x07, 0x07, 0xC7, 0xFE, 0x7C, 0x3C,
  0x7E, 0xE6, 0xC0, 0xDC, 0xFE, 0xE7, 0xC3, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF,
  0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x7C, 0xFE, 0xC6,
  0xC6, 0x7E, 0x7E, 0xC7, 0xC7, 0xC7, 0xFE, 0x7C, 0x3C, 0xFE, 0xC6, 0xC7,
  0xC7, 0xFF, 0x7F, 0x06, 0xC6, 0x7E, 0x7C, 0xF0, 0x03, 0xC0, 0x6C, 0x00,
  0x03, 0xFB, 0x40, 0x03, 0x0F, 0x7E, 0xF0, 0x80, 0xF0, 0x7E, 0x0F, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xF0, 0x7E, 0x0F, 0x03, 0x0F,
  0x7C, 0xF0, 0x80, 0x3C, 0xFE, 0xC7, 0xC7, 0x06, 0x0E, 0x18, 0x38, 0x00,
  0x38, 0x38, 0x1E, 0x18, 0x88, 0x69, 0xB5, 0x2A, 0x97, 0xCB, 0x45, 0xA2,
  0xD3, 0x5D, 0xAB, 0x64, 0x01, 0x08, 0x78, 0x1C, 0x07, 0x81, 0xE0, 0xD8,
  0x33, 0x0C, 0xC7, 0xF1, 0xFE, 0x61, 0xB8, 0x6C, 0x18, 0xFE, 0xFE, 0xC7,
  0xC6, 0xFE, 0xFE, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0x3C, 0x7E, 0xE7, 0xC3,
  0xC0, 0xC0, 0xC0, 0xC3, 0xE7, 0x7E, 0x3C, 0xFC, 0xFE, 0xC6, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xFE, 0xFE,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x3C, 0x7E, 0xE6, 0xC7, 0xC0, 0xCF, 0xCF, 0xC3,
  0xE3, 0x7F, 0x3C, 0xC7, 0xC7, 0xC7, 0xC7, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFF, 0xF8,
  0x3E, 0x7C, 0x18, 0x30, 0x60, 0xC1, 0xE3, 0xEE, 0xF8, 0xE0, 0xC7, 0x63,
  0x33, 0x9B, 0x8D, 0x87, 0xC3, 0xF1, 0x9C, 0xCE, 0x63, 0xB0, 0xC0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xE7, 0xE7, 0xA7,
  0xAF, 0xFF, 0xFB, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3,
  0xD3, 0xDB, 0xDB, 0xCB, 0xCF, 0xCF, 0xC7, 0x3C, 0x7E, 0xE7, 0xC7, 0xC3,
  0xC3, 0xC3, 0xC7, 0xE7, 0x7E, 0x3C, 0xFC, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE,
  0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xE7, 0xC7, 0xC3, 0xC3, 0xC3,
  0xC7, 0xE7, 0x7E, 0x3C, 0x1C, 0x1F, 0x0F, 0xFC, 0x7F, 0xB1, 0xD8, 0x6C,
  0x77, 0xF3, 0xF1, 0x9C, 0xC6, 0x63, 0xB0, 0xC0, 0x3E, 0x3F, 0x98, 0xEC,
  0x07, 0xC1, 0xF8, 0x1E, 0x03, 0xE1, 0xBF, 0xCF, 0x80, 0xFF, 0xFF, 0xC3,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC7, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C, 0xE1, 0x98, 0x66,
  0x39, 0x8C, 0x33, 0x0C, 0xC3, 0x60, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xC0,
  0xF0, 0x6C, 0x19, 0x36, 0x6D, 0x9F, 0x67, 0xF9, 0xDC, 0x77, 0x1C, 0xC3,
  0x30, 0x61, 0x9C, 0xC3, 0x70, 0x78, 0x1C, 0x07, 0x01, 0xE0, 0xD8, 0x33,
  0x18, 0xEE, 0x18, 0xE1, 0x98, 0xE7, 0x30, 0xCC, 0x36, 0x07, 0x81, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x1C, 0x38, 0x30,
  0x60, 0xE0, 0xFF, 0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0xE0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x03, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xE0,
  0x1C, 0x0B, 0x0D, 0x86, 0x46, 0x33, 0x09, 0x06, 0xFF, 0xC0, 0xC2, 0x3C,
  0x7E, 0xE6, 0x7E, 0xFE, 0xC6, 0xCE, 0xFF, 0x73, 0xC0, 0xC0, 0xC0, 0xDC,
  0xFE, 0xE7, 0xC7, 0xC3, 0xC7, 0xE7, 0xFE, 0xDC, 0x3C, 0x7E, 0xE7, 0xC0,
  0xC0, 0xC0, 0xE7, 0x7E, 0x3C, 0x06, 0x06, 0x06, 0x76, 0xFE, 0xE6, 0xC6,
  0xC6, 0xC6, 0xE6, 0xFE, 0x76, 0x3C, 0x7E, 0xC6, 0xFF, 0xFF, 0xC0, 0xE7,
  0x7E, 0x3C, 0x1F, 0x3F, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x7B, 0x7F, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0x7F, 0x7F, 0x07,
  0xFE, 0x7C, 0xC0, 0xC0, 0xC0, 0xDE, 0xDE, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0x18, 0x18, 0x00, 0x78, 0x78, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x0C, 0x30, 0x1F, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1F,
  0xEF, 0x00, 0xE0, 0xE0, 0xE0, 0xE6, 0xEE, 0xEC, 0xF8, 0xFC, 0xEC, 0xEE,
  0xE6, 0xE7, 0x78, 0x78, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0xB6, 0xFF, 0xDB, 0x9B, 0x9B, 0x9B, 0x9B, 0x9B, 0x9B, 0xDE,
  0xDE, 0xE7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0x3C, 0x7E, 0xE7, 0xC3,
  0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0xDC, 0xDE, 0xE7, 0xC7, 0xC3, 0xC7, 0xE7,
  0xDE, 0xDC, 0xC0, 0xC0, 0xC0, 0x76, 0xFE, 0xE6, 0xC6, 0xC6, 0xC6, 0xE6,
  0xFE, 0x76, 0x06, 0x06, 0x06, 0xDF, 0xFE, 0x38, 0xC3, 0x0C, 0x30, 0xC0,
  0x3C, 0x7E, 0xC6, 0xF0, 0x7E, 0x0F, 0xC3, 0xFE, 0x7C, 0x30, 0x63, 0xFF,
  0xF3, 0x06, 0x0C, 0x18, 0x30, 0x7C, 0xF8, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xFB, 0xBB, 0xE1, 0xB0, 0xD8, 0xCE, 0x63, 0x31, 0xB0, 0x78, 0x3C, 0x1C,
  0x00, 0xC0, 0xB0, 0x2C, 0xD9, 0x36, 0x5D, 0x9F, 0xE7, 0x71, 0xCC, 0x73,
  0x00, 0x63, 0x99, 0x8D, 0x83, 0xC1, 0xC0, 0xF0, 0xDC, 0xE6, 0x61, 0x80,
  0xE1, 0xB0, 0xD8, 0xC6, 0x63, 0x31, 0xB0, 0x78, 0x3C, 0x0C, 0x0E, 0x1E,
  0x0E, 0x00, 0xFF, 0xFC, 0x38, 0xE3, 0x8E, 0x18, 0x7F, 0xFE, 0x3D, 0xC6,
  0x18, 0x61, 0x86, 0x30, 0x61, 0x86, 0x18, 0x61, 0xC3, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x03, 0x0C, 0x30, 0x60,
  0xC1, 0x83, 0x3E, 0x00, 0xE0, 0xF9, 0x9F, 0x0E,
};

const GFXglyph LiberationMono_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 6, 5, 10, 2, -12 },
  { 8, 9, 11, 10, 0, -11 },
  { 21, 8, 13, 10, 1, -12 },
  { 34, 10, 11, 10, 0, -11 },
  { 48, 10, 11, 10, 0, -11 },
  { 62, 2, 5, 10, 4, -12 },
  { 64, 4, 15, 10, 3, -12 },
  { 72, 5, 15, 10, 2, -12 },
  { 82, 6, 7, 10, 2, -12 },
  { 88, 8, 8, 10, 1, -9 },
  { 96, 4, 5, 10, 2, -2 },
  { 99, 4, 2, 10, 3, -6 },
  { 100, 2, 2, 10, 4, -2 },
  { 101, 8, 12, 10, 1, -12 },
  { 113, 8, 11, 10, 1, -11 },
  { 124, 8, 11, 10, 1, -11 },
  { 135, 8, 11, 10, 1, -11 },
  { 146, 8, 11, 10, 1, -11 },
  { 157, 8, 11, 10, 1, -11 },
  { 168, 8, 11, 10, 1, -11 },
  { 179, 8, 11, 10, 1, -11 },
  { 190, 8, 11, 10, 1, -11 },
  { 201, 8, 11, 10, 1, -11 },
  { 212, 8, 11, 10, 1, -11 },
  { 223, 2, 9, 10, 4, -9 },
  { 226, 3, 12, 10, 3, -9 },
  { 231, 8, 9, 10, 1, -10 },
  { 240, 8, 6, 10, 1, -8 },
  { 246, 8, 9, 10, 1, -10 },
  { 255, 8, 11, 10, 1, -11 },
  { 266, 9, 15, 10, 0, -12 },
  { 283, 10, 11, 10, 0, -11 },
  { 297, 8, 11, 10, 1, -11 },
  { 308, 8, 11, 10, 1, -11 },
  { 319, 8, 11, 10, 1, -11 },
  { 330, 8, 11, 10, 1, -11 },
  { 341, 8, 11, 10, 1, -11 },
  { 352, 8, 11, 10, 1, -11 },
  { 363, 8, 11, 10, 1, -11 },
  { 374, 7, 11, 10, 1, -11 },
  { 384, 7, 11, 10, 1, -11 },
  { 394, 9, 11, 10, 1, -11 },
  { 407, 7, 11, 10, 2, -11 },
  { 417, 8, 11, 10, 1, -11 },
  { 428, 8, 11, 10, 1, -11 },
  { 439, 8, 11, 10, 1, -11 },
  { 450, 8, 11, 10, 1, -11 },
  { 461, 8, 14, 10, 1, -11 },
  { 475, 9, 11, 10, 1, -11 },
  { 488, 9, 11, 10, 0, -11 },
  { 501, 9, 11, 10, 0, -11 },
  { 514, 8, 11, 10, 1, -11 },
  { 525, 10, 11, 10, 0, -11 },
  { 539, 10, 11, 10, 0, -11 },
  { 553, 10, 11, 10, 0, -11 },
  { 567, 10, 11, 10, 0, -11 },
  { 581, 8, 11, 10, 1, -11 },
  { 592, 5, 15, 10, 3, -12 },
  { 602, 8, 12, 10, 1, -12 },
  { 614, 5, 15, 10, 2, -12 },
  { 624, 9, 7, 10, 0, -11 },
  { 632, 10, 1, 10, 0, 1 },
  { 634, 4, 2, 10, 3, -12 },
  { 635, 8, 9, 10, 1, -9 },
  { 644, 8, 12, 10, 1, -12 },
  { 656, 8, 9, 10, 1, -9 },
  { 665, 8, 12, 10, 1, -12 },
  { 677, 8, 9, 10, 1, -9 },
  { 686, 8, 12, 10, 1, -12 },
  { 698, 8, 12, 10, 1, -9 },
  { 710, 8, 12, 10, 1, -12 },
  { 722, 8, 12, 10, 1, -12 },
  { 734, 6, 15, 10, 1, -12 },
  { 746, 8, 12, 10, 1, -12 },
  { 758, 8, 12, 10, 1, -12 },
  { 770, 8, 9, 10, 1, -9 },
  { 779, 8, 9, 10, 1, -9 },
  { 788, 8, 9, 10, 1, -9 },
  { 797, 8, 12, 10, 1, -9 },
  { 809, 8, 12, 10, 1, -9 },
  { 821, 6, 9, 10, 2, -9 },
  { 828, 8, 9, 10, 1, -9 },
  { 837, 7, 11, 10, 1, -11 },
  { 847, 7, 8, 10, 1, -8 },
  { 854, 9, 9, 10, 0, -9 },
  { 865, 10, 9, 10, 0, -9 },
  { 877, 9, 9, 10, 0, -9 },
  { 888, 9, 12, 10, 0, -9 },
  { 902, 7, 9, 10, 1, -9 },
  { 910, 6, 15, 10, 2, -12 },
  { 922, 2, 16, 10, 4, -12 },
  { 926, 7, 15, 10, 1, -12 },
  { 940, 8, 4, 10, 1, -7 },
};

const GFXfont LiberationMono_Bold16pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold16pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold16pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _LIBERATIONMONO_BOLD16PT7B_H_
