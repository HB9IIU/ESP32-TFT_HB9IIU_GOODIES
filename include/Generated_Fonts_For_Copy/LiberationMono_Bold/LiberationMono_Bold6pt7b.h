#ifndef _LIBERATIONMONO_BOLD6PT7B_H_
#define _LIBERATIONMONO_BOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xD0, 0x5F, 0x80, 0xF8, 0xF0, 0xCE, 0x7B, 0x64, 0xEF, 0x80,
  0xAA, 0x80, 0x95, 0x80, 0xF0, 0x49, 0xA0, 0xC0, 0xC0, 0x80, 0x29, 0x40,
  0x76, 0xB0, 0x49, 0x70, 0x65, 0x70, 0x64, 0xF0, 0x2F, 0x90, 0x7C, 0xB0,
  0x7A, 0xB0, 0xE5, 0x20, 0x7E, 0xF0, 0x75, 0xB0, 0xA0, 0xB0, 0x1F, 0x80,
  0xFC, 0x8D, 0xC0, 0x65, 0x20, 0xFE, 0xF6, 0x46, 0xE9, 0xFE, 0xF0, 0x72,
  0x30, 0xF6, 0xF0, 0xF3, 0xF0, 0xF3, 0xC0, 0x72, 0xB0, 0xBE, 0xD0, 0xE9,
  0x70, 0x64, 0xB0, 0xAC, 0xEA, 0x2B, 0xBF, 0xD0, 0xFE, 0xD0, 0x76, 0xB0,
  0xF7, 0xC0, 0x76, 0xB2, 0xEA, 0xEA, 0xF8, 0xF0, 0xE9, 0x20, 0xB6, 0xB0,
  0x8A, 0x64, 0x9D, 0xEA, 0xA6, 0x6A, 0xA6, 0x44, 0xE5, 0x70, 0xAA, 0x80,
  0x48, 0x90, 0xD5, 0xC0, 0x56, 0x00, 0xF0, 0x40, 0x7F, 0x80, 0x9E, 0xF0,
  0xF1, 0x80, 0x3E, 0xB0, 0xFD, 0x80, 0x6D, 0x20, 0xF5, 0xB0, 0x9E, 0xD0,
  0x09, 0x70, 0x0C, 0x94, 0x97, 0xD0, 0x49, 0x70, 0xFF, 0x80, 0xF6, 0x80,
  0xF5, 0x80, 0xF7, 0xC0, 0xF5, 0x90, 0xE8, 0xEF, 0x80, 0x49, 0x30, 0xB5,
  0x80, 0xA6, 0x40, 0x9E, 0xA0, 0x6A, 0x80, 0xAD, 0x20, 0x6B, 0x80, 0xEA,
  0xC0, 0xF8, 0xA6, 0x80, 0x60,
};

const GFXglyph LiberationMono_Bold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 5, 4, 0, -4 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 4, 4, 4, 0, -4 },
  { 11, 1, 2, 4, 1, -4 },
  { 12, 2, 5, 4, 1, -4 },
  { 14, 2, 5, 4, 1, -4 },
  { 16, 2, 2, 4, 1, -4 },
  { 17, 3, 4, 4, 0, -4 },
  { 19, 1, 2, 4, 1, -1 },
  { 20, 2, 1, 4, 1, -2 },
  { 21, 1, 1, 4, 1, -1 },
  { 22, 3, 4, 4, 0, -4 },
  { 24, 3, 4, 4, 0, -4 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 0, -4 },
  { 40, 3, 4, 4, 0, -4 },
  { 42, 3, 4, 4, 0, -4 },
  { 44, 1, 3, 4, 1, -3 },
  { 45, 1, 4, 4, 1, -3 },
  { 46, 3, 4, 4, 0, -4 },
  { 48, 3, 2, 4, 0, -3 },
  { 49, 3, 4, 4, 0, -4 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 3, 5, 4, 0, -4 },
  { 55, 4, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 3, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 3, 4, 4, 0, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 2, 4, 4, 1, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 3, 5, 4, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 0, -4 },
  { 94, 3, 4, 4, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 4, 4, 4, 0, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 3, 4, 4, 0, -4 },
  { 106, 2, 5, 4, 1, -4 },
  { 108, 3, 4, 4, 0, -4 },
  { 110, 2, 5, 4, 1, -4 },
  { 112, 3, 3, 4, 0, -4 },
  { 114, 4, 1, 4, 0, 0 },
  { 115, 2, 1, 4, 1, -4 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 3, 4, 4, 0, -4 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 3, 4, 4, 0, -4 },
  { 124, 3, 3, 4, 0, -3 },
  { 126, 3, 4, 4, 0, -4 },
  { 128, 3, 4, 4, 0, -3 },
  { 130, 3, 4, 4, 0, -4 },
  { 132, 3, 4, 4, 0, -4 },
  { 134, 3, 5, 4, 0, -4 },
  { 136, 3, 4, 4, 0, -4 },
  { 138, 3, 4, 4, 0, -4 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 3, 3, 4, 0, -3 },
  { 144, 3, 3, 4, 0, -3 },
  { 146, 3, 4, 4, 0, -3 },
  { 148, 3, 4, 4, 0, -3 },
  { 150, 2, 3, 4, 1, -3 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 3, 4, 4, 0, -4 },
  { 155, 3, 3, 4, 0, -3 },
  { 157, 4, 3, 4, 0, -3 },
  { 159, 4, 3, 4, 0, -3 },
  { 161, 3, 3, 4, 0, -3 },
  { 163, 3, 4, 4, 0, -3 },
  { 165, 3, 3, 4, 0, -3 },
  { 167, 2, 5, 4, 1, -4 },
  { 169, 1, 5, 4, 1, -4 },
  { 170, 2, 5, 4, 1, -4 },
  { 172, 3, 1, 4, 0, -2 },
};

const GFXfont LiberationMono_Bold6pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold6pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _LIBERATIONMONO_BOLD6PT7B_H_
