#ifndef _LIBERATIONMONO_BOLD12PT7B_H_
#define _LIBERATIONMONO_BOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDA, 0xD6, 0xB0, 0x24, 0x49, 0xF9, 0x22, 0x9F, 0xD2, 0x24,
  0x10, 0xF9, 0x52, 0x83, 0x82, 0x85, 0xEB, 0x7C, 0x20, 0xE7, 0x4A, 0xA7,
  0x81, 0xE5, 0x52, 0xA7, 0x38, 0x58, 0xA1, 0xC7, 0x5A, 0xB3, 0x3F, 0xF0,
  0x6F, 0x6D, 0xB6, 0xCD, 0x80, 0xC9, 0xB2, 0x4B, 0x6B, 0x00, 0x23, 0x5C,
  0xE5, 0x00, 0x20, 0x8F, 0xC8, 0x20, 0xFA, 0xE0, 0xC0, 0x08, 0x21, 0x0C,
  0x21, 0x84, 0x30, 0x80, 0x73, 0x68, 0xAB, 0x8E, 0x2D, 0x9C, 0x33, 0xC3,
  0x0C, 0x30, 0xC3, 0x3F, 0x73, 0x20, 0x86, 0x31, 0x8C, 0x3F, 0x7A, 0x20,
  0x8C, 0x08, 0x38, 0xBE, 0x0C, 0x38, 0xF3, 0x64, 0xDF, 0xC3, 0x06, 0xFB,
  0x0C, 0x3E, 0x08, 0x38, 0x9C, 0x7B, 0x28, 0x2E, 0xCA, 0x3C, 0x9E, 0xF8,
  0x44, 0x62, 0x31, 0x8C, 0x7B, 0x2C, 0x9C, 0xCA, 0x3C, 0x9E, 0x76, 0xE3,
  0x97, 0x87, 0x6E, 0xC6, 0x6C, 0x00, 0xD6, 0x80, 0x0D, 0xC8, 0x1C, 0x0C,
  0xFC, 0x0F, 0xC0, 0x81, 0xE0, 0xDE, 0x80, 0x7C, 0x88, 0x10, 0xE1, 0x00,
  0x0C, 0x18, 0x3C, 0xC9, 0x0C, 0xFA, 0xB5, 0x6A, 0xDE, 0x40, 0x88, 0xE0,
  0x38, 0x70, 0xA3, 0x66, 0xCF, 0xB1, 0xE3, 0xFB, 0x2C, 0xBC, 0xCF, 0x3C,
  0xFE, 0x3C, 0xCD, 0x06, 0x0C, 0x08, 0x19, 0x9E, 0xF3, 0x6C, 0xF3, 0xCF,
  0x3D, 0xBC, 0xFB, 0x0C, 0x3E, 0xC3, 0x0C, 0x3F, 0xFE, 0x31, 0xFC, 0x63,
  0x18, 0x3C, 0xC9, 0x06, 0x0D, 0xE8, 0xD9, 0x9E, 0xCE, 0x73, 0xFC, 0xE7,
  0x39, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x78, 0xC6, 0x31, 0x8E, 0x7E, 0xCF,
  0x6F, 0x38, 0xF3, 0x6D, 0xB3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xCF,
  0x7D, 0xF7, 0xBE, 0xB8, 0xE3, 0xCE, 0x7B, 0x5A, 0xDE, 0x73, 0x38, 0xC9,
  0x1E, 0x3C, 0x68, 0xD9, 0x1C, 0xFB, 0x3C, 0xF2, 0xFB, 0x0C, 0x30, 0x38,
  0xC9, 0x1E, 0x3C, 0x68, 0xD9, 0x1C, 0x18, 0x1C, 0xFB, 0x3C, 0xF3, 0xFB,
  0x6D, 0xB3, 0x3C, 0x8D, 0x03, 0xC1, 0xF8, 0xD1, 0x9E, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x8C, 0x63, 0x18, 0xC7, 0x6E, 0xC6, 0x8D, 0x93,
  0x62, 0xC5, 0x0E, 0x0C, 0xC3, 0x8F, 0x5A, 0xF6, 0xED, 0x9B, 0x36, 0x46,
  0xD8, 0xE0, 0xC3, 0x85, 0x9B, 0x63, 0xC6, 0x89, 0xB1, 0x63, 0x83, 0x04,
  0x08, 0xF8, 0x63, 0x0C, 0x61, 0x0C, 0x3F, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xF0, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x02, 0x08, 0xF3, 0x33, 0x33, 0x33,
  0x33, 0xF0, 0x38, 0x51, 0xB2, 0x2C, 0x60, 0xFE, 0xCC, 0x73, 0x61, 0xBE,
  0x9A, 0x6E, 0xC0, 0xC3, 0x0F, 0xB2, 0xCE, 0x3C, 0xF2, 0xB8, 0x7B, 0x28,
  0x20, 0x83, 0x27, 0x80, 0x08, 0x5B, 0xB8, 0xC6, 0x3B, 0x68, 0x73, 0x28,
  0xBF, 0x83, 0x27, 0x00, 0x3D, 0x8F, 0x98, 0x61, 0x86, 0x18, 0x60, 0x6F,
  0x7C, 0xE3, 0x8F, 0x76, 0x82, 0xF0, 0x84, 0x2F, 0x9C, 0xC6, 0x31, 0x88,
  0x30, 0x0F, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x30, 0xF3, 0x33, 0x33, 0x33,
  0xE0, 0xC3, 0x0C, 0xB4, 0xF3, 0xCD, 0x36, 0xCC, 0xF0, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0xFC, 0xFD, 0xAF, 0x5E, 0xBD, 0x7A, 0xF5, 0x80, 0xBE, 0x73,
  0x18, 0xC6, 0x20, 0x73, 0x28, 0xE3, 0x8F, 0x27, 0x00, 0xBB, 0x2C, 0xE3,
  0xCF, 0x2F, 0xB0, 0xC0, 0x6E, 0xE3, 0x18, 0xEF, 0xA1, 0x08, 0xDF, 0x31,
  0x8C, 0x63, 0x00, 0x7E, 0x70, 0xF0, 0xC5, 0xE0, 0x63, 0x3E, 0xC6, 0x31,
  0x8C, 0x38, 0x8C, 0x63, 0x1D, 0xF4, 0xC6, 0x89, 0xB3, 0x62, 0x87, 0x0E,
  0x00, 0x83, 0x87, 0x5A, 0xF6, 0xCD, 0x9B, 0x00, 0x44, 0xD8, 0xA0, 0xC2,
  0x8D, 0x91, 0x80, 0xC6, 0x89, 0xB1, 0x62, 0x87, 0x06, 0x08, 0x60, 0xF8,
  0xCC, 0xC6, 0x63, 0xE0, 0x3B, 0x18, 0xC6, 0x61, 0x8C, 0x63, 0x0E, 0xFF,
  0xF0, 0xE1, 0x8C, 0x63, 0x0C, 0xC6, 0x31, 0xB8, 0xE4, 0x70,
};

const GFXglyph LiberationMono_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 5, 4, 7, 1, -9 },
  { 5, 7, 8, 7, 0, -8 },
  { 12, 7, 10, 7, 0, -9 },
  { 21, 7, 8, 7, 0, -8 },
  { 28, 7, 8, 7, 0, -8 },
  { 35, 1, 4, 7, 3, -9 },
  { 36, 3, 11, 7, 2, -9 },
  { 41, 3, 11, 7, 2, -9 },
  { 46, 5, 5, 7, 1, -9 },
  { 50, 6, 5, 7, 1, -7 },
  { 54, 2, 4, 7, 2, -2 },
  { 55, 3, 1, 7, 2, -4 },
  { 56, 1, 2, 7, 3, -2 },
  { 57, 6, 9, 7, 1, -9 },
  { 64, 6, 8, 7, 1, -8 },
  { 70, 6, 8, 7, 1, -8 },
  { 76, 6, 8, 7, 1, -8 },
  { 82, 6, 8, 7, 1, -8 },
  { 88, 7, 8, 7, 0, -8 },
  { 95, 6, 8, 7, 1, -8 },
  { 101, 6, 8, 7, 1, -8 },
  { 107, 5, 8, 7, 1, -8 },
  { 112, 6, 8, 7, 1, -8 },
  { 118, 5, 8, 7, 1, -8 },
  { 123, 1, 7, 7, 3, -7 },
  { 124, 3, 9, 7, 2, -7 },
  { 128, 6, 5, 7, 1, -7 },
  { 132, 6, 3, 7, 1, -6 },
  { 135, 6, 5, 7, 1, -7 },
  { 139, 7, 8, 7, 0, -8 },
  { 146, 7, 11, 7, 0, -9 },
  { 156, 7, 8, 7, 0, -8 },
  { 163, 6, 8, 7, 1, -8 },
  { 169, 7, 8, 7, 0, -8 },
  { 176, 6, 8, 7, 1, -8 },
  { 182, 6, 8, 7, 1, -8 },
  { 188, 5, 8, 7, 1, -8 },
  { 193, 7, 8, 7, 0, -8 },
  { 200, 5, 8, 7, 1, -8 },
  { 205, 5, 8, 7, 1, -8 },
  { 210, 5, 8, 7, 1, -8 },
  { 215, 6, 8, 7, 1, -8 },
  { 221, 6, 8, 7, 1, -8 },
  { 227, 6, 8, 7, 1, -8 },
  { 233, 5, 8, 7, 1, -8 },
  { 238, 7, 8, 7, 0, -8 },
  { 245, 6, 8, 7, 1, -8 },
  { 251, 7, 10, 7, 0, -8 },
  { 260, 6, 8, 7, 1, -8 },
  { 266, 7, 8, 7, 0, -8 },
  { 273, 7, 8, 7, 0, -8 },
  { 280, 5, 8, 7, 1, -8 },
  { 285, 7, 8, 7, 0, -8 },
  { 292, 7, 8, 7, 0, -8 },
  { 299, 7, 8, 7, 0, -8 },
  { 306, 7, 8, 7, 0, -8 },
  { 313, 6, 8, 7, 1, -8 },
  { 319, 4, 11, 7, 2, -9 },
  { 325, 6, 9, 7, 1, -9 },
  { 332, 4, 11, 7, 1, -9 },
  { 338, 7, 5, 7, 0, -8 },
  { 343, 7, 1, 7, 0, 1 },
  { 344, 3, 2, 7, 2, -10 },
  { 345, 6, 7, 7, 1, -7 },
  { 351, 6, 9, 7, 1, -9 },
  { 358, 6, 7, 7, 1, -7 },
  { 364, 5, 9, 7, 1, -9 },
  { 370, 6, 7, 7, 1, -7 },
  { 376, 6, 9, 7, 1, -9 },
  { 383, 6, 9, 7, 1, -7 },
  { 390, 5, 9, 7, 1, -9 },
  { 396, 6, 9, 7, 1, -9 },
  { 403, 4, 11, 7, 1, -9 },
  { 409, 6, 9, 7, 1, -9 },
  { 416, 6, 9, 7, 1, -9 },
  { 423, 7, 7, 7, 0, -7 },
  { 430, 5, 7, 7, 1, -7 },
  { 435, 6, 7, 7, 1, -7 },
  { 441, 6, 9, 7, 1, -7 },
  { 448, 5, 9, 7, 1, -7 },
  { 454, 5, 7, 7, 1, -7 },
  { 459, 5, 7, 7, 1, -7 },
  { 464, 5, 9, 7, 1, -9 },
  { 470, 5, 6, 7, 1, -6 },
  { 474, 7, 7, 7, 0, -7 },
  { 481, 7, 7, 7, 0, -7 },
  { 488, 7, 7, 7, 0, -7 },
  { 495, 7, 9, 7, 0, -7 },
  { 503, 5, 7, 7, 1, -7 },
  { 508, 5, 11, 7, 1, -9 },
  { 515, 1, 12, 7, 3, -9 },
  { 517, 5, 11, 7, 1, -9 },
  { 524, 6, 2, 7, 1, -6 },
};

const GFXfont LiberationMono_Bold12pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold12pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _LIBERATIONMONO_BOLD12PT7B_H_
