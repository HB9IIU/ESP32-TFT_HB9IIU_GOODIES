#ifndef _LIBERATIONMONO_BOLD7PT7B_H_
#define _LIBERATIONMONO_BOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x15, 0x6F, 0xA0, 0x6B, 0x63, 0x70, 0xDE, 0xE7, 0xB0,
  0x66, 0x4B, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x50, 0x70, 0x2F, 0x20, 0xA0,
  0xC0, 0x80, 0x12, 0x24, 0x80, 0x65, 0x99, 0x60, 0x2E, 0x22, 0x70, 0x69,
  0x24, 0xF0, 0x69, 0x21, 0x70, 0x22, 0x6F, 0x20, 0x74, 0x71, 0x60, 0x64,
  0xF9, 0x70, 0xF1, 0x24, 0x40, 0x69, 0x69, 0x70, 0x69, 0xF1, 0x60, 0x90,
  0x41, 0x80, 0x3C, 0x60, 0xF0, 0xF0, 0xC3, 0x68, 0x69, 0x24, 0x40, 0x7B,
  0xFB, 0xC6, 0x66, 0x6F, 0x90, 0xE9, 0xE9, 0xF0, 0x6D, 0x88, 0x70, 0xE9,
  0x99, 0xE0, 0xF8, 0xF8, 0xF0, 0xF3, 0xC8, 0x6D, 0xB9, 0x70, 0x99, 0xF9,
  0x90, 0xE9, 0x2E, 0x64, 0x96, 0x9A, 0xEE, 0x90, 0x92, 0x4E, 0xDF, 0xFB,
  0x90, 0xDD, 0xBB, 0xB0, 0x69, 0x99, 0x60, 0xE9, 0xF8, 0x80, 0x69, 0x99,
  0x63, 0xE9, 0xFA, 0x90, 0x69, 0x61, 0x70, 0xF2, 0x22, 0x20, 0x99, 0x99,
  0x60, 0x99, 0x66, 0x60, 0x99, 0xBF, 0x50, 0x96, 0x26, 0x90, 0x95, 0x62,
  0x20, 0x72, 0x24, 0xF0, 0xEA, 0xB0, 0x44, 0x22, 0x10, 0xD5, 0x70, 0x66,
  0x90, 0xF0, 0x40, 0x61, 0xFF, 0x8A, 0xD9, 0xF0, 0x68, 0x86, 0x17, 0x99,
  0x70, 0x69, 0xE7, 0x7F, 0x44, 0x40, 0x79, 0x97, 0x70, 0x8A, 0xD9, 0x90,
  0x26, 0x22, 0xF0, 0x2C, 0x92, 0xC0, 0x97, 0x6A, 0x62, 0x22, 0xF0, 0xDB,
  0xBB, 0xAD, 0x99, 0x69, 0x96, 0xAD, 0x9F, 0x80, 0x79, 0x97, 0x10, 0xF2,
  0x40, 0x64, 0x37, 0x9A, 0x4E, 0x99, 0x97, 0x95, 0x66, 0x9B, 0xF5, 0x96,
  0x65, 0x95, 0x66, 0x40, 0x72, 0x4F, 0x72, 0x49, 0x80, 0xFE, 0xC9, 0x35,
  0x80, 0xF0,
};

const GFXglyph LiberationMono_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 6, 4, 0, -5 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 4, 2, -5 },
  { 16, 2, 6, 4, 1, -5 },
  { 18, 2, 6, 4, 1, -5 },
  { 20, 2, 3, 4, 1, -5 },
  { 21, 4, 3, 4, 0, -4 },
  { 23, 2, 2, 4, 1, -1 },
  { 24, 2, 1, 4, 1, -2 },
  { 25, 1, 1, 4, 2, -1 },
  { 26, 4, 5, 4, 0, -5 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 4, 5, 4, 0, -5 },
  { 59, 1, 4, 4, 2, -4 },
  { 60, 2, 5, 4, 1, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 6, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 4, 5, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 3, 5, 4, 1, -5 },
  { 99, 3, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 3, 5, 4, 1, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 6, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 4, 5, 4, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 4, 5, 4, 0, -5 },
  { 145, 4, 5, 4, 0, -5 },
  { 148, 2, 6, 4, 1, -5 },
  { 150, 4, 5, 4, 0, -5 },
  { 153, 2, 6, 4, 1, -5 },
  { 155, 4, 3, 4, 0, -5 },
  { 157, 4, 1, 4, 0, 0 },
  { 158, 2, 1, 4, 1, -5 },
  { 159, 4, 4, 4, 0, -4 },
  { 161, 4, 5, 4, 0, -5 },
  { 164, 4, 4, 4, 0, -4 },
  { 166, 4, 5, 4, 0, -5 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 4, 5, 4, 0, -4 },
  { 177, 4, 5, 4, 0, -5 },
  { 180, 4, 5, 4, 0, -5 },
  { 183, 3, 6, 4, 0, -5 },
  { 186, 3, 5, 4, 1, -5 },
  { 188, 4, 5, 4, 0, -5 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 4, 4, 4, 0, -4 },
  { 195, 4, 4, 4, 0, -4 },
  { 197, 4, 5, 4, 0, -4 },
  { 200, 4, 5, 4, 0, -4 },
  { 203, 3, 4, 4, 1, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 3, 5, 4, 1, -5 },
  { 209, 4, 4, 4, 0, -4 },
  { 211, 4, 4, 4, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 5, 4, 0, -4 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 3, 6, 4, 1, -5 },
  { 225, 1, 7, 4, 2, -5 },
  { 226, 3, 6, 4, 1, -5 },
  { 229, 4, 1, 4, 0, -3 },
};

const GFXfont LiberationMono_Bold7pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold7pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _LIBERATIONMONO_BOLD7PT7B_H_
