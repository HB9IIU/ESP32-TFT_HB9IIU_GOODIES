#ifndef _LIBERATIONMONO_BOLD21PT7B_H_
#define _LIBERATIONMONO_BOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xCF, 0x9F, 0x3E, 0x7C, 0x78,
  0xC0, 0x18, 0xC3, 0x10, 0x42, 0x7F, 0xFF, 0xFE, 0x63, 0x0C, 0x41, 0x08,
  0xFF, 0xDF, 0xF9, 0x8C, 0x31, 0x04, 0x20, 0x8C, 0x00, 0x04, 0x07, 0xE1,
  0xFF, 0x72, 0xEE, 0x4D, 0xC8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x9F, 0x13,
  0xF2, 0x7E, 0x5E, 0xFF, 0x8F, 0xC0, 0x20, 0x04, 0x00, 0x78, 0x36, 0x63,
  0x33, 0x31, 0x99, 0x8C, 0xD8, 0x67, 0x81, 0xEC, 0x00, 0xDE, 0x0D, 0xB0,
  0x6C, 0xC6, 0x66, 0x63, 0x32, 0x1B, 0x30, 0x70, 0x0F, 0x00, 0xFC, 0x06,
  0x70, 0x33, 0x81, 0xB8, 0x0F, 0x80, 0xF1, 0x8F, 0xCC, 0xE6, 0x67, 0x1F,
  0x38, 0xF0, 0xC7, 0xC7, 0xFF, 0x9F, 0x1C, 0xFF, 0xED, 0x80, 0x39, 0x9C,
  0xCE, 0x73, 0x98, 0xC6, 0x31, 0x8E, 0x73, 0x8C, 0x71, 0x8E, 0xE1, 0xC3,
  0x8E, 0x38, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x39, 0xCE,
  0x00, 0x18, 0x18, 0x5B, 0xFF, 0x1C, 0x3E, 0x76, 0x22, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x73,
  0x98, 0xCE, 0x63, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x00, 0x1F, 0x0F, 0xE7, 0x1D, 0x87, 0xE1, 0xFB,
  0x7E, 0xDF, 0xB7, 0xE1, 0xF8, 0x76, 0x1D, 0xC7, 0x3F, 0x87, 0xC0, 0x0E,
  0x03, 0xC3, 0xD8, 0x73, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0x1F, 0xE7, 0x1F, 0x87,
  0x01, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0xE0, 0x1C, 0x03, 0x83, 0xC0, 0x7C,
  0x01, 0xC0, 0x1B, 0x83, 0xF8, 0xE7, 0xFC, 0x7E, 0x00, 0x07, 0x80, 0xF0,
  0x3E, 0x0F, 0xC1, 0xB8, 0x77, 0x1C, 0xE3, 0x1C, 0xC3, 0x9F, 0xFF, 0xFF,
  0x81, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0xCF, 0xF9, 0xC0, 0x38, 0x06, 0x00,
  0xDE, 0x1F, 0xF3, 0x8E, 0x01, 0xC0, 0x1F, 0x87, 0x78, 0xE7, 0xF8, 0x7E,
  0x00, 0x1F, 0x0F, 0xE7, 0x1D, 0xC7, 0xE0, 0x3B, 0xCF, 0xFF, 0xC7, 0xE1,
  0xD8, 0x37, 0x1D, 0xC7, 0x3F, 0x87, 0xC0, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x00, 0x1F, 0x1F, 0xE7, 0x1F, 0x87, 0x61, 0xDC, 0x73, 0xF8, 0xFE, 0x71,
  0xF8, 0x7E, 0x1F, 0xC7, 0x7F, 0xCF, 0xC0, 0x1F, 0x1F, 0xE7, 0x3F, 0x87,
  0xE1, 0xF8, 0x77, 0x1D, 0xFB, 0x3D, 0xC0, 0x7E, 0x1D, 0xCE, 0x7F, 0x87,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x39,
  0xDC, 0xE6, 0x33, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0x1F, 0x0F, 0x81, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xC0, 0xF8, 0x7C, 0x7C, 0x1E, 0x02, 0x00, 0x00, 0x1F, 0x1F,
  0xF7, 0x1F, 0x83, 0xE1, 0xC0, 0xF0, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x07, 0x00, 0x07, 0x81, 0x84, 0x30, 0x22, 0x03, 0x67, 0x74,
  0xDD, 0x48, 0xD5, 0x89, 0xD8, 0x9D, 0x19, 0xD1, 0x95, 0x9B, 0x5A, 0xA4,
  0xCC, 0x60, 0x02, 0x04, 0x10, 0xC0, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x3B, 0x01, 0xDC, 0x0C, 0xE0, 0xE3, 0x07, 0x18, 0x3F, 0xE3, 0xFF, 0x1C,
  0x18, 0xE0, 0xEE, 0x07, 0x70, 0x38, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0xEE,
  0x1D, 0xC3, 0xBF, 0xE7, 0xFE, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFD,
  0xFF, 0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x70, 0xEE, 0x0D, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x1F, 0xC3, 0xB8, 0xE3, 0xF8, 0x3E, 0x00, 0xFE, 0x1F,
  0xF3, 0x8F, 0x70, 0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x87, 0x71, 0xEF, 0xF9, 0xFC, 0x00, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xF7, 0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0xEE,
  0x01, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xFC, 0x1F, 0x83, 0xB8, 0xF3, 0xFC,
  0x3E, 0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFF, 0xC7, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC,
  0x1F, 0x8F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF1, 0xF8,
  0xEE, 0x77, 0xF0, 0xF0, 0xE0, 0xEE, 0x1C, 0xE3, 0x8E, 0x78, 0xE7, 0x0E,
  0xE0, 0xFE, 0x0F, 0xF0, 0xF7, 0x0F, 0x78, 0xE3, 0x8E, 0x1C, 0xE1, 0xEE,
  0x0E, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xF1, 0xFE, 0x3F, 0xCF, 0xFD,
  0xFD, 0xBF, 0xB7, 0xF7, 0xBE, 0x77, 0xCE, 0xF9, 0xDF, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xC0, 0xF0, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0x3E, 0xCF,
  0xBB, 0xE6, 0xF9, 0xBE, 0x7F, 0x8F, 0xE3, 0xF8, 0xF0, 0x1F, 0x0F, 0xF1,
  0xC7, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0x38, 0xE7, 0xF8, 0x3E, 0x00, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x0F,
  0xC1, 0xF8, 0x77, 0xFE, 0xFF, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x00, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x87, 0x38, 0xE7, 0xF8, 0x3E, 0x03, 0x80, 0x38, 0x07,
  0xE0, 0x7C, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xFF,
  0xCF, 0xF0, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0E, 0x1F,
  0x83, 0xFE, 0x70, 0xE7, 0x0F, 0x70, 0x07, 0xE0, 0x3F, 0xC0, 0xFE, 0x00,
  0xF0, 0x07, 0xE0, 0x77, 0x0F, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x76, 0x1D, 0xC7, 0x7F, 0x87, 0xC0, 0xE0, 0x73,
  0x83, 0x9C, 0x1C, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x03, 0x38, 0x1D,
  0xC0, 0xEC, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0x80, 0xE0, 0x3F, 0x01,
  0xB8, 0x0C, 0xC0, 0x66, 0x67, 0x33, 0xB9, 0x9D, 0xCF, 0xEC, 0x7D, 0xE3,
  0xEF, 0x0F, 0x78, 0x73, 0xC3, 0x8E, 0x1C, 0x70, 0x70, 0x73, 0xC7, 0x0E,
  0x78, 0x3B, 0x81, 0xF8, 0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x80, 0xEE,
  0x0E, 0x70, 0x71, 0xC7, 0x07, 0x78, 0x38, 0xE0, 0x73, 0x83, 0x8E, 0x38,
  0x73, 0x81, 0xDC, 0x0F, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0x01, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x1D, 0x81, 0x98, 0x39,
  0xC3, 0x0C, 0x30, 0xE6, 0x06, 0x60, 0x70, 0xFF, 0xF8, 0xE3, 0x8E, 0x3F,
  0x0F, 0xF1, 0xCE, 0x00, 0xE3, 0xFC, 0xFF, 0xB8, 0x77, 0x1E, 0xE3, 0xCF,
  0xFD, 0xE3, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x78, 0xDF, 0x9C,
  0x73, 0x8E, 0x60, 0xEC, 0x1D, 0x83, 0xB8, 0xE7, 0x1C, 0xDF, 0xB9, 0xC0,
  0x1F, 0x1F, 0xE7, 0x1F, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x87, 0x71, 0xDF,
  0xE1, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x3D, 0xDF, 0xFF, 0x3F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0xDF, 0xF3, 0xDC, 0x1F, 0x0F, 0xF1,
  0xC7, 0x70, 0x6F, 0xFD, 0xFF, 0xF8, 0x07, 0x00, 0x71, 0xCF, 0xF8, 0x7C,
  0x00, 0x0F, 0xE3, 0xFC, 0x70, 0x0E, 0x0F, 0xFD, 0xFF, 0x87, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3C, 0xDF,
  0xB7, 0x1F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F, 0xC7, 0x71, 0xDF, 0xB3, 0xDC,
  0x07, 0x71, 0xDF, 0xE1, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0xBB,
  0xFF, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x07, 0x07, 0x00,
  0x00, 0x7F, 0x7F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0xFE, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xB9, 0xCE,
  0xE3, 0xB8, 0xFC, 0x3F, 0x8E, 0xE3, 0x9C, 0xE7, 0x38, 0xEE, 0x1C, 0x7E,
  0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0xD9, 0xDF, 0xFF, 0xBB,
  0xE7, 0x7C, 0xCF, 0x99, 0xF3, 0x3E, 0x67, 0xCC, 0xF9, 0x9F, 0x33, 0x80,
  0xE7, 0xBB, 0xFF, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1C, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0E, 0x71, 0xCF, 0xF0, 0x7C, 0x00, 0xE7, 0x8D, 0xF9, 0xC7, 0x38, 0xE6,
  0x0E, 0xC1, 0xD8, 0x3B, 0x8E, 0x71, 0xCD, 0xF9, 0x9C, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0x3D, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xE7, 0xF7,
  0xFE, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x1F,
  0x1F, 0xE6, 0x1D, 0xC0, 0x7E, 0x0F, 0xE0, 0x7C, 0x03, 0xE1, 0xDF, 0xF3,
  0xF0, 0x30, 0x18, 0x0C, 0x1F, 0xEF, 0xF3, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0xF8, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0x73, 0xDF, 0xF3, 0xDC, 0x70, 0x77, 0x07, 0x70, 0xE3,
  0x8E, 0x38, 0xC3, 0x9C, 0x1D, 0xC1, 0xD8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xE0, 0x3E, 0x03, 0x60, 0x36, 0x63, 0x67, 0x36, 0xF7, 0x6D, 0x66, 0xDE,
  0x29, 0xE3, 0x8E, 0x38, 0xE0, 0x70, 0xE3, 0x8E, 0x1D, 0xC1, 0xF8, 0x0F,
  0x00, 0x70, 0x0F, 0x81, 0xDC, 0x39, 0xC3, 0x8E, 0x70, 0x70, 0x70, 0x77,
  0x07, 0x70, 0xE3, 0x8E, 0x38, 0xC1, 0x9C, 0x1D, 0xC0, 0xD8, 0x0F, 0x80,
  0xF0, 0x07, 0x00, 0x70, 0x0E, 0x07, 0xE0, 0x78, 0x00, 0x7F, 0xDF, 0xF0,
  0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0x1F,
  0x8F, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0xF0, 0x78, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0F, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7E, 0x07, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x1C, 0x07, 0x83, 0xC3, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x7E, 0x3E, 0x00, 0x78, 0x3F, 0x8E, 0x3F, 0x81, 0xE0,
};

const GFXglyph LiberationMono_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 14, 13, 5, -14 },
  { 7, 7, 6, 13, 3, -15 },
  { 13, 11, 14, 13, 1, -14 },
  { 33, 11, 17, 13, 1, -15 },
  { 57, 13, 14, 13, 0, -14 },
  { 80, 13, 14, 13, 0, -14 },
  { 103, 3, 6, 13, 5, -15 },
  { 106, 5, 19, 13, 4, -15 },
  { 118, 6, 19, 13, 3, -15 },
  { 133, 8, 8, 13, 2, -15 },
  { 141, 11, 10, 13, 1, -12 },
  { 155, 5, 7, 13, 3, -3 },
  { 160, 6, 2, 13, 3, -7 },
  { 162, 3, 3, 13, 5, -3 },
  { 164, 11, 15, 13, 1, -15 },
  { 185, 10, 14, 13, 1, -14 },
  { 203, 11, 14, 13, 1, -14 },
  { 223, 10, 14, 13, 1, -14 },
  { 241, 11, 14, 13, 1, -14 },
  { 261, 11, 14, 13, 1, -14 },
  { 281, 11, 14, 13, 1, -14 },
  { 301, 10, 14, 13, 1, -14 },
  { 319, 10, 14, 13, 1, -14 },
  { 337, 10, 14, 13, 1, -14 },
  { 355, 10, 14, 13, 1, -14 },
  { 373, 3, 11, 13, 5, -11 },
  { 378, 5, 15, 13, 3, -11 },
  { 388, 11, 11, 13, 1, -13 },
  { 404, 11, 7, 13, 1, -10 },
  { 414, 11, 11, 13, 1, -13 },
  { 430, 10, 14, 13, 1, -14 },
  { 448, 12, 18, 13, 0, -15 },
  { 475, 13, 14, 13, 0, -14 },
  { 498, 11, 14, 13, 1, -14 },
  { 518, 11, 14, 13, 1, -14 },
  { 538, 11, 14, 13, 1, -14 },
  { 558, 11, 14, 13, 1, -14 },
  { 578, 9, 14, 13, 2, -14 },
  { 594, 11, 14, 13, 1, -14 },
  { 614, 10, 14, 13, 1, -14 },
  { 632, 9, 14, 13, 2, -14 },
  { 648, 9, 14, 13, 1, -14 },
  { 664, 12, 14, 13, 1, -14 },
  { 685, 10, 14, 13, 2, -14 },
  { 703, 11, 14, 13, 1, -14 },
  { 723, 10, 14, 13, 1, -14 },
  { 741, 11, 14, 13, 1, -14 },
  { 761, 11, 14, 13, 1, -14 },
  { 781, 11, 18, 13, 1, -14 },
  { 806, 12, 14, 13, 1, -14 },
  { 827, 12, 14, 13, 0, -14 },
  { 848, 11, 14, 13, 1, -14 },
  { 868, 10, 14, 13, 1, -14 },
  { 886, 13, 14, 13, 0, -14 },
  { 909, 13, 14, 13, 0, -14 },
  { 932, 13, 14, 13, 0, -14 },
  { 955, 13, 14, 13, 0, -14 },
  { 978, 11, 14, 13, 1, -14 },
  { 998, 6, 19, 13, 4, -15 },
  { 1013, 11, 15, 13, 1, -15 },
  { 1034, 6, 19, 13, 3, -15 },
  { 1049, 12, 9, 13, 0, -14 },
  { 1063, 13, 1, 13, 0, 1 },
  { 1065, 5, 3, 13, 4, -15 },
  { 1067, 11, 11, 13, 1, -11 },
  { 1083, 11, 15, 13, 1, -15 },
  { 1104, 10, 11, 13, 1, -11 },
  { 1118, 10, 15, 13, 1, -15 },
  { 1137, 11, 11, 13, 1, -11 },
  { 1153, 11, 15, 13, 1, -15 },
  { 1174, 10, 15, 13, 1, -11 },
  { 1193, 10, 15, 13, 1, -15 },
  { 1212, 11, 15, 13, 1, -15 },
  { 1233, 8, 19, 13, 1, -15 },
  { 1252, 10, 15, 13, 2, -15 },
  { 1271, 11, 15, 13, 1, -15 },
  { 1292, 11, 11, 13, 1, -11 },
  { 1308, 10, 11, 13, 1, -11 },
  { 1322, 11, 11, 13, 1, -11 },
  { 1338, 11, 15, 13, 1, -11 },
  { 1359, 10, 15, 13, 1, -11 },
  { 1378, 9, 11, 13, 2, -11 },
  { 1391, 10, 11, 13, 1, -11 },
  { 1405, 9, 14, 13, 2, -14 },
  { 1421, 10, 11, 13, 1, -11 },
  { 1435, 12, 11, 13, 0, -11 },
  { 1452, 12, 11, 13, 0, -11 },
  { 1469, 12, 11, 13, 0, -11 },
  { 1486, 12, 15, 13, 0, -11 },
  { 1509, 10, 11, 13, 1, -11 },
  { 1523, 9, 19, 13, 2, -15 },
  { 1545, 3, 20, 13, 5, -15 },
  { 1553, 9, 19, 13, 2, -15 },
  { 1575, 11, 4, 13, 1, -9 },
};

const GFXfont LiberationMono_Bold21pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold21pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold21pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _LIBERATIONMONO_BOLD21PT7B_H_
