#ifndef _LIBERATIONMONO_BOLD70PT7B_H_
#define _LIBERATIONMONO_BOLD70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF,
  0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01,
  0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xC7, 0xBF, 0xFE, 0x1F, 0xFC, 0x3C, 0x7F,
  0xF0, 0xFF, 0xC1, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0x07, 0xFE, 0x3F, 0xE0,
  0x78, 0x1F, 0xF1, 0xFF, 0x03, 0xC0, 0xFF, 0x8F, 0xF8, 0x1E, 0x07, 0x80,
  0x7F, 0xC0, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x3C,
  0x00, 0x00, 0x7F, 0xFD, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x79, 0xFF, 0xF0, 0x00, 0x03, 0xC1, 0xFF, 0xC0, 0x00, 0x1E,
  0x07, 0xFE, 0x00, 0x00, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0xFF, 0x81,
  0xC0, 0x3C, 0x07, 0xFD, 0xFE, 0x01, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0x01,
  0xFF, 0x7F, 0xC0, 0x78, 0x0F, 0xFB, 0xFF, 0x03, 0xC0, 0x7F, 0xDF, 0xF8,
  0x1E, 0x07, 0xFE, 0x7F, 0xF0, 0xF0, 0x7F, 0xF3, 0xFF, 0xE7, 0x8F, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC1,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0xFF,
  0xC0, 0x01, 0xFC, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x1F, 0x80, 0x00, 0x1F, 0xFF,
  0x8F, 0xC0, 0x00, 0x03, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xFF, 0xC0, 0x00,
  0x03, 0xF1, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0xFC,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x3F,
  0x80, 0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xE0, 0x00,
  0x1F, 0xFF, 0x83, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xFE, 0x7F, 0x80, 0xFE,
  0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xFE,
  0x07, 0xFC, 0x3F, 0x81, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0xDF, 0xC0, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0xFE, 0x3F, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x02,
  0x03, 0xF0, 0x11, 0xF0, 0xFC, 0x1E, 0x7F, 0x3F, 0x3F, 0x9F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xF0, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x03, 0x80,
  0x70, 0x00, 0x40, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xE3,
  0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0x8F, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x80, 0x0F,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x07, 0xFF,
  0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x01,
  0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xF0, 0x3F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x9F, 0xFC,
  0x00, 0xFF, 0xE7, 0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xE0,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x3F,
  0xFE, 0x03, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFE, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFB,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x3F,
  0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0xFF,
  0xF7, 0xFF, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFB, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFD,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0xFF, 0x8F, 0x3C, 0x1F, 0x01, 0xFF,
  0x8F, 0x3E, 0x1F, 0x03, 0xFF, 0xDF, 0x3E, 0x1E, 0x07, 0xE1, 0xDF, 0x3E,
  0x3E, 0x07, 0xC0, 0xFF, 0x1E, 0x3E, 0x0F, 0x80, 0xFE, 0x1E, 0x3E, 0x1F,
  0x80, 0xFE, 0x1E, 0x3C, 0x1F, 0x00, 0x7E, 0x1E, 0x7C, 0x1F, 0x00, 0x7E,
  0x1F, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x7C,
  0x3E, 0x00, 0x7C, 0x1F, 0x7C, 0x7E, 0x00, 0x7C, 0x1F, 0x78, 0x7C, 0x00,
  0x7C, 0x1F, 0x78, 0x7C, 0x00, 0xFC, 0x1F, 0x78, 0x7C, 0x00, 0xFC, 0x1F,
  0x78, 0x7C, 0x00, 0xF8, 0x1E, 0x78, 0x7C, 0x00, 0xF8, 0x1E, 0xF8, 0x7C,
  0x00, 0xF8, 0x1E, 0xF8, 0xFC, 0x00, 0xF8, 0x1E, 0xF8, 0xFC, 0x01, 0xF8,
  0x1E, 0x78, 0xFC, 0x01, 0xF0, 0x3E, 0x78, 0x7C, 0x01, 0xF0, 0x3E, 0x78,
  0x7C, 0x01, 0xF0, 0x3C, 0x78, 0x7C, 0x03, 0xF0, 0x3C, 0x78, 0x7C, 0x03,
  0xF0, 0x7C, 0x7C, 0x7C, 0x07, 0xF0, 0x78, 0x7C, 0x7C, 0x07, 0xF0, 0x78,
  0x7C, 0x3E, 0x0F, 0xF0, 0xF8, 0x7C, 0x3F, 0x1E, 0xF1, 0xF0, 0x3C, 0x3F,
  0xFC, 0x7F, 0xE0, 0x3E, 0x1F, 0xF8, 0x7F, 0xE0, 0x3E, 0x0F, 0xF0, 0x7F,
  0x80, 0x1E, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x03, 0x80,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0,
  0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0xFE, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0C,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xE0,
  0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFE,
  0x3F, 0xF0, 0x07, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC,
  0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F,
  0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0xE0, 0x00, 0x70, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03,
  0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8,
  0x0F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0xC7,
  0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0x80, 0x01,
  0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0x07, 0xEF, 0xFF, 0xF7, 0xF0, 0x7E,
  0xFF, 0xFF, 0x7F, 0x0F, 0xEF, 0xFF, 0xF7, 0xF0, 0xFE, 0xFF, 0xFF, 0x3F,
  0x8F, 0xCF, 0xFF, 0xF3, 0xF9, 0xFC, 0xFF, 0xFF, 0x3F, 0x9F, 0xCF, 0xFF,
  0xF3, 0xF9, 0xFC, 0xFF, 0xFF, 0x1F, 0xDF, 0x8F, 0xFF, 0xF1, 0xFD, 0xF8,
  0xFF, 0xFF, 0x1F, 0xDF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xE0,
  0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x80,
  0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x3F, 0xC0,
  0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0x07, 0xF8,
  0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0x03, 0xFC,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0x01, 0xFE,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07,
  0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xF0,
  0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xF0, 0x00,
  0x7F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x0F,
  0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFC,
  0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x01,
  0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x0F,
  0xF8, 0x0F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFF, 0x07, 0xF8,
  0x1F, 0xE1, 0xFF, 0xE1, 0xFE, 0x07, 0xFC, 0x7F, 0xF8, 0x7F, 0x80, 0xFF,
  0x1F, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xFF, 0x8F, 0xF0, 0x0F, 0xF3, 0xFF,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xBF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xCF, 0xEF, 0xF0, 0x0F, 0xF7, 0xF3, 0xFB, 0xFC, 0x01,
  0xFD, 0xFC, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x3F, 0xBF, 0x80, 0x1F, 0xDF,
  0x87, 0xEF, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFD, 0xFF, 0xD7, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xF9,
  0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0x80, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFC, 0x3F, 0xFE, 0x03,
  0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xF7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF,
  0xE0, 0x1F, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF, 0xF8,
  0x3F, 0xE1, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xFC, 0xFF, 0xC3,
  0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFE, 0x0F, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0x00, 0x3F,
  0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xDF, 0xF8, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07,
  0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFB, 0xFF, 0x07,
  0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xE0,
  0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF,
  0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xF7,
  0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0xFE, 0x01, 0xFF,
  0xF3, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF,
  0xE3, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE,
  0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xCF, 0xFF, 0xFF, 0x3F, 0xE7, 0xFF, 0xFF, 0x9F, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFB, 0xE0, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xEE, 0x00, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xCF,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xF8, 0xFF, 0x83, 0xFE, 0x3F,
  0xCF, 0xFC, 0x3F, 0xF9, 0xFE, 0xFF, 0xF3, 0xFF, 0xEF, 0xF7, 0xFF, 0x9F,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFD, 0xFF, 0x8F, 0xFE, 0x3F, 0xEF, 0xF8,
  0x7F, 0xF0, 0xFF, 0x7F, 0xC1, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xF8, 0x3F,
  0xDF, 0xE0, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFC, 0x07, 0xF7, 0xF8, 0x1F,
  0xE0, 0x3F, 0xBF, 0xC0, 0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xC0, 0x7F, 0x7F, 0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xF0,
  0x1F, 0xDF, 0xC0, 0x7F, 0x80, 0xFE, 0xFE, 0x03, 0xFC, 0x07, 0xF7, 0xF0,
  0x1F, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xF8, 0x0F,
  0xEF, 0xE0, 0x3F, 0xC0, 0x7F, 0x7F, 0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x80, 0xFE, 0xFE, 0x03, 0xFC, 0x07, 0xF7,
  0xF0, 0x1F, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0x7F, 0x7F, 0x01, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x80, 0xFE, 0xFE, 0x03, 0xFC, 0x07,
  0xF7, 0xF0, 0x1F, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xFE, 0x1F, 0xF1,
  0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0xF3, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0x7C, 0x1F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0x7F,
  0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x7F, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xE0,
  0xFF, 0x9F, 0xFF, 0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0x3F, 0xFC, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x1F, 0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC,
  0x01, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xC3,
  0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xF0,
  0x0F, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x1F, 0xF0, 0x1F, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0x07, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF8, 0x7F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF7,
  0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xEF, 0xFC, 0x1F, 0xFF,
  0xF3, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xF0, 0x03,
  0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xFD, 0xFF, 0x3F,
  0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8, 0x01, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F,
  0x80, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x0F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x0C, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0x03,
  0xF8, 0x1F, 0xC1, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xF8, 0x7F, 0x80,
  0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xDF, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF3, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x3F,
  0x1F, 0xC0, 0x3F, 0x9F, 0x87, 0xEF, 0xF0, 0x07, 0xE7, 0xE1, 0xFB, 0xF8,
  0x01, 0xFF, 0xF8, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
};

const GFXglyph LiberationMono_Bold70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 10, 46, 42, 16, -46 },
  { 59, 25, 21, 42, 9, -51 },
  { 125, 38, 46, 42, 2, -46 },
  { 344, 37, 58, 42, 2, -52 },
  { 613, 42, 48, 42, 0, -47 },
  { 865, 41, 48, 42, 1, -47 },
  { 1111, 10, 21, 42, 16, -51 },
  { 1138, 20, 66, 42, 12, -51 },
  { 1303, 20, 66, 42, 10, -51 },
  { 1468, 26, 26, 42, 8, -51 },
  { 1553, 36, 36, 42, 3, -41 },
  { 1715, 16, 23, 42, 9, -10 },
  { 1761, 20, 8, 42, 11, -22 },
  { 1781, 10, 10, 42, 16, -10 },
  { 1794, 36, 52, 42, 3, -51 },
  { 2028, 34, 48, 42, 4, -47 },
  { 2232, 34, 46, 42, 5, -46 },
  { 2428, 34, 47, 42, 4, -47 },
  { 2628, 35, 48, 42, 3, -47 },
  { 2838, 38, 46, 42, 2, -46 },
  { 3057, 34, 47, 42, 4, -46 },
  { 3257, 34, 48, 42, 4, -47 },
  { 3461, 33, 46, 42, 4, -46 },
  { 3651, 34, 48, 42, 4, -47 },
  { 3855, 34, 48, 42, 4, -47 },
  { 4059, 10, 37, 42, 16, -37 },
  { 4106, 17, 50, 42, 11, -37 },
  { 4213, 36, 38, 42, 3, -42 },
  { 4384, 36, 26, 42, 3, -36 },
  { 4501, 36, 38, 42, 3, -42 },
  { 4672, 35, 47, 42, 3, -47 },
  { 4878, 40, 61, 42, 1, -51 },
  { 5183, 42, 46, 42, 0, -46 },
  { 5425, 36, 46, 42, 5, -46 },
  { 5632, 37, 48, 42, 3, -47 },
  { 5854, 34, 46, 42, 5, -46 },
  { 6050, 34, 46, 42, 5, -46 },
  { 6246, 32, 46, 42, 6, -46 },
  { 6430, 36, 48, 42, 3, -47 },
  { 6646, 32, 46, 42, 5, -46 },
  { 6830, 32, 46, 42, 5, -46 },
  { 7014, 32, 47, 42, 3, -46 },
  { 7202, 37, 46, 42, 5, -46 },
  { 7415, 31, 46, 42, 7, -46 },
  { 7594, 36, 46, 42, 3, -46 },
  { 7801, 32, 46, 42, 5, -46 },
  { 7985, 38, 48, 42, 2, -47 },
  { 8213, 34, 46, 42, 5, -46 },
  { 8409, 38, 61, 42, 2, -47 },
  { 8699, 37, 46, 42, 5, -46 },
  { 8912, 39, 48, 42, 1, -47 },
  { 9146, 38, 46, 42, 2, -46 },
  { 9365, 34, 47, 42, 4, -46 },
  { 9565, 42, 46, 42, 0, -46 },
  { 9807, 42, 46, 42, 0, -46 },
  { 10049, 42, 46, 42, 0, -46 },
  { 10291, 42, 46, 42, 0, -46 },
  { 10533, 36, 46, 42, 3, -46 },
  { 10740, 20, 66, 42, 13, -51 },
  { 10905, 36, 52, 42, 3, -51 },
  { 11139, 20, 66, 42, 9, -51 },
  { 11304, 37, 31, 42, 2, -48 },
  { 11448, 42, 3, 42, 0, 4 },
  { 11464, 17, 9, 42, 12, -49 },
  { 11484, 36, 39, 42, 4, -38 },
  { 11660, 34, 52, 42, 5, -51 },
  { 11881, 34, 39, 42, 4, -38 },
  { 12047, 34, 52, 42, 3, -51 },
  { 12268, 36, 39, 42, 3, -38 },
  { 12444, 34, 52, 42, 4, -52 },
  { 12665, 34, 53, 42, 4, -38 },
  { 12891, 33, 51, 42, 5, -51 },
  { 13102, 35, 51, 42, 4, -51 },
  { 13326, 26, 66, 42, 4, -51 },
  { 13541, 34, 51, 42, 6, -51 },
  { 13758, 35, 51, 42, 4, -51 },
  { 13982, 37, 38, 42, 2, -38 },
  { 14158, 33, 38, 42, 5, -38 },
  { 14315, 36, 39, 42, 3, -38 },
  { 14491, 34, 53, 42, 5, -38 },
  { 14717, 34, 53, 42, 3, -38 },
  { 14943, 30, 38, 42, 7, -38 },
  { 15086, 34, 39, 42, 4, -38 },
  { 15252, 30, 48, 42, 5, -47 },
  { 15432, 32, 38, 42, 5, -37 },
  { 15584, 40, 37, 42, 1, -37 },
  { 15769, 42, 37, 42, 0, -37 },
  { 15964, 38, 37, 42, 2, -37 },
  { 16140, 40, 52, 42, 1, -37 },
  { 16400, 32, 37, 42, 5, -37 },
  { 16548, 29, 66, 42, 7, -51 },
  { 16788, 8, 67, 42, 17, -51 },
  { 16855, 29, 66, 42, 6, -51 },
  { 17095, 36, 11, 42, 3, -29 },
};

const GFXfont LiberationMono_Bold70pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold70pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold70pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _LIBERATIONMONO_BOLD70PT7B_H_
