#ifndef _LIBERATIONMONO_BOLD33PT7B_H_
#define _LIBERATIONMONO_BOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xF0, 0xEF, 0x0E,
  0x70, 0xE7, 0x0E, 0x03, 0x87, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x1C, 0x18,
  0x07, 0x0E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFC, 0x38, 0x30, 0x0E, 0x0C, 0x03,
  0x07, 0x00, 0xC1, 0xC0, 0x30, 0x70, 0x1C, 0x18, 0x3F, 0xFF, 0xEF, 0xFF,
  0xF8, 0x60, 0xE0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0xC1, 0xC0,
  0x30, 0x70, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0x80,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x37, 0xC7, 0x8C, 0xF9, 0xE3, 0x3E, 0x78,
  0xC7, 0x1F, 0x30, 0x07, 0xEC, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xC7, 0x9C, 0x31, 0xFF, 0x8C, 0x7D,
  0xE3, 0x1E, 0x7C, 0xCF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xE7, 0xF0, 0x1C, 0xF3,
  0x83, 0x8E, 0x38, 0x30, 0xE3, 0x87, 0x0E, 0x38, 0xE0, 0xE3, 0x8C, 0x0E,
  0x39, 0xC0, 0x73, 0xB8, 0x07, 0xF3, 0x00, 0x3E, 0x70, 0x00, 0x0E, 0x7C,
  0x01, 0xCF, 0xE0, 0x1D, 0xCE, 0x03, 0x9C, 0x70, 0x71, 0x87, 0x07, 0x18,
  0x70, 0xE1, 0x87, 0x1C, 0x1C, 0x71, 0xC1, 0xCE, 0x38, 0x0F, 0xE7, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xF1, 0xE0, 0x0F,
  0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x1E, 0x00, 0x77, 0xC0, 0x07, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC1, 0xC3, 0xFC, 0x3C, 0x7D, 0xE3, 0x87, 0x9F, 0x38,
  0xF0, 0xF7, 0x8F, 0x07, 0xF0, 0xF0, 0x3F, 0x07, 0x81, 0xF0, 0x7C, 0x3F,
  0xD7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E,
  0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0xC3,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8,
  0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0xC7, 0xC3, 0xC3, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x0C, 0xE2, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8, 0x3F,
  0xC7, 0x9E, 0x71, 0xE1, 0x08, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x3E, 0x3E, 0x3C, 0x3C, 0x38, 0x78,
  0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C,
  0x3E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF3, 0xDF, 0xF3,
  0xDF, 0xF3, 0xDF, 0xF3, 0xDF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x78,
  0x3E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0xFD, 0xE0, 0xF9, 0xE0, 0xE1,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xC1, 0xF3, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0xF0,
  0x1F, 0x7C, 0x0F, 0xBF, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xDE, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0x3E, 0x07, 0x8F,
  0x81, 0xC3, 0xE0, 0xF0, 0xF8, 0x78, 0x3E, 0x3C, 0x0F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7B, 0xF0, 0x7F, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1E,
  0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x3F,
  0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC,
  0x0F, 0xE0, 0x3F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xF8, 0x3E,
  0xF8, 0x1E, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF,
  0x3F, 0xFF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1E, 0x78, 0x3E, 0xFC, 0x7E,
  0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x78, 0x78, 0x70, 0x70, 0xE0, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x7F, 0x03,
  0xFF, 0x1F, 0xFE, 0xFF, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFE, 0xFF, 0xF0, 0xFF, 0xC0, 0xFE,
  0x00, 0xF0, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xE0, 0xE0, 0x70,
  0x1C, 0x38, 0x03, 0x8C, 0x00, 0x67, 0x1E, 0x79, 0x8F, 0xFB, 0x67, 0x1C,
  0xF9, 0x87, 0x3C, 0xE1, 0xCF, 0x38, 0x73, 0xCC, 0x1C, 0xF3, 0x06, 0x3C,
  0xC1, 0x8F, 0x70, 0x63, 0xDC, 0x38, 0xF3, 0x0E, 0x6C, 0xC7, 0x9B, 0x39,
  0x6E, 0xEF, 0xDF, 0x19, 0xE3, 0x86, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x02,
  0x07, 0x03, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x07, 0x9E,
  0x00, 0x79, 0xE0, 0x0F, 0x9E, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0,
  0xF0, 0x1E, 0x0F, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xEF,
  0x80, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F,
  0x9F, 0x03, 0xE7, 0xC0, 0x61, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x71, 0xF0,
  0x1F, 0x7C, 0x0F, 0x8F, 0xC7, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0x87, 0xE7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x0F, 0x7C, 0x07,
  0xBE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x3F, 0x7C, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0, 0x38, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFD, 0xF0, 0x1E,
  0xF8, 0x0F, 0x7C, 0x07, 0x9F, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF7, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xF1, 0xF7, 0xFF, 0xDF,
  0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x83, 0xF3,
  0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xFB,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x7E,
  0x0F, 0xCF, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0x83, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0xBE, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x77, 0xEE, 0x77, 0xEE, 0x77, 0xEE, 0x77, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xF7,
  0x1F, 0xF7, 0x9F, 0xF7, 0x9F, 0xF3, 0xDF, 0xF3, 0xDF, 0xF3, 0xCF, 0xF1,
  0xEF, 0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7E, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8,
  0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xEF, 0x80, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xC3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xBE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0x3E, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x0F, 0x8F, 0x83, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x07,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x1F, 0x9E, 0x03,
  0xE7, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3E, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xF8,
  0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0x9E,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0xF1, 0xE7,
  0x8F, 0x1E, 0x78, 0xF1, 0xC7, 0x9F, 0x3C, 0x3D, 0xFB, 0xC3, 0xDF, 0xBC,
  0x3F, 0xFB, 0xC3, 0xFB, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xF8, 0x1F, 0x9F,
  0x81, 0xF1, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF0, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0xF8, 0x0F,
  0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F,
  0x1F, 0x00, 0xF9, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xE0, 0x0F, 0x38, 0x03, 0x8F,
  0x01, 0xE1, 0xC0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x1C, 0xF0, 0x07, 0xBC, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x1E, 0x0F, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0x8F,
  0x87, 0x83, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFF, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x83, 0xF3, 0xE3, 0xF9,
  0xFF, 0xBF, 0x7F, 0x9F, 0x8F, 0x87, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF0, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFE, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x3E, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x78, 0x1F, 0x7C,
  0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x1F, 0x1E, 0x3F, 0xDE, 0x7F,
  0xFE, 0x7C, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C,
  0x7E, 0x7F, 0xDE, 0x3F, 0xDE, 0x1F, 0x1F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7C, 0x3E, 0xF8, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x7C,
  0x3E, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x8F, 0x3F, 0xDF, 0x3F,
  0xFF, 0x7E, 0x3F, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7C,
  0x3F, 0x7F, 0xFF, 0x3F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0xFB,
  0xFC, 0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF0, 0x7C,
  0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8,
  0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1F, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x8F, 0x3F, 0xF7,
  0xEF, 0xFD, 0xFB, 0xEF, 0xDE, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1,
  0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78,
  0xF0, 0xF8, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0xC0, 0xFB,
  0xE0, 0x7D, 0xE0, 0x3E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03,
  0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x7C, 0xF8, 0x7C, 0x3F, 0xFC, 0x0F,
  0xFC, 0x03, 0xF8, 0x00, 0xF8, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFE, 0x3E,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x3E, 0xFF, 0xFE,
  0xFB, 0xFC, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x1F, 0x3F, 0xDE, 0x7F, 0xDE,
  0x7C, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C, 0x7E,
  0x7F, 0xFE, 0x3F, 0xDE, 0x1F, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0xF8, 0xFD, 0xE7, 0xF7,
  0xBF, 0xDE, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3E,
  0x78, 0x1E, 0x78, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xDF,
  0xF7, 0xBF, 0xEF, 0x3F, 0x1E, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0x1E, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0x83, 0xE0, 0xF8, 0x78,
  0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3E, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x70, 0xF1,
  0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x9F, 0x1C, 0x39, 0xF9, 0xC3, 0x9F,
  0x9C, 0x3B, 0xBB, 0xC3, 0xB9, 0xFC, 0x3B, 0x9F, 0xC3, 0xB1, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0xF8, 0x0F, 0x9F,
  0x03, 0xE3, 0xE1, 0xF0, 0x78, 0xF8, 0x1F, 0x3C, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0x3C, 0x07, 0xCF, 0x83, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x0F, 0xBE,
  0x01, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x3E, 0x7C,
  0x0F, 0x0F, 0x03, 0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0xCF,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0xB8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC3, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x3E,
  0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFE, 0x0F,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x01, 0xFC, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0x00, 0x7E,
};

const GFXglyph LiberationMono_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 22, 20, 8, -22 },
  { 12, 12, 10, 20, 4, -24 },
  { 27, 18, 22, 20, 1, -22 },
  { 77, 18, 27, 20, 1, -24 },
  { 138, 20, 22, 20, 0, -22 },
  { 193, 20, 22, 20, 0, -22 },
  { 248, 4, 10, 20, 8, -24 },
  { 253, 9, 31, 20, 6, -24 },
  { 288, 9, 31, 20, 5, -24 },
  { 323, 12, 12, 20, 4, -24 },
  { 341, 16, 18, 20, 2, -20 },
  { 377, 8, 11, 20, 4, -5 },
  { 388, 10, 4, 20, 5, -11 },
  { 393, 4, 5, 20, 8, -5 },
  { 396, 17, 24, 20, 1, -24 },
  { 447, 16, 22, 20, 2, -22 },
  { 491, 16, 22, 20, 2, -22 },
  { 535, 16, 22, 20, 2, -22 },
  { 579, 17, 22, 20, 1, -22 },
  { 626, 18, 22, 20, 1, -22 },
  { 676, 16, 22, 20, 2, -22 },
  { 720, 16, 22, 20, 2, -22 },
  { 764, 16, 22, 20, 2, -22 },
  { 808, 16, 22, 20, 2, -22 },
  { 852, 16, 22, 20, 2, -22 },
  { 896, 4, 18, 20, 8, -18 },
  { 905, 8, 24, 20, 5, -18 },
  { 929, 16, 18, 20, 2, -20 },
  { 965, 16, 12, 20, 2, -17 },
  { 989, 16, 18, 20, 2, -20 },
  { 1025, 17, 22, 20, 1, -22 },
  { 1072, 18, 28, 20, 1, -24 },
  { 1135, 20, 22, 20, 0, -22 },
  { 1190, 17, 22, 20, 2, -22 },
  { 1237, 18, 22, 20, 1, -22 },
  { 1287, 17, 22, 20, 2, -22 },
  { 1334, 16, 22, 20, 2, -22 },
  { 1378, 15, 22, 20, 3, -22 },
  { 1420, 17, 22, 20, 1, -22 },
  { 1467, 16, 22, 20, 2, -22 },
  { 1511, 14, 22, 20, 3, -22 },
  { 1550, 14, 22, 20, 2, -22 },
  { 1589, 18, 22, 20, 2, -22 },
  { 1639, 15, 22, 20, 3, -22 },
  { 1681, 16, 22, 20, 2, -22 },
  { 1725, 16, 22, 20, 2, -22 },
  { 1769, 18, 22, 20, 1, -22 },
  { 1819, 16, 22, 20, 2, -22 },
  { 1863, 18, 29, 20, 1, -22 },
  { 1929, 18, 22, 20, 2, -22 },
  { 1979, 18, 22, 20, 1, -22 },
  { 2029, 18, 22, 20, 1, -22 },
  { 2079, 16, 22, 20, 2, -22 },
  { 2123, 20, 22, 20, 0, -22 },
  { 2178, 20, 22, 20, 0, -22 },
  { 2233, 20, 22, 20, 0, -22 },
  { 2288, 20, 22, 20, 0, -22 },
  { 2343, 17, 22, 20, 1, -22 },
  { 2390, 10, 31, 20, 6, -24 },
  { 2429, 17, 24, 20, 1, -24 },
  { 2480, 10, 31, 20, 4, -24 },
  { 2519, 18, 14, 20, 1, -22 },
  { 2551, 20, 2, 20, 0, 2 },
  { 2556, 8, 4, 20, 6, -23 },
  { 2560, 17, 18, 20, 2, -18 },
  { 2599, 16, 24, 20, 2, -24 },
  { 2647, 16, 18, 20, 2, -18 },
  { 2683, 16, 24, 20, 2, -24 },
  { 2731, 16, 18, 20, 2, -18 },
  { 2767, 16, 24, 20, 2, -24 },
  { 2815, 16, 25, 20, 2, -18 },
  { 2865, 16, 24, 20, 2, -24 },
  { 2913, 16, 24, 20, 2, -24 },
  { 2961, 12, 31, 20, 2, -24 },
  { 3008, 16, 24, 20, 3, -24 },
  { 3056, 16, 24, 20, 2, -24 },
  { 3104, 18, 18, 20, 1, -18 },
  { 3145, 16, 18, 20, 2, -18 },
  { 3181, 17, 18, 20, 1, -18 },
  { 3220, 16, 25, 20, 2, -18 },
  { 3270, 16, 25, 20, 2, -18 },
  { 3320, 14, 18, 20, 3, -18 },
  { 3352, 16, 18, 20, 2, -18 },
  { 3388, 14, 23, 20, 3, -23 },
  { 3429, 15, 17, 20, 2, -17 },
  { 3461, 19, 18, 20, 0, -18 },
  { 3504, 20, 18, 20, 0, -18 },
  { 3549, 18, 18, 20, 1, -18 },
  { 3590, 18, 25, 20, 1, -18 },
  { 3647, 15, 18, 20, 2, -18 },
  { 3681, 14, 31, 20, 3, -24 },
  { 3736, 4, 31, 20, 8, -24 },
  { 3752, 14, 31, 20, 3, -24 },
  { 3807, 16, 6, 20, 2, -14 },
};

const GFXfont LiberationMono_Bold33pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold33pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold33pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _LIBERATIONMONO_BOLD33PT7B_H_
