#ifndef _LIBERATIONMONO_BOLD11PT7B_H_
#define _LIBERATIONMONO_BOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xF6, 0xDD, 0x50, 0x24, 0xA7, 0xCA, 0xFD, 0x25, 0x00, 0x11, 0xE5,
  0xD4, 0x38, 0x5D, 0x5F, 0x10, 0xE5, 0x52, 0xA7, 0xE2, 0xA9, 0x53, 0x00,
  0x38, 0x90, 0xC3, 0x29, 0xD9, 0x1D, 0x80, 0xE0, 0x6B, 0x49, 0x26, 0x4C,
  0x89, 0x36, 0xDA, 0x50, 0x2B, 0x77, 0x50, 0x21, 0x3E, 0x42, 0x00, 0x69,
  0x00, 0xE0, 0xC0, 0x04, 0x20, 0x84, 0x30, 0x86, 0x10, 0x74, 0xE7, 0x79,
  0xCD, 0xC0, 0x67, 0x08, 0x42, 0x13, 0xE0, 0xF4, 0xC6, 0x66, 0x63, 0xE0,
  0x79, 0x30, 0xCC, 0x0D, 0x37, 0x80, 0x18, 0xE2, 0x92, 0xFC, 0x20, 0x80,
  0xFC, 0x3C, 0x31, 0xCF, 0xC0, 0x74, 0x3D, 0x39, 0xED, 0xC0, 0xF8, 0x8C,
  0x46, 0x31, 0x00, 0xF4, 0xE6, 0xC9, 0xCF, 0xC0, 0x74, 0xE7, 0x3F, 0x8F,
  0xC0, 0xCC, 0x50, 0x78, 0x0F, 0xA0, 0xE0, 0x80, 0xF8, 0x3E, 0x83, 0x82,
  0xE8, 0x00, 0x79, 0x30, 0xCC, 0x00, 0xC3, 0x00, 0x39, 0x14, 0x6F, 0xAF,
  0x3B, 0xE0, 0x44, 0xE0, 0x30, 0x70, 0xA3, 0x47, 0xC8, 0xB1, 0x00, 0xF4,
  0xE7, 0xE8, 0xC7, 0xE0, 0x39, 0x34, 0x30, 0x41, 0x93, 0x80, 0xF4, 0xE3,
  0x19, 0xCF, 0xC0, 0xFC, 0x21, 0xF8, 0x43, 0xE0, 0xFC, 0x21, 0xF8, 0x42,
  0x00, 0x39, 0x34, 0x37, 0x45, 0x13, 0x80, 0x9C, 0xE7, 0xF9, 0xCE, 0x60,
  0xF9, 0x08, 0x42, 0x13, 0xE0, 0x71, 0x11, 0x19, 0xF0, 0x9A, 0x4A, 0x38,
  0xF2, 0x69, 0x80, 0xC6, 0x31, 0x8C, 0x63, 0xE0, 0xDE, 0xF7, 0xDA, 0xC6,
  0x20, 0xDE, 0xFF, 0x5A, 0xDE, 0x60, 0x39, 0x3C, 0x71, 0xC5, 0x33, 0x80,
  0xF4, 0xE7, 0xE8, 0x42, 0x00, 0x39, 0x3C, 0x71, 0xC5, 0x37, 0x84, 0x1C,
  0xFA, 0x28, 0xBC, 0x92, 0x68, 0x80, 0x79, 0x36, 0x0E, 0x0F, 0x17, 0x80,
  0xFC, 0x41, 0x04, 0x10, 0x41, 0x00, 0x9C, 0xE7, 0x39, 0xCF, 0xC0, 0xC4,
  0x99, 0x33, 0x42, 0x87, 0x0C, 0x00, 0x87, 0x8B, 0x53, 0xA7, 0xCD, 0x9B,
  0x00, 0x4C, 0xD0, 0xE1, 0x83, 0x8D, 0xB1, 0x00, 0xC4, 0x99, 0xA1, 0xC3,
  0x02, 0x04, 0x00, 0x7C, 0x21, 0x8C, 0x21, 0x8F, 0xC0, 0xF2, 0x49, 0x24,
  0x9C, 0x41, 0x82, 0x0C, 0x10, 0x20, 0x81, 0xF3, 0x33, 0x33, 0x33, 0x3F,
  0x30, 0xA4, 0x93, 0xC4, 0xFE, 0xC8, 0x76, 0xBF, 0x39, 0xFC, 0x84, 0x2D,
  0xB9, 0xCF, 0x76, 0x74, 0xE1, 0x09, 0xB8, 0x18, 0xFF, 0x39, 0xCE, 0x7F,
  0x74, 0xFF, 0x0D, 0xB8, 0x7B, 0x3E, 0xC6, 0x31, 0x8C, 0xEE, 0xE7, 0x3D,
  0xFC, 0x7E, 0x84, 0x2D, 0xB9, 0xCE, 0x73, 0x20, 0x38, 0x42, 0x10, 0x9F,
  0x30, 0xF3, 0x33, 0x33, 0x3E, 0x84, 0x27, 0x6E, 0x7A, 0x53, 0xE1, 0x08,
  0x42, 0x10, 0x9F, 0xFF, 0x5D, 0x75, 0xD7, 0x50, 0xB6, 0xE7, 0x39, 0xCC,
  0x39, 0x34, 0x51, 0x4C, 0xE0, 0xB6, 0xE7, 0x3D, 0xDA, 0x10, 0xFC, 0xE7,
  0x39, 0xFC, 0x63, 0xFE, 0x31, 0x8C, 0x60, 0xF4, 0x38, 0x70, 0xF8, 0x42,
  0x3C, 0x84, 0x21, 0x0F, 0x9C, 0xE7, 0x39, 0xFC, 0xC5, 0x36, 0x9A, 0x38,
  0xC0, 0x85, 0x2B, 0xD3, 0xE6, 0xCD, 0x80, 0x4D, 0xA3, 0x0E, 0x69, 0x30,
  0xC5, 0x36, 0x8A, 0x38, 0xC3, 0x18, 0xF9, 0x88, 0xCC, 0x7C, 0x3B, 0x18,
  0xCC, 0x31, 0x8C, 0x61, 0xC0, 0xFF, 0xC0, 0xE1, 0x08, 0x41, 0x98, 0x84,
  0x27, 0x00, 0xC1, 0xC0,
};

const GFXglyph LiberationMono_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 7, 7, 3, -7 },
  { 2, 4, 3, 7, 1, -8 },
  { 4, 6, 7, 7, 0, -7 },
  { 10, 6, 9, 7, 0, -8 },
  { 17, 7, 7, 7, 0, -7 },
  { 24, 7, 7, 7, 0, -7 },
  { 31, 1, 3, 7, 3, -8 },
  { 32, 3, 10, 7, 2, -8 },
  { 36, 3, 10, 7, 2, -8 },
  { 40, 4, 5, 7, 1, -8 },
  { 43, 5, 5, 7, 1, -6 },
  { 47, 3, 3, 7, 1, -2 },
  { 49, 3, 1, 7, 2, -4 },
  { 50, 1, 2, 7, 3, -2 },
  { 51, 6, 8, 7, 0, -8 },
  { 57, 5, 7, 7, 1, -7 },
  { 62, 5, 7, 7, 1, -7 },
  { 67, 5, 7, 7, 1, -7 },
  { 72, 6, 7, 7, 0, -7 },
  { 78, 6, 7, 7, 0, -7 },
  { 84, 5, 7, 7, 1, -7 },
  { 89, 5, 7, 7, 1, -7 },
  { 94, 5, 7, 7, 1, -7 },
  { 99, 5, 7, 7, 1, -7 },
  { 104, 5, 7, 7, 1, -7 },
  { 109, 1, 6, 7, 3, -6 },
  { 110, 2, 7, 7, 2, -6 },
  { 112, 5, 5, 7, 1, -6 },
  { 116, 5, 3, 7, 1, -5 },
  { 118, 5, 5, 7, 1, -6 },
  { 122, 6, 7, 7, 0, -7 },
  { 128, 6, 10, 7, 0, -8 },
  { 136, 7, 7, 7, 0, -7 },
  { 143, 5, 7, 7, 1, -7 },
  { 148, 6, 7, 7, 0, -7 },
  { 154, 5, 7, 7, 1, -7 },
  { 159, 5, 7, 7, 1, -7 },
  { 164, 5, 7, 7, 1, -7 },
  { 169, 6, 7, 7, 0, -7 },
  { 175, 5, 7, 7, 1, -7 },
  { 180, 5, 7, 7, 1, -7 },
  { 185, 4, 7, 7, 1, -7 },
  { 189, 6, 7, 7, 1, -7 },
  { 195, 5, 7, 7, 1, -7 },
  { 200, 5, 7, 7, 1, -7 },
  { 205, 5, 7, 7, 1, -7 },
  { 210, 6, 7, 7, 0, -7 },
  { 216, 5, 7, 7, 1, -7 },
  { 221, 6, 9, 7, 0, -7 },
  { 228, 6, 7, 7, 1, -7 },
  { 234, 6, 7, 7, 0, -7 },
  { 240, 6, 7, 7, 0, -7 },
  { 246, 5, 7, 7, 1, -7 },
  { 251, 7, 7, 7, 0, -7 },
  { 258, 7, 7, 7, 0, -7 },
  { 265, 7, 7, 7, 0, -7 },
  { 272, 7, 7, 7, 0, -7 },
  { 279, 6, 7, 7, 0, -7 },
  { 285, 3, 10, 7, 2, -8 },
  { 289, 6, 8, 7, 0, -8 },
  { 295, 4, 10, 7, 1, -8 },
  { 300, 6, 5, 7, 0, -7 },
  { 304, 7, 1, 7, 0, 1 },
  { 305, 3, 2, 7, 2, -9 },
  { 306, 5, 6, 7, 1, -6 },
  { 310, 5, 8, 7, 1, -8 },
  { 315, 5, 6, 7, 1, -6 },
  { 319, 5, 8, 7, 1, -8 },
  { 324, 5, 6, 7, 1, -6 },
  { 328, 5, 8, 7, 1, -8 },
  { 333, 5, 8, 7, 1, -6 },
  { 338, 5, 8, 7, 1, -8 },
  { 343, 5, 8, 7, 1, -8 },
  { 348, 4, 10, 7, 1, -8 },
  { 353, 5, 8, 7, 1, -8 },
  { 358, 5, 8, 7, 1, -8 },
  { 363, 6, 6, 7, 0, -6 },
  { 368, 5, 6, 7, 1, -6 },
  { 372, 6, 6, 7, 0, -6 },
  { 377, 5, 8, 7, 1, -6 },
  { 382, 5, 8, 7, 1, -6 },
  { 387, 5, 6, 7, 1, -6 },
  { 391, 5, 6, 7, 1, -6 },
  { 395, 5, 8, 7, 1, -8 },
  { 400, 5, 6, 7, 1, -6 },
  { 404, 6, 6, 7, 0, -6 },
  { 409, 7, 6, 7, 0, -6 },
  { 415, 6, 6, 7, 0, -6 },
  { 420, 6, 8, 7, 0, -6 },
  { 426, 5, 6, 7, 1, -6 },
  { 430, 5, 10, 7, 1, -8 },
  { 437, 1, 10, 7, 3, -8 },
  { 439, 5, 10, 7, 1, -8 },
  { 446, 5, 2, 7, 1, -5 },
};

const GFXfont LiberationMono_Bold11pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold11pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold11pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _LIBERATIONMONO_BOLD11PT7B_H_
