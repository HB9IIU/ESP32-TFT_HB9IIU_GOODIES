#ifndef _IBMPLEXMONO_LIGHT69PT7B_H_
#define _IBMPLEXMONO_LIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light69pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7C, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFE, 0x1C, 0x7F, 0x81, 0xFC, 0x0E, 0x0F, 0xE0, 0xF8,
  0x07, 0x01, 0xF8, 0xF8, 0x03, 0x80, 0x3E, 0x78, 0x01, 0xC0, 0x0E, 0x3C,
  0x00, 0xE0, 0x06, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0xE0, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x03, 0xF8, 0x1C, 0x00,
  0x00, 0xFF, 0x8E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x38, 0xFF, 0x80, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x0E,
  0x03, 0xF0, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x3C, 0x80, 0x03, 0x80, 0x1E, 0xE0, 0x01, 0xC0, 0x0F, 0xF8,
  0x00, 0xE0, 0x0F, 0xBE, 0x00, 0x70, 0x0F, 0x8F, 0xC0, 0x38, 0x0F, 0xC3,
  0xF0, 0x1C, 0x0F, 0xC0, 0xFF, 0x0E, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF1, 0xFF, 0xF0, 0x00, 0x07, 0x8F, 0x83, 0xE0, 0x00, 0x1C,
  0x3C, 0x03, 0xC0, 0x00, 0xF1, 0xE0, 0x07, 0x00, 0x03, 0x87, 0x00, 0x0E,
  0x00, 0x1E, 0x3C, 0x00, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x03, 0xC3,
  0x80, 0x03, 0xC0, 0x0E, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x38, 0x00, 0x3C,
  0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x0E,
  0x00, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x0F,
  0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x81, 0xE0, 0x00, 0x7F, 0xFC, 0x07,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x07, 0xFF, 0xC0, 0x00,
  0xF0, 0x3E, 0x0F, 0x80, 0x03, 0x81, 0xE0, 0x0F, 0x00, 0x1E, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x38, 0x00,
  0x3C, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x78, 0x03, 0x80, 0x03, 0xC1, 0xC0,
  0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x00,
  0xE1, 0xE0, 0x03, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x00, 0x1E, 0x3C, 0x00,
  0x1C, 0x00, 0x71, 0xE0, 0x00, 0x78, 0x03, 0xC7, 0x80, 0x00, 0xF8, 0x3E,
  0x3C, 0x00, 0x01, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0x7C, 0x00, 0xFF, 0x83, 0xE3, 0xF0, 0x07, 0xFC, 0x3E, 0x0F, 0x80, 0x3C,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x03,
  0xE0, 0x78, 0x0F, 0x00, 0x0F, 0x83, 0x80, 0x78, 0x00, 0x3E, 0x1C, 0x07,
  0xC0, 0x01, 0xF0, 0xE0, 0x3C, 0x00, 0x07, 0xC7, 0x01, 0xE0, 0x00, 0x1F,
  0x78, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x78, 0x00, 0x01, 0xFC, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xFC,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x6F, 0x80, 0x7C, 0x00,
  0x07, 0x3E, 0x03, 0xF0, 0x00, 0xF0, 0xF8, 0x0F, 0xF0, 0x1F, 0x83, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xFF, 0xF0,
  0x00, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x78, 0x00,
  0x27, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0x01, 0xE0, 0x3F, 0xFF, 0xFC, 0x3C,
  0x3F, 0xF8, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0x80, 0x1F, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xFC,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xEF, 0x00, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x0F, 0xC3, 0xC0, 0x00,
  0x0F, 0xC1, 0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x0F, 0xC0, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x78, 0x10, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x78, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x90, 0x00, 0x00, 0x1F, 0x30, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x3F, 0xE0, 0x00, 0xE1, 0xFF, 0xF8, 0x03, 0xC7, 0xFF, 0xF8, 0x07, 0xBF,
  0xFF, 0xFC, 0x0F, 0x7C, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC4, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xE0,
  0x01, 0xE1, 0xFF, 0xF8, 0x03, 0xC7, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF, 0xFC,
  0x1E, 0x7C, 0x03, 0xFC, 0x3D, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xF9,
  0xEC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xDE, 0x3F, 0x00, 0x07, 0x3C, 0x3F,
  0xC0, 0x3E, 0xF0, 0x3F, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xC3, 0xC0, 0x1F,
  0xFF, 0x0F, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7C, 0x1F, 0x0F, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x0F, 0xC1, 0xDE, 0x00, 0x7F, 0xC7, 0x70, 0x07, 0xFF, 0x9D, 0xC0, 0x1F,
  0xFF, 0x77, 0x00, 0xFC, 0x1D, 0xFC, 0x07, 0xC0, 0x17, 0xF0, 0x1E, 0x00,
  0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x01, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x07,
  0xF0, 0x3C, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x7F, 0x03, 0xC0, 0x01, 0xFC,
  0x0F, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x7F, 0x03,
  0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x1F, 0xC0, 0xF0,
  0x00, 0x7F, 0x03, 0xC0, 0x01, 0xFC, 0x07, 0x00, 0x07, 0xF0, 0x1E, 0x00,
  0x3F, 0xC0, 0x78, 0x00, 0xF7, 0x00, 0xF0, 0x05, 0xDC, 0x03, 0xF8, 0xF7,
  0x70, 0x07, 0xFF, 0x9D, 0xE0, 0x0F, 0xFE, 0x77, 0x80, 0x1F, 0xF1, 0xDE,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0xFE, 0x1E,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0C, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x3E, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x7F,
  0x83, 0xC0, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xFC, 0x3C,
  0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0D, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0xEF, 0x07, 0xE0, 0x01, 0xCF, 0x03, 0xF8, 0x07, 0xCF, 0x01, 0xFF,
  0xFF, 0x8F, 0x00, 0xFF, 0xFF, 0x0F, 0x00, 0x7F, 0xFE, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x03, 0xE3, 0xFE, 0x00, 0x01, 0xF1,
  0xEF, 0x00, 0x00, 0xF9, 0xE7, 0xC0, 0x00, 0x7D, 0xE1, 0xF0, 0x00, 0x3F,
  0xF0, 0xF8, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x07,
  0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xC0, 0x00, 0x7F, 0xFB, 0xC0, 0x00,
  0xEF, 0xF7, 0x80, 0x03, 0xDF, 0xE7, 0x80, 0x07, 0xBF, 0xCF, 0x00, 0x0E,
  0x7F, 0x8E, 0x00, 0x3C, 0xFF, 0x1E, 0x00, 0x71, 0xFE, 0x1C, 0x01, 0xE3,
  0xFC, 0x3C, 0x03, 0x87, 0xF8, 0x78, 0x0F, 0x0F, 0xF0, 0x78, 0x1E, 0x1F,
  0xE0, 0xF0, 0x38, 0x3F, 0xC0, 0xE0, 0xF0, 0x7F, 0x81, 0xE1, 0xC0, 0xFF,
  0x01, 0xC7, 0x81, 0xFE, 0x03, 0xCE, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0,
  0x1F, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0xFF, 0x00, 0x38, 0x01, 0xFE, 0x00,
  0x70, 0x03, 0xFC, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x80, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xDE, 0x00,
  0x00, 0xFE, 0xF0, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x3F, 0x9E, 0x00, 0x01,
  0xFC, 0xF8, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x7F, 0x1F, 0x00, 0x03, 0xF8,
  0x78, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0xFE, 0x0F, 0x00, 0x07, 0xF0, 0x78,
  0x00, 0x3F, 0x81, 0xE0, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0x3C, 0x00,
  0x7F, 0x01, 0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0x3C, 0x00, 0xFE,
  0x01, 0xF0, 0x07, 0xF0, 0x07, 0x80, 0x3F, 0x80, 0x3C, 0x01, 0xFC, 0x00,
  0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x7F, 0x00, 0x1E, 0x03, 0xF8, 0x00, 0xF0,
  0x1F, 0xC0, 0x03, 0xC0, 0xFE, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0xF8, 0x3F,
  0x80, 0x03, 0xC1, 0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x78, 0x7F, 0x00,
  0x03, 0xE3, 0xF8, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x78, 0xFE, 0x00, 0x01,
  0xE7, 0xF0, 0x00, 0x0F, 0x3F, 0x80, 0x00, 0x3D, 0xFC, 0x00, 0x01, 0xEF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0xF0, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x0F, 0xE3,
  0xC0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x02, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x40, 0x00,
  0x00, 0x1F, 0x70, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x07, 0xCF, 0xE0, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x1C, 0xF0, 0x03, 0xE0, 0x03, 0x9E, 0x00, 0x7C, 0x00, 0x73,
  0xC0, 0x0F, 0xC0, 0x1E, 0x78, 0x01, 0xF8, 0x03, 0xC7, 0x00, 0x7F, 0x00,
  0x78, 0xE0, 0x0E, 0xE0, 0x0F, 0x1C, 0x01, 0xDE, 0x01, 0xE3, 0x80, 0x3B,
  0xC0, 0x3C, 0x78, 0x0F, 0x38, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0xE1, 0xE0,
  0x38, 0xF0, 0x1C, 0x3C, 0x07, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0x70,
  0xF0, 0x38, 0x38, 0x0E, 0x1E, 0x07, 0x07, 0x83, 0xC3, 0xC0, 0xE0, 0xF0,
  0x78, 0x38, 0x3C, 0x0E, 0x0F, 0x07, 0x07, 0x81, 0xC1, 0xE0, 0xE0, 0xE0,
  0x3C, 0x3C, 0x1C, 0x1C, 0x07, 0x87, 0x83, 0xC7, 0x80, 0x70, 0xE0, 0x78,
  0xF0, 0x0E, 0x1C, 0x0F, 0x1C, 0x01, 0xE3, 0x81, 0xE3, 0x80, 0x3C, 0x70,
  0x3C, 0xF0, 0x03, 0x8E, 0x07, 0x9E, 0x00, 0x71, 0xC0, 0xF3, 0x80, 0x0F,
  0x78, 0x0E, 0x70, 0x01, 0xEF, 0x01, 0xDE, 0x00, 0x1D, 0xE0, 0x3B, 0xC0,
  0x03, 0xBC, 0x07, 0x70, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x01, 0xE6, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10,
  0x0E, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x01, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x03, 0xE0,
  0x10, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0x80, 0x01, 0xE0, 0x7E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1D, 0xE0,
  0x3F, 0x80, 0x7C, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0xF0, 0x7F, 0xFC, 0x03,
  0xC3, 0xFF, 0xFC, 0x0F, 0x1F, 0xFF, 0xF8, 0x3C, 0xF8, 0x0F, 0xF0, 0xF7,
  0x00, 0x0F, 0xC3, 0xD8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x01, 0xF3, 0xD8, 0x00, 0x0F,
  0x8F, 0x70, 0x00, 0xFC, 0x3C, 0xF8, 0x0F, 0xF0, 0xF1, 0xFF, 0xFF, 0x83,
  0xC3, 0xFF, 0xFC, 0x0F, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x10, 0x78, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0x0F,
  0x01, 0xFF, 0xF0, 0x78, 0x1F, 0xFF, 0xC3, 0xC1, 0xFF, 0xFF, 0x9E, 0x1F,
  0xC0, 0x3C, 0xF1, 0xF8, 0x00, 0x77, 0x9F, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x1D, 0xE1, 0xFC, 0x03, 0xCF, 0x07, 0xFF, 0xFE, 0x78,
  0x1F, 0xFF, 0xC3, 0xC0, 0x7F, 0xFC, 0x1E, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x41, 0xE0, 0x00, 0x00, 0xE3,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x18, 0x00, 0x03, 0xFF, 0xEC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0xFE, 0x1C, 0x00, 0x00, 0x0F,
  0x9C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x3F, 0x00, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0xFF, 0x00, 0xE0, 0xFF, 0xF8, 0x38, 0x7F, 0xFF, 0x0E, 0x3F, 0xFF, 0xE3,
  0x9E, 0x01, 0xFC, 0xEE, 0x00, 0x1F, 0xBB, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x7C, 0x0F, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80,
  0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x1E, 0x0F, 0xC0, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0x79, 0xFF, 0x80, 0x00,
  0xF7, 0xCF, 0x80, 0x01, 0xFF, 0x0F, 0x80, 0x03, 0xFC, 0x0F, 0x00, 0x07,
  0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x00, 0xF8, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0xFC, 0x01, 0xF8, 0x78, 0xFF, 0x83, 0xFF, 0x3C, 0xFF,
  0xC3, 0xFF, 0x9E, 0xFF, 0xF1, 0xFF, 0xEF, 0x60, 0xF9, 0xC1, 0xF7, 0xE0,
  0x3E, 0x80, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x0F, 0xF0,
  0x01, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0x78, 0x01, 0xFE,
  0x00, 0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x1F,
  0xC0, 0x07, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03,
  0xF8, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0x00,
  0x7F, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0x80,
  0x0F, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xF0,
  0x01, 0xFC, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0xE0, 0x03,
  0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x70, 0xE0, 0x3F, 0xC0, 0x38, 0x3F,
  0xFE, 0x0E, 0x1F, 0xFF, 0xC3, 0x8F, 0xFF, 0xF8, 0xE7, 0x80, 0x7F, 0x3B,
  0x80, 0x07, 0xEE, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x01,
  0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x03, 0xC1, 0xFF, 0xF0, 0x0F,
  0x0F, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0xE0, 0xF3, 0xE0, 0x3F, 0xC3, 0xDC,
  0x00, 0x3F, 0x0F, 0x60, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x60, 0x00, 0x3E,
  0x3D, 0xC0, 0x03, 0xF0, 0xF3, 0xE0, 0x3F, 0xC3, 0xC7, 0xFF, 0xFE, 0x0F,
  0x0F, 0xFF, 0xF0, 0x3C, 0x1F, 0xFF, 0x00, 0xF0, 0x0F, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x78, 0x0F, 0xFF, 0x83, 0xC0, 0xFF, 0xFE, 0x1E, 0x0F,
  0xFF, 0xFC, 0xF0, 0xFE, 0x01, 0xE7, 0x8F, 0xC0, 0x03, 0xBC, 0xFC, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xEF, 0x0F, 0xE0, 0x1E, 0x78,
  0x3F, 0xFF, 0xF3, 0xC0, 0xFF, 0xFE, 0x1E, 0x03, 0xFF, 0xE0, 0xF0, 0x03,
  0xFC, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x3F, 0x87, 0x80,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x18, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x79, 0x00, 0x00, 0x00, 0xF3,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x7C, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0x79, 0xF8, 0x00, 0xEF, 0x3F, 0xC0, 0x79, 0xE3, 0xFF, 0xFF, 0x3C,
  0x3F, 0xFF, 0xC7, 0x81, 0xFF, 0xE0, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3B, 0x80,
  0x07, 0xC0, 0x03, 0xDC, 0x00, 0x3F, 0x00, 0x1E, 0xE0, 0x01, 0xF8, 0x00,
  0xF7, 0x00, 0x1D, 0xC0, 0x07, 0x3C, 0x00, 0xEE, 0x00, 0x39, 0xE0, 0x07,
  0x70, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0xF1,
  0xC0, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0x78, 0x07, 0x0E,
  0x01, 0xC3, 0xC0, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x70,
  0x1C, 0x1C, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE0, 0x70, 0x1C, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0xE1, 0xE0,
  0x38, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F, 0x1C, 0x01,
  0xC3, 0x80, 0x78, 0xE0, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E,
  0x70, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x03, 0xF0,
  0x00, 0x77, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x81, 0xFF, 0x00, 0x00, 0xF0,
  0xFF, 0xE0, 0x00, 0x38, 0x7F, 0xFC, 0x00, 0x0E, 0x1E, 0x1F, 0x80, 0x07,
  0x8F, 0x01, 0xF0, 0x01, 0xE3, 0x80, 0x3E, 0x00, 0x71, 0xE0, 0x07, 0xC0,
  0x3C, 0x70, 0x01, 0xF8, 0x1E, 0x1C, 0x00, 0x3F, 0x0F, 0x8F, 0x00, 0x07,
  0xFF, 0xC3, 0x80, 0x00, 0xFF, 0xE0, 0xE0, 0x00, 0x0F, 0xF0, 0x18, 0x00,
  0x01, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Light69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 8, 48, 41, 17, -48 },
  { 49, 15, 18, 41, 13, -51 },
  { 83, 39, 48, 41, 1, -48 },
  { 317, 33, 64, 41, 4, -56 },
  { 581, 38, 50, 41, 2, -49 },
  { 819, 37, 50, 41, 2, -49 },
  { 1051, 4, 18, 41, 19, -51 },
  { 1060, 18, 62, 41, 15, -52 },
  { 1200, 18, 62, 41, 8, -52 },
  { 1340, 35, 34, 41, 3, -38 },
  { 1489, 33, 34, 41, 4, -38 },
  { 1630, 10, 19, 41, 15, -8 },
  { 1654, 19, 4, 41, 11, -23 },
  { 1664, 8, 7, 41, 17, -7 },
  { 1671, 28, 62, 41, 7, -52 },
  { 1888, 33, 50, 41, 4, -49 },
  { 2095, 33, 48, 41, 5, -48 },
  { 2293, 32, 49, 41, 5, -49 },
  { 2489, 31, 50, 41, 4, -49 },
  { 2683, 35, 48, 41, 3, -48 },
  { 2893, 31, 49, 41, 5, -48 },
  { 3083, 31, 49, 41, 5, -48 },
  { 3273, 31, 48, 41, 5, -48 },
  { 3459, 33, 50, 41, 4, -49 },
  { 3666, 31, 49, 41, 5, -49 },
  { 3856, 8, 36, 41, 17, -36 },
  { 3892, 10, 47, 41, 15, -36 },
  { 3951, 30, 39, 41, 6, -41 },
  { 4098, 33, 17, 41, 4, -30 },
  { 4169, 30, 39, 41, 6, -41 },
  { 4316, 29, 49, 41, 6, -49 },
  { 4494, 30, 57, 41, 5, -49 },
  { 4708, 36, 48, 41, 3, -48 },
  { 4924, 31, 48, 41, 6, -48 },
  { 5110, 32, 50, 41, 5, -49 },
  { 5310, 30, 48, 41, 7, -48 },
  { 5490, 29, 48, 41, 7, -48 },
  { 5664, 29, 48, 41, 7, -48 },
  { 5838, 32, 50, 41, 4, -49 },
  { 6038, 29, 48, 41, 6, -48 },
  { 6212, 29, 48, 41, 6, -48 },
  { 6386, 27, 49, 41, 6, -48 },
  { 6552, 33, 48, 41, 6, -48 },
  { 6750, 28, 48, 41, 9, -48 },
  { 6918, 31, 48, 41, 5, -48 },
  { 7104, 29, 48, 41, 6, -48 },
  { 7278, 33, 50, 41, 4, -49 },
  { 7485, 30, 48, 41, 7, -48 },
  { 7665, 33, 60, 41, 4, -49 },
  { 7913, 30, 48, 41, 7, -48 },
  { 8093, 33, 50, 41, 4, -49 },
  { 8300, 37, 48, 41, 2, -48 },
  { 8522, 29, 49, 41, 6, -48 },
  { 8700, 35, 48, 41, 3, -48 },
  { 8910, 35, 48, 41, 3, -48 },
  { 9120, 37, 48, 41, 2, -48 },
  { 9342, 39, 48, 41, 1, -48 },
  { 9576, 35, 48, 41, 3, -48 },
  { 9786, 18, 62, 41, 17, -52 },
  { 9926, 28, 62, 41, 7, -52 },
  { 10143, 18, 62, 41, 7, -52 },
  { 10283, 34, 27, 41, 4, -48 },
  { 10398, 33, 4, 41, 4, 7 },
  { 10415, 10, 13, 41, 13, -54 },
  { 10432, 32, 37, 41, 5, -36 },
  { 10580, 30, 52, 41, 7, -51 },
  { 10775, 29, 37, 41, 6, -36 },
  { 10910, 29, 52, 41, 5, -51 },
  { 11099, 31, 37, 41, 5, -36 },
  { 11243, 32, 51, 41, 5, -51 },
  { 11447, 33, 55, 41, 5, -40 },
  { 11674, 26, 51, 41, 8, -51 },
  { 11840, 29, 52, 41, 8, -52 },
  { 12029, 25, 66, 41, 6, -52 },
  { 12236, 31, 51, 41, 8, -51 },
  { 12434, 30, 51, 41, 6, -51 },
  { 12626, 33, 36, 41, 4, -36 },
  { 12775, 26, 36, 41, 8, -36 },
  { 12892, 31, 37, 41, 5, -36 },
  { 13036, 30, 50, 41, 7, -36 },
  { 13224, 29, 50, 41, 5, -36 },
  { 13406, 34, 36, 41, 5, -36 },
  { 13559, 31, 37, 41, 5, -36 },
  { 13703, 33, 48, 41, 3, -48 },
  { 13901, 27, 37, 41, 7, -36 },
  { 14026, 31, 36, 41, 5, -36 },
  { 14166, 37, 36, 41, 2, -36 },
  { 14333, 32, 36, 41, 5, -36 },
  { 14477, 33, 50, 41, 4, -36 },
  { 14684, 29, 36, 41, 6, -36 },
  { 14815, 26, 62, 41, 8, -52 },
  { 15017, 3, 62, 41, 19, -52 },
  { 15041, 26, 62, 41, 8, -52 },
  { 15243, 34, 14, 41, 4, -28 },
};

const GFXfont IBMPlexMono_Light69pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light69pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light69pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _IBMPLEXMONO_LIGHT69PT7B_H_
