#ifndef _IBMPLEXMONO_LIGHT48PT7B_H_
#define _IBMPLEXMONO_LIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light48pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x18, 0x42, 0x10, 0x84, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x80, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60,
  0x70, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x1F, 0xF0, 0x3F, 0xF3, 0xFE, 0x07,
  0xFE, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0C, 0x01, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xE0, 0x0C,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x06, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0x8C, 0xFC, 0x3C,
  0x18, 0x3C, 0x70, 0x30, 0x3D, 0xC0, 0x60, 0x33, 0x80, 0xC0, 0x07, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18,
  0x00, 0xE0, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xF0, 0xC0, 0x00, 0xF9, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x18, 0x78,
  0x00, 0x30, 0x78, 0x00, 0x60, 0x70, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xE0,
  0x03, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0E, 0x80,
  0x30, 0x1F, 0x80, 0x60, 0x77, 0x80, 0xC0, 0xE7, 0xC1, 0x87, 0x87, 0xE3,
  0x3E, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0xE3, 0xFE, 0x00, 0x38, 0xE1, 0xC0, 0x06, 0x38, 0x0C, 0x01, 0xC6,
  0x01, 0xC0, 0x30, 0xC0, 0x38, 0x0E, 0x38, 0x03, 0x01, 0x87, 0x00, 0x60,
  0x70, 0xE0, 0x0C, 0x0C, 0x1C, 0x01, 0x83, 0x03, 0x80, 0x30, 0xE0, 0x30,
  0x0E, 0x18, 0x06, 0x01, 0xC7, 0x00, 0xE0, 0x30, 0xC0, 0x0E, 0x1C, 0x20,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x0E, 0x3C, 0x38, 0x03, 0x86, 0x03,
  0x00, 0xE1, 0xC0, 0x30, 0x18, 0x30, 0x06, 0x07, 0x06, 0x00, 0xC0, 0xC0,
  0xC0, 0x1C, 0x38, 0x18, 0x03, 0x86, 0x03, 0x00, 0x71, 0xC0, 0x60, 0x0C,
  0x30, 0x0C, 0x01, 0x8E, 0x01, 0xC0, 0x33, 0x80, 0x18, 0x0E, 0x60, 0x03,
  0xC3, 0x9C, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xC1, 0xE0, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x04, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xCE, 0x38, 0x0F, 0xEE, 0x0E, 0x07, 0x07,
  0x03, 0x83, 0x87, 0x00, 0xE1, 0xC3, 0x80, 0x30, 0xC1, 0xC0, 0x1C, 0x60,
  0xC0, 0x07, 0x30, 0x60, 0x01, 0xD8, 0x30, 0x00, 0x7C, 0x18, 0x00, 0x1C,
  0x0E, 0x00, 0x0F, 0x07, 0x00, 0x05, 0xC1, 0xC0, 0x06, 0xF0, 0xF0, 0x06,
  0x3C, 0x3C, 0x0E, 0x0F, 0x0F, 0xFE, 0x03, 0x81, 0xFC, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0E, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x60, 0x1C, 0x07, 0x7F,
  0x0E, 0x1F, 0x8F, 0xF7, 0x7F, 0xA0, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x08, 0x00, 0x40, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x7C, 0xF1, 0xE3, 0xC7, 0x1E, 0x38, 0x70, 0xE1, 0x87,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3E, 0x0F,
  0x00, 0xF0, 0x07, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x77,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x1C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x06, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x70,
  0x0F, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x1C, 0x00,
  0x60, 0x1C, 0x00, 0x40, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0x81, 0xE0, 0xF0,
  0x03, 0x87, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xD8, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0xFC, 0x07, 0xC0, 0xF0, 0x78, 0x03, 0xC7, 0x80, 0x0F, 0x18, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x74, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xCF, 0x00, 0x1C, 0x3E, 0x03, 0xC0,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC3, 0xF8, 0x0E, 0x7F, 0xF0, 0x76, 0x07,
  0xC3, 0x40, 0x0F, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x74, 0x00, 0x07, 0x70, 0x00, 0x3B, 0xC0,
  0x03, 0x8F, 0x00, 0x3C, 0x3E, 0x07, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x87, 0xF0, 0x1C, 0x7F, 0xF0, 0x73, 0x01, 0xE1, 0xD0,
  0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0xE1, 0x80,
  0x07, 0x87, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x03, 0x83, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x06, 0x07, 0x00, 0x1C, 0x07, 0x80, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x03, 0x87, 0x80, 0x03, 0x8E,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xCE, 0x00,
  0x03, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x0F, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x80, 0xF0,
  0x70, 0x03, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00,
  0x79, 0xC0, 0x05, 0xC7, 0x80, 0xCE, 0x1F, 0xFC, 0xE0, 0x3F, 0x87, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF7, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7F,
  0xFF, 0xF0, 0x3C, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xCF, 0x1E, 0x3C,
  0x71, 0xE3, 0x87, 0x0E, 0x18, 0x70, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1E, 0x07, 0xC3, 0xC0, 0x1E, 0x78, 0x00,
  0xE7, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38, 0x03, 0x83,
  0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x37, 0x00, 0x01, 0xB8, 0x07, 0xCF, 0x80, 0xFF, 0x7C, 0x0F, 0x0F, 0xE0,
  0x60, 0x3F, 0x07, 0x00, 0xF8, 0x30, 0x07, 0xC1, 0x80, 0x3E, 0x0C, 0x01,
  0xF0, 0xE0, 0x0F, 0x87, 0x00, 0x7C, 0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x06,
  0x00, 0xF8, 0x30, 0x07, 0xC1, 0x80, 0x3E, 0x0E, 0x01, 0xF0, 0x70, 0x0F,
  0x81, 0xC0, 0xFE, 0x07, 0xFB, 0xF0, 0x1F, 0x9D, 0x80, 0x20, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x18, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x07, 0x00,
  0x60, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xE0,
  0x03, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0E, 0x00, 0x3C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0E, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x78, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xE0,
  0xF8, 0x3C, 0x01, 0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x04, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x47, 0x00, 0x03, 0x9C, 0x00, 0x1C,
  0xF0, 0x01, 0xC3, 0xC0, 0x1E, 0x0F, 0x03, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x38, 0x03, 0xC1, 0xC0, 0x07, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x0C, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x19,
  0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x01,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x78, 0x1E, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0x78, 0xE0,
  0x00, 0xE3, 0x80, 0x01, 0xDC, 0x00, 0x04, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF1, 0xC0, 0x07, 0xC7, 0x80,
  0x37, 0x0F, 0x83, 0x9C, 0x0F, 0xFC, 0x70, 0x0F, 0xC0, 0x00, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x63,
  0xC0, 0x1C, 0x3C, 0x0F, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xEC, 0x00, 0x0F, 0x30, 0x00, 0x78, 0xC0, 0x01, 0xC3,
  0x00, 0x0E, 0x0C, 0x00, 0x70, 0x30, 0x03, 0xC0, 0xC0, 0x1E, 0x03, 0x00,
  0xF0, 0x0C, 0x03, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0xE0, 0x03, 0x07, 0x80,
  0x0C, 0x3C, 0x00, 0x31, 0xF8, 0x00, 0xC7, 0xE0, 0x03, 0x3B, 0xC0, 0x0D,
  0xC7, 0x00, 0x3E, 0x0E, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0xE0, 0x30, 0x03, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1E, 0x0C, 0x00, 0x38,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x30,
  0x00, 0x1E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFD, 0x80, 0x0D, 0xEE, 0x00,
  0xEF, 0x70, 0x07, 0x79, 0x80, 0x33, 0xCE, 0x03, 0x9E, 0x30, 0x18, 0xF1,
  0xC1, 0xC7, 0x8E, 0x0C, 0x3C, 0x30, 0xE1, 0xE1, 0xC7, 0x0F, 0x06, 0x30,
  0x78, 0x3B, 0x83, 0xC0, 0xD8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x10, 0x0F, 0x00, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xF7, 0x00, 0x1F, 0xB8, 0x00, 0xFC, 0xE0, 0x07,
  0xE7, 0x00, 0x3F, 0x1C, 0x01, 0xF8, 0xE0, 0x0F, 0xC7, 0x00, 0x7E, 0x1C,
  0x03, 0xF0, 0xE0, 0x1F, 0x83, 0x80, 0xFC, 0x1C, 0x07, 0xE0, 0x70, 0x3F,
  0x03, 0x81, 0xF8, 0x0E, 0x0F, 0xC0, 0x70, 0x7E, 0x01, 0x83, 0xF0, 0x0E,
  0x1F, 0x80, 0x70, 0xFC, 0x01, 0xC7, 0xE0, 0x0E, 0x3F, 0x00, 0x39, 0xF8,
  0x01, 0xCF, 0xC0, 0x07, 0x7E, 0x00, 0x3B, 0xF0, 0x00, 0xDF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x3E, 0x0F, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x07, 0x07,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x0F, 0x00, 0x70, 0x0F, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x00, 0xF1, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x03, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3C, 0x0F, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x07, 0x07, 0x00,
  0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x71, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x80,
  0x3C, 0x07, 0x81, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38,
  0x00, 0xF1, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C,
  0xE0, 0x03, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xC0, 0xE0, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x70, 0x00,
  0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7C, 0x07, 0xE1, 0xE0, 0x03, 0xE3,
  0x80, 0x01, 0xCE, 0x00, 0x01, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x74, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x3F, 0x01, 0xF0, 0x1F,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x37, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xE7, 0x00, 0x07,
  0x38, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x7F,
  0xFC, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x30, 0x0E, 0x03, 0x9C, 0x0F,
  0x01, 0xCE, 0x07, 0xC0, 0xE7, 0x03, 0xE0, 0x73, 0x81, 0xB0, 0x39, 0xC1,
  0xD8, 0x18, 0xE0, 0xEE, 0x0C, 0x70, 0x67, 0x06, 0x18, 0x31, 0x83, 0x0C,
  0x18, 0xC1, 0x86, 0x1C, 0x70, 0xC3, 0x0C, 0x38, 0xE1, 0x86, 0x0C, 0x70,
  0xE3, 0x06, 0x38, 0x73, 0x83, 0x9C, 0x39, 0x81, 0xCE, 0x1C, 0xC0, 0x67,
  0x0E, 0x60, 0x33, 0x07, 0x70, 0x1D, 0x81, 0xB8, 0x0E, 0xC0, 0xD8, 0x07,
  0x60, 0x6C, 0x01, 0xB0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x87,
  0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x3C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x83, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0,
  0x07, 0x07, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x1D, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x21, 0xC1, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x06, 0x01, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x08, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0x80, 0x18, 0x3C, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00,
  0xC3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x2C,
  0x1C, 0x00, 0x58, 0x1E, 0x07, 0x3F, 0x1F, 0xFC, 0x3E, 0x0F, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC3, 0xF8, 0x0E, 0x7F, 0xF0, 0x77, 0x03,
  0xC3, 0xE0, 0x07, 0x1E, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x80, 0x00,
  0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0D, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C,
  0xF0, 0x00, 0xE7, 0xC0, 0x0E, 0x3B, 0x81, 0xE1, 0xCF, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x1C,
  0x38, 0x00, 0xE7, 0x00, 0x04, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x04, 0x70, 0x00, 0x63, 0x00, 0x0F, 0x38, 0x01, 0xC1,
  0xE0, 0x7C, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0xF0, 0x70, 0x7F, 0xE3, 0x87, 0x81, 0xDC, 0x70, 0x02, 0xE7, 0x00,
  0x0F, 0x30, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0x78, 0xE0, 0x05,
  0xC3, 0xC0, 0xEE, 0x0F, 0xFC, 0x70, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x47, 0x00, 0x03, 0x9C, 0x00, 0x38, 0x70, 0x03, 0x83, 0xE0, 0x78,
  0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xF6, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x78, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x60, 0xE0,
  0x00, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x03, 0x00, 0x06, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0F, 0x07, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0xE0, 0x00, 0xE3, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x79, 0xE0,
  0x03, 0xE1, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0xFE,
  0x0E, 0x7F, 0xF1, 0xDC, 0x0F, 0x3E, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x00,
  0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xEF, 0xFF,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0xEC, 0x00, 0x1C, 0x60, 0x01, 0xC3,
  0x00, 0x1C, 0x18, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x03, 0xC0, 0x30, 0x3C,
  0x01, 0x83, 0xC0, 0x0C, 0x3C, 0x00, 0x63, 0xE0, 0x03, 0x3F, 0x80, 0x1B,
  0x9E, 0x00, 0xF8, 0x70, 0x07, 0x81, 0xC0, 0x38, 0x0F, 0x01, 0x80, 0x3C,
  0x0C, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x00, 0x0E, 0x18, 0x00, 0x78, 0xC0,
  0x01, 0xE6, 0x00, 0x07, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x70, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC1, 0xF1,
  0xDF, 0xC7, 0xF3, 0xE1, 0xD8, 0x77, 0x03, 0xA0, 0x6E, 0x03, 0x80, 0xFC,
  0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0,
  0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07,
  0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70,
  0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01,
  0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0E, 0xE1, 0xFC, 0x1C,
  0xFF, 0xE3, 0xB8, 0x1E, 0x7C, 0x01, 0xEF, 0x00, 0x1D, 0xC0, 0x01, 0xB8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0x81, 0xE0, 0x78, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00,
  0x39, 0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0xC0,
  0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x03, 0xC0, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xE1, 0xFC, 0x07, 0x3F, 0xF8, 0x3B,
  0x81, 0xE1, 0xF0, 0x03, 0x8F, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01,
  0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x06,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00,
  0x0E, 0x78, 0x00, 0x73, 0xE0, 0x07, 0x1D, 0xC0, 0xF0, 0xE7, 0xFF, 0x07,
  0x0F, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xF8, 0x38, 0x3F, 0xF1, 0xC3, 0xC0, 0xEE, 0x38, 0x01,
  0x73, 0x80, 0x07, 0x98, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x60,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x00,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x3C,
  0x70, 0x02, 0xE1, 0xE0, 0x77, 0x07, 0xFE, 0x38, 0x0F, 0xE1, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0xFF, 0xC1,
  0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0x38, 0x00, 0x06, 0x40, 0x00, 0x0D, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0x80, 0xF8, 0x70, 0x01, 0xE7, 0x00, 0x07, 0x38,
  0x00, 0x11, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x39, 0xE0, 0x01, 0xC7, 0xC0,
  0x7C, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1E, 0xE0,
  0x03, 0xDE, 0x00, 0xB9, 0xE0, 0x77, 0x1F, 0xFC, 0xE0, 0xFE, 0x00, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0xE0, 0x00, 0xE7, 0x00, 0x07,
  0x18, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0x60, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x00, 0x03, 0x18, 0x00, 0x1D, 0xC0, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x80, 0xFC, 0x06, 0xC0, 0x7E, 0x03, 0x60, 0x37, 0x01, 0xB0, 0x19,
  0x81, 0xD8, 0x0C, 0xC0, 0xC6, 0x06, 0x60, 0x63, 0x03, 0x30, 0x31, 0x83,
  0x9C, 0x18, 0xC1, 0xCE, 0x18, 0x70, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x0C,
  0x30, 0xC3, 0x06, 0x18, 0x63, 0x83, 0x1C, 0x39, 0x80, 0xCE, 0x1C, 0xC0,
  0x66, 0x06, 0x60, 0x33, 0x03, 0x30, 0x19, 0x81, 0xB0, 0x0C, 0xC0, 0xD8,
  0x03, 0x60, 0x6C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x07, 0x80, 0x3C, 0x0E,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC7,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x0E,
  0x0E, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0xC3, 0x80, 0x07, 0x8E, 0x00, 0x0E, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x87,
  0x00, 0x06, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x60,
  0x30, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0x18, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x78, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x06, 0x3F, 0x80, 0x0C, 0xE3, 0x80, 0x3B, 0x83, 0x80, 0x66,
  0x03, 0x80, 0xDC, 0x03, 0x83, 0xB0, 0x03, 0x8E, 0x60, 0x03, 0xF8, 0xC0,
  0x03, 0xE0,
};

const GFXglyph IBMPlexMono_Light48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 5, 34, 29, 12, -34 },
  { 23, 11, 13, 29, 9, -36 },
  { 41, 27, 34, 29, 1, -34 },
  { 156, 23, 45, 29, 3, -39 },
  { 286, 27, 35, 29, 1, -34 },
  { 405, 25, 35, 29, 2, -34 },
  { 515, 3, 13, 29, 13, -36 },
  { 520, 13, 43, 29, 10, -36 },
  { 590, 12, 43, 29, 6, -36 },
  { 655, 25, 24, 29, 2, -26 },
  { 730, 23, 22, 29, 3, -26 },
  { 794, 7, 12, 29, 10, -5 },
  { 805, 13, 2, 29, 8, -16 },
  { 809, 5, 5, 29, 12, -5 },
  { 813, 19, 43, 29, 5, -36 },
  { 916, 23, 35, 29, 3, -34 },
  { 1017, 24, 34, 29, 3, -34 },
  { 1119, 21, 34, 29, 4, -34 },
  { 1209, 21, 35, 29, 3, -34 },
  { 1301, 25, 34, 29, 2, -34 },
  { 1408, 21, 35, 29, 4, -34 },
  { 1500, 22, 35, 29, 3, -34 },
  { 1597, 22, 34, 29, 3, -34 },
  { 1691, 23, 35, 29, 3, -34 },
  { 1792, 21, 34, 29, 4, -34 },
  { 1882, 5, 25, 29, 12, -25 },
  { 1898, 7, 32, 29, 10, -25 },
  { 1926, 21, 27, 29, 4, -28 },
  { 1997, 23, 11, 29, 3, -20 },
  { 2029, 21, 27, 29, 4, -28 },
  { 2100, 20, 34, 29, 4, -34 },
  { 2185, 21, 39, 29, 4, -34 },
  { 2288, 25, 34, 29, 2, -34 },
  { 2395, 22, 34, 29, 4, -34 },
  { 2489, 21, 35, 29, 4, -34 },
  { 2581, 21, 34, 29, 5, -34 },
  { 2671, 20, 34, 29, 5, -34 },
  { 2756, 20, 34, 29, 5, -34 },
  { 2841, 22, 35, 29, 3, -34 },
  { 2938, 21, 34, 29, 4, -34 },
  { 3028, 21, 34, 29, 4, -34 },
  { 3118, 19, 35, 29, 4, -34 },
  { 3202, 22, 34, 29, 5, -34 },
  { 3296, 20, 34, 29, 6, -34 },
  { 3381, 21, 34, 29, 4, -34 },
  { 3471, 21, 34, 29, 4, -34 },
  { 3561, 23, 35, 29, 3, -34 },
  { 3662, 21, 34, 29, 5, -34 },
  { 3752, 23, 41, 29, 3, -34 },
  { 3870, 21, 34, 29, 5, -34 },
  { 3960, 23, 35, 29, 3, -34 },
  { 4061, 26, 34, 29, 1, -34 },
  { 4172, 21, 35, 29, 4, -34 },
  { 4264, 25, 34, 29, 2, -34 },
  { 4371, 25, 34, 29, 2, -34 },
  { 4478, 25, 34, 29, 2, -34 },
  { 4585, 27, 34, 29, 1, -34 },
  { 4700, 25, 34, 29, 2, -34 },
  { 4807, 12, 43, 29, 12, -36 },
  { 4872, 19, 43, 29, 5, -36 },
  { 4975, 12, 43, 29, 5, -36 },
  { 5040, 23, 19, 29, 3, -34 },
  { 5095, 23, 2, 29, 3, 5 },
  { 5101, 7, 9, 29, 9, -37 },
  { 5109, 23, 26, 29, 3, -25 },
  { 5184, 21, 37, 29, 5, -36 },
  { 5282, 20, 26, 29, 5, -25 },
  { 5347, 21, 37, 29, 3, -36 },
  { 5445, 21, 26, 29, 4, -25 },
  { 5514, 22, 36, 29, 4, -36 },
  { 5613, 23, 37, 29, 4, -27 },
  { 5720, 19, 36, 29, 5, -36 },
  { 5806, 21, 36, 29, 5, -36 },
  { 5901, 17, 46, 29, 5, -36 },
  { 5999, 21, 36, 29, 6, -36 },
  { 6094, 21, 36, 29, 4, -36 },
  { 6189, 23, 25, 29, 3, -25 },
  { 6261, 19, 25, 29, 5, -25 },
  { 6321, 21, 26, 29, 4, -25 },
  { 6390, 21, 35, 29, 5, -25 },
  { 6482, 21, 35, 29, 3, -25 },
  { 6574, 23, 25, 29, 4, -25 },
  { 6646, 21, 26, 29, 4, -25 },
  { 6715, 23, 34, 29, 2, -34 },
  { 6813, 19, 26, 29, 5, -25 },
  { 6875, 21, 25, 29, 4, -25 },
  { 6941, 25, 25, 29, 2, -25 },
  { 7020, 22, 25, 29, 3, -25 },
  { 7089, 23, 35, 29, 3, -25 },
  { 7190, 20, 25, 29, 4, -25 },
  { 7253, 19, 43, 29, 5, -36 },
  { 7356, 3, 43, 29, 13, -36 },
  { 7373, 19, 43, 29, 5, -36 },
  { 7476, 23, 9, 29, 3, -19 },
};

const GFXfont IBMPlexMono_Light48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_LIGHT48PT7B_H_
