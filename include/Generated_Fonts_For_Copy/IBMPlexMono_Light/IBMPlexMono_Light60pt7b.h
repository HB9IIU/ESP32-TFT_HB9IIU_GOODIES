#ifndef _IBMPLEXMONO_LIGHT60PT7B_H_
#define _IBMPLEXMONO_LIGHT60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light60pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F,
  0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x0F,
  0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0x8E, 0x7F, 0x80, 0xF8, 0x38,
  0x3F, 0x07, 0x80, 0xE0, 0x3E, 0x1C, 0x03, 0x80, 0x78, 0xF0, 0x0E, 0x00,
  0xC3, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x38, 0x7E, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0xC0, 0x0E, 0x01, 0xE7, 0x00, 0x38,
  0x07, 0xBE, 0x00, 0xE0, 0x3C, 0x3E, 0x03, 0x81, 0xF0, 0x7C, 0x0E, 0x0F,
  0x80, 0xFE, 0x38, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF1, 0xFF,
  0xE0, 0x00, 0x38, 0xF8, 0x3C, 0x00, 0x1C, 0x38, 0x07, 0x80, 0x07, 0x1C,
  0x00, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x01, 0xE1, 0xC0, 0x07, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0x3C, 0x1C, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x1C, 0x07,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x70,
  0x38, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x07,
  0x83, 0x80, 0x0F, 0x83, 0xC1, 0xE0, 0x01, 0xFF, 0xE0, 0x70, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0E, 0x07, 0xFF, 0x80, 0x07, 0x83, 0xC1, 0xF0, 0x01, 0xC1, 0xE0,
  0x1C, 0x00, 0xF0, 0x70, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x1C, 0x0E,
  0x00, 0x38, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0x38, 0x3C, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0xE0, 0x03, 0x87, 0x80, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0x38,
  0xE0, 0x01, 0xE0, 0x1C, 0x38, 0x00, 0x3C, 0x1F, 0x1C, 0x00, 0x07, 0xFF,
  0x87, 0x00, 0x00, 0xFF, 0xC2, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0xFE, 0x0F, 0x3C, 0x00, 0xFE, 0x1E, 0x1E, 0x00, 0xFE, 0x3C, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x81, 0xC0, 0x78, 0x07, 0x81, 0xC0, 0x70, 0x03, 0xC1,
  0xC0, 0xF0, 0x01, 0xE1, 0xC0, 0xF0, 0x00, 0xF1, 0xC0, 0xF0, 0x00, 0x79,
  0xC0, 0xE0, 0x00, 0x39, 0xC0, 0xE0, 0x00, 0x3D, 0x80, 0xE0, 0x00, 0x1F,
  0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x0D, 0xE0, 0x7C, 0x00, 0x18, 0xF0, 0x3E, 0x00, 0x78,
  0xF8, 0x1F, 0x81, 0xF0, 0x78, 0x0F, 0xFF, 0xE0, 0x3C, 0x07, 0xFF, 0x80,
  0x1E, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xFF, 0xC7,
  0x8F, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x08, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x1F, 0x80,
  0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F, 0xF0,
  0x0F, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF7, 0x00, 0x00,
  0x1F, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x1F, 0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x1F, 0x00, 0xE0,
  0x01, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x10, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xC0, 0x00, 0x1E, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x90,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x0F, 0xF0, 0x07,
  0x8F, 0xFF, 0x01, 0xCF, 0xFF, 0xF0, 0x77, 0x80, 0xFE, 0x1F, 0x80, 0x07,
  0xC7, 0xC0, 0x00, 0xF8, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xBE, 0x00, 0x03, 0xC7, 0xE0, 0x01, 0xE0, 0xFE, 0x03, 0xF8, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x03, 0x87, 0xFF, 0x80,
  0x39, 0xFF, 0xFE, 0x07, 0xBC, 0x03, 0xF0, 0x77, 0x00, 0x0F, 0x87, 0x60,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0x01, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x6E, 0x1F, 0x00, 0x0E, 0xE0, 0xFE, 0x03, 0xDE,
  0x07, 0xFF, 0xF9, 0xC0, 0x1F, 0xFE, 0x1C, 0x00, 0x7F, 0x83, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x1E, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0x1F, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0x1C, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF7, 0x00,
  0x3F, 0x0E, 0xE0, 0x0F, 0xF9, 0xDC, 0x03, 0xFF, 0x3B, 0x80, 0xF8, 0x37,
  0x70, 0x3C, 0x03, 0xEE, 0x07, 0x00, 0x3D, 0xC0, 0xE0, 0x07, 0xB8, 0x3C,
  0x00, 0x77, 0x07, 0x80, 0x0F, 0xE0, 0xE0, 0x01, 0xFC, 0x1C, 0x00, 0x3F,
  0x83, 0x80, 0x07, 0xF0, 0x70, 0x00, 0xFE, 0x0E, 0x00, 0x1F, 0xC1, 0xC0,
  0x03, 0xF8, 0x38, 0x00, 0x7F, 0x07, 0x00, 0x0E, 0xE0, 0xF0, 0x01, 0xDC,
  0x0E, 0x00, 0x3B, 0x81, 0xC0, 0x0F, 0x70, 0x3C, 0x01, 0xEE, 0x03, 0xC0,
  0x5D, 0xC0, 0x7E, 0x7B, 0xB8, 0x07, 0xFE, 0x77, 0x00, 0x7F, 0x8E, 0xE0,
  0x01, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0x80, 0x03, 0xF0, 0xE0, 0x00, 0x3E, 0x38,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0E, 0x00, 0x03, 0xE3, 0x80, 0x00,
  0x7C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xCE, 0x00,
  0x03, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0xF0,
  0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C, 0x00,
  0x1F, 0x0F, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x11, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3E, 0x3C, 0x00, 0x05, 0xC7, 0xC0, 0x01, 0xB8, 0x7C, 0x00, 0x67, 0x07,
  0xE0, 0x3C, 0xE0, 0x7F, 0xFF, 0x1C, 0x07, 0xFF, 0xC3, 0x80, 0x1F, 0xC0,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07,
  0x8F, 0x00, 0x1E, 0x1F, 0x80, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x07, 0xCE, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0x1F, 0x00, 0xE0, 0x03, 0xE0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0,
  0x7C, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0xE1, 0xF8, 0x00, 0x0E, 0x1F, 0xC0,
  0x00, 0xE3, 0xFC, 0x00, 0x0E, 0x79, 0xE0, 0x00, 0xEF, 0x1F, 0x00, 0x0F,
  0xE0, 0xF0, 0x00, 0xFC, 0x07, 0x80, 0x0F, 0xC0, 0x78, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0xF8, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0x00, 0x0F,
  0xFF, 0x70, 0x00, 0xEF, 0xF7, 0x80, 0x1E, 0xFF, 0x38, 0x01, 0xCF, 0xF3,
  0xC0, 0x1C, 0xFF, 0x1C, 0x03, 0x8F, 0xF1, 0xC0, 0x38, 0xFF, 0x0E, 0x07,
  0x8F, 0xF0, 0xE0, 0x70, 0xFF, 0x0F, 0x07, 0x0F, 0xF0, 0x70, 0xE0, 0xFF,
  0x07, 0x0E, 0x0F, 0xF0, 0x39, 0xE0, 0xFF, 0x03, 0x9C, 0x0F, 0xF0, 0x3D,
  0xC0, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0x70, 0x0F, 0xF0, 0x06, 0x00, 0xFF, 0x00,
  0x60, 0x0F, 0xF0, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x70,
  0x00, 0x3F, 0xDE, 0x00, 0x0F, 0xF3, 0x80, 0x03, 0xFC, 0xF0, 0x00, 0xFF,
  0x3C, 0x00, 0x3F, 0xC7, 0x80, 0x0F, 0xF1, 0xE0, 0x03, 0xFC, 0x38, 0x00,
  0xFF, 0x0F, 0x00, 0x3F, 0xC1, 0xC0, 0x0F, 0xF0, 0x78, 0x03, 0xFC, 0x0E,
  0x00, 0xFF, 0x03, 0xC0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x1E, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x00, 0xF0, 0x3F, 0xC0, 0x3C, 0x0F, 0xF0, 0x07, 0x03,
  0xFC, 0x01, 0xE0, 0xFF, 0x00, 0x38, 0x3F, 0xC0, 0x0F, 0x0F, 0xF0, 0x01,
  0xC3, 0xFC, 0x00, 0x78, 0xFF, 0x00, 0x1E, 0x3F, 0xC0, 0x03, 0xCF, 0xF0,
  0x00, 0xF3, 0xFC, 0x00, 0x1C, 0xFF, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0xEF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0xFC, 0xE0, 0x00, 0x0F, 0x38, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0xFC, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE3, 0x80, 0x00, 0xFC, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x78, 0x00, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00,
  0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x04, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x40, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0x7C, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x7C, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x38,
  0x00, 0x07, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x7E, 0x01, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x07, 0x80,
  0x39, 0xC0, 0x1E, 0x00, 0xE7, 0x00, 0xFC, 0x03, 0x9C, 0x03, 0xF0, 0x0E,
  0x70, 0x0F, 0xC0, 0x39, 0xC0, 0x3F, 0x00, 0xE7, 0x01, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x78, 0x1C, 0xE0, 0x39, 0xE0, 0x73, 0x81, 0xE3, 0x83,
  0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE1,
  0xC1, 0xC3, 0x87, 0x03, 0x87, 0x0E, 0x1C, 0x0E, 0x1C, 0x38, 0x70, 0x38,
  0x70, 0xE1, 0xC0, 0xF1, 0xC3, 0x8E, 0x01, 0xC7, 0x0E, 0x38, 0x07, 0x1C,
  0x3C, 0xE0, 0x1C, 0x70, 0x73, 0x80, 0x73, 0xC1, 0xDC, 0x00, 0xEE, 0x07,
  0x70, 0x03, 0xB8, 0x1D, 0xC0, 0x0E, 0xE0, 0x77, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xC8,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x20, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x07,
  0x02, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x38, 0x06, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x01, 0xC0, 0xF8, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x2E, 0x07, 0xC0, 0x07, 0x70, 0x1F, 0x80,
  0xF3, 0xFC, 0x7F, 0xFF, 0x1F, 0xE1, 0xFF, 0xF0, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x3C, 0x3F, 0xFC, 0x0F, 0x3F,
  0xFF, 0x83, 0xDE, 0x03, 0xF0, 0xF6, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xCF, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x7C, 0xF6,
  0x00, 0x3E, 0x3D, 0xE0, 0x3F, 0x0F, 0x3F, 0xFF, 0x83, 0xC3, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x03, 0xE1, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x04, 0x3C, 0x00,
  0x03, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE1, 0xF0, 0x01, 0xE0, 0x7E,
  0x03, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x7F, 0x03, 0xC0, 0xFF, 0xF0, 0xF0, 0x7F, 0xFF,
  0x3C, 0x3F, 0x01, 0xEF, 0x1F, 0x00, 0x1B, 0xCF, 0x80, 0x03, 0xF3, 0xC0,
  0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x1F, 0x00,
  0x1B, 0xC3, 0xF0, 0x1E, 0xF0, 0x7F, 0xFF, 0x3C, 0x0F, 0xFF, 0x0F, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x70, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x1F, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xF9, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x1C, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xC3, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x07, 0xF0, 0x1C, 0x3F, 0xF8,
  0x39, 0xFF, 0xFC, 0x73, 0x80, 0xF8, 0xEC, 0x00, 0x79, 0xF0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xBC,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x03, 0xC0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x1E, 0x3F, 0x00, 0x03, 0xCF, 0xE0, 0x00, 0x7B, 0xDE, 0x00, 0x0F, 0xF1,
  0xE0, 0x01, 0xFC, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x8E, 0x7F, 0x87, 0xFC, 0xEF,
  0xFC, 0x7F, 0xEE, 0xC3, 0xEE, 0x1E, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xF0,
  0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E,
  0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F,
  0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07,
  0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00,
  0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00,
  0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0,
  0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0,
  0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0x01, 0xC3,
  0xFF, 0x83, 0x9F, 0xFF, 0xC7, 0x38, 0x0F, 0x8E, 0xC0, 0x07, 0x9F, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x3C, 0x3F, 0xFC, 0x0F, 0x3F, 0xFF, 0x83, 0xDE, 0x03,
  0xF0, 0xF6, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xCF, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x7C, 0xF6, 0x00, 0x3E, 0x3D, 0xE0,
  0x3F, 0x0F, 0x3F, 0xFF, 0x83, 0xC3, 0xFF, 0xC0, 0xF0, 0x3F, 0x80, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xF0, 0xF0, 0x7F, 0xFF, 0x3C, 0x3F, 0x01, 0xEF,
  0x1F, 0x00, 0x1B, 0xCF, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x1B, 0xC3, 0xF0, 0x1E,
  0xF0, 0x7F, 0xFF, 0x3C, 0x0F, 0xFF, 0x0F, 0x00, 0x7F, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0x9E, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7E, 0x01, 0xFC,
  0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x31, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x0F, 0x8F, 0xE0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0xF9, 0xE0, 0x03, 0x71, 0xF0, 0x1C, 0xE3, 0xFF, 0xF9, 0xC1, 0xFF,
  0xC3, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0,
  0x0E, 0x70, 0x06, 0x60, 0x0E, 0x70, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x0E, 0x30, 0x0C, 0x38, 0x0C, 0x30,
  0x1C, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x18, 0x18, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x0C,
  0x38, 0x1C, 0x70, 0x0E, 0x38, 0x0C, 0x70, 0x0E, 0x30, 0x0E, 0x70, 0x0E,
  0x30, 0x0E, 0x60, 0x06, 0x70, 0x0E, 0x60, 0x07, 0x70, 0x0E, 0xE0, 0x07,
  0x70, 0x0E, 0xE0, 0x07, 0x70, 0x06, 0xE0, 0x07, 0x60, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x1F, 0xE0, 0x00, 0x70, 0xFF,
  0xC0, 0x01, 0x87, 0x8F, 0x80, 0x0E, 0x3C, 0x0F, 0x00, 0x38, 0xE0, 0x3E,
  0x01, 0xE7, 0x00, 0x78, 0x07, 0x1C, 0x00, 0xF0, 0x3C, 0x70, 0x01, 0xF1,
  0xE1, 0x80, 0x03, 0xFF, 0x0E, 0x00, 0x07, 0xF8, 0x18, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Light60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 6, 42, 36, 15, -42 },
  { 33, 12, 16, 36, 12, -44 },
  { 57, 34, 42, 36, 1, -42 },
  { 236, 30, 56, 36, 3, -49 },
  { 446, 34, 44, 36, 1, -43 },
  { 633, 32, 44, 36, 2, -43 },
  { 809, 4, 16, 36, 16, -44 },
  { 817, 16, 54, 36, 13, -46 },
  { 925, 16, 54, 36, 7, -46 },
  { 1033, 30, 30, 36, 3, -33 },
  { 1146, 28, 29, 36, 4, -33 },
  { 1248, 9, 16, 36, 13, -7 },
  { 1266, 16, 3, 36, 10, -20 },
  { 1272, 6, 6, 36, 15, -6 },
  { 1277, 24, 54, 36, 6, -46 },
  { 1439, 28, 44, 36, 4, -43 },
  { 1593, 29, 42, 36, 4, -42 },
  { 1746, 28, 43, 36, 4, -43 },
  { 1897, 27, 44, 36, 3, -43 },
  { 2046, 31, 42, 36, 2, -42 },
  { 2209, 26, 43, 36, 5, -42 },
  { 2349, 28, 43, 36, 4, -42 },
  { 2500, 27, 42, 36, 4, -42 },
  { 2642, 28, 44, 36, 4, -43 },
  { 2796, 28, 43, 36, 4, -43 },
  { 2947, 6, 31, 36, 15, -31 },
  { 2971, 9, 40, 36, 13, -31 },
  { 3016, 26, 34, 36, 5, -35 },
  { 3127, 28, 15, 36, 4, -26 },
  { 3180, 26, 34, 36, 5, -35 },
  { 3291, 25, 43, 36, 5, -43 },
  { 3426, 27, 50, 36, 4, -43 },
  { 3595, 32, 42, 36, 2, -42 },
  { 3763, 26, 42, 36, 6, -42 },
  { 3900, 28, 44, 36, 4, -43 },
  { 4054, 26, 42, 36, 6, -42 },
  { 4191, 25, 42, 36, 6, -42 },
  { 4323, 26, 42, 36, 6, -42 },
  { 4460, 27, 44, 36, 4, -43 },
  { 4609, 26, 42, 36, 5, -42 },
  { 4746, 26, 42, 36, 5, -42 },
  { 4883, 23, 43, 36, 5, -42 },
  { 5007, 28, 42, 36, 6, -42 },
  { 5154, 24, 42, 36, 8, -42 },
  { 5280, 28, 42, 36, 4, -42 },
  { 5427, 26, 42, 36, 5, -42 },
  { 5564, 28, 44, 36, 4, -43 },
  { 5718, 26, 42, 36, 6, -42 },
  { 5855, 28, 53, 36, 4, -43 },
  { 6041, 26, 42, 36, 6, -42 },
  { 6178, 29, 44, 36, 3, -43 },
  { 6338, 32, 42, 36, 2, -42 },
  { 6506, 26, 43, 36, 5, -42 },
  { 6646, 30, 42, 36, 3, -42 },
  { 6804, 30, 42, 36, 3, -42 },
  { 6962, 32, 42, 36, 2, -42 },
  { 7130, 34, 42, 36, 1, -42 },
  { 7309, 30, 42, 36, 3, -42 },
  { 7467, 16, 54, 36, 14, -46 },
  { 7575, 24, 54, 36, 6, -46 },
  { 7737, 16, 54, 36, 6, -46 },
  { 7845, 30, 24, 36, 3, -42 },
  { 7935, 28, 3, 36, 4, 6 },
  { 7946, 8, 11, 36, 12, -46 },
  { 7957, 29, 33, 36, 4, -32 },
  { 8077, 26, 45, 36, 6, -44 },
  { 8224, 25, 33, 36, 6, -32 },
  { 8328, 26, 45, 36, 4, -44 },
  { 8475, 26, 33, 36, 5, -32 },
  { 8583, 27, 44, 36, 5, -44 },
  { 8732, 28, 48, 36, 5, -35 },
  { 8900, 23, 44, 36, 7, -44 },
  { 9027, 26, 45, 36, 7, -45 },
  { 9174, 21, 57, 36, 6, -45 },
  { 9324, 27, 44, 36, 7, -44 },
  { 9473, 26, 44, 36, 5, -44 },
  { 9616, 28, 32, 36, 4, -32 },
  { 9728, 23, 32, 36, 7, -32 },
  { 9820, 28, 33, 36, 4, -32 },
  { 9936, 26, 44, 36, 6, -32 },
  { 10079, 26, 44, 36, 4, -32 },
  { 10222, 28, 31, 36, 5, -31 },
  { 10331, 26, 33, 36, 5, -32 },
  { 10439, 29, 42, 36, 2, -42 },
  { 10592, 23, 32, 36, 6, -31 },
  { 10684, 28, 31, 36, 4, -31 },
  { 10793, 32, 31, 36, 2, -31 },
  { 10917, 28, 31, 36, 4, -31 },
  { 11026, 28, 43, 36, 4, -31 },
  { 11177, 24, 31, 36, 6, -31 },
  { 11270, 22, 54, 36, 7, -46 },
  { 11419, 4, 54, 36, 16, -46 },
  { 11446, 22, 54, 36, 7, -46 },
  { 11595, 30, 12, 36, 3, -24 },
};

const GFXfont IBMPlexMono_Light60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_LIGHT60PT7B_H_
