#ifndef _IBMPLEXMONO_LIGHT25PT7B_H_
#define _IBMPLEXMONO_LIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light25pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x00, 0x3F, 0xE0, 0x8C, 0x63, 0x18, 0xC6,
  0x20, 0x02, 0x10, 0x04, 0x60, 0x08, 0xC0, 0x11, 0x00, 0x62, 0x00, 0x84,
  0x1F, 0x1F, 0x82, 0x30, 0x04, 0x40, 0x18, 0x83, 0xF1, 0xF0, 0x42, 0x00,
  0x8C, 0x01, 0x10, 0x06, 0x20, 0x0C, 0x40, 0x10, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x1F, 0x83, 0x27, 0x31, 0x09, 0x08, 0x08, 0x40, 0x62, 0x03,
  0x10, 0x0E, 0x80, 0x0F, 0x80, 0x27, 0x01, 0x08, 0x08, 0x40, 0x43, 0x42,
  0x16, 0x11, 0x9C, 0x98, 0x3F, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x78,
  0x0E, 0x20, 0xE1, 0x85, 0x04, 0x68, 0x22, 0x43, 0x23, 0x11, 0x0F, 0x10,
  0x00, 0x00, 0x47, 0x84, 0x46, 0x26, 0x12, 0x20, 0xB1, 0x05, 0x0C, 0x38,
  0x23, 0x80, 0xF0, 0x1F, 0x01, 0x8C, 0x08, 0x30, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x38, 0x3A, 0x21, 0x30, 0x89, 0x06, 0xC8, 0x1C,
  0x40, 0x63, 0x03, 0x8C, 0x26, 0x3E, 0x18, 0xFE, 0x06, 0x10, 0x61, 0x82,
  0x0C, 0x10, 0x20, 0x40, 0x83, 0x06, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0xC0, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0xC0, 0xC0, 0x81, 0x01, 0x02, 0x04,
  0x08, 0x18, 0x30, 0x40, 0x81, 0x02, 0x08, 0x10, 0x61, 0x82, 0x18, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x0C, 0x21, 0xBD, 0x78, 0x3E, 0x00,
  0xE0, 0x0D, 0x80, 0x44, 0x04, 0x10, 0x60, 0xC0, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x37, 0x66, 0x44, 0xC0, 0xFE, 0xFF, 0x80, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x60, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x71, 0x8E, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xD0, 0x11, 0x04,
  0x1F, 0x00, 0x0E, 0x01, 0xE0, 0x36, 0x06, 0x60, 0x86, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xF0, 0x3F, 0x0C, 0x33, 0x03, 0x40, 0x20, 0x04, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0xFF, 0xE0, 0x1F, 0x83, 0x0C, 0x60, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x0C, 0x0F, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0xC0, 0x27, 0x0C, 0x1F, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0xD0, 0x04,
  0x80, 0x44, 0x06, 0x20, 0x21, 0x02, 0x08, 0x30, 0x41, 0x02, 0x10, 0x11,
  0x80, 0x8F, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xC8,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x78, 0x70, 0xC8, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xF0, 0x13, 0x06, 0x3F, 0x00, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0xF8, 0xE0, 0xD8, 0x0F,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0xD0, 0x13, 0x06, 0x1F, 0x00, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0x68, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0x0C,
  0x1B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD0, 0x13, 0x06, 0x1F, 0x0C, 0x1B,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x1B, 0x06, 0x1F, 0x80, 0x1F, 0x0C,
  0x19, 0x01, 0x60, 0x38, 0x03, 0x00, 0x70, 0x1E, 0x03, 0x60, 0xA3, 0xEC,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x77, 0x70, 0x00, 0x00, 0x00, 0x03, 0x76, 0x64,
  0x4C, 0x00, 0x20, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x01,
  0x00, 0x00, 0x1F, 0x0C, 0x19, 0x01, 0x60, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0x0F, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x1F, 0x06, 0x11, 0x01, 0x20, 0x2C, 0x07, 0x0F, 0x63, 0x2C,
  0x43, 0x88, 0x33, 0x06, 0x60, 0xC4, 0x18, 0x87, 0x10, 0xE1, 0xEE, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x40, 0x1B,
  0x00, 0xD8, 0x04, 0x40, 0x63, 0x03, 0x18, 0x10, 0x41, 0x83, 0x0C, 0x18,
  0x7F, 0xC6, 0x03, 0x30, 0x19, 0x00, 0x58, 0x03, 0xC0, 0x18, 0xFF, 0x18,
  0x1B, 0x01, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x16, 0x06, 0xFF, 0x18, 0x1B,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x06, 0xFF, 0x80, 0x1F, 0x86,
  0x19, 0x81, 0xA0, 0x1C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x58, 0x19, 0x86, 0x1F, 0x80, 0xFF, 0x18,
  0x33, 0x01, 0x60, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x16, 0x0C, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xF8, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xD8, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x06,
  0x19, 0x01, 0x60, 0x3C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E,
  0x00, 0xC0, 0x18, 0x07, 0x80, 0xD0, 0x1B, 0x85, 0x1F, 0x20, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xF8, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0xFF, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0xE0, 0x3F, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xD0, 0x3C, 0x09, 0x86, 0x3E, 0x00, 0xC0, 0x3C, 0x06, 0xC0,
  0xCC, 0x18, 0xC3, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD6, 0x0F, 0x20, 0xE3,
  0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x30, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xC0, 0xC0, 0x78, 0x0E, 0x82,
  0xD0, 0x5B, 0x1B, 0x22, 0x66, 0xCC, 0x51, 0x8E, 0x30, 0x86, 0x10, 0xC2,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x3D, 0x07, 0xB0, 0xF2, 0x1E, 0x63, 0xC4, 0x78, 0xCF, 0x09, 0xE1,
  0xBC, 0x17, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0x1F, 0x04, 0x11, 0x01,
  0x60, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0xD0, 0x11, 0x04, 0x1F, 0x00, 0xFF, 0x98, 0x0B, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xFF, 0x98, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x04, 0x11, 0x01,
  0x60, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0xD0, 0x13, 0x06, 0x1F, 0x00, 0x80, 0x10, 0x03, 0xE0,
  0xFF, 0x98, 0x0B, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x02, 0xFF,
  0x98, 0xC3, 0x0C, 0x60, 0x8C, 0x19, 0x81, 0x30, 0x36, 0x03, 0xC0, 0x60,
  0x0F, 0xC3, 0x07, 0x60, 0x14, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x80,
  0x07, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0xC0, 0x37, 0x06,
  0x1F, 0x80, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xD0, 0x13, 0x06, 0x1F, 0x00, 0xC0, 0x1A, 0x00, 0x90, 0x04, 0xC0,
  0x62, 0x03, 0x10, 0x10, 0xC1, 0x86, 0x0C, 0x10, 0x40, 0xC6, 0x06, 0x30,
  0x11, 0x00, 0xD8, 0x06, 0xC0, 0x14, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xA1, 0x89, 0x1C, 0x48, 0xA2, 0x45,
  0x12, 0x6C, 0x93, 0x24, 0x91, 0x26, 0x89, 0x3C, 0x79, 0xC1, 0xCE, 0x0E,
  0x30, 0x60, 0xC0, 0x1B, 0x01, 0x8C, 0x08, 0x60, 0xC1, 0x8C, 0x04, 0x40,
  0x36, 0x00, 0xE0, 0x03, 0x00, 0x28, 0x03, 0x60, 0x11, 0x81, 0x84, 0x18,
  0x30, 0x80, 0xCC, 0x06, 0xC0, 0x18, 0xC0, 0x1E, 0x00, 0xD8, 0x0C, 0x40,
  0x43, 0x06, 0x08, 0x20, 0x63, 0x01, 0xB0, 0x05, 0x00, 0x38, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F, 0xF0,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00,
  0xFF, 0xF8, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0xC0, 0x07, 0x00, 0x28, 0x03, 0x60, 0x11, 0x01, 0x8C, 0x08, 0x20, 0x81,
  0x8C, 0x06, 0x40, 0x16, 0x00, 0xC0, 0xFF, 0xF8, 0x8C, 0x42, 0x30, 0x3E,
  0x06, 0x18, 0xC0, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x3F, 0xCC, 0x0C, 0x80,
  0xC8, 0x0C, 0x80, 0xCC, 0x3C, 0x3C, 0x70, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x09, 0xF2, 0x86, 0xC0, 0xA0, 0x38, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0xC0, 0xA8, 0x69, 0xF0, 0x1F, 0x86, 0x19, 0x81, 0xA0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x81, 0x98, 0x61,
  0xF8, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x11, 0xE5, 0x85, 0xC0,
  0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0xD8, 0x53,
  0xE4, 0x1F, 0x06, 0x11, 0x01, 0x60, 0x3C, 0x07, 0x00, 0x7F, 0xFC, 0x00,
  0x80, 0x18, 0x01, 0x01, 0x98, 0x61, 0xF0, 0x07, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xE0,
  0x00, 0xF1, 0xF8, 0x31, 0x86, 0x0C, 0x40, 0x44, 0x04, 0x40, 0x46, 0x0C,
  0x31, 0x83, 0xF0, 0x60, 0x04, 0x00, 0x60, 0x07, 0xFC, 0xC0, 0x28, 0x03,
  0x80, 0x3C, 0x06, 0x3F, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x79, 0x42, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xFE, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x3C, 0x0C, 0x83, 0x10, 0xC2, 0x30,
  0x4C, 0x0A, 0xC1, 0x8C, 0x20, 0xC4, 0x0C, 0x81, 0x90, 0x1A, 0x01, 0x80,
  0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x83, 0xFF, 0x80, 0xB9, 0xD9, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61,
  0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x42, 0x9E, 0x50, 0xB0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x1F, 0x04, 0x11, 0x01, 0x60, 0x3C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x78, 0x0D, 0x01, 0x10, 0x41, 0xF0, 0x9F, 0x28, 0x6C, 0x0A, 0x03, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x3C, 0x0A, 0x86, 0x9F, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x58, 0x5C, 0x0F, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x0D, 0x85, 0x3E, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0xF9, 0xF0, 0xA0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0xE0,
  0x1F, 0x0C, 0x19, 0x01, 0xA0, 0x04, 0x00, 0xE0, 0x07, 0xE0, 0x06, 0x00,
  0x60, 0x07, 0x01, 0xB0, 0x61, 0xF8, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x78, 0x53, 0xC8, 0xC0,
  0x38, 0x0D, 0x01, 0x30, 0x62, 0x0C, 0x41, 0x0C, 0x60, 0x88, 0x11, 0x03,
  0x60, 0x28, 0x05, 0x00, 0xE0, 0x82, 0x0C, 0x28, 0x61, 0x43, 0x8A, 0x34,
  0x51, 0x26, 0xC9, 0x22, 0x49, 0x12, 0x48, 0x93, 0x45, 0x8C, 0x18, 0x60,
  0xC3, 0x06, 0x00, 0xC0, 0x6C, 0x18, 0x82, 0x18, 0xC1, 0xB0, 0x1C, 0x01,
  0x00, 0x70, 0x1B, 0x06, 0x30, 0x82, 0x30, 0x6C, 0x06, 0x80, 0x38, 0x0D,
  0x01, 0x30, 0x26, 0x0C, 0x41, 0x0C, 0x60, 0x88, 0x19, 0x01, 0x60, 0x28,
  0x07, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x1E, 0x00, 0x7F, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x20, 0x0F, 0xFE, 0x1F, 0x88, 0x04, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x06, 0x06, 0x3C, 0x01, 0x80, 0x40, 0x30, 0x10, 0x18, 0x18, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x7C, 0xFF, 0xFF, 0xFC, 0xF8, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x40, 0x60, 0x30, 0x0C, 0x01, 0xE3, 0x03, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x47, 0xC0, 0x38, 0x1B, 0x20,
  0x90, 0x84, 0x82, 0x6C, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_Light25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 17, 15, 6, -17 },
  { 8, 5, 7, 15, 5, -19 },
  { 13, 15, 17, 15, 0, -17 },
  { 45, 13, 23, 15, 1, -20 },
  { 83, 13, 17, 15, 1, -17 },
  { 111, 13, 17, 15, 1, -17 },
  { 139, 1, 7, 15, 7, -19 },
  { 140, 7, 22, 15, 5, -19 },
  { 160, 7, 22, 15, 3, -19 },
  { 180, 13, 12, 15, 1, -14 },
  { 200, 11, 11, 15, 2, -13 },
  { 216, 4, 7, 15, 5, -3 },
  { 220, 7, 1, 15, 4, -8 },
  { 221, 3, 3, 15, 6, -3 },
  { 223, 11, 22, 15, 2, -19 },
  { 254, 11, 17, 15, 2, -17 },
  { 278, 12, 17, 15, 2, -17 },
  { 304, 11, 17, 15, 2, -17 },
  { 328, 12, 17, 15, 1, -17 },
  { 354, 13, 17, 15, 1, -17 },
  { 382, 11, 17, 15, 2, -17 },
  { 406, 11, 17, 15, 2, -17 },
  { 430, 11, 17, 15, 2, -17 },
  { 454, 11, 17, 15, 2, -17 },
  { 478, 11, 17, 15, 2, -17 },
  { 502, 3, 14, 15, 6, -14 },
  { 508, 4, 18, 15, 5, -14 },
  { 517, 11, 14, 15, 2, -15 },
  { 537, 11, 6, 15, 2, -11 },
  { 546, 11, 14, 15, 2, -15 },
  { 566, 11, 17, 15, 2, -17 },
  { 590, 11, 20, 15, 2, -17 },
  { 618, 13, 17, 15, 1, -17 },
  { 646, 11, 17, 15, 2, -17 },
  { 670, 11, 17, 15, 2, -17 },
  { 694, 11, 17, 15, 2, -17 },
  { 718, 11, 17, 15, 2, -17 },
  { 742, 11, 17, 15, 2, -17 },
  { 766, 11, 17, 15, 2, -17 },
  { 790, 11, 17, 15, 2, -17 },
  { 814, 11, 17, 15, 2, -17 },
  { 838, 10, 17, 15, 2, -17 },
  { 860, 12, 17, 15, 2, -17 },
  { 886, 10, 17, 15, 3, -17 },
  { 908, 11, 17, 15, 2, -17 },
  { 932, 11, 17, 15, 2, -17 },
  { 956, 11, 17, 15, 2, -17 },
  { 980, 11, 17, 15, 2, -17 },
  { 1004, 11, 20, 15, 2, -17 },
  { 1032, 11, 17, 15, 2, -17 },
  { 1056, 12, 17, 15, 1, -17 },
  { 1082, 13, 17, 15, 1, -17 },
  { 1110, 11, 17, 15, 2, -17 },
  { 1134, 13, 17, 15, 1, -17 },
  { 1162, 13, 17, 15, 1, -17 },
  { 1190, 13, 17, 15, 1, -17 },
  { 1218, 13, 17, 15, 1, -17 },
  { 1246, 13, 17, 15, 1, -17 },
  { 1274, 7, 22, 15, 6, -19 },
  { 1294, 11, 22, 15, 2, -19 },
  { 1325, 7, 22, 15, 2, -19 },
  { 1345, 13, 10, 15, 1, -17 },
  { 1362, 13, 1, 15, 1, 3 },
  { 1364, 4, 5, 15, 5, -20 },
  { 1367, 12, 13, 15, 2, -13 },
  { 1387, 10, 19, 15, 3, -19 },
  { 1411, 11, 13, 15, 2, -13 },
  { 1429, 10, 19, 15, 2, -19 },
  { 1453, 11, 13, 15, 2, -13 },
  { 1471, 12, 19, 15, 2, -19 },
  { 1500, 12, 19, 15, 2, -14 },
  { 1529, 9, 19, 15, 3, -19 },
  { 1551, 11, 19, 15, 3, -19 },
  { 1578, 9, 24, 15, 2, -19 },
  { 1605, 11, 19, 15, 3, -19 },
  { 1632, 11, 19, 15, 2, -19 },
  { 1659, 11, 13, 15, 2, -13 },
  { 1677, 9, 13, 15, 3, -13 },
  { 1692, 11, 13, 15, 2, -13 },
  { 1710, 10, 18, 15, 3, -13 },
  { 1733, 10, 18, 15, 2, -13 },
  { 1756, 12, 13, 15, 2, -13 },
  { 1776, 11, 13, 15, 2, -13 },
  { 1794, 12, 17, 15, 1, -17 },
  { 1820, 9, 13, 15, 3, -13 },
  { 1835, 11, 13, 15, 2, -13 },
  { 1853, 13, 13, 15, 1, -13 },
  { 1875, 11, 13, 15, 2, -13 },
  { 1893, 11, 18, 15, 2, -13 },
  { 1918, 11, 13, 15, 2, -13 },
  { 1936, 9, 22, 15, 3, -19 },
  { 1961, 1, 22, 15, 7, -19 },
  { 1964, 9, 22, 15, 3, -19 },
  { 1989, 13, 5, 15, 1, -10 },
};

const GFXfont IBMPlexMono_Light25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_LIGHT25PT7B_H_
