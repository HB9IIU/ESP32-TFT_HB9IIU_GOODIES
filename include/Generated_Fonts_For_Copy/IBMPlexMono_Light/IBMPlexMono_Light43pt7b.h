#ifndef _IBMPLEXMONO_LIGHT43PT7B_H_
#define _IBMPLEXMONO_LIGHT43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light43pt7bBitmaps[] PROGMEM = {
  0x00, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xBC, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60,
  0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x01, 0xC1,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83,
  0x80, 0x03, 0x83, 0x00, 0xFF, 0x83, 0xFC, 0xFF, 0x03, 0xFC, 0x03, 0x03,
  0x00, 0x03, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x7C, 0xC7, 0x87, 0x86,
  0x0E, 0x38, 0x30, 0x39, 0x81, 0x80, 0x9C, 0x0C, 0x00, 0xE0, 0x60, 0x07,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x1E, 0x30,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0x1E, 0x00,
  0x18, 0x38, 0x00, 0xC0, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x18, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x36, 0x03, 0x03, 0xF8, 0x18, 0x1C, 0xE0,
  0xC1, 0xC3, 0xE6, 0x3C, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x07, 0x3F,
  0xC0, 0x06, 0x70, 0xE0, 0x0C, 0x60, 0x30, 0x0C, 0xE0, 0x30, 0x18, 0xC0,
  0x30, 0x18, 0xC0, 0x38, 0x30, 0xC0, 0x38, 0x70, 0xC0, 0x38, 0x60, 0xC0,
  0x30, 0xE0, 0xE0, 0x30, 0xC0, 0x60, 0x71, 0x80, 0x70, 0xE1, 0x80, 0x3F,
  0xC2, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x01,
  0x87, 0x1C, 0x03, 0x8C, 0x06, 0x03, 0x0C, 0x06, 0x06, 0x18, 0x07, 0x06,
  0x18, 0x03, 0x0C, 0x18, 0x03, 0x0C, 0x18, 0x03, 0x18, 0x18, 0x07, 0x38,
  0x0C, 0x06, 0x30, 0x0C, 0x06, 0x70, 0x07, 0x1C, 0x60, 0x07, 0xFC, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x1F, 0x8E, 0x70, 0x3F,
  0x38, 0x70, 0x60, 0x60, 0xE0, 0xC1, 0xC0, 0xE1, 0x83, 0x00, 0xE3, 0x0E,
  0x00, 0xE6, 0x1C, 0x00, 0xEC, 0x38, 0x00, 0xF8, 0x70, 0x00, 0xE0, 0x60,
  0x01, 0xC0, 0xE0, 0x02, 0xC0, 0xE0, 0x09, 0xC1, 0xE0, 0x71, 0xC1, 0xFF,
  0xC1, 0xC0, 0xFE, 0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x70, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x0C, 0x06, 0xFC,
  0x30, 0xFD, 0xFE, 0xDF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0xE1, 0x80, 0x03, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x3E, 0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xC3, 0x86, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x07, 0x83, 0x80, 0x38, 0x30, 0x01, 0xC7,
  0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0E, 0x07, 0xC0, 0xF0,
  0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70,
  0x00, 0xE3, 0x00, 0x1C, 0x38, 0x03, 0x81, 0xE0, 0x78, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEC, 0x00, 0x0E, 0x60,
  0x01, 0xE3, 0x00, 0x1E, 0x18, 0x01, 0xE0, 0xC0, 0x1E, 0x06, 0x00, 0xE0,
  0x30, 0x02, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x1E, 0x0F, 0x03, 0x80, 0x38, 0x70, 0x01, 0xC6, 0x00, 0x1C,
  0xE0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x1C, 0x38, 0x00,
  0xE1, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x20, 0x00, 0x6F, 0x00, 0x0E, 0x78, 0x01, 0xC3, 0xE0, 0x78, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00,
  0x07, 0x60, 0x00, 0x19, 0x80, 0x00, 0xE6, 0x00, 0x07, 0x18, 0x00, 0x18,
  0x60, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60,
  0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x01, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0xE0, 0x01,
  0x83, 0x00, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x1F, 0xC0, 0x6F, 0xFE, 0x0F,
  0x81, 0xE3, 0xC0, 0x0E, 0x30, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x60,
  0x00, 0xFE, 0x00, 0x39, 0xE0, 0x07, 0x1F, 0x03, 0xC1, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x71, 0xFC, 0x07, 0x7F,
  0xF0, 0x6E, 0x07, 0x8F, 0x80, 0x1C, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xE0, 0x78,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x3E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xC3,
  0x80, 0x1C, 0x1E, 0x07, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xE0, 0x78,
  0x38, 0x01, 0xC6, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00,
  0x0E, 0x78, 0x01, 0xE3, 0xE0, 0x7C, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xC6,
  0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0xF7, 0x00, 0x0F, 0x38, 0x01,
  0xE1, 0xE0, 0x76, 0x0F, 0xFC, 0xE0, 0x3F, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFD, 0xE0, 0x3C, 0xF9, 0xF3, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xE3, 0xC7,
  0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x0E, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xC0, 0xF1, 0xC0, 0x0E, 0x60, 0x03, 0xB8, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x1E,
  0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0x01, 0x9C, 0x00, 0x3B, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x07, 0xCD, 0x83, 0xFD, 0xF0, 0x70, 0xBE, 0x1C, 0x0F,
  0xC3, 0x00, 0xF8, 0x60, 0x1F, 0x1C, 0x03, 0xE3, 0x80, 0x7C, 0x70, 0x0F,
  0x8E, 0x01, 0xF1, 0xC0, 0x3E, 0x18, 0x07, 0xC3, 0x00, 0xF8, 0x60, 0x3F,
  0x0E, 0x07, 0x60, 0xFF, 0x6C, 0x0F, 0xCD, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xE0,
  0x00, 0x63, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x00,
  0xC0, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x60, 0x18, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x07, 0x01, 0xC0, 0x0C, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xE0, 0x01, 0x83, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x70,
  0x00, 0x31, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x70, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x80, 0x3C, 0x70,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x31, 0xC0,
  0x1E, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xE0, 0x07, 0x9C, 0x00, 0x3B, 0x80,
  0x03, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x07, 0x70, 0x03, 0xCF, 0xFF,
  0xF1, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x03, 0xC1,
  0xC0, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x70, 0x00, 0x67, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x06, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x1C, 0x01, 0xC0,
  0xF0, 0x3C, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0x80, 0x78, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x00, 0x77,
  0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x37, 0x00, 0x0E, 0xE0, 0x01, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0x70,
  0x0F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x78, 0x1E, 0x1E, 0x00,
  0xE3, 0x80, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x13, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x80, 0x03,
  0x70, 0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x05, 0x8F, 0x03, 0xB0, 0xFF, 0xE6,
  0x07, 0xF0, 0xC0, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xFF, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x40, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x70,
  0x0E, 0x78, 0x1C, 0x3F, 0xF8, 0x0F, 0xE0, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1E,
  0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0x7C, 0x00, 0xE7, 0xC0, 0x0E, 0xEE, 0x00, 0xFC,
  0x70, 0x0F, 0x87, 0x00, 0xF0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E,
  0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFE, 0xC0, 0x37, 0xEC, 0x03, 0x7E, 0xE0, 0x67, 0xE6, 0x06,
  0x7E, 0x70, 0xE7, 0xE3, 0x0C, 0x7E, 0x31, 0xC7, 0xE1, 0x98, 0x7E, 0x19,
  0x87, 0xE1, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x06, 0x07, 0xE0,
  0x60, 0x7E, 0x04, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xD8, 0x00, 0xF7, 0x00, 0x3C, 0xC0, 0x0F, 0x38, 0x03, 0xC6,
  0x00, 0xF1, 0xC0, 0x3C, 0x30, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0x70,
  0x3C, 0x1C, 0x0F, 0x03, 0x03, 0xC0, 0xE0, 0xF0, 0x18, 0x3C, 0x07, 0x0F,
  0x00, 0xC3, 0xC0, 0x38, 0xF0, 0x06, 0x3C, 0x01, 0xCF, 0x00, 0x73, 0xC0,
  0x0E, 0xF0, 0x03, 0xBC, 0x00, 0x6F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x07, 0x83, 0x80, 0x38, 0x30,
  0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0x00, 0x1C, 0x38, 0x03, 0x81, 0xE0, 0x78, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0x80, 0x1E, 0x70,
  0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0D, 0xC0,
  0x03, 0xB8, 0x01, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x07, 0x83,
  0x80, 0x38, 0x30, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x06,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60,
  0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x1C, 0x38, 0x03, 0x81,
  0xE0, 0x78, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0x80, 0x1E, 0x70, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x01, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1C, 0x0C, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x38, 0x38, 0x03, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x63,
  0x80, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xC0, 0x01, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0x80, 0xF8, 0x78, 0x00, 0xE3, 0x80, 0x03, 0xB8,
  0x00, 0x11, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x3F, 0x80, 0x03, 0x9E, 0x00, 0x3C, 0x7C, 0x07, 0xC0,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0x98, 0x00, 0xE7, 0x00, 0x38, 0xF0, 0x3C, 0x1F,
  0xFE, 0x01, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x60, 0x60, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x60,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC1, 0xC0, 0x03,
  0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x78, 0x19, 0x81, 0xE0, 0x66, 0x07, 0x81, 0x98, 0x1E, 0x06,
  0x60, 0xDC, 0x19, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x98, 0x33, 0x0E, 0x71,
  0xCC, 0x31, 0xC6, 0x18, 0xC7, 0x18, 0x63, 0x0C, 0x61, 0x8C, 0x33, 0x86,
  0x30, 0xCC, 0x1C, 0xC3, 0x30, 0x33, 0x0C, 0xC0, 0xCC, 0x37, 0x03, 0x30,
  0xD8, 0x0E, 0xC3, 0x60, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF0,
  0x07, 0x80, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x38, 0x70, 0x00, 0x60, 0xE0,
  0x01, 0xC0, 0xE0, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0x80, 0x03, 0x87, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x1C, 0x00,
  0x18, 0x38, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x70, 0x38, 0x00, 0x60, 0x70, 0x00, 0xE1, 0xC0, 0x00, 0xE7, 0x00,
  0x01, 0xDE, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0x98, 0x00, 0x18, 0xE0, 0x01, 0xC3, 0x00, 0x0C,
  0x1C, 0x00, 0xE0, 0x70, 0x06, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x00, 0x30,
  0x30, 0x01, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x39, 0xC0, 0x00, 0xEC, 0x00,
  0x03, 0xE0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x21, 0xC1, 0xC1,
  0x81, 0x83, 0x83, 0x03, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x3C, 0x0E, 0x07,
  0x00, 0x70, 0x60, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x07, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x01,
  0x86, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0x60, 0x05, 0x87, 0x81, 0xD8, 0x3F, 0xF9, 0xF0, 0xFE, 0x0F, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x3F, 0x03,
  0x3F, 0xF0, 0xD8, 0x1E, 0x3C, 0x01, 0xCE, 0x00, 0x3B, 0x00, 0x0E, 0xC0,
  0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B,
  0x80, 0x0E, 0xF0, 0x07, 0x36, 0x07, 0x8C, 0xFF, 0xC3, 0x0F, 0xC0, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0, 0x0E, 0x70, 0x01, 0x9C, 0x00,
  0x56, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x9C, 0x00, 0x73, 0x80, 0x38, 0x78, 0x1C, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x3F, 0x0C, 0x3F, 0xF3, 0x1E, 0x0E, 0xCE, 0x00, 0xB7, 0x00, 0x1D, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36,
  0x00, 0x0D, 0xC0, 0x07, 0x38, 0x02, 0xCF, 0x83, 0xB0, 0xFF, 0xCC, 0x0F,
  0xC3, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x30,
  0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x6F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x43, 0x80, 0x0E, 0x3C, 0x01,
  0xC1, 0xE0, 0x78, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0xC0,
  0x0F, 0xFE, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x78, 0x00, 0x73, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xE0,
  0x07, 0xC7, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC3, 0xF0, 0xCF, 0xFC, 0xD8, 0x1E, 0xD0, 0x0E, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x9F, 0xFF, 0x3F, 0xFC,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0xF1, 0xC0, 0x3C, 0x38, 0x0E, 0x07,
  0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x73, 0xE0, 0x0E,
  0xDC, 0x01, 0xF1, 0xC0, 0x3C, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x3C, 0x1C,
  0x03, 0x83, 0x80, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0x77, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x87, 0xCD, 0xFC, 0xFE, 0xF1, 0xD8, 0x7E,
  0x0F, 0x07, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03,
  0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC3,
  0xF0, 0xCF, 0xFC, 0xD8, 0x1E, 0xD0, 0x0E, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x1E, 0x07, 0x83, 0x80, 0x1C, 0x30, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00,
  0xE6, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70,
  0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0x81, 0xE0, 0x78, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0xC3, 0xF0, 0x33, 0xFF, 0x0D, 0x81, 0xE3, 0xC0, 0x1C, 0xE0,
  0x03, 0xB0, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x06, 0xC0, 0x03, 0xB8, 0x00, 0xEF, 0x00, 0x73, 0x60, 0x78, 0xCF,
  0xFC, 0x30, 0xFC, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xF0, 0xC3, 0xFF, 0x31, 0xE0, 0xEC, 0xE0, 0x0B, 0x70, 0x01, 0xD8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0x60, 0x00, 0xDC, 0x00, 0x73, 0x80, 0x2C, 0xF8, 0x3B, 0x0F, 0xFC, 0xC0,
  0xFC, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0xC0, 0x77, 0x00, 0x03, 0xA0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x70, 0x1F, 0x1C, 0x00, 0x73, 0x00, 0x04, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x40, 0x00,
  0x6C, 0x00, 0x0F, 0xC0, 0x03, 0x9F, 0x01, 0xE0, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x03, 0xB8, 0x01, 0xDC, 0x01,
  0x67, 0x83, 0xB1, 0xFF, 0x98, 0x3F, 0x0C, 0xE0, 0x00, 0x76, 0x00, 0x06,
  0x70, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x18, 0x01,
  0x81, 0x80, 0x38, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0xE0,
  0x60, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x98, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xE0, 0x38, 0x06, 0xC0, 0x78, 0x0D, 0x80, 0xF0, 0x1B, 0x01,
  0xE0, 0x36, 0x02, 0x40, 0x6C, 0x0C, 0xC1, 0x8C, 0x19, 0x83, 0x18, 0x33,
  0x06, 0x30, 0x46, 0x0C, 0x61, 0x84, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18,
  0xC1, 0x8C, 0x31, 0x83, 0x30, 0x63, 0x06, 0x60, 0x66, 0x0C, 0xC0, 0xCC,
  0x19, 0x81, 0x98, 0x32, 0x03, 0x20, 0x3C, 0x02, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xF7, 0x00, 0x0C, 0x38,
  0x01, 0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x07, 0x0E, 0x00,
  0x39, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x39, 0x80, 0x03, 0x1C, 0x00, 0x70, 0xE0, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x03, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xEE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x30,
  0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x18, 0x1C, 0x03, 0x80,
  0xC0, 0x30, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x70, 0xE0,
  0x03, 0x0C, 0x00, 0x39, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x01, 0xC0, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0x00, 0x18, 0xFE, 0x00,
  0xCE, 0x38, 0x06, 0x60, 0xC0, 0x36, 0x03, 0x03, 0x30, 0x1C, 0x19, 0x80,
  0x71, 0x9C, 0x01, 0xFC, 0xC0, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Light43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 5, 30, 26, 10, -30 },
  { 20, 10, 11, 26, 8, -32 },
  { 34, 24, 30, 26, 1, -30 },
  { 124, 21, 38, 26, 2, -34 },
  { 224, 24, 30, 26, 1, -30 },
  { 314, 23, 30, 26, 1, -30 },
  { 401, 2, 11, 26, 12, -32 },
  { 404, 12, 39, 26, 9, -33 },
  { 463, 11, 39, 26, 5, -33 },
  { 517, 22, 21, 26, 2, -24 },
  { 575, 20, 20, 26, 3, -23 },
  { 625, 7, 12, 26, 9, -5 },
  { 636, 12, 2, 26, 7, -14 },
  { 639, 5, 5, 26, 10, -5 },
  { 643, 18, 39, 26, 4, -33 },
  { 731, 20, 30, 26, 3, -30 },
  { 806, 21, 30, 26, 3, -30 },
  { 885, 20, 30, 26, 3, -30 },
  { 960, 20, 30, 26, 2, -30 },
  { 1035, 22, 30, 26, 2, -30 },
  { 1118, 19, 30, 26, 3, -30 },
  { 1190, 20, 30, 26, 3, -30 },
  { 1265, 20, 30, 26, 3, -30 },
  { 1340, 20, 30, 26, 3, -30 },
  { 1415, 20, 30, 26, 3, -30 },
  { 1490, 5, 23, 26, 10, -23 },
  { 1505, 7, 30, 26, 9, -23 },
  { 1532, 18, 24, 26, 4, -25 },
  { 1586, 20, 10, 26, 3, -18 },
  { 1611, 18, 24, 26, 4, -25 },
  { 1665, 18, 30, 26, 4, -30 },
  { 1733, 19, 35, 26, 3, -30 },
  { 1817, 22, 30, 26, 2, -30 },
  { 1900, 19, 30, 26, 4, -30 },
  { 1972, 20, 30, 26, 3, -30 },
  { 2047, 19, 30, 26, 4, -30 },
  { 2119, 18, 30, 26, 4, -30 },
  { 2187, 19, 30, 26, 4, -30 },
  { 2259, 19, 30, 26, 3, -30 },
  { 2331, 18, 30, 26, 4, -30 },
  { 2399, 18, 30, 26, 4, -30 },
  { 2467, 16, 30, 26, 4, -30 },
  { 2527, 20, 30, 26, 4, -30 },
  { 2602, 17, 30, 26, 6, -30 },
  { 2666, 20, 30, 26, 3, -30 },
  { 2741, 18, 30, 26, 4, -30 },
  { 2809, 20, 30, 26, 3, -30 },
  { 2884, 19, 30, 26, 4, -30 },
  { 2956, 20, 36, 26, 3, -30 },
  { 3046, 19, 30, 26, 4, -30 },
  { 3118, 21, 30, 26, 2, -30 },
  { 3197, 23, 30, 26, 1, -30 },
  { 3284, 18, 30, 26, 4, -30 },
  { 3352, 22, 30, 26, 2, -30 },
  { 3435, 22, 30, 26, 2, -30 },
  { 3518, 23, 30, 26, 1, -30 },
  { 3605, 24, 30, 26, 1, -30 },
  { 3695, 22, 30, 26, 2, -30 },
  { 3778, 12, 39, 26, 10, -33 },
  { 3837, 18, 39, 26, 4, -33 },
  { 3925, 11, 39, 26, 4, -33 },
  { 3979, 21, 17, 26, 2, -30 },
  { 4024, 20, 2, 26, 3, 5 },
  { 4029, 7, 8, 26, 8, -33 },
  { 4036, 20, 22, 26, 3, -22 },
  { 4091, 18, 32, 26, 5, -32 },
  { 4163, 18, 22, 26, 4, -22 },
  { 4213, 18, 32, 26, 3, -32 },
  { 4285, 20, 22, 26, 3, -22 },
  { 4340, 20, 32, 26, 3, -32 },
  { 4420, 21, 33, 26, 3, -24 },
  { 4507, 16, 32, 26, 5, -32 },
  { 4571, 18, 31, 26, 5, -31 },
  { 4641, 15, 40, 26, 4, -31 },
  { 4716, 19, 32, 26, 5, -32 },
  { 4792, 18, 32, 26, 4, -32 },
  { 4864, 20, 22, 26, 3, -22 },
  { 4919, 16, 22, 26, 5, -22 },
  { 4963, 20, 22, 26, 3, -22 },
  { 5018, 18, 31, 26, 5, -22 },
  { 5088, 18, 31, 26, 3, -22 },
  { 5158, 21, 22, 26, 3, -22 },
  { 5216, 19, 22, 26, 3, -22 },
  { 5269, 21, 30, 26, 2, -30 },
  { 5348, 17, 22, 26, 4, -22 },
  { 5395, 20, 22, 26, 3, -22 },
  { 5450, 23, 22, 26, 1, -22 },
  { 5514, 20, 22, 26, 3, -22 },
  { 5569, 20, 31, 26, 3, -22 },
  { 5647, 18, 22, 26, 4, -22 },
  { 5697, 16, 39, 26, 5, -33 },
  { 5775, 2, 39, 26, 12, -33 },
  { 5785, 16, 39, 26, 5, -33 },
  { 5863, 21, 9, 26, 2, -17 },
};

const GFXfont IBMPlexMono_Light43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_LIGHT43PT7B_H_
