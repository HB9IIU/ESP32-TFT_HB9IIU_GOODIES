#ifndef _IBMPLEXMONO_LIGHT26PT7B_H_
#define _IBMPLEXMONO_LIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light26pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDA, 0x49, 0x20, 0x03, 0xEC, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xC0, 0x03, 0x10, 0x04, 0x20, 0x08, 0x40, 0x11, 0x80, 0x23, 0x00,
  0xC6, 0x1F, 0x8F, 0x82, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x11, 0x87, 0xE3,
  0xE0, 0xC4, 0x01, 0x08, 0x02, 0x30, 0x04, 0x60, 0x18, 0x80, 0x31, 0x00,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0x83, 0x37, 0x31, 0x8D, 0x8C, 0x0C,
  0x60, 0x63, 0x03, 0x18, 0x0C, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0x98, 0x0C,
  0x60, 0x61, 0x03, 0x0A, 0x18, 0xF8, 0xC6, 0x66, 0x61, 0xFC, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x38, 0x0F, 0x10, 0x28, 0x21, 0xA0, 0x84, 0x82, 0x32,
  0x08, 0x88, 0x24, 0x31, 0x30, 0x38, 0x00, 0x03, 0xC0, 0x98, 0x86, 0x43,
  0x13, 0x04, 0x8C, 0x12, 0x30, 0x50, 0x43, 0xC1, 0x8A, 0x03, 0xC0, 0x0F,
  0x00, 0xC3, 0x02, 0x04, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x01, 0x90, 0xE4, 0x62, 0x30, 0xC8, 0x81, 0xA2, 0x03, 0x88,
  0x06, 0x30, 0x28, 0x61, 0x10, 0xF8, 0x70, 0xFF, 0xFC, 0x0E, 0x30, 0x41,
  0x06, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0,
  0x81, 0x03, 0x02, 0x02, 0x06, 0x07, 0xC0, 0x40, 0x40, 0xC0, 0x81, 0x81,
  0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x41,
  0x82, 0x08, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x0C, 0x30, 0xFD,
  0xBC, 0x7F, 0x00, 0xE0, 0x05, 0x80, 0x66, 0x06, 0x10, 0x20, 0xC3, 0x02,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x6F, 0xED, 0x20,
  0xFE, 0x7D, 0x80, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x1F, 0x03, 0x0C, 0x60, 0x6C, 0x02, 0xC0, 0x28, 0x03, 0x80, 0x38, 0x03,
  0x86, 0x38, 0x63, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x26, 0x06,
  0x30, 0xC1, 0xF0, 0x0E, 0x01, 0xA0, 0x32, 0x06, 0x20, 0xC2, 0x08, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x1F, 0x06, 0x0C, 0xC0, 0x4C, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0x1F, 0x83, 0x06,
  0x60, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x0C, 0x0F, 0x00, 0x0E,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x3C, 0x03, 0x70, 0x61, 0xF8,
  0x00, 0xE0, 0x0F, 0x00, 0x58, 0x06, 0xC0, 0x66, 0x02, 0x30, 0x31, 0x83,
  0x0C, 0x10, 0x61, 0x83, 0x18, 0x18, 0x80, 0xCC, 0x06, 0x7F, 0xFC, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x7F, 0xE6, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0xF8, 0x70, 0xC4, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x2C, 0x06, 0x60, 0xC1, 0xF0, 0x03, 0x80, 0x60,
  0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x04, 0xF8, 0xF0, 0xCC, 0x06,
  0xC0, 0x2C, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x24, 0x06, 0x30, 0xC1, 0xF0,
  0xFF, 0xF8, 0x03, 0x80, 0x68, 0x06, 0x80, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x1F, 0x86, 0x0C, 0x40, 0x6C, 0x02, 0xC0, 0x2C, 0x02,
  0x40, 0x62, 0x0C, 0x1F, 0x06, 0x0C, 0xC0, 0x28, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x02, 0x60, 0xE1, 0xF8, 0x1F, 0x03, 0x0C, 0x40, 0x6C, 0x02,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x77, 0x0E, 0x1F, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x7D, 0x80, 0x00,
  0x00, 0x3E, 0xC0, 0x7D, 0x80, 0x00, 0x00, 0x37, 0xF6, 0x90, 0x00, 0x20,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x08, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x00, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x20,
  0x00, 0x1F, 0x8E, 0x19, 0x01, 0xE0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x0E,
  0x0F, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x1F, 0x06, 0x19, 0x81, 0x20, 0x14, 0x03, 0x8F, 0x63, 0x1C,
  0x41, 0x88, 0x31, 0x06, 0x20, 0xC4, 0x18, 0x83, 0x10, 0x63, 0x1E, 0x3D,
  0x40, 0x08, 0x01, 0x80, 0x18, 0x00, 0xFC, 0x03, 0x00, 0x1C, 0x00, 0x58,
  0x01, 0x60, 0x0C, 0x80, 0x23, 0x00, 0x8C, 0x06, 0x10, 0x18, 0x60, 0x41,
  0x83, 0x02, 0x0F, 0xFC, 0x20, 0x31, 0x80, 0x46, 0x01, 0x10, 0x06, 0xC0,
  0x0B, 0x00, 0x30, 0xFF, 0x8C, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0x6C, 0x0C, 0xFF, 0x8C, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x02, 0xC0, 0x6F, 0xF8, 0x0F, 0x83, 0x0E, 0x60, 0x24, 0x03,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x36, 0x02, 0x30, 0xE0, 0xF8, 0xFE, 0x10, 0x32,
  0x03, 0x40, 0x28, 0x05, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xA0, 0x14, 0x06, 0x81, 0x9F, 0xC0, 0xFF, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xFF, 0xF0, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xD0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x86,
  0x19, 0x81, 0xA0, 0x1C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0B, 0x03, 0x30, 0xA3, 0xE4, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xF8,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x04,
  0xFF, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F,
  0xFC, 0x3F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1C, 0x07, 0x03, 0x61, 0x8F, 0xC0,
  0xC0, 0x3E, 0x03, 0x30, 0x11, 0x81, 0x8C, 0x18, 0x61, 0x83, 0x18, 0x19,
  0x80, 0xDE, 0x06, 0xB0, 0x38, 0xC1, 0xC3, 0x0C, 0x18, 0x60, 0x63, 0x01,
  0x18, 0x0C, 0xC0, 0x36, 0x00, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFC, 0xC0, 0x7E, 0x07, 0xA0, 0x7B,
  0x0B, 0xB0, 0xB9, 0x1B, 0x99, 0x38, 0xB3, 0x8E, 0x38, 0x63, 0x84, 0x38,
  0x43, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x1D, 0x83, 0xB0, 0x72, 0x0E, 0x61, 0xC4, 0x38, 0xC7,
  0x08, 0xE1, 0x9C, 0x13, 0x83, 0x70, 0x2E, 0x07, 0xC0, 0xF8, 0x0C, 0x1F,
  0x03, 0x0C, 0x60, 0x6C, 0x02, 0xC0, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x26, 0x06, 0x30,
  0xC1, 0xF0, 0xFF, 0x90, 0x1A, 0x01, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x02, 0x80, 0xDF, 0xE2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x1F, 0x03, 0x0C, 0x60, 0x6C, 0x02, 0xC0, 0x28, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x02,
  0xC0, 0x26, 0x06, 0x30, 0xC1, 0xF0, 0x06, 0x00, 0x60, 0x03, 0xE0, 0xFF,
  0x90, 0x1A, 0x01, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x80, 0xDF,
  0xE2, 0x10, 0x43, 0x08, 0x31, 0x02, 0x20, 0x64, 0x04, 0x80, 0xD0, 0x0C,
  0x0F, 0xC1, 0x83, 0x98, 0x06, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0D, 0x00,
  0x7C, 0x02, 0x70, 0x70, 0xFE, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x50, 0x1A, 0x03,
  0x20, 0xC3, 0xF0, 0xC0, 0x0A, 0x00, 0xD8, 0x06, 0xC0, 0x22, 0x03, 0x10,
  0x18, 0xC0, 0x86, 0x04, 0x10, 0x60, 0xC3, 0x06, 0x10, 0x11, 0x80, 0xCC,
  0x06, 0x40, 0x16, 0x00, 0xF0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x14, 0x00, 0xA1, 0x85, 0x0C, 0x28, 0xE3, 0x45, 0x9A,
  0x24, 0xD1, 0x26, 0xD9, 0x26, 0x8D, 0x34, 0x69, 0xA1, 0x4F, 0x0A, 0x30,
  0x71, 0x83, 0x80, 0xC0, 0x1D, 0x80, 0x63, 0x03, 0x0C, 0x08, 0x18, 0x60,
  0x33, 0x00, 0xC8, 0x01, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x58, 0x03, 0x30,
  0x08, 0xC0, 0x61, 0x83, 0x02, 0x08, 0x0C, 0x60, 0x1B, 0x00, 0x30, 0xC0,
  0x0F, 0x00, 0x66, 0x01, 0x88, 0x0C, 0x30, 0x20, 0x61, 0x80, 0x8C, 0x03,
  0x20, 0x05, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x07, 0xFF,
  0xC0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFF, 0x03, 0x00, 0x38, 0x01, 0x60, 0x11, 0x81, 0x84,
  0x08, 0x30, 0xC0, 0x84, 0x06, 0x60, 0x16, 0x00, 0xC0, 0xFF, 0xF0, 0x4C,
  0x62, 0x10, 0x1F, 0x06, 0x18, 0xC0, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x3F,
  0xCE, 0x04, 0xC0, 0x48, 0x04, 0xC1, 0xCC, 0x14, 0x3E, 0x70, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0xC5, 0x0C, 0xC0, 0xD0, 0x0A,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0xC0, 0xD4, 0x32, 0x7C,
  0x00, 0x0F, 0x86, 0x19, 0x81, 0xA0, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x98, 0x60, 0xF8, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC7, 0xDB, 0x07, 0x40, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x03, 0x40, 0x6C, 0x1C, 0x79, 0x80, 0x1F, 0x03,
  0x0C, 0x60, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xFF, 0xFC, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x23, 0x06, 0x1F, 0x80, 0x03, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xE0, 0x00,
  0x71, 0xF8, 0x30, 0xC6, 0x04, 0x60, 0x64, 0x06, 0x40, 0x66, 0x04, 0x30,
  0xC3, 0xF0, 0x60, 0x04, 0x00, 0x60, 0x03, 0xFE, 0xC0, 0x3C, 0x01, 0xC0,
  0x14, 0x03, 0x3F, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09,
  0xF2, 0x86, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0C, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09,
  0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C,
  0x08, 0xC3, 0x0C, 0x60, 0xCC, 0x0D, 0xC0, 0xF6, 0x0C, 0x60, 0xC3, 0x0C,
  0x18, 0xC0, 0xCC, 0x06, 0xC0, 0x30, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC3, 0xFF, 0x80, 0xB9, 0xEC, 0xE3,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x10, 0x9F, 0x28, 0x6C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x1F, 0x03,
  0x0C, 0x40, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C,
  0x02, 0x40, 0x63, 0x0C, 0x1F, 0x80, 0x9F, 0x14, 0x33, 0x03, 0x40, 0x28,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0B, 0x03, 0x50, 0xC9, 0xF1,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x6C, 0x1D, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0D, 0x01, 0xB0, 0x71,
  0xE6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0xFC, 0xF8, 0x68, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x0F, 0xFE, 0x00, 0x1F, 0x86, 0x0E, 0x40, 0x24, 0x00,
  0x40, 0x07, 0x00, 0x1F, 0x80, 0x06, 0x00, 0x20, 0x03, 0xC0, 0x26, 0x06,
  0x1F, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xFC,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xC0, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0D, 0x87, 0x3E,
  0xC0, 0xC0, 0x34, 0x02, 0x40, 0x66, 0x04, 0x20, 0x42, 0x0C, 0x30, 0x81,
  0x18, 0x19, 0x00, 0x90, 0x0B, 0x00, 0xE0, 0x06, 0x00, 0x83, 0x0E, 0x0C,
  0x2C, 0x70, 0xB1, 0x42, 0x44, 0x89, 0x12, 0x24, 0xC9, 0x92, 0x24, 0x68,
  0xD1, 0xA1, 0x42, 0x85, 0x0C, 0x14, 0x30, 0x70, 0xC0, 0x36, 0x04, 0x30,
  0xC1, 0x18, 0x19, 0x00, 0xE0, 0x06, 0x00, 0xF0, 0x19, 0x01, 0x18, 0x20,
  0xC6, 0x06, 0xC0, 0x30, 0x80, 0x3C, 0x02, 0x40, 0x66, 0x04, 0x20, 0x43,
  0x0C, 0x30, 0x81, 0x18, 0x19, 0x00, 0xB0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x7F, 0xE0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0F,
  0xFE, 0x0F, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x80, 0x43, 0xE0, 0x0C, 0x01, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x80,
  0x1F, 0x1C, 0x04, 0x01, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x43, 0xF0, 0x3C, 0x09, 0x30, 0x50, 0xC6, 0x83, 0x2C, 0x0E,
  0x00,
};

const GFXglyph IBMPlexMono_Light26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 18, 16, 6, -18 },
  { 8, 6, 7, 16, 5, -19 },
  { 14, 15, 18, 16, 0, -18 },
  { 48, 13, 24, 16, 1, -21 },
  { 87, 14, 18, 16, 1, -18 },
  { 119, 14, 18, 16, 1, -18 },
  { 151, 2, 7, 16, 7, -19 },
  { 153, 7, 24, 16, 6, -20 },
  { 174, 7, 24, 16, 3, -20 },
  { 195, 13, 13, 16, 1, -14 },
  { 217, 12, 13, 16, 2, -14 },
  { 237, 3, 7, 16, 6, -3 },
  { 240, 7, 1, 16, 4, -8 },
  { 241, 3, 3, 16, 6, -3 },
  { 243, 11, 24, 16, 2, -20 },
  { 276, 12, 18, 16, 2, -18 },
  { 303, 12, 18, 16, 2, -18 },
  { 330, 12, 18, 16, 2, -18 },
  { 357, 12, 18, 16, 1, -18 },
  { 384, 13, 18, 16, 1, -18 },
  { 414, 12, 18, 16, 2, -18 },
  { 441, 12, 18, 16, 2, -18 },
  { 468, 12, 18, 16, 2, -18 },
  { 495, 12, 18, 16, 2, -18 },
  { 522, 12, 18, 16, 2, -18 },
  { 549, 3, 14, 16, 6, -14 },
  { 555, 3, 18, 16, 6, -14 },
  { 562, 11, 15, 16, 2, -15 },
  { 583, 12, 6, 16, 2, -11 },
  { 592, 11, 15, 16, 2, -15 },
  { 613, 11, 18, 16, 2, -18 },
  { 638, 11, 21, 16, 2, -18 },
  { 667, 14, 18, 16, 1, -18 },
  { 699, 12, 18, 16, 2, -18 },
  { 726, 12, 18, 16, 2, -18 },
  { 753, 11, 18, 16, 3, -18 },
  { 778, 10, 18, 16, 3, -18 },
  { 801, 11, 18, 16, 3, -18 },
  { 826, 11, 18, 16, 2, -18 },
  { 851, 11, 18, 16, 2, -18 },
  { 876, 11, 18, 16, 2, -18 },
  { 901, 10, 18, 16, 2, -18 },
  { 924, 13, 18, 16, 2, -18 },
  { 954, 11, 18, 16, 3, -18 },
  { 979, 12, 18, 16, 2, -18 },
  { 1006, 11, 18, 16, 2, -18 },
  { 1031, 12, 18, 16, 2, -18 },
  { 1058, 11, 18, 16, 3, -18 },
  { 1083, 12, 21, 16, 2, -18 },
  { 1115, 11, 18, 16, 3, -18 },
  { 1140, 13, 18, 16, 1, -18 },
  { 1170, 14, 18, 16, 1, -18 },
  { 1202, 11, 18, 16, 2, -18 },
  { 1227, 13, 18, 16, 1, -18 },
  { 1257, 13, 18, 16, 1, -18 },
  { 1287, 14, 18, 16, 1, -18 },
  { 1319, 14, 18, 16, 1, -18 },
  { 1351, 13, 18, 16, 1, -18 },
  { 1381, 7, 24, 16, 6, -20 },
  { 1402, 11, 24, 16, 2, -20 },
  { 1435, 7, 24, 16, 2, -20 },
  { 1456, 13, 10, 16, 1, -18 },
  { 1473, 12, 1, 16, 2, 3 },
  { 1475, 4, 5, 16, 5, -20 },
  { 1478, 12, 13, 16, 2, -13 },
  { 1498, 11, 19, 16, 3, -19 },
  { 1525, 11, 13, 16, 2, -13 },
  { 1543, 11, 19, 16, 2, -19 },
  { 1570, 12, 13, 16, 2, -13 },
  { 1590, 12, 19, 16, 2, -19 },
  { 1619, 12, 19, 16, 2, -14 },
  { 1648, 10, 19, 16, 3, -19 },
  { 1672, 11, 19, 16, 3, -19 },
  { 1699, 10, 24, 16, 2, -19 },
  { 1729, 12, 19, 16, 3, -19 },
  { 1758, 11, 19, 16, 2, -19 },
  { 1785, 12, 13, 16, 2, -13 },
  { 1805, 10, 13, 16, 3, -13 },
  { 1822, 12, 13, 16, 2, -13 },
  { 1842, 11, 18, 16, 3, -13 },
  { 1867, 11, 18, 16, 2, -13 },
  { 1892, 13, 13, 16, 2, -13 },
  { 1914, 12, 13, 16, 2, -13 },
  { 1934, 13, 18, 16, 1, -18 },
  { 1964, 10, 13, 16, 3, -13 },
  { 1981, 12, 13, 16, 2, -13 },
  { 2001, 14, 13, 16, 1, -13 },
  { 2024, 12, 13, 16, 2, -13 },
  { 2044, 12, 18, 16, 2, -13 },
  { 2071, 11, 13, 16, 2, -13 },
  { 2089, 10, 24, 16, 3, -20 },
  { 2119, 1, 24, 16, 7, -20 },
  { 2122, 10, 24, 16, 3, -20 },
  { 2152, 13, 5, 16, 1, -10 },
};

const GFXfont IBMPlexMono_Light26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_LIGHT26PT7B_H_
