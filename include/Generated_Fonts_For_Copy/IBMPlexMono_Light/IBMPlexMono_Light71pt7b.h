#ifndef _IBMPLEXMONO_LIGHT71PT7B_H_
#define _IBMPLEXMONO_LIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light71pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x3E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE3, 0xCF, 0xF8, 0x0F, 0xC0, 0xF0, 0x7F, 0x07, 0xE0, 0x3C,
  0x07, 0xE1, 0xF0, 0x0F, 0x00, 0xFC, 0xF8, 0x03, 0xC0, 0x1E, 0x3C, 0x00,
  0xF0, 0x03, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x03, 0xC0,
  0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xC3, 0xFC, 0x00,
  0x00, 0xF0, 0x3F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0xC0, 0x03,
  0xC0, 0x0F, 0x78, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x3C, 0x01, 0xF7, 0xE0,
  0x0F, 0x00, 0xF8, 0xFC, 0x03, 0xC0, 0x7E, 0x1F, 0xC0, 0xF0, 0x7F, 0x03,
  0xFE, 0x3C, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x0F, 0xFE, 0x00, 0x00,
  0x78, 0x7F, 0xFE, 0x00, 0x00, 0xF1, 0xF0, 0x3E, 0x00, 0x03, 0xC3, 0xC0,
  0x3E, 0x00, 0x07, 0x8F, 0x00, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x78, 0x00, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0x07, 0x83, 0x80, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x03, 0x80,
  0x3C, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0x80, 0x78, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x03, 0xFF, 0xF0,
  0x20, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x00, 0x70, 0xF0, 0x00, 0xE0,
  0x00, 0xE1, 0xC0, 0x01, 0xE0, 0x03, 0xC7, 0x80, 0x01, 0xC0, 0x07, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0xF0, 0x00, 0x03,
  0xFF, 0xE1, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x7C, 0xFC, 0x00, 0xFF, 0x83, 0xE1, 0xF8, 0x03,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x0F, 0x80, 0xE0, 0x1F, 0x00, 0x1F, 0x03, 0x80, 0x78, 0x00, 0x3E, 0x0E,
  0x01, 0xE0, 0x00, 0x7C, 0x38, 0x0F, 0x80, 0x01, 0xF0, 0xE0, 0x3E, 0x00,
  0x03, 0xE7, 0x80, 0xF0, 0x00, 0x07, 0xDE, 0x03, 0xC0, 0x00, 0x0F, 0xF0,
  0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x1F, 0x00, 0x00, 0x77, 0xC0, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0xFE, 0x00,
  0x1E, 0x1F, 0x01, 0xFE, 0x03, 0xF0, 0x3E, 0x03, 0xFF, 0xFF, 0x80, 0x7C,
  0x07, 0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x02, 0x78,
  0x00, 0xF0, 0x00, 0xF7, 0xF0, 0x0F, 0x00, 0x7F, 0xFF, 0xE0, 0xF0, 0x3F,
  0xF3, 0xFF, 0xCF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x7F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0x3F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00,
  0x1F, 0x8F, 0x00, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x07, 0xE0, 0xF0, 0x00,
  0x03, 0xF0, 0x3C, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x00, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07, 0x81, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xFC, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x0C, 0x00,
  0x00, 0x3E, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x20, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xFC, 0x00, 0x1C, 0x1F,
  0xFF, 0x00, 0x1C, 0x7F, 0xFF, 0xC0, 0x1C, 0xFF, 0xFF, 0xE0, 0x1D, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7C, 0x04, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x10, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0x3C, 0x1F,
  0xFF, 0x00, 0x3C, 0x7F, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xE0, 0x79, 0xF0,
  0x0F, 0xF8, 0x7B, 0xC0, 0x01, 0xF8, 0x7B, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x2F, 0x3F,
  0x00, 0x00, 0x6F, 0x1F, 0xC0, 0x01, 0xDF, 0x0F, 0xF0, 0x07, 0x9E, 0x07,
  0xFF, 0xFF, 0x1E, 0x03, 0xFF, 0xFE, 0x1E, 0x00, 0xFF, 0xFC, 0x3E, 0x00,
  0x1F, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x0F, 0x83, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x1F, 0x83, 0xBC, 0x00, 0xFF, 0xC7, 0x78, 0x03, 0xFF, 0xCE,
  0xF0, 0x0F, 0xFF, 0x9D, 0xC0, 0x3F, 0x03, 0xBB, 0x80, 0x7C, 0x01, 0x77,
  0x00, 0xF0, 0x01, 0xFE, 0x03, 0xC0, 0x03, 0xFC, 0x07, 0x80, 0x03, 0xF8,
  0x0F, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x1F, 0xC0,
  0x70, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0xFE, 0x07,
  0x80, 0x01, 0xFC, 0x07, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x07, 0xF0, 0x1C,
  0x00, 0x0F, 0xE0, 0x38, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3F, 0x80, 0xF0,
  0x00, 0x7F, 0x01, 0xE0, 0x01, 0xEE, 0x01, 0xE0, 0x03, 0xDC, 0x03, 0xE0,
  0x0B, 0xB8, 0x03, 0xF0, 0xF7, 0x78, 0x07, 0xFF, 0xCE, 0xF0, 0x07, 0xFF,
  0x9D, 0xE0, 0x07, 0xFC, 0x3B, 0xC0, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x00,
  0x01, 0xFC, 0x1E, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0xFC, 0x78, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x83,
  0xC0, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0xD3, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x3E, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x07, 0xF8, 0x1E,
  0x00, 0x01, 0xF8, 0x3C, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x01, 0xF8, 0xF0,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x0F, 0xC7, 0x80, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xFC, 0x1E, 0x00,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBC,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01, 0xD3,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF7, 0x80, 0x03, 0xFF, 0xFB, 0xC0, 0x01,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x06, 0xF0,
  0xFC, 0x00, 0x07, 0x78, 0x3F, 0x00, 0x07, 0x3C, 0x0F, 0xF0, 0x1F, 0x9E,
  0x03, 0xFF, 0xFF, 0x8F, 0x00, 0xFF, 0xFF, 0x87, 0x80, 0x1F, 0xFF, 0x03,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF1, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC3, 0xF0,
  0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x07,
  0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x83,
  0xF0, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x00, 0xF1,
  0xFF, 0x80, 0x00, 0x79, 0xF3, 0xE0, 0x00, 0x3D, 0xF1, 0xF0, 0x00, 0x1F,
  0xF0, 0x7C, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x03,
  0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xF7, 0x80, 0x00, 0xFF, 0xF7, 0x80, 0x00, 0xFF, 0xF3, 0x80, 0x01,
  0xEF, 0xF3, 0xC0, 0x01, 0xEF, 0xF3, 0xC0, 0x01, 0xCF, 0xF1, 0xE0, 0x03,
  0xCF, 0xF1, 0xE0, 0x03, 0xCF, 0xF0, 0xE0, 0x07, 0x8F, 0xF0, 0xF0, 0x07,
  0x8F, 0xF0, 0xF0, 0x07, 0x0F, 0xF0, 0x78, 0x0F, 0x0F, 0xF0, 0x78, 0x0E,
  0x0F, 0xF0, 0x38, 0x1E, 0x0F, 0xF0, 0x3C, 0x1E, 0x0F, 0xF0, 0x1C, 0x3C,
  0x0F, 0xF0, 0x1E, 0x3C, 0x0F, 0xF0, 0x1E, 0x38, 0x0F, 0xF0, 0x0F, 0x78,
  0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x0F, 0xF0, 0x03, 0xC0,
  0x0F, 0xF0, 0x01, 0xC0, 0x0F, 0xF0, 0x01, 0x80, 0x0F, 0xF0, 0x00, 0x80,
  0x0F, 0xF0, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x01, 0xFD,
  0xF0, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0x7F, 0x1E,
  0x00, 0x01, 0xFC, 0x78, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x1F, 0xC3, 0xC0,
  0x00, 0x7F, 0x0F, 0x80, 0x01, 0xFC, 0x1E, 0x00, 0x07, 0xF0, 0x7C, 0x00,
  0x1F, 0xC0, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xFC, 0x07, 0x80, 0x07,
  0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xFC,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x00,
  0x3C, 0x01, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x01, 0xE0, 0x1F, 0xC0, 0x07,
  0x80, 0x7F, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x78,
  0x1F, 0xC0, 0x01, 0xE0, 0x7F, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x0F, 0x07,
  0xF0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x78, 0x7F, 0x00, 0x01, 0xF1, 0xFC,
  0x00, 0x03, 0xC7, 0xF0, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x1E, 0x7F, 0x00,
  0x00, 0x79, 0xFC, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x00,
  0x7F, 0x1E, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7E, 0x78,
  0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0x00, 0x7F, 0x1E, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x7E, 0x78, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1,
  0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x30, 0x00, 0x00, 0x07, 0xDC, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x00, 0x0E, 0x78, 0x00, 0xF8, 0x00, 0xE7, 0x80, 0x0F, 0x80,
  0x1E, 0x38, 0x01, 0xF8, 0x01, 0xE3, 0x80, 0x1F, 0xC0, 0x1E, 0x38, 0x01,
  0xFC, 0x01, 0xE3, 0xC0, 0x1D, 0xC0, 0x1E, 0x3C, 0x03, 0xDC, 0x01, 0xE3,
  0xC0, 0x3D, 0xE0, 0x1E, 0x3C, 0x03, 0x9E, 0x01, 0xE3, 0xC0, 0x38, 0xE0,
  0x1C, 0x3C, 0x07, 0x8E, 0x01, 0xC3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x07,
  0x0F, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x3C, 0x1C, 0x0F, 0x07, 0x03, 0xC1,
  0xC0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78,
  0x3C, 0x1E, 0x1E, 0x03, 0x83, 0xC1, 0xE1, 0xE0, 0x3C, 0x3C, 0x1E, 0x1C,
  0x03, 0xC3, 0xC1, 0xE1, 0xC0, 0x3C, 0x38, 0x1E, 0x3C, 0x01, 0xC3, 0x81,
  0xE3, 0xC0, 0x1E, 0x38, 0x1E, 0x38, 0x01, 0xE3, 0x81, 0xE3, 0x80, 0x1E,
  0x78, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0xE7, 0x80, 0x0F, 0x78, 0x0E, 0x78,
  0x00, 0xF7, 0x80, 0xE7, 0x00, 0x0F, 0x78, 0x0F, 0xF0, 0x00, 0x77, 0x80,
  0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x0F, 0x90, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10,
  0x1C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x00,
  0x3C, 0x07, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0E, 0xF0,
  0x0F, 0xE0, 0x1F, 0xBF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x1F,
  0xE0, 0x03, 0xC1, 0xFF, 0xF0, 0x0F, 0x1F, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF,
  0xE0, 0xF7, 0xC0, 0x3F, 0xC3, 0xDC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF8, 0xF7, 0x00,
  0x0F, 0xC3, 0xDF, 0x00, 0xFF, 0x0F, 0x3F, 0xFF, 0xF8, 0x3C, 0x7F, 0xFF,
  0x80, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x47, 0xC0, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE0, 0x7F, 0x80, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x3C, 0x03, 0xFF, 0xE0, 0xF0, 0x3F,
  0xFF, 0xC3, 0xC1, 0xFF, 0xFF, 0x8F, 0x0F, 0xF0, 0x1F, 0x3C, 0x7F, 0x00,
  0x0E, 0xF1, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x3F, 0x3C, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xBC, 0x3F, 0xC0, 0x7C, 0xF0, 0x7F,
  0xFF, 0xE3, 0xC0, 0xFF, 0xFF, 0x0F, 0x00, 0xFF, 0xF8, 0x3C, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x08, 0x3E, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0xC0, 0x00, 0x1F,
  0xFF, 0xB0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x01, 0xF3,
  0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x01, 0xE7, 0xE0, 0x00,
  0x01, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1F, 0xE0, 0x1E, 0x0F, 0xFF, 0x03,
  0xC7, 0xFF, 0xF8, 0x79, 0xFF, 0xFF, 0x8F, 0x7C, 0x07, 0xF9, 0xEE, 0x00,
  0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7E, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x3F, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0xFF,
  0x00, 0x00, 0xF1, 0xFF, 0x00, 0x00, 0xF3, 0xEF, 0x80, 0x00, 0xF7, 0xC7,
  0xC0, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFE, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x7C, 0x00, 0xFC, 0x3C, 0x7F, 0xC0, 0xFF,
  0xCF, 0x3F, 0xF8, 0x7F, 0xF3, 0xCF, 0xFF, 0x3F, 0xFE, 0xF7, 0x07, 0xCE,
  0x0F, 0xBD, 0x00, 0xF6, 0x01, 0xFF, 0x80, 0x1D, 0x00, 0x3F, 0xE0, 0x07,
  0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00,
  0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F,
  0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00,
  0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0,
  0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03,
  0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80,
  0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x1F, 0xE0, 0x1E, 0x0F, 0xFF,
  0x03, 0xC7, 0xFF, 0xF8, 0x79, 0xFF, 0xFF, 0x8F, 0x7C, 0x07, 0xF9, 0xEE,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x07,
  0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xF0, 0x1F, 0xE0, 0x03, 0xC1,
  0xFF, 0xF0, 0x0F, 0x1F, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xE0, 0xF7, 0xC0,
  0x3F, 0xC3, 0xDC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF8, 0xF7, 0x00, 0x0F, 0xC3, 0xDF,
  0x00, 0xFF, 0x0F, 0x3F, 0xFF, 0xF8, 0x3C, 0x7F, 0xFF, 0x80, 0xF0, 0x7F,
  0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3C, 0x03,
  0xFF, 0xE0, 0xF0, 0x3F, 0xFF, 0xC3, 0xC1, 0xFF, 0xFF, 0x8F, 0x0F, 0xF0,
  0x1F, 0x3C, 0x7F, 0x00, 0x0E, 0xF1, 0xF0, 0x00, 0x1F, 0xCF, 0x80, 0x00,
  0x3F, 0x3C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xBC, 0x3F,
  0xC0, 0x7C, 0xF0, 0x7F, 0xFF, 0xE3, 0xC0, 0xFF, 0xFF, 0x0F, 0x00, 0xFF,
  0xF8, 0x3C, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x1F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x18, 0x3E, 0x00, 0x00, 0x10, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x20, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x1E, 0xFE, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x7C, 0x1F, 0xF0, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x6F, 0x3F, 0x00, 0x0E, 0xF1, 0xFC, 0x03,
  0xCF, 0x0F, 0xFF, 0xF8, 0xF0, 0x7F, 0xFF, 0x0F, 0x03, 0xFF, 0xE0, 0xF0,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x0F,
  0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1D,
  0xC0, 0x01, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0xC0, 0x03, 0xDE, 0x00, 0x3F,
  0x80, 0x0F, 0x78, 0x00, 0xEE, 0x00, 0x3D, 0xE0, 0x03, 0xB8, 0x00, 0xE7,
  0x80, 0x0E, 0xE0, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x78, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0xC0, 0x1C, 0x70, 0x07, 0x8F,
  0x00, 0xF1, 0xC0, 0x1C, 0x3C, 0x03, 0x87, 0x80, 0x70, 0x70, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0F, 0x07, 0x00, 0xE0, 0xE0, 0x3C, 0x1E,
  0x07, 0x03, 0x80, 0xF0, 0x78, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x0F, 0x01, 0xC0, 0xE0, 0x38,
  0x38, 0x07, 0x87, 0x80, 0xE0, 0xE0, 0x0E, 0x1E, 0x03, 0xC3, 0x80, 0x38,
  0x70, 0x0F, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x71,
  0xC0, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x07, 0x1C, 0x00, 0x73,
  0xC0, 0x1E, 0xF0, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0x07, 0xB8, 0x00, 0xEE,
  0x00, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x01, 0xF8,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xC0, 0xFF, 0x80, 0x00, 0x3C, 0x3F, 0xF8, 0x00, 0x07, 0x07,
  0xFF, 0x80, 0x00, 0xE1, 0xF1, 0xF8, 0x00, 0x1C, 0x7C, 0x0F, 0x80, 0x07,
  0x8F, 0x00, 0xF8, 0x00, 0xE3, 0xC0, 0x0F, 0x80, 0x3C, 0x78, 0x00, 0xF8,
  0x07, 0x8E, 0x00, 0x1F, 0x81, 0xE1, 0xC0, 0x01, 0xF8, 0x7C, 0x78, 0x00,
  0x1F, 0xFF, 0x0F, 0x00, 0x01, 0xFF, 0xC1, 0xC0, 0x00, 0x1F, 0xF0, 0x18,
  0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Light71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 8, 51, 43, 17, -50 },
  { 52, 15, 19, 43, 14, -53 },
  { 88, 40, 50, 43, 1, -50 },
  { 338, 34, 65, 43, 4, -57 },
  { 615, 39, 51, 43, 2, -50 },
  { 864, 38, 51, 43, 2, -50 },
  { 1107, 4, 19, 43, 19, -53 },
  { 1117, 19, 64, 43, 15, -54 },
  { 1269, 19, 64, 43, 8, -54 },
  { 1421, 36, 35, 43, 3, -39 },
  { 1579, 34, 34, 43, 4, -39 },
  { 1724, 11, 19, 43, 15, -8 },
  { 1751, 20, 4, 43, 11, -24 },
  { 1761, 8, 8, 43, 17, -7 },
  { 1769, 29, 64, 43, 7, -54 },
  { 2001, 34, 51, 43, 4, -50 },
  { 2218, 34, 50, 43, 5, -50 },
  { 2431, 33, 50, 43, 5, -50 },
  { 2638, 32, 51, 43, 4, -50 },
  { 2842, 37, 50, 43, 3, -50 },
  { 3074, 32, 51, 43, 5, -50 },
  { 3278, 32, 51, 43, 5, -50 },
  { 3482, 32, 50, 43, 5, -50 },
  { 3682, 34, 51, 43, 4, -50 },
  { 3899, 32, 50, 43, 5, -50 },
  { 4099, 8, 38, 43, 17, -37 },
  { 4137, 11, 48, 43, 15, -37 },
  { 4203, 31, 40, 43, 6, -42 },
  { 4358, 34, 18, 43, 4, -31 },
  { 4435, 31, 40, 43, 6, -42 },
  { 4590, 30, 51, 43, 6, -50 },
  { 4782, 31, 58, 43, 5, -50 },
  { 5007, 37, 50, 43, 3, -50 },
  { 5239, 31, 50, 43, 7, -50 },
  { 5433, 33, 51, 43, 5, -50 },
  { 5644, 31, 50, 43, 7, -50 },
  { 5838, 30, 50, 43, 7, -50 },
  { 6026, 30, 50, 43, 7, -50 },
  { 6214, 33, 51, 43, 4, -50 },
  { 6425, 30, 50, 43, 6, -50 },
  { 6613, 30, 50, 43, 6, -50 },
  { 6801, 28, 51, 43, 6, -50 },
  { 6980, 33, 50, 43, 7, -50 },
  { 7187, 29, 50, 43, 9, -50 },
  { 7369, 32, 50, 43, 5, -50 },
  { 7569, 30, 50, 43, 6, -50 },
  { 7757, 34, 51, 43, 4, -50 },
  { 7974, 31, 50, 43, 7, -50 },
  { 8168, 34, 62, 43, 4, -50 },
  { 8432, 31, 50, 43, 7, -50 },
  { 8626, 34, 51, 43, 4, -50 },
  { 8843, 38, 50, 43, 2, -50 },
  { 9081, 30, 51, 43, 6, -50 },
  { 9273, 37, 50, 43, 3, -50 },
  { 9505, 36, 50, 43, 3, -50 },
  { 9730, 38, 50, 43, 2, -50 },
  { 9968, 40, 50, 43, 1, -50 },
  { 10218, 36, 50, 43, 3, -50 },
  { 10443, 19, 64, 43, 17, -54 },
  { 10595, 29, 64, 43, 7, -54 },
  { 10827, 18, 64, 43, 7, -54 },
  { 10971, 35, 28, 43, 4, -50 },
  { 11094, 34, 4, 43, 4, 7 },
  { 11111, 10, 13, 43, 14, -55 },
  { 11128, 34, 38, 43, 5, -37 },
  { 11290, 30, 54, 43, 8, -53 },
  { 11493, 29, 38, 43, 7, -37 },
  { 11631, 30, 54, 43, 5, -53 },
  { 11834, 32, 38, 43, 5, -37 },
  { 11986, 33, 53, 43, 5, -53 },
  { 12205, 34, 56, 43, 5, -41 },
  { 12443, 27, 53, 43, 8, -53 },
  { 12622, 30, 54, 43, 8, -54 },
  { 12825, 25, 68, 43, 7, -54 },
  { 13038, 32, 53, 43, 8, -53 },
  { 13250, 31, 53, 43, 6, -53 },
  { 13456, 34, 37, 43, 4, -37 },
  { 13614, 27, 37, 43, 8, -37 },
  { 13739, 32, 38, 43, 5, -37 },
  { 13891, 30, 51, 43, 8, -37 },
  { 14083, 30, 51, 43, 5, -37 },
  { 14275, 34, 37, 43, 6, -37 },
  { 14433, 32, 38, 43, 5, -37 },
  { 14585, 34, 50, 43, 3, -50 },
  { 14798, 28, 38, 43, 7, -37 },
  { 14931, 32, 37, 43, 5, -37 },
  { 15079, 38, 37, 43, 2, -37 },
  { 15255, 33, 37, 43, 5, -37 },
  { 15408, 33, 51, 43, 5, -37 },
  { 15619, 29, 37, 43, 7, -37 },
  { 15754, 27, 64, 43, 8, -54 },
  { 15970, 3, 64, 43, 20, -54 },
  { 15994, 27, 64, 43, 8, -54 },
  { 16210, 35, 15, 43, 4, -29 },
};

const GFXfont IBMPlexMono_Light71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_LIGHT71PT7B_H_
