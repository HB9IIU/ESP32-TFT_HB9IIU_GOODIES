#ifndef _IBMPLEXMONO_LIGHT32PT7B_H_
#define _IBMPLEXMONO_LIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light32pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x69, 0x24, 0x90, 0x00, 0x7F, 0xC0, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x21, 0x81, 0xF8, 0x7F,
  0x7E, 0x1F, 0xC1, 0x86, 0x00, 0x61, 0x00, 0x10, 0x40, 0x04, 0x30, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF0, 0x30, 0xC0, 0x0C, 0x20, 0x02, 0x18, 0x00, 0x86,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x10, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x7F, 0x03, 0xFF, 0x8F, 0x33, 0x98, 0x63, 0xB0, 0xC2, 0xC1,
  0x80, 0x83, 0x01, 0x86, 0x03, 0x8C, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0xCE, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x3C, 0x18, 0x7C,
  0x31, 0xDE, 0x67, 0x1F, 0xFC, 0x0F, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x3E, 0x00, 0xDF, 0xC0, 0x6E, 0x30, 0x33, 0x06, 0x0C, 0x81, 0x86,
  0x20, 0x61, 0x08, 0x18, 0xC3, 0x06, 0x20, 0xE3, 0x18, 0x1F, 0xC4, 0x03,
  0xE2, 0x00, 0x00, 0x78, 0x06, 0x7F, 0x03, 0x18, 0x60, 0xCC, 0x18, 0x63,
  0x02, 0x10, 0xC0, 0x8C, 0x30, 0x22, 0x0C, 0x19, 0x81, 0x86, 0x40, 0x7F,
  0x30, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x06, 0x1C, 0x06, 0x03, 0x03,
  0x02, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x07, 0x81, 0xE7, 0xE0, 0xF6, 0x38, 0x43, 0x0E, 0x63, 0x03, 0xB1, 0x80,
  0xF8, 0xC0, 0x38, 0x60, 0x0C, 0x38, 0x07, 0x0E, 0x0C, 0xC3, 0xFC, 0x70,
  0xFC, 0x1C, 0xFF, 0xFF, 0xC0, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x20,
  0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x02,
  0x04, 0x0B, 0xE2, 0x3E, 0x3F, 0xF8, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xD8,
  0x00, 0xC6, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x60, 0x30, 0x20, 0x08, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x7F, 0xFF, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x7B, 0x9C, 0xC6, 0x73, 0x18, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x0E, 0x1E, 0x1C,
  0x3C, 0x38, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x19,
  0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x0E, 0x80, 0x1C, 0x80, 0x38, 0x80, 0x70, 0x80, 0xE0, 0x80, 0x40, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6,
  0x00, 0xD8, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0,
  0x7F, 0xC3, 0x83, 0x98, 0x07, 0x40, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x3F, 0x80, 0xFE, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0xDC, 0x0E, 0x3F, 0xF0, 0x3F,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1A, 0x00, 0x19, 0x00, 0x08, 0x80,
  0x0C, 0x40, 0x0C, 0x20, 0x04, 0x10, 0x06, 0x08, 0x06, 0x04, 0x02, 0x02,
  0x02, 0x01, 0x03, 0x00, 0x81, 0x00, 0x41, 0x00, 0x21, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x3F, 0xFC, 0x7F, 0xF8, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x67, 0xE0, 0xDF, 0xF1, 0xE0, 0xE3, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x80, 0x1B, 0x80, 0x31,
  0xC1, 0xC1, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x63, 0xE0, 0xDF,
  0xF1, 0xE0, 0xF3, 0x00, 0x6E, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x60, 0x06, 0xC0, 0x19, 0x80, 0x31, 0xC1, 0xC1, 0xFF, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x16, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3,
  0x00, 0x66, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0x30, 0x06, 0x60, 0x0C, 0x70,
  0x70, 0x3F, 0xC0, 0xFF, 0x83, 0x01, 0xCC, 0x01, 0xB0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3B, 0xC0, 0xE3, 0xFF, 0x81, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0x66, 0x00, 0xCC, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x06, 0xC0, 0x1D, 0xC0, 0x79, 0xC1, 0xB1, 0xFE,
  0xC1, 0xF9, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x73, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xCE, 0x63,
  0x39, 0x8C, 0x60, 0x00, 0x08, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x18, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x18, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0,
  0x3C, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x01, 0xF0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x8C,
  0x07, 0x60, 0x0D, 0x80, 0x36, 0x1E, 0x50, 0xFD, 0x43, 0x0F, 0x18, 0x1C,
  0x60, 0x71, 0x81, 0xC6, 0x07, 0x18, 0x1C, 0x60, 0x71, 0x81, 0xC7, 0x0D,
  0x0F, 0xD4, 0x1F, 0x58, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x58, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x18, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x7F, 0xF8,
  0x7F, 0xFC, 0x30, 0x06, 0x18, 0x03, 0x9C, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x36, 0x00, 0x0C, 0xFF, 0xC3, 0xFF, 0xCC, 0x07, 0x30, 0x06, 0xC0, 0x1B,
  0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xCF, 0xFE, 0x3F, 0xFC,
  0xC0, 0x3B, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x0E, 0xFF, 0xF3, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xE0, 0x70, 0x61,
  0x80, 0x67, 0x00, 0x6C, 0x00, 0x98, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x04, 0xE0, 0x0C, 0xC0, 0x30, 0xE0, 0xC0, 0xFF, 0x00, 0xFC, 0x00,
  0xFF, 0x83, 0xFF, 0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x1C, 0xFF,
  0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xBF, 0xFE,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0xFF, 0xBF, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x00, 0xB0, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x1D, 0xC0, 0x39, 0xC1, 0xB1, 0xFE,
  0x60, 0xF8, 0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x76, 0x0E, 0x3F, 0xC1, 0xF8,
  0xC0, 0x0F, 0x80, 0x3B, 0x00, 0xE6, 0x01, 0x8C, 0x06, 0x18, 0x18, 0x30,
  0x60, 0x61, 0x80, 0xC7, 0x01, 0x9C, 0x03, 0x7C, 0x06, 0xD8, 0x0F, 0x18,
  0x1C, 0x38, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x71, 0x80, 0x63, 0x00, 0x66,
  0x00, 0xEC, 0x00, 0xD8, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E,
  0x80, 0xFD, 0x83, 0x7B, 0x06, 0xF3, 0x09, 0xE6, 0x33, 0xC4, 0x47, 0x8D,
  0x8F, 0x0B, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x20, 0xF0, 0x41, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1D, 0x80, 0xEC, 0x07, 0x30, 0x39,
  0x81, 0xCC, 0x0E, 0x30, 0x71, 0x83, 0x86, 0x1C, 0x30, 0xE0, 0xC7, 0x06,
  0x38, 0x19, 0xC0, 0xCE, 0x03, 0x70, 0x1B, 0x80, 0x7C, 0x03, 0xE0, 0x1C,
  0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x19, 0xC0, 0x71,
  0xC1, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xCC, 0x03, 0xB0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x03, 0xBF, 0xFC, 0xFF, 0xE3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x19, 0xC0, 0x71, 0xC1, 0xC1, 0xFF,
  0x00, 0xFC, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xF8, 0x03, 0xF0,
  0xFF, 0xE3, 0xFF, 0xCC, 0x03, 0xB0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xBF, 0xFC, 0xFF, 0xC3, 0x06,
  0x0C, 0x18, 0x30, 0x30, 0xC0, 0xE3, 0x01, 0x8C, 0x03, 0x30, 0x0E, 0xC0,
  0x1B, 0x00, 0x30, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0, 0x73, 0x00, 0x7C, 0x00,
  0x58, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x3B, 0xC0, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x0E, 0xE0, 0xE3, 0xFF, 0x0F, 0xE0, 0xE0, 0x01, 0xB0, 0x01,
  0x98, 0x00, 0xCE, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x30,
  0x08, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC1, 0x80,
  0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x02, 0x30, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xA0, 0x00, 0xD0,
  0x00, 0x68, 0x00, 0x36, 0x00, 0x13, 0x00, 0x09, 0x87, 0x04, 0xC3, 0x86,
  0x61, 0x43, 0x30, 0xB1, 0x98, 0xD8, 0xCC, 0x6C, 0x66, 0x32, 0x31, 0x11,
  0x98, 0x98, 0xCC, 0x4C, 0x64, 0x36, 0x12, 0x1A, 0x0D, 0x0F, 0x06, 0x87,
  0x83, 0xC3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x03, 0xB8, 0x01, 0x8C, 0x01,
  0x83, 0x01, 0xC1, 0xC0, 0xC0, 0x60, 0xC0, 0x18, 0x60, 0x0E, 0x60, 0x03,
  0x60, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x36, 0x00, 0x1B, 0x80,
  0x18, 0xC0, 0x18, 0x30, 0x0C, 0x1C, 0x0C, 0x06, 0x0E, 0x01, 0x86, 0x00,
  0xC6, 0x00, 0x37, 0x00, 0x0C, 0xC0, 0x01, 0xD8, 0x00, 0xE6, 0x00, 0x30,
  0xC0, 0x18, 0x38, 0x06, 0x06, 0x03, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x06,
  0x30, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0x07,
  0x00, 0x1B, 0x00, 0x23, 0x00, 0xC6, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x0C,
  0x30, 0x08, 0xC0, 0x19, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFC, 0x47, 0x18, 0x61, 0x0C, 0x0F, 0xC0, 0x7F, 0xC1, 0xC1, 0xC2,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x0F, 0xFC, 0x3F, 0xF8, 0xE0,
  0x33, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x07, 0x1C, 0x16, 0x1F, 0xEF,
  0x1F, 0x0E, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x31, 0xF0, 0xCF, 0xF3, 0x41, 0xEE, 0x01, 0xB0, 0x06, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x06, 0xE0, 0x1B, 0x41, 0xEC, 0xFF, 0x31, 0xF0, 0x0F, 0xC0, 0xFF, 0x0E,
  0x0C, 0xC0, 0x36, 0x01, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0xB0, 0x0C, 0xE0, 0xC3, 0xFC, 0x0F, 0xC0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC3, 0xE3, 0x1F, 0xEC, 0xE0, 0xB6, 0x01, 0xD8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x03, 0x60,
  0x1C, 0xE0, 0xB1, 0xFE, 0xC3, 0xE3, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE1,
  0x80, 0x66, 0x00, 0xCC, 0x00, 0x90, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x46, 0x01, 0x8E, 0x0E, 0x0F, 0xF8,
  0x07, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x1F, 0xFF, 0xBF, 0xFF, 0x00,
  0x1F, 0x00, 0x1F, 0x07, 0xD0, 0x1F, 0xF0, 0x38, 0x38, 0x30, 0x18, 0x30,
  0x0C, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x38, 0x38, 0x1F, 0xF0, 0x0F,
  0xC0, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x20,
  0x06, 0x40, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x70, 0x0E, 0x3F, 0xFC, 0x1F,
  0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0xF8, 0xCF, 0xE6, 0x83, 0xB8, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x06, 0xC0, 0x73, 0x03, 0x8C, 0x1C, 0x30, 0xE0, 0xC7, 0x03,
  0x30, 0x0D, 0xE0, 0x3D, 0xC0, 0xE3, 0x03, 0x06, 0x0C, 0x0C, 0x30, 0x38,
  0xC0, 0x73, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xDE, 0x3D, 0xFC, 0xFF, 0x8D, 0x1E, 0x0C, 0x3C, 0x18, 0x78, 0x20,
  0x70, 0x40, 0xE0, 0x81, 0xC1, 0x03, 0x82, 0x07, 0x04, 0x0E, 0x08, 0x1C,
  0x10, 0x38, 0x20, 0x70, 0x40, 0xE0, 0x81, 0xC1, 0x02, 0xC7, 0xC6, 0x7F,
  0x34, 0x1D, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x18, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x00,
  0x90, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x26,
  0x00, 0xCE, 0x03, 0x8E, 0x0E, 0x0F, 0xF8, 0x07, 0xE0, 0xC7, 0xC3, 0x3F,
  0xCD, 0x07, 0xB8, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1B, 0x80, 0x6D, 0x07, 0xB3,
  0xFC, 0xC7, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0x8C, 0x7F, 0xB3, 0x82, 0xD8, 0x07, 0x60, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60,
  0x0D, 0x80, 0x73, 0x82, 0xC7, 0xFB, 0x0F, 0x8C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0x3F, 0xFF, 0x7F, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xF0, 0xE0, 0x73, 0x00,
  0x46, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x6C, 0x01, 0xBE, 0x07, 0x1F, 0xFC, 0x0F,
  0xE0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xB0, 0x1D, 0xC1, 0xE7, 0xFB, 0x1F,
  0x98, 0xC0, 0x06, 0xC0, 0x19, 0x80, 0x31, 0x00, 0x63, 0x01, 0x86, 0x03,
  0x04, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x18, 0x40, 0x31, 0x80, 0x23, 0x00,
  0x64, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xC0, 0x03, 0x80, 0xC1, 0xC1, 0xE0,
  0xE0, 0xF0, 0x50, 0x68, 0x28, 0x34, 0x16, 0x13, 0x1B, 0x09, 0x8C, 0x84,
  0xC4, 0x46, 0x62, 0x33, 0x13, 0x19, 0x89, 0x84, 0x84, 0x82, 0x43, 0x41,
  0x21, 0xA0, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x18, 0x0C, 0x00, 0xE0, 0x0E,
  0xE0, 0x18, 0xC0, 0x60, 0xC1, 0x80, 0xC7, 0x01, 0xCC, 0x01, 0xB0, 0x01,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x63, 0x00, 0xC7, 0x03, 0x06,
  0x0C, 0x06, 0x38, 0x06, 0xE0, 0x0E, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x31,
  0x00, 0x63, 0x01, 0x86, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x08, 0x30, 0x18,
  0xC0, 0x31, 0x80, 0x32, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xC1, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x03, 0x00, 0x38, 0x7F, 0x03, 0xFC, 0x00, 0x70, 0x01, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xFC, 0x0F, 0xE1, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x3F, 0xC1, 0xFE, 0x00, 0x3C, 0x02, 0xFC, 0x05, 0x9C, 0x1E,
  0x1C, 0x3C, 0x1C, 0xD0, 0x1F, 0xA0, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Light32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 3, 22, 19, 8, -22 },
  { 10, 7, 9, 19, 6, -24 },
  { 18, 18, 22, 19, 1, -22 },
  { 68, 15, 28, 19, 2, -25 },
  { 121, 18, 22, 19, 1, -22 },
  { 171, 17, 22, 19, 1, -22 },
  { 218, 2, 9, 19, 9, -24 },
  { 221, 8, 28, 19, 7, -24 },
  { 249, 8, 28, 19, 4, -24 },
  { 277, 17, 16, 19, 1, -18 },
  { 311, 15, 16, 19, 2, -18 },
  { 341, 5, 9, 19, 7, -4 },
  { 347, 9, 2, 19, 5, -11 },
  { 350, 3, 3, 19, 8, -3 },
  { 352, 13, 28, 19, 3, -24 },
  { 398, 15, 22, 19, 2, -22 },
  { 440, 16, 22, 19, 2, -22 },
  { 484, 15, 22, 19, 2, -22 },
  { 526, 14, 22, 19, 2, -22 },
  { 565, 17, 22, 19, 1, -22 },
  { 612, 15, 22, 19, 2, -22 },
  { 654, 15, 22, 19, 2, -22 },
  { 696, 15, 22, 19, 2, -22 },
  { 738, 15, 22, 19, 2, -22 },
  { 780, 15, 22, 19, 2, -22 },
  { 822, 3, 17, 19, 8, -17 },
  { 829, 5, 22, 19, 7, -17 },
  { 843, 13, 18, 19, 3, -19 },
  { 873, 15, 8, 19, 2, -14 },
  { 888, 13, 18, 19, 3, -19 },
  { 918, 13, 22, 19, 3, -22 },
  { 954, 14, 26, 19, 2, -22 },
  { 1000, 17, 22, 19, 1, -22 },
  { 1047, 14, 22, 19, 3, -22 },
  { 1086, 15, 22, 19, 2, -22 },
  { 1128, 14, 22, 19, 3, -22 },
  { 1167, 14, 22, 19, 3, -22 },
  { 1206, 14, 22, 19, 3, -22 },
  { 1245, 15, 22, 19, 2, -22 },
  { 1287, 13, 22, 19, 3, -22 },
  { 1323, 13, 22, 19, 3, -22 },
  { 1359, 12, 22, 19, 3, -22 },
  { 1392, 15, 22, 19, 3, -22 },
  { 1434, 13, 22, 19, 4, -22 },
  { 1470, 15, 22, 19, 2, -22 },
  { 1512, 13, 22, 19, 3, -22 },
  { 1548, 15, 22, 19, 2, -22 },
  { 1590, 14, 22, 19, 3, -22 },
  { 1629, 15, 27, 19, 2, -22 },
  { 1680, 14, 22, 19, 3, -22 },
  { 1719, 15, 22, 19, 2, -22 },
  { 1761, 17, 22, 19, 1, -22 },
  { 1808, 13, 22, 19, 3, -22 },
  { 1844, 17, 22, 19, 1, -22 },
  { 1891, 17, 22, 19, 1, -22 },
  { 1938, 17, 22, 19, 1, -22 },
  { 1985, 18, 22, 19, 1, -22 },
  { 2035, 16, 22, 19, 2, -22 },
  { 2079, 8, 28, 19, 8, -24 },
  { 2107, 13, 28, 19, 3, -24 },
  { 2153, 8, 28, 19, 3, -24 },
  { 2181, 15, 13, 19, 2, -22 },
  { 2206, 15, 2, 19, 2, 3 },
  { 2210, 5, 6, 19, 6, -25 },
  { 2214, 15, 17, 19, 2, -17 },
  { 2246, 14, 24, 19, 3, -24 },
  { 2288, 13, 17, 19, 3, -17 },
  { 2316, 14, 24, 19, 2, -24 },
  { 2358, 15, 17, 19, 2, -17 },
  { 2390, 15, 24, 19, 2, -24 },
  { 2435, 16, 25, 19, 2, -19 },
  { 2485, 13, 24, 19, 3, -24 },
  { 2524, 13, 24, 19, 4, -24 },
  { 2563, 11, 30, 19, 3, -24 },
  { 2605, 14, 24, 19, 4, -24 },
  { 2647, 14, 24, 19, 3, -24 },
  { 2689, 15, 17, 19, 2, -17 },
  { 2721, 13, 17, 19, 3, -17 },
  { 2749, 15, 17, 19, 2, -17 },
  { 2781, 14, 23, 19, 3, -17 },
  { 2822, 14, 23, 19, 2, -17 },
  { 2863, 16, 17, 19, 2, -17 },
  { 2897, 15, 17, 19, 2, -17 },
  { 2929, 16, 22, 19, 1, -22 },
  { 2973, 13, 17, 19, 3, -17 },
  { 3001, 15, 17, 19, 2, -17 },
  { 3033, 17, 17, 19, 1, -17 },
  { 3070, 15, 17, 19, 2, -17 },
  { 3102, 15, 23, 19, 2, -17 },
  { 3146, 13, 17, 19, 3, -17 },
  { 3174, 13, 28, 19, 3, -24 },
  { 3220, 1, 28, 19, 9, -24 },
  { 3224, 13, 28, 19, 3, -24 },
  { 3270, 15, 7, 19, 2, -13 },
};

const GFXfont IBMPlexMono_Light32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_LIGHT32PT7B_H_
