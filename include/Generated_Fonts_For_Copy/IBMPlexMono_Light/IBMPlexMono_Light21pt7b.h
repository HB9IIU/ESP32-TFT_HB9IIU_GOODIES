#ifndef _IBMPLEXMONO_LIGHT21PT7B_H_
#define _IBMPLEXMONO_LIGHT21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light21pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x48, 0x01, 0xB8, 0x9C, 0xE7, 0x39, 0xCC, 0x04,
  0x40, 0x44, 0x04, 0xC0, 0x48, 0x08, 0x87, 0x8F, 0x08, 0x80, 0x88, 0x09,
  0x8F, 0x9E, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x13, 0x00, 0x04, 0x01,
  0x01, 0xF1, 0x93, 0x44, 0x51, 0x04, 0x41, 0x10, 0x34, 0x07, 0xC0, 0x4C,
  0x11, 0x04, 0x41, 0x1C, 0x45, 0x93, 0x1F, 0x01, 0x00, 0x40, 0x38, 0x14,
  0x42, 0x42, 0x24, 0x24, 0x42, 0x44, 0x48, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0xB3, 0x12, 0x13, 0x21, 0x22, 0x14, 0x33, 0xC1, 0xE0, 0x1E, 0x04, 0x61,
  0x08, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x03, 0x87, 0xC8, 0x90, 0x92, 0x0A,
  0x41, 0x88, 0x19, 0x85, 0x8F, 0x18, 0xFC, 0x19, 0x88, 0x84, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x41, 0x08, 0x21, 0x86, 0xC0, 0x81, 0x06, 0x08, 0x20,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x86, 0x10, 0x8C, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x42, 0x2F, 0x5E, 0x3C, 0x03, 0x80, 0xD0, 0x31, 0x04, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x76, 0x64, 0xC0, 0xFC, 0xDC, 0x01, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x20, 0x00, 0x1F, 0x08, 0x64, 0x09, 0x01, 0x40, 0x70,
  0x1C, 0xC7, 0x31, 0xC0, 0x70, 0x14, 0x05, 0x01, 0x40, 0x88, 0x61, 0xF0,
  0x0E, 0x03, 0xC0, 0xD8, 0x33, 0x0C, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x1F, 0xF8, 0x3C, 0x61, 0xA0,
  0x50, 0x20, 0x18, 0x08, 0x04, 0x04, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04,
  0x03, 0xFE, 0x1E, 0x18, 0x64, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x78,
  0x03, 0x80, 0x20, 0x0C, 0x03, 0xC0, 0x98, 0x63, 0xE0, 0x03, 0x00, 0x60,
  0x14, 0x06, 0x80, 0x90, 0x22, 0x04, 0x41, 0x08, 0x61, 0x08, 0x22, 0x04,
  0x7F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x7F, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x02, 0x79, 0xC6, 0x01, 0x80, 0x40, 0x20, 0x18, 0x1E, 0x18, 0xF8, 0x0E,
  0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x02, 0xF9, 0x86, 0x81, 0xC0, 0x60, 0x30,
  0x18, 0x1A, 0x18, 0xF8, 0xFF, 0xF0, 0x1C, 0x0B, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x1F,
  0x08, 0x64, 0x0D, 0x01, 0x40, 0x50, 0x32, 0x18, 0x78, 0x61, 0x90, 0x1C,
  0x07, 0x01, 0x40, 0x58, 0x21, 0xF0, 0x3E, 0x21, 0xA0, 0x70, 0x18, 0x0C,
  0x06, 0x07, 0x85, 0x3D, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x60, 0xC0, 0xDC,
  0x00, 0x00, 0x1B, 0x80, 0x67, 0x00, 0x00, 0x00, 0x07, 0x66, 0x4C, 0x00,
  0x81, 0x81, 0x83, 0x06, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x10, 0x00, 0x3E, 0x21,
  0xA0, 0x50, 0x30, 0x18, 0x08, 0x18, 0x30, 0x10, 0x08, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x3E, 0x21, 0xB0, 0x50, 0x18, 0xEC, 0x8E, 0x43, 0x21,
  0x90, 0xC8, 0x64, 0x32, 0x38, 0xEC, 0x03, 0x00, 0xC0, 0x3F, 0x00, 0x0C,
  0x01, 0xC0, 0x28, 0x0D, 0x01, 0x30, 0x22, 0x0C, 0x41, 0x08, 0x20, 0x87,
  0xF1, 0x02, 0x20, 0x64, 0x05, 0x80, 0xA0, 0x18, 0xFE, 0x41, 0xA0, 0x50,
  0x38, 0x1C, 0x0A, 0x0D, 0xFC, 0x81, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0B,
  0xF8, 0x3E, 0x30, 0xB0, 0x30, 0x28, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x2C, 0x0B, 0x08, 0xF8, 0xFC, 0x41, 0xA0, 0x50, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x14, 0x1B, 0xF0, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x03, 0xFE, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x1F, 0x0C, 0x66,
  0x0D, 0x02, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC7, 0xF0, 0x14, 0x05, 0x01,
  0x60, 0xCC, 0x51, 0xE4, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0xFF, 0x84, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x43, 0xFE, 0x7F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x83, 0xC2, 0x3C, 0x80, 0xE0, 0x68, 0x32, 0x18, 0x8C, 0x22,
  0x09, 0x82, 0xA0, 0xEC, 0x31, 0x08, 0x22, 0x0C, 0x81, 0x20, 0x68, 0x0C,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x81, 0xE0, 0xF0, 0xF4, 0x5A, 0x2D, 0xA6, 0x53, 0x31,
  0x88, 0xC4, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0xC0, 0xE0, 0x78, 0x34,
  0x1B, 0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0x30, 0xD8, 0x2C, 0x1E,
  0x06, 0x1F, 0x08, 0x64, 0x09, 0x01, 0x40, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x14, 0x05, 0x01, 0x40, 0x88, 0x61, 0xF0, 0xFF, 0x40, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x07, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x1F, 0x08, 0x64, 0x09, 0x01, 0x40, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x14, 0x05, 0x01, 0x40, 0x88, 0x61, 0xF0, 0x10, 0x04, 0x01, 0xE0,
  0xFF, 0x40, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x07, 0xFC, 0x8C, 0x42, 0x21,
  0x90, 0x48, 0x14, 0x0A, 0x02, 0x1F, 0x18, 0x34, 0x05, 0x00, 0x40, 0x10,
  0x03, 0x00, 0x7C, 0x00, 0xC0, 0x10, 0x04, 0x01, 0xC0, 0x58, 0x23, 0xF0,
  0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x3C, 0x12,
  0x18, 0xF8, 0x80, 0x78, 0x09, 0x01, 0x20, 0x66, 0x08, 0x41, 0x08, 0x61,
  0x08, 0x31, 0x02, 0x20, 0x4C, 0x0D, 0x00, 0xA0, 0x1C, 0x03, 0x00, 0x80,
  0x30, 0x0E, 0x01, 0x40, 0x28, 0xC5, 0x98, 0xB2, 0x92, 0x52, 0x4A, 0x4A,
  0x49, 0x45, 0x28, 0xA5, 0x14, 0xC3, 0x98, 0x60, 0xC0, 0x68, 0x18, 0x82,
  0x18, 0xC1, 0x10, 0x34, 0x03, 0x80, 0x20, 0x0E, 0x03, 0x40, 0x44, 0x10,
  0xC6, 0x08, 0x80, 0xA0, 0x18, 0xC0, 0x36, 0x02, 0x20, 0x63, 0x04, 0x10,
  0xC0, 0x88, 0x09, 0x00, 0x50, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0xFF, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x3F,
  0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x60, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x1F, 0xC0, 0x0C, 0x02, 0x81, 0x20, 0x44, 0x21, 0x98,
  0x24, 0x0F, 0x01, 0xFF, 0xC0, 0x89, 0x10, 0x3E, 0x18, 0x44, 0x18, 0x02,
  0x00, 0x8F, 0xE4, 0x09, 0x02, 0xC1, 0x90, 0xA3, 0xCC, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0xF2, 0x8D, 0x83, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x0E, 0x8D, 0x3C, 0x3E, 0x30, 0x90, 0x70, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x40, 0xB0, 0x8F, 0x80, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xF5, 0x86,
  0x81, 0x40, 0xE0, 0x70, 0x38, 0x14, 0x0A, 0x05, 0x86, 0x3D, 0x3E, 0x31,
  0xB0, 0x50, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0xA0, 0x8F, 0x80, 0x0F,
  0x84, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x21, 0xFF, 0x01, 0xCF, 0x84, 0x33, 0x04, 0xC1, 0x30,
  0x44, 0x30, 0xF8, 0x40, 0x30, 0x07, 0xF2, 0x02, 0x80, 0xE0, 0x3C, 0x19,
  0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9E, 0xA3, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x31, 0xFF, 0x06,
  0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x0F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x6C, 0x33, 0x18, 0xCC, 0x36, 0x0E, 0xC3, 0x10, 0xC2, 0x30, 0x4C, 0x1B,
  0x03, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0xB9, 0xF3, 0x98, 0x46, 0x11,
  0x84, 0x61, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x44, 0x9E, 0xA3, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3E, 0x21, 0xA0, 0x50,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x21, 0x8F, 0x80, 0x9E, 0x51, 0xB0,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC1, 0xD1, 0xA7, 0x90, 0x08, 0x04,
  0x02, 0x00, 0x1E, 0xB0, 0xD0, 0x28, 0x1C, 0x0E, 0x07, 0x02, 0x81, 0x40,
  0xB0, 0xC7, 0xA0, 0x10, 0x08, 0x04, 0x02, 0xF3, 0xC5, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0xF8, 0x3E, 0x20, 0xA0,
  0x30, 0x06, 0x01, 0xF0, 0x06, 0x01, 0x80, 0xE0, 0x8F, 0x80, 0x08, 0x02,
  0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC1, 0x43, 0x3D, 0x80, 0xC0, 0xB0, 0x48, 0x24, 0x21, 0x10, 0x88,
  0x48, 0x14, 0x0A, 0x06, 0x00, 0x84, 0x31, 0x86, 0x29, 0x45, 0x28, 0xA4,
  0xA4, 0x94, 0x92, 0x8A, 0x51, 0x4C, 0x31, 0x86, 0x00, 0x81, 0xA0, 0x98,
  0x86, 0x81, 0xC0, 0x40, 0x70, 0x4C, 0x62, 0x20, 0xA0, 0x60, 0xC0, 0x50,
  0x36, 0x08, 0x82, 0x21, 0x04, 0x41, 0x30, 0x68, 0x0A, 0x03, 0x00, 0x40,
  0x30, 0x08, 0x06, 0x07, 0x00, 0xFF, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xC0,
  0x40, 0x40, 0x40, 0x60, 0x3F, 0xE0, 0x1F, 0x10, 0x10, 0x10, 0x18, 0x08,
  0x04, 0x04, 0x0C, 0xF0, 0x0C, 0x04, 0x04, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x1F, 0xFF, 0xFF, 0xE0, 0xF8, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10,
  0x10, 0x0F, 0x18, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0xF8, 0x30,
  0x53, 0x18, 0x66, 0x0E,
};

const GFXglyph IBMPlexMono_Light21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 5, 6, 13, 4, -16 },
  { 11, 12, 15, 13, 0, -15 },
  { 34, 10, 19, 13, 1, -17 },
  { 58, 12, 15, 13, 0, -15 },
  { 81, 11, 15, 13, 1, -15 },
  { 102, 1, 6, 13, 6, -16 },
  { 103, 5, 19, 13, 5, -16 },
  { 115, 6, 19, 13, 2, -16 },
  { 130, 11, 10, 13, 1, -12 },
  { 144, 10, 11, 13, 1, -12 },
  { 158, 4, 5, 13, 4, -2 },
  { 161, 6, 1, 13, 3, -7 },
  { 162, 3, 2, 13, 5, -2 },
  { 163, 9, 19, 13, 2, -16 },
  { 185, 10, 15, 13, 1, -15 },
  { 204, 11, 15, 13, 1, -15 },
  { 225, 9, 15, 13, 2, -15 },
  { 242, 10, 15, 13, 1, -15 },
  { 261, 11, 15, 13, 1, -15 },
  { 282, 9, 15, 13, 2, -15 },
  { 299, 9, 15, 13, 2, -15 },
  { 316, 10, 15, 13, 1, -15 },
  { 335, 10, 15, 13, 1, -15 },
  { 354, 9, 15, 13, 2, -15 },
  { 371, 3, 11, 13, 5, -11 },
  { 376, 4, 14, 13, 4, -11 },
  { 383, 9, 12, 13, 2, -12 },
  { 397, 10, 5, 13, 1, -9 },
  { 404, 9, 12, 13, 2, -12 },
  { 418, 9, 15, 13, 2, -15 },
  { 435, 9, 17, 13, 2, -15 },
  { 455, 11, 15, 13, 1, -15 },
  { 476, 9, 15, 13, 2, -15 },
  { 493, 9, 15, 13, 2, -15 },
  { 510, 9, 15, 13, 2, -15 },
  { 527, 9, 15, 13, 2, -15 },
  { 544, 9, 15, 13, 2, -15 },
  { 561, 10, 15, 13, 1, -15 },
  { 580, 9, 15, 13, 2, -15 },
  { 597, 9, 15, 13, 2, -15 },
  { 614, 8, 15, 13, 2, -15 },
  { 629, 10, 15, 13, 2, -15 },
  { 648, 8, 15, 13, 3, -15 },
  { 663, 9, 15, 13, 2, -15 },
  { 680, 9, 15, 13, 2, -15 },
  { 697, 10, 15, 13, 1, -15 },
  { 716, 9, 15, 13, 2, -15 },
  { 733, 10, 18, 13, 1, -15 },
  { 756, 9, 15, 13, 2, -15 },
  { 773, 10, 15, 13, 1, -15 },
  { 792, 11, 15, 13, 1, -15 },
  { 813, 9, 15, 13, 2, -15 },
  { 830, 11, 15, 13, 1, -15 },
  { 851, 11, 15, 13, 1, -15 },
  { 872, 11, 15, 13, 1, -15 },
  { 893, 12, 15, 13, 0, -15 },
  { 916, 11, 15, 13, 1, -15 },
  { 937, 6, 19, 13, 5, -16 },
  { 952, 9, 19, 13, 2, -16 },
  { 974, 6, 19, 13, 2, -16 },
  { 989, 10, 8, 13, 1, -15 },
  { 999, 10, 1, 13, 1, 2 },
  { 1001, 3, 4, 13, 4, -16 },
  { 1003, 10, 11, 13, 1, -11 },
  { 1017, 9, 16, 13, 2, -16 },
  { 1035, 9, 11, 13, 2, -11 },
  { 1048, 9, 16, 13, 1, -16 },
  { 1066, 9, 11, 13, 2, -11 },
  { 1079, 9, 16, 13, 2, -16 },
  { 1097, 10, 16, 13, 2, -12 },
  { 1117, 8, 16, 13, 2, -16 },
  { 1133, 9, 16, 13, 2, -16 },
  { 1151, 7, 20, 13, 2, -16 },
  { 1169, 10, 16, 13, 2, -16 },
  { 1189, 9, 16, 13, 2, -16 },
  { 1207, 10, 11, 13, 1, -11 },
  { 1221, 8, 11, 13, 2, -11 },
  { 1232, 9, 11, 13, 2, -11 },
  { 1245, 9, 15, 13, 2, -11 },
  { 1262, 9, 15, 13, 1, -11 },
  { 1279, 10, 11, 13, 2, -11 },
  { 1293, 9, 11, 13, 2, -11 },
  { 1306, 10, 15, 13, 1, -15 },
  { 1325, 8, 11, 13, 2, -11 },
  { 1336, 9, 11, 13, 2, -11 },
  { 1349, 11, 11, 13, 1, -11 },
  { 1365, 9, 11, 13, 2, -11 },
  { 1378, 10, 15, 13, 1, -11 },
  { 1397, 9, 11, 13, 2, -11 },
  { 1410, 8, 19, 13, 2, -16 },
  { 1429, 1, 19, 13, 6, -16 },
  { 1432, 8, 19, 13, 2, -16 },
  { 1451, 10, 4, 13, 1, -8 },
};

const GFXfont IBMPlexMono_Light21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_LIGHT21PT7B_H_
