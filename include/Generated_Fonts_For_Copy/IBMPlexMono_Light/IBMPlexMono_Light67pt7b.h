#ifndef _IBMPLEXMONO_LIGHT67PT7B_H_
#define _IBMPLEXMONO_LIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light67pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFF, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF1, 0xC7, 0xF8,
  0x0F, 0x81, 0xC0, 0xFC, 0x1F, 0x01, 0xC0, 0x7E, 0x3E, 0x01, 0xC0, 0x1F,
  0x3C, 0x01, 0xC0, 0x0E, 0x3C, 0x01, 0xC0, 0x08, 0x78, 0x01, 0xC0, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x1F, 0x01, 0xC0, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x07, 0xF9, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xC7, 0xF8, 0x00, 0x01, 0xC0, 0xFC,
  0x00, 0x01, 0xC0, 0x7C, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x0F,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x20, 0x01, 0xC0, 0x0F,
  0x70, 0x01, 0xC0, 0x1F, 0xF8, 0x01, 0xC0, 0x1E, 0x7C, 0x01, 0xC0, 0x3E,
  0x7E, 0x01, 0xC0, 0x7C, 0x3F, 0x81, 0xC0, 0xF8, 0x0F, 0xF1, 0xC7, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x07, 0x87, 0xC1, 0xF0, 0x00, 0x1C, 0x3C,
  0x01, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0x80, 0x03, 0x87, 0x80, 0x0E, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x70, 0x00, 0x70, 0x03, 0xC1, 0xC0,
  0x01, 0xC0, 0x1E, 0x07, 0x00, 0x07, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03,
  0xC0, 0x70, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x07, 0xC1,
  0xF0, 0x38, 0x00, 0x0F, 0xFF, 0x81, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x07, 0xFF, 0xC0, 0x00, 0x70,
  0x3E, 0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x1C,
  0x00, 0x78, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x0E, 0x03,
  0xC0, 0x03, 0x80, 0x78, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x80, 0x1C, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0xE0, 0x00, 0x3E, 0x0F, 0x87, 0x80, 0x00, 0x7F, 0xFC, 0x1C,
  0x00, 0x00, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xDE, 0x00,
  0x1F, 0xE0, 0xF8, 0xF0, 0x01, 0xFE, 0x1F, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x38, 0x07, 0x80, 0x07, 0x83, 0x80, 0xF0, 0x00, 0x3C,
  0x38, 0x0F, 0x00, 0x01, 0xE3, 0x80, 0xF0, 0x00, 0x1F, 0x38, 0x0F, 0x00,
  0x00, 0xF3, 0x80, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01,
  0xF8, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x03, 0x3E, 0x03, 0xE0,
  0x00, 0x71, 0xF0, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0xFC, 0x07, 0xC0, 0x78,
  0x07, 0xFF, 0xF8, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x7F, 0x80,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x07, 0x80,
  0x06, 0xFC, 0x01, 0xE0, 0x0F, 0xFF, 0xF0, 0x78, 0x1F, 0xF7, 0xFF, 0x9E,
  0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x01, 0xE0, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07,
  0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F,
  0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x01,
  0x80, 0x07, 0x80, 0x00, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x03, 0xC0, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x20, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0x3F,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x03, 0xFC, 0x00, 0x3C, 0x3F, 0xFE, 0x00, 0xF3, 0xFF, 0xFE,
  0x03, 0xDE, 0x01, 0xFC, 0x0E, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3,
  0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x1F,
  0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x03, 0xFC, 0x00, 0x7C, 0x3F, 0xFE, 0x01, 0xE3, 0xFF, 0xFE,
  0x07, 0x9E, 0x01, 0xFC, 0x1E, 0xE0, 0x01, 0xF8, 0xF6, 0x00, 0x01, 0xF3,
  0xD0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF8, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x6F, 0x1F, 0x80, 0x07,
  0x3C, 0x3F, 0x80, 0x79, 0xE0, 0x7F, 0xFF, 0xC7, 0x80, 0x7F, 0xFE, 0x1E,
  0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0x3E, 0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x38, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x1D, 0xC0, 0x03, 0xF0, 0xEE, 0x00, 0x7F, 0xC7, 0x70, 0x07, 0xFF,
  0x3F, 0x80, 0x7C, 0x0D, 0xFC, 0x07, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0xFF,
  0x01, 0xC0, 0x07, 0xF8, 0x1E, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0xFE, 0x07,
  0x00, 0x07, 0xF0, 0x38, 0x00, 0x3F, 0x81, 0xC0, 0x01, 0xFC, 0x0E, 0x00,
  0x0F, 0xE0, 0x70, 0x00, 0x7F, 0x03, 0x80, 0x03, 0xF8, 0x1C, 0x00, 0x1F,
  0xC0, 0xE0, 0x00, 0xFE, 0x07, 0x00, 0x07, 0xF0, 0x38, 0x00, 0x3F, 0x81,
  0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x7F, 0x01, 0xC0,
  0x07, 0xF8, 0x0F, 0x00, 0x3D, 0xC0, 0x3C, 0x02, 0xEE, 0x01, 0xF8, 0xF7,
  0x70, 0x07, 0xFF, 0x3B, 0x80, 0x1F, 0xF1, 0xDE, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x41, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x04, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x01, 0xE0, 0x01, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x78, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x7C,
  0x3C, 0x00, 0x0F, 0xC1, 0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x41, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x03, 0x78,
  0x7C, 0x00, 0x0E, 0xF0, 0x7E, 0x00, 0x39, 0xE0, 0x7F, 0x01, 0xF3, 0xC0,
  0x7F, 0xFF, 0xC7, 0x80, 0x3F, 0xFE, 0x0F, 0x00, 0x1F, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xC7, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0xF0, 0x7E, 0x00, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0xF0, 0xFF, 0x00,
  0x00, 0xF1, 0xEF, 0x80, 0x00, 0xF3, 0xC7, 0xC0, 0x00, 0xF7, 0xC3, 0xC0,
  0x00, 0xFF, 0x83, 0xE0, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xC0, 0x00, 0xEF, 0xF7, 0x80,
  0x07, 0xBF, 0xCE, 0x00, 0x1E, 0xFF, 0x3C, 0x00, 0x73, 0xFC, 0xF0, 0x03,
  0xCF, 0xF1, 0xE0, 0x0E, 0x3F, 0xC7, 0x80, 0x78, 0xFF, 0x0E, 0x01, 0xC3,
  0xFC, 0x3C, 0x07, 0x0F, 0xF0, 0x70, 0x3C, 0x3F, 0xC1, 0xE0, 0xE0, 0xFF,
  0x07, 0x87, 0x83, 0xFC, 0x0F, 0x1C, 0x0F, 0xF0, 0x3C, 0xF0, 0x3F, 0xC0,
  0x73, 0x80, 0xFF, 0x01, 0xEE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0,
  0x0F, 0xF0, 0x03, 0x00, 0x3F, 0xC0, 0x0C, 0x00, 0xFF, 0x00, 0x10, 0x03,
  0xFC, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0x78, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x7F, 0x3C, 0x00, 0x07,
  0xF3, 0xC0, 0x00, 0x7F, 0x1E, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x7F, 0x0F,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x7F, 0x0F, 0x80, 0x07, 0xF0, 0x78, 0x00,
  0x7F, 0x07, 0x80, 0x07, 0xF0, 0x3C, 0x00, 0x7F, 0x03, 0xC0, 0x07, 0xF0,
  0x1E, 0x00, 0x7F, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0xF0,
  0x07, 0xF0, 0x07, 0x80, 0x7F, 0x00, 0x78, 0x07, 0xF0, 0x07, 0x80, 0x7F,
  0x00, 0x3C, 0x07, 0xF0, 0x03, 0xC0, 0x7F, 0x00, 0x1E, 0x07, 0xF0, 0x01,
  0xE0, 0x7F, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0xF0, 0x7F, 0x00, 0x07, 0x87,
  0xF0, 0x00, 0x78, 0x7F, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x3C, 0x7F, 0x00,
  0x03, 0xC7, 0xF0, 0x00, 0x1E, 0x7F, 0x00, 0x01, 0xE7, 0xF0, 0x00, 0x0F,
  0x7F, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF8,
  0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x7E, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0x80, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x08,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x20, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x01, 0xF8,
  0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x7C, 0x00, 0xE7, 0x80, 0x3F, 0x00, 0x39,
  0xE0, 0x0F, 0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07, 0x9E, 0x00, 0xFE, 0x01,
  0xE3, 0x80, 0x3F, 0x80, 0x78, 0xE0, 0x1E, 0xE0, 0x1E, 0x38, 0x07, 0x38,
  0x07, 0x8E, 0x01, 0xCF, 0x01, 0xC3, 0x80, 0x73, 0xC0, 0x70, 0xE0, 0x3C,
  0x70, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x0F, 0x03, 0x87, 0x81, 0xC3, 0xC0,
  0xE1, 0xE0, 0x70, 0xF0, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x0E, 0x0F, 0x0F,
  0x07, 0x03, 0xC3, 0xC1, 0xC1, 0xC0, 0xF0, 0xF0, 0x70, 0xF0, 0x1C, 0x3C,
  0x1C, 0x38, 0x07, 0x0E, 0x07, 0x0E, 0x01, 0xE3, 0x81, 0xC3, 0x80, 0x78,
  0xE0, 0x71, 0xE0, 0x0E, 0x38, 0x1E, 0x70, 0x03, 0x8E, 0x07, 0x9C, 0x00,
  0xE3, 0x81, 0xE7, 0x00, 0x3C, 0xE0, 0x7B, 0xC0, 0x0F, 0x78, 0x1E, 0xF0,
  0x01, 0xDE, 0x07, 0xB8, 0x00, 0x77, 0x80, 0xEE, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x30, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x04, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x18, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x01, 0xFC, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xB8, 0x1E, 0x00, 0x03, 0x70, 0x3E,
  0x00, 0x1C, 0xE0, 0x3F, 0x00, 0xF1, 0xFE, 0x3F, 0xFF, 0xC1, 0xFC, 0x3F,
  0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x03, 0xFC, 0x00, 0xF0, 0x7F, 0xF8, 0x07, 0x8F, 0xFF, 0xF0,
  0x3C, 0xF0, 0x1F, 0xC1, 0xEE, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x3C, 0x7E, 0x00, 0x03, 0xE3, 0xDC, 0x00, 0x3E, 0x1E, 0x78, 0x0F,
  0xE0, 0xF1, 0xFF, 0xFE, 0x07, 0x83, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0xF8, 0x0F, 0x01, 0xFF, 0xF0, 0xF0, 0x7F, 0xFF, 0x8F, 0x0F, 0xE0, 0x3C,
  0xF1, 0xF8, 0x00, 0xEF, 0x1E, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x0E, 0xF0, 0xFE, 0x03, 0xCF, 0x07, 0xFF, 0xF8, 0xF0, 0x1F, 0xFF,
  0x0F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xC0,
  0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0x0F, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xE3, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x0E, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0x80,
  0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x7F, 0x80, 0xF0, 0xFF, 0xF8, 0x3C, 0x7F, 0xFF,
  0x0F, 0x3C, 0x07, 0xE3, 0xDC, 0x00, 0x7C, 0xF4, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC3, 0xF0, 0x00,
  0x0F, 0x1F, 0xE0, 0x00, 0x3C, 0xF7, 0xC0, 0x00, 0xFF, 0x8F, 0x80, 0x03,
  0xFC, 0x1E, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xFC, 0x03, 0xF0, 0xF3, 0xFE,
  0x0F, 0xFC, 0xF7, 0xFF, 0x1F, 0xFC, 0xF6, 0x0F, 0x98, 0x3E, 0xFC, 0x07,
  0xB0, 0x1E, 0xF8, 0x03, 0xA0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x3C, 0x3F, 0xFE, 0x0F, 0x1F, 0xFF, 0xC3,
  0xCF, 0x01, 0xF8, 0xF7, 0x00, 0x1F, 0x3D, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7B, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xF0,
  0x1F, 0xE0, 0x07, 0x83, 0xFF, 0xC0, 0x3C, 0x7F, 0xFF, 0x81, 0xE7, 0x80,
  0xFE, 0x0F, 0x70, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE3,
  0xF0, 0x00, 0x1F, 0x1E, 0xE0, 0x01, 0xF0, 0xF3, 0xC0, 0x7F, 0x07, 0x8F,
  0xFF, 0xF0, 0x3C, 0x1F, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xF0, 0x1F, 0xFF, 0x0F,
  0x07, 0xFF, 0xF8, 0xF0, 0xFE, 0x03, 0xCF, 0x1F, 0x80, 0x0E, 0xF1, 0xE0,
  0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x1F, 0x1E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0xEF, 0x0F, 0xE0, 0x3C,
  0xF0, 0x7F, 0xFF, 0x8F, 0x01, 0xFF, 0xF0, 0xF0, 0x07, 0xF8, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x1E, 0xC0, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x7C, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xDE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0xEF, 0x1F, 0x80, 0xF3, 0xC3,
  0xFF, 0xF8, 0xF0, 0x7F, 0xFC, 0x3C, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x0F, 0x70, 0x01, 0xF8, 0x00, 0xF7, 0x00,
  0x1F, 0x80, 0x0E, 0x70, 0x01, 0xF8, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x0E,
  0x78, 0x01, 0x9C, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x1E, 0x38, 0x03, 0x9C,
  0x01, 0xE3, 0x80, 0x38, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x1C,
  0x1C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x03, 0x81, 0xE0,
  0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x01,
  0xC7, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x73, 0x00, 0x0E, 0xE0,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0xC0,
  0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x03,
  0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x03, 0xFC, 0x00, 0x03, 0xC3, 0xFF,
  0x00, 0x01, 0xC3, 0xC3, 0xE0, 0x00, 0xE3, 0xC0, 0xF0, 0x00, 0xF1, 0xC0,
  0x3C, 0x00, 0x71, 0xE0, 0x0F, 0x00, 0x38, 0xE0, 0x03, 0xC0, 0x3C, 0xF0,
  0x00, 0xF0, 0x3C, 0x70, 0x00, 0x3C, 0x3C, 0x38, 0x00, 0x0F, 0xFE, 0x1C,
  0x00, 0x03, 0xFE, 0x0E, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Light67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 8, 47, 40, 16, -47 },
  { 48, 14, 18, 40, 13, -50 },
  { 80, 38, 47, 40, 1, -47 },
  { 304, 32, 63, 40, 4, -55 },
  { 556, 38, 49, 40, 1, -48 },
  { 789, 36, 49, 40, 2, -48 },
  { 1010, 4, 18, 40, 18, -50 },
  { 1019, 17, 60, 40, 15, -51 },
  { 1147, 18, 60, 40, 8, -51 },
  { 1282, 34, 33, 40, 3, -37 },
  { 1423, 32, 33, 40, 4, -37 },
  { 1555, 10, 18, 40, 14, -8 },
  { 1578, 18, 3, 40, 11, -22 },
  { 1585, 8, 7, 40, 16, -7 },
  { 1592, 28, 60, 40, 6, -51 },
  { 1802, 32, 49, 40, 4, -48 },
  { 1998, 33, 47, 40, 4, -47 },
  { 2192, 31, 48, 40, 5, -48 },
  { 2378, 30, 49, 40, 4, -48 },
  { 2562, 34, 47, 40, 3, -47 },
  { 2762, 30, 48, 40, 5, -47 },
  { 2942, 30, 48, 40, 5, -47 },
  { 3122, 30, 47, 40, 5, -47 },
  { 3299, 32, 49, 40, 4, -48 },
  { 3495, 30, 48, 40, 5, -48 },
  { 3675, 8, 35, 40, 16, -35 },
  { 3710, 10, 45, 40, 14, -35 },
  { 3767, 29, 38, 40, 6, -39 },
  { 3905, 32, 15, 40, 4, -28 },
  { 3965, 29, 38, 40, 6, -39 },
  { 4103, 28, 48, 40, 6, -48 },
  { 4271, 29, 55, 40, 5, -48 },
  { 4471, 35, 47, 40, 3, -47 },
  { 4677, 30, 47, 40, 6, -47 },
  { 4854, 31, 49, 40, 5, -48 },
  { 5044, 29, 47, 40, 7, -47 },
  { 5215, 29, 47, 40, 6, -47 },
  { 5386, 29, 47, 40, 6, -47 },
  { 5557, 31, 49, 40, 4, -48 },
  { 5747, 28, 47, 40, 6, -47 },
  { 5912, 28, 47, 40, 6, -47 },
  { 6077, 26, 48, 40, 6, -47 },
  { 6233, 32, 47, 40, 6, -47 },
  { 6421, 27, 47, 40, 9, -47 },
  { 6580, 30, 47, 40, 5, -47 },
  { 6757, 28, 47, 40, 6, -47 },
  { 6922, 32, 49, 40, 4, -48 },
  { 7118, 30, 47, 40, 6, -47 },
  { 7295, 32, 58, 40, 4, -48 },
  { 7527, 30, 47, 40, 6, -47 },
  { 7704, 32, 49, 40, 4, -48 },
  { 7900, 36, 47, 40, 2, -47 },
  { 8112, 28, 48, 40, 6, -47 },
  { 8280, 34, 47, 40, 3, -47 },
  { 8480, 34, 47, 40, 3, -47 },
  { 8680, 36, 47, 40, 2, -47 },
  { 8892, 38, 47, 40, 1, -47 },
  { 9116, 34, 47, 40, 3, -47 },
  { 9316, 18, 60, 40, 16, -51 },
  { 9451, 28, 60, 40, 6, -51 },
  { 9661, 18, 60, 40, 6, -51 },
  { 9796, 33, 27, 40, 4, -47 },
  { 9908, 32, 3, 40, 4, 7 },
  { 9920, 10, 12, 40, 13, -52 },
  { 9935, 31, 36, 40, 5, -35 },
  { 10075, 29, 51, 40, 7, -50 },
  { 10260, 28, 36, 40, 6, -35 },
  { 10386, 28, 51, 40, 5, -50 },
  { 10565, 30, 36, 40, 5, -35 },
  { 10700, 31, 50, 40, 5, -50 },
  { 10894, 32, 52, 40, 5, -38 },
  { 11102, 26, 50, 40, 7, -50 },
  { 11265, 29, 50, 40, 7, -50 },
  { 11447, 24, 63, 40, 6, -50 },
  { 11636, 30, 50, 40, 8, -50 },
  { 11824, 29, 50, 40, 6, -50 },
  { 12006, 32, 35, 40, 4, -35 },
  { 12146, 26, 35, 40, 7, -35 },
  { 12260, 30, 36, 40, 5, -35 },
  { 12395, 29, 48, 40, 7, -35 },
  { 12569, 28, 48, 40, 5, -35 },
  { 12737, 32, 35, 40, 5, -35 },
  { 12877, 30, 36, 40, 5, -35 },
  { 13012, 32, 47, 40, 3, -47 },
  { 13200, 26, 36, 40, 7, -35 },
  { 13317, 30, 35, 40, 5, -35 },
  { 13449, 36, 35, 40, 2, -35 },
  { 13607, 30, 35, 40, 5, -35 },
  { 13739, 32, 48, 40, 4, -35 },
  { 13931, 28, 35, 40, 6, -35 },
  { 14054, 26, 60, 40, 7, -51 },
  { 14249, 4, 60, 40, 18, -51 },
  { 14279, 26, 60, 40, 7, -51 },
  { 14474, 33, 13, 40, 4, -27 },
};

const GFXfont IBMPlexMono_Light67pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light67pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light67pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _IBMPLEXMONO_LIGHT67PT7B_H_
