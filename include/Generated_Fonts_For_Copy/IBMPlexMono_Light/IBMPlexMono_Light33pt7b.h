#ifndef _IBMPLEXMONO_LIGHT33PT7B_H_
#define _IBMPLEXMONO_LIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light33pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x64, 0x40, 0x00, 0x0E, 0xFF,
  0xE0, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x10, 0x40, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC1, 0xFC, 0x3F, 0x7E, 0x0F, 0xC1, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x04, 0x0F, 0xC3, 0xFB, 0xF0, 0xFE, 0x0C, 0x30, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x20, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x39,
  0x9E, 0x61, 0x86, 0x61, 0x83, 0x61, 0x80, 0x61, 0x80, 0x61, 0x80, 0x61,
  0x80, 0x39, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0x8E, 0x01,
  0x87, 0x01, 0x83, 0x01, 0x83, 0x01, 0x83, 0xC1, 0x83, 0xE1, 0x86, 0x79,
  0x9E, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3E,
  0x00, 0xDF, 0xC0, 0x2E, 0x38, 0x1B, 0x06, 0x0C, 0xC0, 0x83, 0x30, 0x21,
  0x8C, 0x08, 0x43, 0x06, 0x30, 0xE1, 0x88, 0x1F, 0xC6, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x01, 0x8F, 0xE0, 0xC6, 0x18, 0x31, 0x03, 0x18,
  0xC0, 0xC6, 0x30, 0x33, 0x0C, 0x0C, 0x81, 0x03, 0x60, 0x61, 0x90, 0x0F,
  0xEC, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0xF8, 0x07, 0x0C, 0x07, 0x03, 0x03,
  0x01, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x81, 0xE3, 0xE0, 0xF3, 0x38, 0x63, 0x0E, 0x33, 0x03, 0x11, 0x80,
  0xC8, 0xC0, 0x34, 0x60, 0x0E, 0x30, 0x07, 0x0C, 0x03, 0xC7, 0x07, 0x61,
  0xFF, 0x18, 0x3E, 0x06, 0xFF, 0xFF, 0xC0, 0x03, 0x83, 0x03, 0x01, 0x01,
  0x81, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x1C, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x06,
  0x02, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x02, 0x06, 0x05, 0xE3, 0x1F, 0x7F, 0xFC, 0x07, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x66, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x30, 0x30,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x39, 0x9C, 0xE6,
  0x31, 0x98, 0xC0, 0xFF, 0xFF, 0xF0, 0xEF, 0xFE, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x3C, 0x30, 0x0C, 0x60, 0x0E, 0x60,
  0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0x83, 0xC3,
  0x83, 0xC1, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x0E, 0x30, 0x0C, 0x38, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x70, 0xC0, 0xE0,
  0xC0, 0x40, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x1F,
  0xF0, 0x38, 0x38, 0x70, 0x1C, 0x60, 0x0C, 0xC0, 0x0C, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xC0, 0x3F, 0xE0, 0xE0,
  0xE3, 0x00, 0xE6, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x37, 0x00, 0x67, 0x03, 0x87, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x06, 0x0C, 0x03, 0x06,
  0x03, 0x03, 0x03, 0x01, 0x81, 0x00, 0xC1, 0x80, 0x61, 0x80, 0x30, 0x80,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x7F, 0xF9, 0xFF, 0xE6, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x47, 0xC1, 0x7F, 0xCF, 0x07, 0xB8,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0xF0, 0x06, 0x70, 0x78, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x33, 0xE0, 0xDF, 0xF1, 0xE0, 0xF3, 0x80, 0x76, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x40, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x80, 0x63, 0x81,
  0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x38, 0x1C, 0x0F, 0xF0, 0x0F,
  0xF0, 0x38, 0x1C, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x60, 0x06, 0x78, 0x1C, 0x3F, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0xF0, 0xE0, 0x73, 0x80, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x01,
  0xE0, 0x03, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x80, 0x73, 0x81, 0x63,
  0xFC, 0xC1, 0xF3, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xEF, 0xFE, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE6, 0x73, 0x98, 0xC6, 0x63, 0x00, 0x00, 0x04, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0xC0, 0x1F,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x7C, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x3F, 0xF0,
  0x70, 0xE1, 0x80, 0x63, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x7B, 0x43,
  0xF6, 0x86, 0x1D, 0x08, 0x1E, 0x30, 0x3C, 0x60, 0x78, 0xC0, 0xF1, 0x81,
  0xE3, 0x03, 0x46, 0x06, 0x86, 0x0D, 0x0F, 0xFB, 0x0F, 0xB6, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x23, 0x00, 0x18, 0x60, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC0, 0xC0,
  0x30, 0x30, 0x08, 0x0C, 0x06, 0x01, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x30,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0x98, 0x00,
  0x6E, 0x00, 0x1C, 0xFF, 0xC1, 0xFF, 0xE3, 0x00, 0xE6, 0x00, 0xCC, 0x01,
  0xD8, 0x01, 0xB0, 0x03, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x63, 0xFF, 0x87,
  0xFF, 0x8C, 0x03, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x9F, 0xFF, 0x3F, 0xF8, 0x00, 0x03,
  0xE0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x73, 0x00, 0x6C, 0x00, 0x58, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x04, 0xC0, 0x19, 0xC0,
  0x71, 0xC1, 0xC1, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC3, 0x01,
  0xC6, 0x00, 0xCC, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x76, 0x00, 0xCC, 0x07, 0x1F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xF0, 0x61, 0x80, 0x66, 0x00, 0x6C, 0x00,
  0x98, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80,
  0x19, 0x80, 0x73, 0xC1, 0xE3, 0xFE, 0xC1, 0xF1, 0x80, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1A, 0x01,
  0xF0, 0x0D, 0xC0, 0x67, 0x0E, 0x1F, 0xF0, 0x7E, 0x00, 0xC0, 0x07, 0xC0,
  0x0C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x70, 0xC0, 0xE0, 0xC0, 0xC0, 0xC1,
  0x80, 0xC3, 0x00, 0xC6, 0x00, 0xCF, 0x00, 0xDF, 0x00, 0xF9, 0x80, 0xF1,
  0xC0, 0xE0, 0xC0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0,
  0x18, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x3E, 0xC0, 0xDD, 0x81, 0xB9, 0x06, 0x73,
  0x0C, 0xE6, 0x11, 0xC6, 0x63, 0x8C, 0xC7, 0x0B, 0x0E, 0x1E, 0x1C, 0x18,
  0x38, 0x30, 0x70, 0x40, 0xE0, 0x81, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x03, 0xD8, 0x0F, 0x60, 0x3C, 0xC0, 0xF3, 0x03, 0xC6, 0x0F,
  0x18, 0x3C, 0x60, 0xF0, 0xC3, 0xC3, 0x0F, 0x06, 0x3C, 0x18, 0xF0, 0x33,
  0xC0, 0xCF, 0x01, 0xBC, 0x06, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x3C, 0x30, 0x0C, 0x60, 0x0E, 0x60,
  0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x0E, 0x30, 0x0C, 0x38, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF,
  0xE1, 0xFF, 0xF3, 0x00, 0x76, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x77, 0xFF, 0xCF, 0xFE, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38,
  0x3C, 0x30, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x30, 0x0C, 0x38,
  0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xFC, 0x00, 0xFC, 0xFF, 0xE1, 0xFF, 0xF3, 0x00, 0x76, 0x00, 0x6C, 0x00,
  0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x77,
  0xFF, 0xCF, 0xFE, 0x18, 0x30, 0x30, 0x70, 0x60, 0x60, 0xC0, 0x61, 0x80,
  0xC3, 0x00, 0xC6, 0x01, 0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x80, 0x0F,
  0xE0, 0x3F, 0xF8, 0x78, 0x1C, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x7C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x06, 0xE0, 0x06, 0x78, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0x98, 0x06,
  0x70, 0x38, 0xFF, 0xC0, 0xFC, 0x00, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x66, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xE0, 0x18, 0x30, 0x0C, 0x18,
  0x06, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x30, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x6C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0xD0,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x83, 0x06, 0xC3, 0x83,
  0x61, 0xE1, 0xB0, 0xF0, 0xD8, 0x58, 0x4C, 0x64, 0x22, 0x33, 0x11, 0x19,
  0x98, 0x88, 0xCC, 0x6C, 0x26, 0x36, 0x1B, 0x1B, 0x0D, 0x8D, 0x06, 0xC6,
  0x81, 0x63, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x60, 0x01, 0x9C, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x18, 0x1C, 0x0E, 0x03, 0x03, 0x00, 0x61, 0x80,
  0x1C, 0xE0, 0x03, 0x30, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x01,
  0xE0, 0x00, 0xDC, 0x00, 0x33, 0x00, 0x18, 0x60, 0x0E, 0x1C, 0x03, 0x03,
  0x01, 0x80, 0x60, 0xE0, 0x18, 0x30, 0x03, 0x18, 0x00, 0xEE, 0x00, 0x1C,
  0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x38, 0xC0, 0x0C, 0x38, 0x06, 0x06,
  0x01, 0x81, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x18, 0x01, 0x8E, 0x00, 0x33,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFC,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x3F, 0xFF, 0xFC, 0x01, 0x80, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x0C,
  0x30, 0x0C, 0x30, 0x18, 0x18, 0x10, 0x18, 0x30, 0x0C, 0x60, 0x0C, 0x60,
  0x06, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x47, 0x0C, 0x61,
  0x84, 0x0F, 0xC0, 0x3F, 0xF0, 0x70, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x0F, 0xF8, 0x3F, 0xF8, 0x70, 0x18, 0x60, 0x18, 0xC0,
  0x18, 0xC0, 0x18, 0x60, 0x28, 0x70, 0x68, 0x3F, 0xCF, 0x1F, 0x8F, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x23,
  0xF0, 0x9F, 0xE2, 0xC1, 0xCC, 0x03, 0xB0, 0x06, 0x80, 0x1A, 0x00, 0x68,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x68, 0x01, 0xB0, 0x06, 0xC0, 0x3A,
  0xC1, 0xC9, 0xFE, 0x23, 0xE0, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06,
  0x60, 0x0F, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x09, 0xC0, 0x73, 0x83, 0x87, 0xFC, 0x0F, 0xC0, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC3,
  0xF3, 0x1F, 0xEC, 0xE0, 0xF7, 0x00, 0xD8, 0x03, 0x40, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0xD8, 0x03, 0x70, 0x0C,
  0xE0, 0xF1, 0xFE, 0xC3, 0xF3, 0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0x98, 0x06,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x09, 0x80, 0x77, 0x83, 0x8F, 0xFC, 0x0F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x3F, 0xFF, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x7C,
  0x3F, 0x81, 0xFF, 0x03, 0x07, 0x0C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60,
  0x18, 0xC0, 0x31, 0x80, 0x61, 0x83, 0x81, 0xFE, 0x07, 0xF8, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0xFF, 0xF7, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0x7F, 0xFC, 0x3F, 0xC0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xF8, 0x9F, 0xEB, 0x0F,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x03, 0x00, 0x1E,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x6F, 0xFE,
  0xFF, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x0E, 0xC0, 0x31, 0x80, 0xC3, 0x03, 0x06, 0x0C,
  0x0C, 0x70, 0x19, 0xC0, 0x37, 0x80, 0x79, 0x80, 0xE1, 0x81, 0x83, 0x83,
  0x03, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x07, 0x30, 0x07, 0x60, 0x07, 0xFF,
  0x03, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xDE, 0x1C, 0xDF, 0x3E, 0xE3, 0x46, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0x8F, 0x89, 0xFE, 0xB0, 0xFC, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xF1, 0x80,
  0x66, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0x66, 0x01, 0x8E, 0x0F, 0x0F, 0xFC, 0x07,
  0xE0, 0x8F, 0xC2, 0x7F, 0x8B, 0x07, 0x30, 0x0E, 0xC0, 0x1A, 0x00, 0x68,
  0x01, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xA0, 0x06, 0xC0, 0x1B,
  0x00, 0xEB, 0x07, 0x27, 0xF8, 0x8F, 0x82, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0F, 0xCC, 0x7F, 0xB3, 0x83,
  0xDC, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xD0, 0x03, 0x60, 0x0D, 0xC0, 0x33, 0x83, 0xC7, 0xFB, 0x0F,
  0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0xFE, 0x3F, 0xFD, 0xFC, 0x1A, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x7F, 0xFE, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF,
  0xC7, 0x03, 0xD8, 0x02, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x03, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x03, 0x8F,
  0xFE, 0x0F, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xB0, 0x0D,
  0xC1, 0xE7, 0xFB, 0x1F, 0x98, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x11, 0x80,
  0x63, 0x00, 0xC6, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x30, 0x18, 0x60,
  0x30, 0x80, 0x23, 0x00, 0x66, 0x00, 0xC8, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0x80, 0xC0, 0xC0, 0xF0, 0x70, 0x24, 0x1E, 0x09, 0x05, 0x86, 0x41, 0x21,
  0x98, 0x48, 0x66, 0x33, 0x19, 0x8C, 0xC4, 0x22, 0x31, 0x08, 0x84, 0x42,
  0x61, 0x30, 0xD8, 0x6C, 0x34, 0x1B, 0x0D, 0x02, 0x81, 0x40, 0xA0, 0x70,
  0x38, 0x1C, 0x0E, 0x00, 0x60, 0x06, 0x60, 0x18, 0xE0, 0x60, 0xC0, 0xC0,
  0xC3, 0x00, 0xCC, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x80, 0x1B,
  0x80, 0x73, 0x00, 0xC3, 0x03, 0x03, 0x0C, 0x07, 0x38, 0x06, 0xE0, 0x06,
  0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x06, 0x60,
  0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFF, 0xFB, 0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x70, 0xFE, 0x0F, 0xE0, 0x07, 0x00, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x0F, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x07, 0xF0, 0x7F, 0x0E,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0x0F, 0xE0, 0x1C, 0x03, 0x3E, 0x03,
  0x63, 0x03, 0x41, 0x86, 0xC0, 0xC6, 0xC0, 0xFC, 0x80, 0x38,
};

const GFXglyph IBMPlexMono_Light33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 23, 20, 8, -23 },
  { 13, 7, 9, 20, 6, -24 },
  { 21, 18, 23, 20, 1, -23 },
  { 73, 16, 29, 20, 2, -26 },
  { 131, 18, 23, 20, 1, -23 },
  { 183, 17, 23, 20, 1, -23 },
  { 232, 2, 9, 20, 9, -24 },
  { 235, 9, 30, 20, 7, -25 },
  { 269, 9, 30, 20, 4, -25 },
  { 303, 17, 16, 20, 1, -18 },
  { 337, 16, 16, 20, 2, -18 },
  { 369, 5, 9, 20, 7, -4 },
  { 375, 10, 2, 20, 5, -11 },
  { 378, 4, 4, 20, 8, -4 },
  { 380, 14, 30, 20, 3, -25 },
  { 433, 16, 23, 20, 2, -23 },
  { 479, 16, 23, 20, 2, -23 },
  { 525, 16, 23, 20, 2, -23 },
  { 571, 15, 23, 20, 2, -23 },
  { 615, 17, 23, 20, 1, -23 },
  { 664, 14, 23, 20, 3, -23 },
  { 705, 15, 23, 20, 2, -23 },
  { 749, 15, 23, 20, 2, -23 },
  { 793, 16, 23, 20, 2, -23 },
  { 839, 15, 23, 20, 2, -23 },
  { 883, 4, 18, 20, 8, -18 },
  { 892, 5, 23, 20, 7, -18 },
  { 907, 14, 18, 20, 3, -19 },
  { 939, 16, 8, 20, 2, -14 },
  { 955, 14, 18, 20, 3, -19 },
  { 987, 14, 23, 20, 3, -23 },
  { 1028, 15, 27, 20, 2, -23 },
  { 1079, 18, 23, 20, 1, -23 },
  { 1131, 15, 23, 20, 3, -23 },
  { 1175, 15, 23, 20, 2, -23 },
  { 1219, 15, 23, 20, 3, -23 },
  { 1263, 14, 23, 20, 3, -23 },
  { 1304, 14, 23, 20, 3, -23 },
  { 1345, 15, 23, 20, 2, -23 },
  { 1389, 14, 23, 20, 3, -23 },
  { 1430, 14, 23, 20, 3, -23 },
  { 1471, 13, 23, 20, 3, -23 },
  { 1509, 16, 23, 20, 3, -23 },
  { 1555, 14, 23, 20, 4, -23 },
  { 1596, 15, 23, 20, 2, -23 },
  { 1640, 14, 23, 20, 3, -23 },
  { 1681, 16, 23, 20, 2, -23 },
  { 1727, 15, 23, 20, 3, -23 },
  { 1771, 16, 28, 20, 2, -23 },
  { 1827, 15, 23, 20, 3, -23 },
  { 1871, 16, 23, 20, 2, -23 },
  { 1917, 18, 23, 20, 1, -23 },
  { 1969, 14, 23, 20, 3, -23 },
  { 2010, 17, 23, 20, 1, -23 },
  { 2059, 17, 23, 20, 1, -23 },
  { 2108, 18, 23, 20, 1, -23 },
  { 2160, 18, 23, 20, 1, -23 },
  { 2212, 16, 23, 20, 2, -23 },
  { 2258, 9, 30, 20, 8, -25 },
  { 2292, 14, 30, 20, 3, -25 },
  { 2345, 9, 30, 20, 3, -25 },
  { 2379, 16, 13, 20, 2, -23 },
  { 2405, 16, 2, 20, 2, 3 },
  { 2409, 5, 6, 20, 6, -25 },
  { 2413, 16, 17, 20, 2, -17 },
  { 2447, 14, 24, 20, 4, -24 },
  { 2489, 14, 17, 20, 3, -17 },
  { 2519, 14, 24, 20, 2, -24 },
  { 2561, 14, 17, 20, 3, -17 },
  { 2591, 15, 24, 20, 3, -24 },
  { 2636, 15, 26, 20, 3, -19 },
  { 2685, 12, 24, 20, 4, -24 },
  { 2721, 14, 24, 20, 4, -24 },
  { 2763, 12, 31, 20, 3, -24 },
  { 2810, 15, 24, 20, 4, -24 },
  { 2855, 14, 24, 20, 3, -24 },
  { 2897, 16, 17, 20, 2, -17 },
  { 2931, 12, 17, 20, 4, -17 },
  { 2957, 15, 17, 20, 2, -17 },
  { 2989, 14, 24, 20, 4, -17 },
  { 3031, 14, 24, 20, 2, -17 },
  { 3073, 15, 17, 20, 3, -17 },
  { 3105, 14, 17, 20, 3, -17 },
  { 3135, 16, 23, 20, 1, -23 },
  { 3181, 13, 17, 20, 3, -17 },
  { 3209, 15, 17, 20, 2, -17 },
  { 3241, 18, 17, 20, 1, -17 },
  { 3280, 15, 17, 20, 2, -17 },
  { 3312, 16, 24, 20, 2, -17 },
  { 3360, 14, 17, 20, 3, -17 },
  { 3390, 12, 30, 20, 4, -25 },
  { 3435, 2, 30, 20, 9, -25 },
  { 3443, 12, 30, 20, 4, -25 },
  { 3488, 16, 7, 20, 2, -14 },
};

const GFXfont IBMPlexMono_Light33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_LIGHT33PT7B_H_
