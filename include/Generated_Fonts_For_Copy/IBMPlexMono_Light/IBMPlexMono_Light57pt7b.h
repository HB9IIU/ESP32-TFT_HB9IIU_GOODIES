#ifndef _IBMPLEXMONO_LIGHT57PT7B_H_
#define _IBMPLEXMONO_LIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light57pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x38, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xF0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x73, 0xF8, 0x1F, 0x07, 0x07,
  0xC1, 0xE0, 0x70, 0x1E, 0x3C, 0x07, 0x00, 0xF3, 0x80, 0x70, 0x04, 0x38,
  0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03,
  0xE0, 0x70, 0x00, 0x1F, 0x07, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0x3F, 0x80, 0x00, 0x70, 0x7C, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x70, 0x1E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x0F, 0x20,
  0x07, 0x00, 0xF7, 0x00, 0x70, 0x0E, 0xF8, 0x07, 0x01, 0xE7, 0xC0, 0x70,
  0x3E, 0x3F, 0x07, 0x07, 0xC1, 0xFC, 0x73, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x0F, 0xFC, 0x00, 0x0E,
  0x1F, 0xFE, 0x00, 0x0E, 0x3C, 0x1E, 0x00, 0x1C, 0x78, 0x07, 0x00, 0x38,
  0x70, 0x07, 0x00, 0x38, 0x70, 0x03, 0x80, 0x70, 0x60, 0x03, 0x80, 0x70,
  0xE0, 0x03, 0x80, 0xE0, 0xE0, 0x03, 0x80, 0xE0, 0x60, 0x03, 0x81, 0xC0,
  0x60, 0x03, 0x81, 0xC0, 0x70, 0x03, 0x83, 0x80, 0x70, 0x07, 0x07, 0x00,
  0x78, 0x07, 0x07, 0x00, 0x3C, 0x1E, 0x0E, 0x00, 0x1F, 0xFE, 0x0E, 0x00,
  0x0F, 0xFC, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x78, 0x3F, 0xF8, 0x00, 0x70, 0x78, 0x3C, 0x00, 0xE0, 0xF0, 0x1E,
  0x00, 0xE0, 0xE0, 0x0E, 0x01, 0xC0, 0xC0, 0x06, 0x01, 0xC1, 0xC0, 0x07,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x01, 0xC0, 0x07,
  0x0E, 0x01, 0xC0, 0x07, 0x0E, 0x01, 0xC0, 0x07, 0x1C, 0x00, 0xC0, 0x06,
  0x1C, 0x00, 0xE0, 0x0E, 0x38, 0x00, 0xF0, 0x1E, 0x38, 0x00, 0x78, 0x3C,
  0x70, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0x1F, 0xF0, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x78, 0xF0, 0x0F, 0xF3, 0xC1,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0F, 0x03, 0x81, 0xC0, 0x1E,
  0x0E, 0x0F, 0x00, 0x3C, 0x38, 0x38, 0x00, 0x78, 0xC0, 0xE0, 0x00, 0xF3,
  0x03, 0x80, 0x01, 0xFC, 0x0E, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x00, 0x01, 0xF8, 0x1E,
  0x00, 0x0C, 0xF0, 0x3C, 0x00, 0x71, 0xE0, 0xFC, 0x07, 0x83, 0xC1, 0xFF,
  0xFC, 0x07, 0x81, 0xFF, 0xE0, 0x0F, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x04, 0x00, 0x38, 0x00,
  0xBE, 0x01, 0xC0, 0x3D, 0xFE, 0x0E, 0x1F, 0xF7, 0xFE, 0x77, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x78, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x3E, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0xF8, 0x38,
  0x00, 0x3E, 0x07, 0x00, 0x0F, 0x80, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x78,
  0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7E,
  0x03, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8,
  0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x60, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC8, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x07,
  0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x3F, 0xC0, 0x0E, 0x3F, 0xFC, 0x03, 0x9F, 0xFF, 0xC0, 0xEE, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x71, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x07, 0xE0, 0x3F, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x3F, 0xC0, 0x1E, 0x3F, 0xFC, 0x07, 0x9F, 0xFF, 0xC1, 0xCF,
  0x01, 0xF8, 0x76, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xF0, 0x1F,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xE0,
  0x01, 0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x1B,
  0x87, 0xF0, 0x1E, 0xE0, 0xFF, 0xFF, 0x38, 0x0F, 0xFF, 0x1E, 0x00, 0xFF,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x1E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0,
  0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x60, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0x70,
  0x70, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x7E, 0x3B, 0x80, 0x7F,
  0x9D, 0xC0, 0x7F, 0xEE, 0xE0, 0x7C, 0x1F, 0xE0, 0x38, 0x07, 0xF0, 0x38,
  0x01, 0xF8, 0x1C, 0x00, 0xFC, 0x0E, 0x00, 0x7E, 0x07, 0x00, 0x3F, 0x07,
  0x80, 0x1F, 0x83, 0xC0, 0x0F, 0xC1, 0xE0, 0x07, 0xE0, 0xF0, 0x03, 0xF0,
  0x78, 0x01, 0xF8, 0x1C, 0x00, 0xFC, 0x0E, 0x00, 0x7E, 0x07, 0x00, 0x3F,
  0x03, 0x80, 0x1D, 0x81, 0xE0, 0x0E, 0xE0, 0x78, 0x0F, 0x70, 0x3F, 0x3F,
  0xB8, 0x0F, 0xFD, 0xDC, 0x03, 0xFC, 0xEE, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1E, 0x00, 0x1F, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x47, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x04,
  0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x1E, 0x0F, 0x80, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x0F, 0x87, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x1F, 0x0E, 0x00,
  0x3F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x01, 0xF0,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x87, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCE, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x3F, 0x1F, 0x00, 0x1B, 0xC3,
  0xF0, 0x1E, 0xF0, 0x7F, 0xFF, 0x3C, 0x07, 0xFF, 0x0F, 0x00, 0x7F, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00,
  0x07, 0x9E, 0x00, 0x1E, 0x7C, 0x00, 0xF0, 0xF8, 0x0F, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x79, 0xFE,
  0x00, 0x0F, 0x79, 0xE0, 0x01, 0xEE, 0x1E, 0x00, 0x3F, 0xC3, 0xC0, 0x07,
  0xF0, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x07,
  0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFB, 0x80, 0x07, 0x7E,
  0xE0, 0x01, 0xDF, 0x9C, 0x00, 0xE7, 0xE7, 0x00, 0x39, 0xF8, 0xE0, 0x0E,
  0x7E, 0x38, 0x07, 0x1F, 0x8F, 0x01, 0xC7, 0xE1, 0xC0, 0xE1, 0xF8, 0x70,
  0x38, 0x7E, 0x0E, 0x1C, 0x1F, 0x83, 0x87, 0x07, 0xE0, 0x71, 0xC1, 0xF8,
  0x1C, 0xE0, 0x7E, 0x07, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0C,
  0x01, 0xF8, 0x01, 0x00, 0x7E, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7,
  0x00, 0x07, 0xE7, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0xC0, 0x07, 0xE1,
  0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE1, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0,
  0xF0, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x0E, 0x07, 0xE0,
  0x0E, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x87, 0xE0,
  0x03, 0x87, 0xE0, 0x03, 0xC7, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xE7, 0xE0,
  0x00, 0xE7, 0xE0, 0x00, 0xE7, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1C, 0x00, 0x0F,
  0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x81, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3E, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x08, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x20, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0xC1, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x1F, 0x00, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x70, 0x0F,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D,
  0xE0, 0x1E, 0x00, 0xE7, 0x00, 0xF0, 0x07, 0x38, 0x07, 0xC0, 0x39, 0xC0,
  0x7E, 0x01, 0x8E, 0x03, 0xF0, 0x1C, 0x70, 0x1D, 0x80, 0xE3, 0x80, 0xCE,
  0x07, 0x1C, 0x0E, 0x70, 0x38, 0xE0, 0x73, 0x81, 0xC7, 0x03, 0x8C, 0x0E,
  0x38, 0x18, 0x70, 0x71, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x1C, 0x38,
  0x70, 0xE0, 0xE1, 0xC3, 0x03, 0x87, 0x0E, 0x38, 0x1C, 0x30, 0x71, 0xC0,
  0xE3, 0x83, 0x8E, 0x07, 0x1C, 0x1C, 0x70, 0x1C, 0xE0, 0xE7, 0x00, 0xE7,
  0x07, 0x38, 0x07, 0x38, 0x39, 0xC0, 0x39, 0xC1, 0xCE, 0x00, 0xEE, 0x0E,
  0xE0, 0x07, 0x70, 0x37, 0x00, 0x3B, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x03,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x07,
  0x80, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0xF0, 0x0E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0x20, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x02, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x1C, 0x00, 0x0F, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x87,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x01,
  0x38, 0x3F, 0x01, 0xE7, 0xF3, 0xFF, 0xF8, 0xFE, 0x1F, 0xFE, 0x0F, 0xC0,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x7F, 0x00, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF, 0xF0,
  0xE7, 0x01, 0xF8, 0xEC, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xEC, 0x00, 0x7C,
  0xE7, 0x01, 0xF8, 0xE3, 0xFF, 0xF0, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC,
  0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x04,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x06,
  0x3C, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x1F, 0x00, 0x1E, 0x0F, 0xC0, 0x7C,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0xFE, 0x07,
  0x03, 0xFF, 0x87, 0x0F, 0xFF, 0xC7, 0x1F, 0x80, 0xE7, 0x1E, 0x00, 0x37,
  0x3C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x37, 0x1F, 0x80, 0xE7, 0x0F, 0xFF, 0xC7,
  0x03, 0xFF, 0x87, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0xE0, 0x00, 0x0E,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xF9, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x1C, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x7F, 0x03, 0x87,
  0xFF, 0x0E, 0x3F, 0xFE, 0x39, 0xC0, 0x7C, 0xEC, 0x00, 0xFB, 0xA0, 0x01,
  0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFB, 0x80,
  0x00, 0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38,
  0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0E, 0x01, 0xF0, 0x07, 0x01, 0xF0, 0x03,
  0x81, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0x71, 0xF8, 0x00,
  0x39, 0xFE, 0x00, 0x1D, 0xC7, 0x80, 0x0F, 0xC1, 0xE0, 0x07, 0xC0, 0xF0,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00,
  0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3E,
  0x1C, 0xFF, 0x1F, 0xF3, 0xBF, 0xE3, 0xFF, 0x7C, 0x1E, 0xC1, 0xEF, 0x01,
  0xF0, 0x1D, 0xC0, 0x3C, 0x03, 0xB8, 0x07, 0x80, 0x7F, 0x00, 0x70, 0x07,
  0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07,
  0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F,
  0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38,
  0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8,
  0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0,
  0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0,
  0x1C, 0x01, 0xC0, 0x00, 0x7F, 0x03, 0x87, 0xFF, 0x0E, 0x3F, 0xFE, 0x39,
  0xC0, 0x7C, 0xEC, 0x00, 0xFB, 0xA0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x70, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x07,
  0x00, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xE1, 0xFF,
  0xC0, 0xE3, 0xFF, 0xF0, 0xE7, 0x01, 0xF8, 0xEC, 0x00, 0x7C, 0xF8, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x3C, 0xEC, 0x00, 0x7C, 0xE7, 0x01, 0xF8, 0xE3, 0xFF, 0xF0, 0xE1, 0xFF,
  0xC0, 0xE0, 0x7F, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0x87, 0x0F, 0xFF, 0xC7, 0x1F, 0x80, 0xE7, 0x1E, 0x00,
  0x37, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x37, 0x1F, 0x80, 0xE7, 0x0F, 0xFF,
  0xC7, 0x03, 0xFF, 0x87, 0x00, 0xFE, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0,
  0x03, 0x9C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x01, 0xFC, 0x1E, 0x00, 0x0F, 0x8F,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x20, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xBE, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF0, 0x7E,
  0x00, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0x78, 0x00, 0x7D, 0xF0, 0x03, 0x73, 0xF0, 0x3D, 0xC7, 0xFF,
  0xE7, 0x0F, 0xFF, 0x1C, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0F,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x03,
  0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E,
  0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x70, 0x0E, 0xC0,
  0x1D, 0xC0, 0x3B, 0x00, 0x67, 0x00, 0xCE, 0x03, 0x9C, 0x03, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0x86, 0x03, 0x8E,
  0x06, 0x1C, 0x0C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xC1, 0xC3, 0x83,
  0x03, 0x07, 0x06, 0x0C, 0x0E, 0x1C, 0x18, 0x70, 0x38, 0x70, 0x71, 0xC0,
  0xE1, 0x81, 0xC7, 0x01, 0x86, 0x07, 0x18, 0x06, 0x38, 0x1C, 0x60, 0x1C,
  0xE0, 0x33, 0x80, 0x73, 0x80, 0xCE, 0x00, 0xCE, 0x03, 0xB0, 0x03, 0x30,
  0x0E, 0xC0, 0x0E, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x70, 0xFF, 0x00, 0x07, 0x1F, 0xF8, 0x00,
  0x71, 0xC3, 0xC0, 0x07, 0x38, 0x1E, 0x00, 0xE3, 0x80, 0xF0, 0x0E, 0x70,
  0x07, 0x00, 0xE7, 0x00, 0x78, 0x1C, 0x60, 0x03, 0xE3, 0xCE, 0x00, 0x1F,
  0xF8, 0xE0, 0x00, 0xFF, 0x06, 0x00, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Light57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 6, 40, 34, 14, -40 },
  { 31, 12, 15, 34, 11, -42 },
  { 54, 32, 40, 34, 1, -40 },
  { 214, 28, 53, 34, 3, -46 },
  { 400, 32, 41, 34, 1, -40 },
  { 564, 30, 41, 34, 2, -40 },
  { 718, 4, 15, 34, 15, -42 },
  { 726, 16, 51, 34, 12, -43 },
  { 828, 15, 51, 34, 7, -43 },
  { 924, 29, 28, 34, 3, -31 },
  { 1026, 27, 27, 34, 4, -31 },
  { 1118, 9, 15, 34, 12, -6 },
  { 1135, 16, 3, 34, 9, -19 },
  { 1141, 6, 6, 34, 14, -6 },
  { 1146, 24, 51, 34, 5, -43 },
  { 1299, 27, 41, 34, 4, -40 },
  { 1438, 27, 40, 34, 4, -40 },
  { 1573, 26, 40, 34, 4, -40 },
  { 1703, 26, 41, 34, 3, -40 },
  { 1837, 30, 40, 34, 2, -40 },
  { 1987, 26, 41, 34, 4, -40 },
  { 2121, 26, 41, 34, 4, -40 },
  { 2255, 26, 40, 34, 4, -40 },
  { 2385, 27, 41, 34, 4, -40 },
  { 2524, 26, 40, 34, 4, -40 },
  { 2654, 6, 30, 34, 14, -30 },
  { 2677, 9, 39, 34, 12, -30 },
  { 2721, 24, 32, 34, 5, -33 },
  { 2817, 27, 13, 34, 4, -24 },
  { 2861, 24, 32, 34, 5, -33 },
  { 2957, 24, 40, 34, 5, -40 },
  { 3077, 25, 46, 34, 4, -40 },
  { 3221, 30, 40, 34, 2, -40 },
  { 3371, 25, 40, 34, 5, -40 },
  { 3496, 26, 41, 34, 4, -40 },
  { 3630, 25, 40, 34, 6, -40 },
  { 3755, 24, 40, 34, 6, -40 },
  { 3875, 24, 40, 34, 6, -40 },
  { 3995, 26, 41, 34, 4, -40 },
  { 4129, 24, 40, 34, 5, -40 },
  { 4249, 24, 40, 34, 5, -40 },
  { 4369, 22, 41, 34, 5, -40 },
  { 4482, 27, 40, 34, 5, -40 },
  { 4617, 23, 40, 34, 7, -40 },
  { 4732, 26, 40, 34, 4, -40 },
  { 4862, 24, 40, 34, 5, -40 },
  { 4982, 27, 41, 34, 4, -40 },
  { 5121, 25, 40, 34, 6, -40 },
  { 5246, 27, 49, 34, 4, -40 },
  { 5412, 25, 40, 34, 6, -40 },
  { 5537, 28, 41, 34, 3, -40 },
  { 5681, 30, 40, 34, 2, -40 },
  { 5831, 24, 41, 34, 5, -40 },
  { 5954, 30, 40, 34, 2, -40 },
  { 6104, 29, 40, 34, 3, -40 },
  { 6249, 30, 40, 34, 2, -40 },
  { 6399, 32, 40, 34, 1, -40 },
  { 6559, 28, 40, 34, 3, -40 },
  { 6699, 15, 51, 34, 14, -43 },
  { 6795, 24, 51, 34, 5, -43 },
  { 6948, 15, 51, 34, 5, -43 },
  { 7044, 28, 23, 34, 3, -40 },
  { 7125, 28, 3, 34, 3, 6 },
  { 7136, 8, 10, 34, 11, -44 },
  { 7146, 27, 31, 34, 4, -30 },
  { 7251, 24, 43, 34, 6, -42 },
  { 7380, 24, 31, 34, 5, -30 },
  { 7473, 24, 43, 34, 4, -42 },
  { 7602, 26, 31, 34, 4, -30 },
  { 7703, 27, 42, 34, 4, -42 },
  { 7845, 28, 45, 34, 4, -33 },
  { 8003, 22, 42, 34, 6, -42 },
  { 8119, 25, 42, 34, 6, -42 },
  { 8251, 21, 53, 34, 5, -42 },
  { 8391, 25, 42, 34, 7, -42 },
  { 8523, 24, 42, 34, 5, -42 },
  { 8649, 27, 30, 34, 4, -30 },
  { 8751, 22, 30, 34, 6, -30 },
  { 8834, 26, 31, 34, 4, -30 },
  { 8935, 24, 41, 34, 6, -30 },
  { 9058, 24, 41, 34, 4, -30 },
  { 9181, 28, 29, 34, 4, -29 },
  { 9283, 26, 31, 34, 4, -30 },
  { 9384, 28, 40, 34, 2, -40 },
  { 9524, 22, 30, 34, 6, -29 },
  { 9607, 26, 29, 34, 4, -29 },
  { 9702, 30, 29, 34, 2, -29 },
  { 9811, 26, 29, 34, 4, -29 },
  { 9906, 27, 40, 34, 4, -29 },
  { 10041, 24, 29, 34, 5, -29 },
  { 10128, 22, 51, 34, 6, -43 },
  { 10269, 3, 51, 34, 16, -43 },
  { 10289, 22, 51, 34, 6, -43 },
  { 10430, 28, 12, 34, 3, -23 },
};

const GFXfont IBMPlexMono_Light57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_LIGHT57PT7B_H_
