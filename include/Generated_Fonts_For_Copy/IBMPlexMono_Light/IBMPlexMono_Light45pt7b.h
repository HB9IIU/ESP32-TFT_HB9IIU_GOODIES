#ifndef _IBMPLEXMONO_LIGHT45PT7B_H_
#define _IBMPLEXMONO_LIGHT45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light45pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0xC4, 0x21,
  0x08, 0x40, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFD, 0xC0, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x00,
  0x30, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x1F, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F,
  0xF0, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x1F, 0xF0,
  0x3F, 0xEF, 0xF8, 0x3F, 0xF0, 0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xC6, 0x7C, 0x38, 0x30, 0xF3,
  0x81, 0x81, 0xDC, 0x0C, 0x04, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x30, 0x03, 0xC1, 0x80, 0x0F,
  0x0C, 0x00, 0x3E, 0x60, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x06, 0x3E, 0x00, 0x30, 0x70, 0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x68, 0x06, 0x07,
  0xC0, 0x30, 0x3F, 0x81, 0x83, 0x9E, 0x0C, 0x3C, 0x7C, 0x67, 0xC1, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xCE,
  0x1C, 0x00, 0xCC, 0x06, 0x00, 0xE6, 0x03, 0x80, 0x67, 0x00, 0xC0, 0x73,
  0x00, 0x60, 0x31, 0x80, 0x30, 0x30, 0xC0, 0x18, 0x38, 0x60, 0x0C, 0x18,
  0x38, 0x06, 0x1C, 0x0C, 0x07, 0x0C, 0x06, 0x03, 0x0E, 0x01, 0xC3, 0x86,
  0x00, 0xFF, 0x87, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x70, 0xFF, 0x00, 0x30, 0xE1, 0xC0, 0x38, 0x60, 0x30, 0x18,
  0x70, 0x18, 0x1C, 0x30, 0x0E, 0x0C, 0x18, 0x03, 0x0E, 0x0C, 0x01, 0x86,
  0x06, 0x00, 0xC6, 0x03, 0x00, 0x67, 0x01, 0x80, 0x73, 0x00, 0xC0, 0x33,
  0x80, 0x30, 0x19, 0x80, 0x1C, 0x39, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x87, 0x80, 0x0E, 0x01,
  0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0xE0, 0x3F, 0x1C, 0x60, 0x3F, 0x38, 0x70, 0x30, 0x30, 0x38,
  0x30, 0x70, 0x1C, 0x30, 0x60, 0x0E, 0x30, 0x60, 0x07, 0x30, 0xE0, 0x03,
  0x30, 0xE0, 0x03, 0xE0, 0xE0, 0x01, 0xE0, 0x60, 0x00, 0xE0, 0x70, 0x00,
  0xF0, 0x70, 0x01, 0xB8, 0x38, 0x03, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0xFC,
  0x07, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x20, 0x1C, 0x02, 0xF8, 0x38, 0x3F, 0xFE,
  0x73, 0xFC, 0x7F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x3C,
  0xF7, 0x9E, 0x79, 0xC7, 0x1C, 0xE3, 0x8C, 0x30, 0xFF, 0xFF, 0xFF, 0xC0,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38,
  0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCE, 0x00, 0x0E,
  0x60, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x81, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F,
  0x03, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x33, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0xE0, 0x3C, 0x1E,
  0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xEE, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83,
  0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0x81, 0xE0, 0x70, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x73,
  0x80, 0x03, 0x84, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1E, 0x07, 0x83, 0x80, 0x3C, 0x70, 0x01, 0xC2, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00, 0x1C, 0x3C,
  0x07, 0x81, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18,
  0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x18, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x01, 0x80, 0xE0,
  0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x0F, 0xC0,
  0x33, 0xFF, 0x83, 0x60, 0x3C, 0x38, 0x01, 0xE3, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x60, 0x00, 0x7F, 0x00, 0x0E, 0x78,
  0x01, 0xE3, 0xE0, 0x7C, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x0F, 0xE0, 0x39, 0xFF, 0xC1, 0xB8, 0x0F,
  0x0D, 0x80, 0x3C, 0x78, 0x00, 0xE7, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x07,
  0x60, 0x00, 0x33, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x01, 0xC1, 0xC0,
  0x1E, 0x07, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0x80, 0xF0, 0x78, 0x03, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xE3, 0x80, 0x0E, 0x0E, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0xF0, 0x1E, 0x0E, 0x00, 0x38, 0xE0, 0x00, 0xEE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x77, 0x00, 0x07, 0x1C,
  0x00, 0x70, 0x78, 0x0F, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xC0, 0xF0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x38,
  0x00, 0x39, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x01, 0xE7, 0x00, 0x1E, 0x3C, 0x01, 0xB0, 0xF8, 0x1D, 0x83, 0xFF, 0x9C,
  0x07, 0xF0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF,
  0xEE, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x3D, 0xE7, 0x9E, 0x71, 0xC7, 0x38, 0xE3, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xF8,
  0x3E, 0x3C, 0x01, 0xC7, 0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x3A, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x18, 0x00, 0xE3, 0x80,
  0x06, 0x30, 0x00, 0x67, 0x00, 0x07, 0x70, 0x00, 0x36, 0x01, 0xE3, 0x60,
  0x7F, 0xB6, 0x0F, 0x0B, 0x60, 0xC0, 0x7E, 0x1C, 0x07, 0xE1, 0xC0, 0x3E,
  0x18, 0x03, 0xE1, 0x80, 0x3E, 0x18, 0x03, 0xE1, 0x80, 0x3E, 0x18, 0x03,
  0xE1, 0x80, 0x3E, 0x18, 0x03, 0xE1, 0x80, 0x3E, 0x1C, 0x03, 0x60, 0xC0,
  0x76, 0x0E, 0x07, 0x60, 0x7F, 0xB6, 0x03, 0xF3, 0x60, 0x08, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x19, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x06, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x70, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x30,
  0x01, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0x00, 0x06, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x31, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE6, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x70,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x03, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC,
  0x01, 0xE0, 0xF0, 0x1C, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x18, 0xE0,
  0x00, 0xE6, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x70, 0x00, 0x61, 0xC0, 0x07, 0x07,
  0x00, 0x70, 0x1E, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00,
  0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x0F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0x03, 0xC1, 0xC0, 0x1E, 0x38, 0x00,
  0xE3, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0x60, 0x00, 0x37, 0x00, 0x03, 0x70, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00,
  0xB1, 0xC0, 0x1B, 0x0F, 0x07, 0x30, 0x7F, 0xE3, 0x01, 0xF8, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xA0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xE7, 0x00, 0x71, 0xE0, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x38,
  0x70, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03,
  0x9F, 0x80, 0x1C, 0xFC, 0x00, 0xEE, 0x70, 0x07, 0xE1, 0xC0, 0x3E, 0x0E,
  0x01, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0xF0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x79, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xF6, 0x00, 0xDF, 0xB8,
  0x0E, 0xFC, 0xC0, 0x67, 0xE7, 0x03, 0x3F, 0x38, 0x39, 0xF8, 0xC1, 0x8F,
  0xC7, 0x1C, 0x7E, 0x18, 0xC3, 0xF0, 0xEE, 0x1F, 0x83, 0x60, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0x40, 0x7E,
  0x02, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x03,
  0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x1C, 0x07,
  0x83, 0x80, 0xF0, 0x30, 0x1E, 0x07, 0x03, 0xC0, 0x60, 0x78, 0x0E, 0x0F,
  0x01, 0xC1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80, 0x38, 0xF0, 0x07, 0x1E,
  0x00, 0x73, 0xC0, 0x0E, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xC1, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0x60, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00,
  0x33, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x0E,
  0x00, 0xE0, 0x3C, 0x1E, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x03, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0,
  0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0x60, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x80, 0x03,
  0x8C, 0x00, 0x18, 0x70, 0x01, 0xC1, 0xC0, 0x1C, 0x07, 0x83, 0xC0, 0x1F,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x03, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFE, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x0E, 0x00, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0x70, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xF0, 0x1F, 0x07, 0x00,
  0x1E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x47, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x74, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xF0, 0x00, 0x38, 0xF0, 0x01,
  0xC1, 0xF0, 0x1F, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1D,
  0x80, 0x03, 0x38, 0x00, 0xE3, 0x80, 0x38, 0x78, 0x0F, 0x07, 0xFF, 0xC0,
  0x3F, 0xE0, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x18, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x60, 0x03,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x60,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x30, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x70,
  0x19, 0x80, 0xE0, 0x33, 0x03, 0xE0, 0x66, 0x06, 0xC0, 0xCE, 0x0D, 0x81,
  0x9C, 0x1B, 0x07, 0x38, 0x77, 0x0E, 0x70, 0xC6, 0x1C, 0x61, 0x8C, 0x38,
  0xC3, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x18, 0x31, 0x86, 0x30, 0x63, 0x0C,
  0x60, 0xE6, 0x19, 0xC1, 0xCC, 0x33, 0x01, 0x98, 0x76, 0x03, 0x30, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x61, 0xC0,
  0x01, 0xC1, 0xC0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x80,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x38, 0x00,
  0x18, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x03, 0x9E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00, 0x07,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0x81,
  0xC0, 0x07, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E,
  0x60, 0x00, 0x0D, 0x40, 0x00, 0x14, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x43, 0x87, 0x1C, 0x38, 0x60, 0xC3, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x07,
  0x03, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x10, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1E, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38,
  0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x86, 0x00,
  0x2C, 0x38, 0x03, 0x60, 0xF0, 0x73, 0xE3, 0xFF, 0x0F, 0x07, 0xE0, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x3F, 0x03,
  0x1F, 0xF8, 0x66, 0x07, 0x8D, 0x00, 0x79, 0xC0, 0x07, 0x38, 0x00, 0x77,
  0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x34,
  0x01, 0xE6, 0x60, 0x78, 0xC7, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x3C, 0x1E, 0x0E, 0x00, 0xE3, 0x80, 0x0C, 0x60, 0x01, 0xDC,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x23, 0x80, 0x0E, 0x38,
  0x03, 0x83, 0xC1, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x7E, 0x0C, 0x3F, 0xF1, 0x8F,
  0x03, 0x33, 0xC0, 0x16, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x03, 0x60,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x01, 0xCF, 0x00, 0x58, 0xF0,
  0x33, 0x0F, 0xFC, 0x60, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xC1, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x08, 0x60, 0x00, 0xE3, 0x80,
  0x06, 0x0E, 0x00, 0x70, 0x3C, 0x0F, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xD8, 0x01,
  0xFF, 0xE0, 0x0F, 0x07, 0x80, 0x70, 0x07, 0x01, 0x80, 0x0C, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0x60, 0x03, 0x01, 0xC0, 0x1C, 0x03, 0xC1, 0xE0, 0x07,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x60, 0x01, 0xE3, 0x00, 0x01, 0x98, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x38, 0xF0, 0x03,
  0xC1, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x61, 0xFC, 0x31, 0xFF, 0x19, 0x83, 0xCD, 0x00, 0x77, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x7F, 0xFE, 0x7F, 0xFC,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x78, 0x70, 0x07,
  0x83, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x38,
  0x70, 0x01, 0xC7, 0x80, 0x0E, 0xFE, 0x00, 0x7E, 0x70, 0x03, 0xE1, 0xC0,
  0x1E, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xF0, 0x38, 0x03, 0x81, 0xC0,
  0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0x78, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x83,
  0xE6, 0x7E, 0x3F, 0xB4, 0x3B, 0x1F, 0xC0, 0xD0, 0x7C, 0x07, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0x03, 0xF8, 0x63, 0xFE, 0x33, 0x07, 0x9A, 0x00, 0xEE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0,
  0x38, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00,
  0x0E, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x0E,
  0x00, 0xE0, 0x3C, 0x1E, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x18, 0xFF, 0xC3, 0x30, 0x3C, 0x68, 0x03, 0xCE, 0x00, 0x39, 0xC0, 0x03,
  0xB8, 0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x39,
  0xA0, 0x0F, 0x33, 0x03, 0xC6, 0x3F, 0xF0, 0xC1, 0xF8, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x8C, 0x78, 0x19,
  0x9E, 0x00, 0xB3, 0x80, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x03, 0xB8, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x02, 0xC7, 0x81, 0x98,
  0x7F, 0xE3, 0x03, 0xF0, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xC0, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1A,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1E, 0x03, 0xC3, 0x80, 0x0F, 0x38,
  0x00, 0x63, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x36, 0x00, 0x03, 0xF0, 0x00, 0x77, 0x80, 0x0E, 0x1E, 0x03, 0xE0, 0xFF,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x77, 0x00, 0x5B, 0xC0, 0xCC, 0x7F, 0xC6, 0x1F, 0xC0, 0xE0, 0x00, 0x3B,
  0x80, 0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0x60, 0x03, 0x03, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0xE0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x83, 0x80, 0x0C, 0x18,
  0x00, 0x70, 0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x77, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x1C,
  0x03, 0xB0, 0x0E, 0x01, 0x98, 0x0F, 0x80, 0xCC, 0x06, 0xC0, 0x66, 0x03,
  0x60, 0x33, 0x81, 0xB0, 0x38, 0xC0, 0xC8, 0x18, 0x60, 0xC6, 0x0C, 0x30,
  0x63, 0x06, 0x18, 0x31, 0x83, 0x0C, 0x18, 0xC1, 0x87, 0x18, 0x31, 0xC1,
  0x8C, 0x18, 0xC0, 0xC6, 0x0C, 0x60, 0x63, 0x06, 0x30, 0x31, 0x81, 0x18,
  0x19, 0x80, 0xCC, 0x0E, 0xC0, 0x66, 0x03, 0x60, 0x36, 0x01, 0xB0, 0x1B,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0xF0, 0x00,
  0x79, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x80, 0xE0, 0x38, 0x03,
  0x81, 0x80, 0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xDC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00, 0x06,
  0x70, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x00, 0x06,
  0x1C, 0x00, 0x70, 0x60, 0x03, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x60,
  0x0C, 0x03, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0x70, 0x70, 0x01, 0x83, 0x80,
  0x0C, 0x18, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00, 0x36,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x78, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x1E, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0x80, 0x0E, 0x3F, 0x80, 0x18, 0xE3, 0x80, 0x31, 0x83, 0x80, 0x67, 0x03,
  0x81, 0x8C, 0x03, 0x83, 0x18, 0x03, 0x8C, 0x30, 0x03, 0xF8, 0xE0, 0x03,
  0xC0,
};

const GFXglyph IBMPlexMono_Light45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 5, 31, 27, 11, -31 },
  { 21, 9, 12, 27, 9, -33 },
  { 35, 25, 31, 27, 1, -31 },
  { 132, 21, 43, 27, 3, -37 },
  { 245, 25, 33, 27, 1, -32 },
  { 349, 24, 33, 27, 1, -32 },
  { 448, 3, 12, 27, 12, -33 },
  { 453, 12, 40, 27, 10, -34 },
  { 513, 12, 40, 27, 5, -34 },
  { 573, 23, 22, 27, 2, -25 },
  { 637, 21, 22, 27, 3, -25 },
  { 695, 6, 12, 27, 10, -5 },
  { 704, 13, 2, 27, 7, -15 },
  { 708, 5, 5, 27, 11, -5 },
  { 712, 19, 40, 27, 4, -34 },
  { 807, 21, 33, 27, 3, -32 },
  { 894, 22, 31, 27, 3, -31 },
  { 980, 21, 32, 27, 3, -32 },
  { 1064, 20, 33, 27, 3, -32 },
  { 1147, 23, 31, 27, 2, -31 },
  { 1237, 20, 32, 27, 3, -31 },
  { 1317, 21, 32, 27, 3, -31 },
  { 1401, 21, 31, 27, 3, -31 },
  { 1483, 21, 33, 27, 3, -32 },
  { 1570, 21, 32, 27, 3, -32 },
  { 1654, 5, 24, 27, 11, -24 },
  { 1669, 6, 31, 27, 10, -24 },
  { 1693, 19, 25, 27, 4, -26 },
  { 1753, 21, 11, 27, 3, -19 },
  { 1782, 19, 25, 27, 4, -26 },
  { 1842, 19, 32, 27, 4, -32 },
  { 1918, 20, 37, 27, 3, -32 },
  { 2011, 23, 31, 27, 2, -31 },
  { 2101, 20, 31, 27, 4, -31 },
  { 2179, 21, 33, 27, 3, -32 },
  { 2266, 20, 31, 27, 4, -31 },
  { 2344, 19, 31, 27, 4, -31 },
  { 2418, 20, 31, 27, 4, -31 },
  { 2496, 20, 33, 27, 3, -32 },
  { 2579, 19, 31, 27, 4, -31 },
  { 2653, 19, 31, 27, 4, -31 },
  { 2727, 17, 32, 27, 4, -31 },
  { 2795, 21, 31, 27, 4, -31 },
  { 2877, 18, 31, 27, 6, -31 },
  { 2947, 21, 31, 27, 3, -31 },
  { 3029, 19, 31, 27, 4, -31 },
  { 3103, 21, 33, 27, 3, -32 },
  { 3190, 20, 31, 27, 4, -31 },
  { 3268, 21, 38, 27, 3, -32 },
  { 3368, 20, 31, 27, 4, -31 },
  { 3446, 22, 33, 27, 2, -32 },
  { 3537, 25, 31, 27, 1, -31 },
  { 3634, 19, 32, 27, 4, -31 },
  { 3710, 23, 31, 27, 2, -31 },
  { 3800, 23, 31, 27, 2, -31 },
  { 3890, 23, 31, 27, 2, -31 },
  { 3980, 25, 31, 27, 1, -31 },
  { 4077, 23, 31, 27, 2, -31 },
  { 4167, 12, 40, 27, 11, -34 },
  { 4227, 19, 40, 27, 4, -34 },
  { 4322, 12, 40, 27, 4, -34 },
  { 4382, 23, 18, 27, 2, -31 },
  { 4434, 21, 2, 27, 3, 5 },
  { 4440, 6, 8, 27, 9, -35 },
  { 4446, 21, 25, 27, 3, -24 },
  { 4512, 19, 34, 27, 5, -33 },
  { 4593, 19, 25, 27, 4, -24 },
  { 4653, 19, 34, 27, 3, -33 },
  { 4734, 21, 25, 27, 3, -24 },
  { 4800, 21, 33, 27, 3, -33 },
  { 4887, 22, 36, 27, 3, -26 },
  { 4986, 17, 33, 27, 5, -33 },
  { 5057, 19, 33, 27, 5, -33 },
  { 5136, 16, 42, 27, 4, -33 },
  { 5220, 21, 33, 27, 5, -33 },
  { 5307, 19, 33, 27, 4, -33 },
  { 5386, 21, 24, 27, 3, -24 },
  { 5449, 17, 24, 27, 5, -24 },
  { 5500, 21, 25, 27, 3, -24 },
  { 5566, 19, 33, 27, 5, -24 },
  { 5645, 19, 33, 27, 3, -24 },
  { 5724, 21, 23, 27, 4, -23 },
  { 5785, 20, 25, 27, 3, -24 },
  { 5848, 22, 31, 27, 2, -31 },
  { 5934, 17, 24, 27, 5, -23 },
  { 5985, 21, 23, 27, 3, -23 },
  { 6046, 25, 23, 27, 1, -23 },
  { 6118, 21, 23, 27, 3, -23 },
  { 6179, 21, 32, 27, 3, -23 },
  { 6263, 19, 23, 27, 4, -23 },
  { 6318, 17, 40, 27, 5, -34 },
  { 6403, 3, 40, 27, 12, -34 },
  { 6418, 17, 40, 27, 5, -34 },
  { 6503, 23, 9, 27, 2, -18 },
};

const GFXfont IBMPlexMono_Light45pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light45pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _IBMPLEXMONO_LIGHT45PT7B_H_
