#ifndef _IBMPLEXMONO_LIGHT37PT7B_H_
#define _IBMPLEXMONO_LIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light37pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x62, 0x20, 0x00, 0x00,
  0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x7F, 0x87, 0xFB,
  0xF8, 0x3F, 0xC0, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86,
  0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x01,
  0x87, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xC4,
  0x70, 0xC1, 0x0E, 0x70, 0x40, 0xD8, 0x10, 0x06, 0x04, 0x01, 0x81, 0x00,
  0x60, 0x40, 0x1C, 0x10, 0x03, 0x84, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x04, 0x78, 0x01, 0x06, 0x00, 0x41, 0xC0, 0x10, 0x30, 0x04,
  0x0C, 0x01, 0x03, 0x40, 0x40, 0xF8, 0x10, 0x77, 0x04, 0x38, 0xF1, 0x1C,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x1F, 0x00, 0x33, 0xF8, 0x03, 0x61, 0xC0, 0x6C, 0x0C, 0x04,
  0xC0, 0x40, 0xCC, 0x06, 0x18, 0xC0, 0x61, 0x8C, 0x06, 0x30, 0xC0, 0x43,
  0x0C, 0x0C, 0x60, 0x61, 0xC6, 0x03, 0xF8, 0x80, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xE0, 0x33, 0x86, 0x06, 0x30, 0x30, 0x43, 0x03, 0x0C,
  0x20, 0x31, 0x82, 0x03, 0x18, 0x20, 0x33, 0x03, 0x03, 0x30, 0x30, 0x36,
  0x03, 0x86, 0x60, 0x1F, 0xEC, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x7F, 0x80,
  0x0E, 0x1C, 0x01, 0x80, 0xE0, 0x18, 0x04, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x01, 0xF3, 0xB8, 0x1F, 0x31, 0xC1, 0x86, 0x0E, 0x10, 0x60,
  0x71, 0x0C, 0x03, 0xB0, 0xC0, 0x1F, 0x0C, 0x00, 0xF0, 0xC0, 0x06, 0x0E,
  0x00, 0x70, 0x70, 0x0B, 0x83, 0x83, 0x9C, 0x1F, 0xF0, 0xE0, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x30, 0x37, 0xC6, 0x3E, 0x3F, 0xFF,
  0x20, 0xFF, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x33, 0x00, 0x0E, 0x30,
  0x03, 0x87, 0x00, 0x60, 0x60, 0x18, 0x06, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x39, 0xDE, 0xE7, 0x31, 0x9C, 0xC6, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE0, 0xE0,
  0xE0, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0xE0, 0xF8, 0x78,
  0x3E, 0x0E, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x19,
  0x80, 0x06, 0x70, 0x01, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0x78, 0x38, 0x0F,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x76, 0x00, 0x39,
  0x80, 0x1C, 0x60, 0x0E, 0x18, 0x07, 0x06, 0x03, 0x81, 0x80, 0x40, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xFC, 0x0E, 0x0F, 0x0E, 0x01, 0xCE,
  0x00, 0x66, 0x00, 0x31, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x07, 0xFE, 0x0F, 0x07, 0x86, 0x00, 0xE6, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x74, 0x00, 0x3F, 0x00, 0x19, 0xC0, 0x1C,
  0x70, 0x3C, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0x70, 0x00, 0x37, 0x00, 0x06, 0x70, 0x00, 0xC7,
  0x00, 0x0C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x60,
  0x70, 0x06, 0x07, 0x00, 0xC0, 0x70, 0x18, 0x07, 0x01, 0x80, 0x70, 0x30,
  0x07, 0x06, 0x00, 0x70, 0x60, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x3F, 0xFE, 0x3F, 0xFE, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x63, 0xF0, 0x6F, 0xFC,
  0x78, 0x1E, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x40, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x78, 0x1C,
  0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x63, 0xF0, 0xEF, 0xFC, 0xD8, 0x1E, 0xF0, 0x06, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07,
  0x70, 0x06, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x83, 0xC0, 0xF0, 0xE0, 0x0C, 0x70, 0x03, 0x98,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00, 0xE3, 0x80,
  0x30, 0x70, 0x38, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xF1, 0xC0, 0x0E,
  0x60, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xD8,
  0x00, 0x77, 0x00, 0x38, 0xF0, 0x3C, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x07,
  0xE0, 0x0F, 0xFC, 0x0E, 0x07, 0x0E, 0x00, 0xC6, 0x00, 0x76, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xDC, 0x00,
  0xE7, 0x00, 0x71, 0xC0, 0xD8, 0x7F, 0xCC, 0x1F, 0x8C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x7B, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xDE, 0xE7, 0x31, 0x9C, 0xC6, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3C,
  0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0x40, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0x03, 0xF0, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x07,
  0xE0, 0x1F, 0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0xF3, 0xC1, 0xFB, 0xC3, 0x87, 0xC3, 0x03, 0xC6,
  0x03, 0xC6, 0x03, 0xC6, 0x03, 0xC6, 0x03, 0xC6, 0x03, 0xC6, 0x03, 0xC6,
  0x03, 0xC7, 0x03, 0xC3, 0x07, 0xC3, 0xFB, 0xC1, 0xFB, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x01, 0x98, 0x00,
  0x19, 0x80, 0x01, 0x9C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xE0,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x18, 0x01, 0x83, 0x80,
  0x1C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xE7, 0x00, 0x06, 0x60,
  0x00, 0x6E, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x07, 0x1C, 0x01,
  0xCE, 0x00, 0x67, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70,
  0x03, 0x38, 0x03, 0x9C, 0x03, 0x8F, 0xFF, 0x87, 0xFF, 0xE3, 0x80, 0x39,
  0xC0, 0x0E, 0xE0, 0x03, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x1C, 0xFF, 0xFC, 0x7F, 0xFC, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0x07, 0x87, 0x00, 0xE7, 0x00, 0x33, 0x00,
  0x1F, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3B, 0x80, 0x18, 0xE0,
  0x1C, 0x38, 0x3C, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0xC0, 0x78, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x83, 0x87, 0x00, 0xE3, 0x00,
  0x3B, 0x80, 0x0D, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03,
  0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x37, 0x00, 0x19, 0x80,
  0x1C, 0xE0, 0x1E, 0x3C, 0x1B, 0x0F, 0xF9, 0x81, 0xF8, 0xC0, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x6C, 0x00, 0xDC, 0x01, 0x98,
  0x07, 0x3C, 0x1C, 0x3F, 0xF0, 0x1F, 0x80, 0xE0, 0x01, 0xF8, 0x00, 0xCE,
  0x00, 0x73, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x03, 0x03, 0x81,
  0x80, 0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x9E, 0x00, 0xEF, 0x80,
  0x3B, 0x70, 0x0F, 0x8E, 0x03, 0xC1, 0x80, 0xF0, 0x70, 0x38, 0x0E, 0x0E,
  0x01, 0x83, 0x80, 0x70, 0xE0, 0x0C, 0x38, 0x01, 0x8E, 0x00, 0x73, 0x80,
  0x0C, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xD8, 0x0F, 0xD8, 0x1B, 0xD8, 0x1B, 0xCC, 0x33, 0xCC,
  0x33, 0xC6, 0x23, 0xC6, 0x63, 0xC3, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC,
  0x03, 0xCE, 0x03, 0xC6, 0x03, 0xC7, 0x03, 0xC3, 0x03, 0xC3, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC0, 0xC3, 0xC0, 0xC3, 0xC0, 0x63, 0xC0, 0x63, 0xC0,
  0x73, 0xC0, 0x33, 0xC0, 0x3B, 0xC0, 0x1B, 0xC0, 0x1B, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE0, 0xE0, 0xE0, 0x1C,
  0x30, 0x03, 0x1C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x19, 0x80, 0x06,
  0x70, 0x01, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0x78, 0x38, 0x0F, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x0E, 0xC0, 0x1C, 0xFF, 0xFC, 0xFF, 0xF0, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE0,
  0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00,
  0x19, 0x80, 0x06, 0x70, 0x01, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0x78, 0x38,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0xC0, 0x1C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0xC1, 0x80,
  0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x18,
  0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x07, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xC0, 0xF1, 0xC0, 0x0E, 0x60, 0x01, 0xD8, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x40, 0x01, 0xF8, 0x00, 0x67, 0x00, 0x38,
  0xF0, 0x3C, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C,
  0x1F, 0xFC, 0x07, 0xF0, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x80, 0x03, 0x30,
  0x00, 0xE6, 0x00, 0x18, 0xE0, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x38,
  0x03, 0x03, 0x00, 0xE0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x18, 0x03, 0x03, 0x00, 0x70, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x1C,
  0x60, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xEC, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x07,
  0x06, 0xC1, 0xE0, 0xD8, 0x3C, 0x19, 0x07, 0x83, 0x30, 0xD0, 0x66, 0x13,
  0x0C, 0xC6, 0x61, 0x18, 0xCC, 0x63, 0x18, 0x8C, 0x62, 0x19, 0x8C, 0xC3,
  0x31, 0x98, 0x66, 0x33, 0x04, 0xC6, 0x40, 0xD8, 0xD8, 0x1B, 0x0B, 0x03,
  0x61, 0xE0, 0x6C, 0x3C, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x00, 0x73, 0x00,
  0x0E, 0x38, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x03, 0x80, 0xE0, 0x30, 0x06,
  0x06, 0x00, 0x70, 0xE0, 0x03, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0xD8, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x19, 0x80,
  0x03, 0x9C, 0x00, 0x30, 0xE0, 0x07, 0x06, 0x00, 0x60, 0x70, 0x0C, 0x03,
  0x01, 0xC0, 0x18, 0x18, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xEE, 0x00,
  0x07, 0xE0, 0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x38,
  0x01, 0xC1, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0xE0, 0x70, 0x06, 0x06, 0x00,
  0x30, 0xE0, 0x03, 0x8C, 0x00, 0x19, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0C, 0xC0,
  0x07, 0x18, 0x01, 0x86, 0x00, 0xC0, 0xC0, 0x30, 0x38, 0x18, 0x06, 0x0E,
  0x01, 0xC3, 0x00, 0x31, 0xC0, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x34, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x43, 0x86, 0x0C, 0x38, 0x60, 0xC0,
  0x0F, 0xC0, 0x1F, 0xF8, 0x1C, 0x0E, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x38, 0xF0, 0x6C,
  0x3F, 0xE3, 0xC7, 0xE1, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xE0, 0xCF,
  0xF8, 0xD8, 0x3C, 0xE0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xE0, 0x0C, 0xD8, 0x3C, 0xCF, 0xF8, 0xC7, 0xE0, 0x03,
  0xF0, 0x0F, 0xF8, 0x1C, 0x1C, 0x38, 0x06, 0x70, 0x03, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x04, 0x70, 0x03, 0x38, 0x06, 0x1C, 0x1E, 0x0F, 0xFC, 0x03,
  0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x0F, 0xC6, 0x7F, 0xCD, 0xE0, 0xDB, 0x80, 0x7E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xB8, 0x07, 0x78, 0x36,
  0x7F, 0xCC, 0x3F, 0x18, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x1C, 0x70, 0x0E,
  0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x02, 0x70, 0x07,
  0x3C, 0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x80, 0x7F,
  0xE0, 0x38, 0x1C, 0x0C, 0x03, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x01, 0x87, 0x00, 0xE0, 0xE0, 0x70, 0x1F, 0xF8, 0x03, 0xF8, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x60, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01,
  0xBC, 0x01, 0xE7, 0xFF, 0xE0, 0x3F, 0xE0, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC7, 0xE3, 0x3F,
  0xCD, 0x83, 0xB8, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x7F, 0xF9, 0xFF,
  0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x07, 0x60, 0x06, 0x30, 0x06,
  0x18, 0x06, 0x0C, 0x0E, 0x06, 0x0E, 0x03, 0x0E, 0x01, 0x8E, 0x00, 0xCF,
  0x80, 0x6C, 0xE0, 0x3C, 0x30, 0x1C, 0x1C, 0x0C, 0x07, 0x06, 0x01, 0xC3,
  0x00, 0x71, 0x80, 0x18, 0xC0, 0x0E, 0x60, 0x03, 0xB0, 0x00, 0xE0, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x0F, 0x37, 0xE7, 0xED, 0x1B, 0x1F,
  0x83, 0x83, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0,
  0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30,
  0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0C,
  0xC7, 0xE3, 0x3F, 0xCD, 0x83, 0xB8, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0x07, 0xE0,
  0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x07, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0,
  0xC7, 0xE0, 0xCF, 0xF8, 0xD8, 0x3C, 0xE0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xE0, 0x0C, 0xD8, 0x3C, 0xCF, 0xF8,
  0xC7, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x0F, 0xC6, 0x7F, 0xCD, 0xE0, 0xDB, 0x80, 0x7E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xB8, 0x07, 0x78, 0x36,
  0x7F, 0xCC, 0x3F, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x36, 0x00,
  0x0D, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x07, 0xF0, 0x1F, 0xFC, 0x38, 0x1E, 0x60, 0x07, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x40, 0x03, 0xE0, 0x07, 0x78, 0x0E, 0x3F, 0xFC,
  0x07, 0xF0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x07, 0x70, 0x7C, 0xFF, 0xB1, 0xF8, 0xC0, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C,
  0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0xC0, 0x60, 0x3C, 0x07, 0x03, 0x60, 0xF0, 0x36, 0x0D, 0x02, 0x60,
  0xD0, 0x66, 0x09, 0x86, 0x61, 0x98, 0x66, 0x19, 0x86, 0x21, 0x88, 0x63,
  0x10, 0xC4, 0x31, 0x0C, 0xC3, 0x30, 0xCC, 0x33, 0x04, 0xC3, 0x30, 0x4C,
  0x12, 0x06, 0xC1, 0xE0, 0x68, 0x1E, 0x06, 0x81, 0xE0, 0x38, 0x1C, 0x03,
  0x80, 0xE0, 0x03, 0x30, 0x03, 0x0C, 0x03, 0x87, 0x03, 0x81, 0xC1, 0x80,
  0x61, 0x80, 0x19, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xE7, 0x00, 0x61, 0x80, 0x60, 0x60, 0x70, 0x38, 0x30,
  0x0E, 0x30, 0x03, 0x30, 0x00, 0xE0, 0xE0, 0x01, 0xD8, 0x00, 0x67, 0x00,
  0x18, 0xC0, 0x0C, 0x30, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x03, 0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x03, 0x18, 0x00,
  0xCC, 0x00, 0x3B, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x3F, 0xC0, 0xFF,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xFF, 0x03, 0xFC, 0x1C, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x3F, 0xE0, 0xFF, 0x00,
  0x1E, 0x00, 0xCF, 0xC0, 0x33, 0x38, 0x0D, 0x87, 0x03, 0x60, 0xE1, 0xB0,
  0x1C, 0xEC, 0x03, 0xF3, 0x00, 0x78,
};

const GFXglyph IBMPlexMono_Light37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 4, 26, 22, 9, -26 },
  { 14, 8, 10, 22, 7, -27 },
  { 24, 21, 26, 22, 1, -26 },
  { 93, 18, 34, 22, 2, -30 },
  { 170, 20, 26, 22, 1, -26 },
  { 235, 20, 26, 22, 1, -26 },
  { 300, 2, 10, 22, 10, -27 },
  { 303, 10, 33, 22, 8, -28 },
  { 345, 10, 33, 22, 4, -28 },
  { 387, 19, 18, 22, 2, -20 },
  { 430, 18, 18, 22, 2, -20 },
  { 471, 5, 10, 22, 8, -4 },
  { 478, 10, 2, 22, 6, -12 },
  { 481, 4, 4, 22, 9, -4 },
  { 483, 15, 33, 22, 4, -28 },
  { 545, 18, 26, 22, 2, -26 },
  { 604, 18, 26, 22, 2, -26 },
  { 663, 17, 26, 22, 3, -26 },
  { 719, 17, 26, 22, 2, -26 },
  { 775, 20, 26, 22, 1, -26 },
  { 840, 16, 26, 22, 3, -26 },
  { 892, 16, 26, 22, 3, -26 },
  { 944, 16, 26, 22, 3, -26 },
  { 996, 18, 26, 22, 2, -26 },
  { 1055, 17, 26, 22, 3, -26 },
  { 1111, 4, 20, 22, 9, -20 },
  { 1121, 5, 26, 22, 8, -20 },
  { 1138, 16, 21, 22, 3, -22 },
  { 1180, 18, 9, 22, 2, -16 },
  { 1201, 16, 21, 22, 3, -22 },
  { 1243, 16, 26, 22, 3, -26 },
  { 1295, 16, 30, 22, 3, -26 },
  { 1355, 20, 26, 22, 1, -26 },
  { 1420, 17, 26, 22, 3, -26 },
  { 1476, 17, 26, 22, 3, -26 },
  { 1532, 16, 26, 22, 4, -26 },
  { 1584, 15, 26, 22, 4, -26 },
  { 1633, 15, 26, 22, 4, -26 },
  { 1682, 17, 26, 22, 2, -26 },
  { 1738, 16, 26, 22, 3, -26 },
  { 1790, 16, 26, 22, 3, -26 },
  { 1842, 15, 26, 22, 3, -26 },
  { 1891, 18, 26, 22, 3, -26 },
  { 1950, 15, 26, 22, 5, -26 },
  { 1999, 16, 26, 22, 3, -26 },
  { 2051, 16, 26, 22, 3, -26 },
  { 2103, 18, 26, 22, 2, -26 },
  { 2162, 16, 26, 22, 4, -26 },
  { 2214, 18, 31, 22, 2, -26 },
  { 2284, 16, 26, 22, 4, -26 },
  { 2336, 18, 26, 22, 2, -26 },
  { 2395, 20, 26, 22, 1, -26 },
  { 2460, 16, 26, 22, 3, -26 },
  { 2512, 19, 26, 22, 2, -26 },
  { 2574, 19, 26, 22, 2, -26 },
  { 2636, 20, 26, 22, 1, -26 },
  { 2701, 20, 26, 22, 1, -26 },
  { 2766, 18, 26, 22, 2, -26 },
  { 2825, 10, 33, 22, 9, -28 },
  { 2867, 15, 33, 22, 4, -28 },
  { 2929, 9, 33, 22, 4, -28 },
  { 2967, 18, 15, 22, 2, -26 },
  { 3001, 18, 2, 22, 2, 4 },
  { 3006, 6, 7, 22, 7, -29 },
  { 3012, 17, 19, 22, 3, -19 },
  { 3053, 16, 27, 22, 4, -27 },
  { 3107, 16, 19, 22, 3, -19 },
  { 3145, 15, 27, 22, 3, -27 },
  { 3196, 16, 19, 22, 3, -19 },
  { 3234, 17, 27, 22, 3, -27 },
  { 3292, 18, 28, 22, 3, -21 },
  { 3355, 14, 27, 22, 4, -27 },
  { 3403, 16, 27, 22, 4, -27 },
  { 3457, 14, 34, 22, 3, -27 },
  { 3517, 17, 27, 22, 4, -27 },
  { 3575, 16, 27, 22, 3, -27 },
  { 3629, 18, 19, 22, 2, -19 },
  { 3672, 14, 19, 22, 4, -19 },
  { 3706, 16, 19, 22, 3, -19 },
  { 3744, 16, 26, 22, 4, -19 },
  { 3796, 15, 26, 22, 3, -19 },
  { 3845, 18, 19, 22, 3, -19 },
  { 3888, 16, 19, 22, 3, -19 },
  { 3926, 18, 26, 22, 1, -26 },
  { 3985, 14, 19, 22, 4, -19 },
  { 4019, 16, 19, 22, 3, -19 },
  { 4057, 20, 19, 22, 1, -19 },
  { 4105, 17, 19, 22, 3, -19 },
  { 4146, 18, 26, 22, 2, -19 },
  { 4205, 16, 19, 22, 3, -19 },
  { 4243, 14, 33, 22, 4, -28 },
  { 4301, 2, 33, 22, 10, -28 },
  { 4310, 14, 33, 22, 4, -28 },
  { 4368, 18, 8, 22, 2, -15 },
};

const GFXfont IBMPlexMono_Light37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_LIGHT37PT7B_H_
