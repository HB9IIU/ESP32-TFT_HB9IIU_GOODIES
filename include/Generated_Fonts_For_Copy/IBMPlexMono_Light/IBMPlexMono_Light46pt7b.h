#ifndef _IBMPLEXMONO_LIGHT46PT7B_H_
#define _IBMPLEXMONO_LIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light46pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x31,
  0x8C, 0x42, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x01,
  0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0xFF, 0xC0, 0x30, 0x38, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18,
  0x1C, 0x03, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x00, 0xE0, 0x60, 0x00,
  0x38, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xCC, 0x7C, 0x38, 0x30, 0x79, 0xC0, 0xC0, 0xF7,
  0x03, 0x01, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x00,
  0x07, 0x8C, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0C, 0x7C, 0x00, 0x30, 0x70, 0x00, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0x0C,
  0x07, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x07,
  0x40, 0x30, 0x1F, 0x80, 0xC0, 0xEF, 0x03, 0x03, 0x9E, 0x0C, 0x1C, 0x3E,
  0x31, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x73, 0x87, 0x00, 0x39, 0xC0, 0xE0, 0x0C, 0x60, 0x18,
  0x07, 0x38, 0x06, 0x01, 0x8E, 0x01, 0x80, 0xE3, 0x80, 0x60, 0x30, 0xE0,
  0x18, 0x18, 0x38, 0x06, 0x0E, 0x0E, 0x01, 0x83, 0x01, 0x80, 0x61, 0xC0,
  0x70, 0x38, 0x60, 0x0E, 0x1C, 0x38, 0x01, 0xFE, 0x0C, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03,
  0x0F, 0xF8, 0x01, 0x83, 0x87, 0x00, 0xE1, 0x80, 0xC0, 0x30, 0x60, 0x18,
  0x1C, 0x38, 0x06, 0x06, 0x0C, 0x01, 0x83, 0x83, 0x00, 0x60, 0xC0, 0xC0,
  0x18, 0x60, 0x30, 0x06, 0x18, 0x0E, 0x01, 0x8C, 0x01, 0x80, 0x67, 0x00,
  0x60, 0x39, 0x80, 0x0E, 0x1C, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0xC0, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x04, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0x07, 0x70, 0x0F, 0x87, 0x1C, 0x06, 0x07,
  0x07, 0x07, 0x07, 0x01, 0xC3, 0x83, 0x80, 0x71, 0xC1, 0x80, 0x18, 0xC0,
  0xC0, 0x0E, 0x60, 0xE0, 0x03, 0xB0, 0x70, 0x00, 0xF8, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x07, 0x00, 0x0B, 0x83, 0x80, 0x0D, 0xE0, 0xE0, 0x0C,
  0x78, 0x3C, 0x0C, 0x1C, 0x0F, 0xFC, 0x07, 0x01, 0xF8, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x18, 0x02, 0xF0,
  0x18, 0x1E, 0xFE, 0x18, 0xFE, 0x1F, 0xFF, 0xF9, 0x03, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE7, 0x00, 0x01,
  0xC3, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0x70, 0x04, 0x00, 0x20, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x78, 0xF1,
  0xC7, 0x8F, 0x1C, 0x38, 0x61, 0xC3, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xF0, 0x3C, 0x07, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E,
  0x60, 0x00, 0x39, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x03, 0x81, 0xC0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3D, 0x80,
  0x01, 0xE6, 0x00, 0x0F, 0x18, 0x00, 0x78, 0x60, 0x03, 0xC1, 0x80, 0x1E,
  0x06, 0x00, 0xE0, 0x18, 0x01, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0x81, 0xE0, 0x78, 0x03, 0x87, 0x80, 0x0E, 0x38, 0x00, 0x71,
  0x80, 0x01, 0xD4, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE2,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x0E, 0x70, 0x01, 0xC3, 0xC0, 0x78, 0x1F, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x1F, 0xC0, 0x67,
  0xFF, 0x06, 0xE0, 0x78, 0x78, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x6C, 0x00, 0x0E, 0xE0, 0x00,
  0xE7, 0x00, 0x1C, 0x3C, 0x07, 0x81, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x7F, 0x01,
  0xCF, 0xFE, 0x0E, 0xE0, 0x78, 0x6C, 0x00, 0xE3, 0xC0, 0x03, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x60, 0x00,
  0xE3, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x3C, 0x0F, 0x00, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x3C, 0x0F, 0x00,
  0x38, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0x70, 0x03, 0x80, 0xF0, 0x3C, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x78, 0x0F, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01,
  0xC3, 0x80, 0x0F, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0xC3, 0x80,
  0x07, 0x38, 0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x0F, 0x3C, 0x00, 0xF8, 0xF8, 0x1D, 0xC1,
  0xFF, 0xCC, 0x03, 0xF8, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0x3C, 0xF9, 0xF3, 0xE3, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3,
  0xC7, 0x8E, 0x3C, 0x78, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xF8, 0x1E, 0x1C, 0x00, 0xE7, 0x00, 0x1D,
  0xC0, 0x01, 0xF8, 0x00, 0x39, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xC0, 0xF0, 0x38, 0x03, 0x81, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xC0,
  0x01, 0xC6, 0x00, 0x06, 0x70, 0x00, 0x33, 0x00, 0x01, 0x98, 0x07, 0xCE,
  0xC0, 0xFF, 0x76, 0x07, 0x0F, 0xB0, 0x70, 0x3D, 0x83, 0x00, 0xFC, 0x38,
  0x07, 0xE1, 0xC0, 0x3F, 0x0E, 0x01, 0xF8, 0x70, 0x0F, 0xC3, 0x80, 0x7E,
  0x1C, 0x03, 0xF0, 0xE0, 0x1F, 0x87, 0x00, 0xEC, 0x38, 0x07, 0x60, 0xC0,
  0x3B, 0x06, 0x01, 0xD8, 0x38, 0x1E, 0xC0, 0xFF, 0x76, 0x03, 0xF3, 0xB8,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC7, 0x00, 0x01,
  0xC3, 0x00, 0x01, 0xC3, 0x80, 0x01, 0x83, 0x80, 0x03, 0x81, 0x80, 0x03,
  0x81, 0xC0, 0x03, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70,
  0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xCE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x07,
  0x8F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x00, 0x3C, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE,
  0x00, 0x3C, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xE0, 0x78, 0x1C, 0x01, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x1C, 0xE0,
  0x00, 0x66, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x31, 0x80, 0x03, 0x8E,
  0x00, 0x38, 0x38, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x1F, 0x0C, 0x00, 0x78, 0xC0,
  0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0xEC,
  0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00,
  0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0,
  0x07, 0x8C, 0x01, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0xC1,
  0x80, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x3C, 0x70, 0x02, 0xE1, 0xE0,
  0x77, 0x07, 0xFF, 0x38, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x1B,
  0x80, 0x0E, 0xE0, 0x03, 0x9C, 0x01, 0xC3, 0xC1, 0xE0, 0x7F, 0xF0, 0x07,
  0xF0, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00,
  0x78, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x38, 0x1C, 0x00, 0xE0,
  0xE0, 0x03, 0x87, 0x00, 0x0E, 0x3E, 0x00, 0x39, 0xF8, 0x00, 0xEE, 0x70,
  0x03, 0xF8, 0xE0, 0x0F, 0xC3, 0x80, 0x3E, 0x07, 0x00, 0xF0, 0x1E, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x0E, 0x00, 0x1E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0D, 0xF6, 0x00, 0xEF, 0xB8, 0x06,
  0x7C, 0xC0, 0x73, 0xE7, 0x03, 0x1F, 0x18, 0x18, 0xF8, 0xE1, 0xC7, 0xC7,
  0x0C, 0x3E, 0x18, 0xE1, 0xF0, 0xE6, 0x0F, 0x83, 0x70, 0x7C, 0x1F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1C, 0x07, 0xC0, 0x60, 0x3E, 0x02,
  0x01, 0xF0, 0x10, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0xC0, 0x07, 0xEE, 0x00, 0x7E,
  0x60, 0x07, 0xE7, 0x00, 0x7E, 0x70, 0x07, 0xE3, 0x80, 0x7E, 0x38, 0x07,
  0xE1, 0xC0, 0x7E, 0x1C, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0x60,
  0x7E, 0x07, 0x07, 0xE0, 0x30, 0x7E, 0x03, 0x87, 0xE0, 0x38, 0x7E, 0x01,
  0xC7, 0xE0, 0x1C, 0x7E, 0x00, 0xE7, 0xE0, 0x0E, 0x7E, 0x00, 0x77, 0xE0,
  0x07, 0x7E, 0x00, 0x37, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0x3C, 0x07, 0x00,
  0x78, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0x60, 0x00, 0x39, 0x80,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03,
  0x81, 0xC0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x00, 0x79, 0xC0, 0x01, 0xCE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x78, 0x38,
  0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x60, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0x60, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x70, 0x07, 0x80, 0xF0,
  0x3C, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x00, 0x79, 0xC0, 0x01, 0xCE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x03, 0x9C, 0x00, 0x38, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x38,
  0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0F,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3C, 0x07, 0xE0, 0xE0, 0x01, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x39, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xDF,
  0x00, 0x07, 0x8F, 0x00, 0x1E, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x60,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC3, 0x80, 0x1C, 0x3E, 0x07, 0x80,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0x80, 0x01, 0x83, 0x80, 0x01,
  0xC3, 0x80, 0x01, 0xC3, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x3C, 0x0E, 0x60,
  0x3C, 0x0E, 0x60, 0x3C, 0x0E, 0x70, 0x7C, 0x0E, 0x70, 0x6E, 0x0C, 0x70,
  0x6E, 0x0C, 0x70, 0x66, 0x0C, 0x70, 0xE6, 0x0C, 0x30, 0xC7, 0x0C, 0x30,
  0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC3, 0x1C, 0x31, 0x83, 0x9C, 0x31,
  0x83, 0x9C, 0x31, 0x81, 0x9C, 0x3B, 0x81, 0x98, 0x3B, 0x01, 0xD8, 0x3B,
  0x01, 0xD8, 0x3B, 0x00, 0xD8, 0x3F, 0x00, 0xD8, 0x1F, 0x00, 0xF8, 0x1E,
  0x00, 0xF8, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01,
  0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0x83, 0x80, 0x03,
  0x81, 0xC0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0x78, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x38,
  0x60, 0x00, 0x60, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x60, 0x03, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x61, 0xC1, 0xC1, 0xC3, 0x83, 0x83,
  0x03, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xE0, 0xF8, 0x0E, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0x80, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xF0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3,
  0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x60, 0x01, 0xC1, 0xC0,
  0x0B, 0x03, 0xC0, 0xCF, 0xC7, 0xFE, 0x1F, 0x07, 0xE0, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x87, 0xE0,
  0x73, 0xFF, 0x0E, 0xC0, 0xF1, 0xF0, 0x07, 0x3C, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xBC, 0x00, 0x77,
  0xC0, 0x1C, 0xEC, 0x0F, 0x1C, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0x03, 0xC1, 0xC0, 0x1C, 0x38, 0x00, 0xE3, 0x00,
  0x04, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x06,
  0x38, 0x00, 0xF1, 0xC0, 0x1E, 0x0F, 0x03, 0xC0, 0x7F, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x03, 0xF8, 0x70, 0xFF, 0xE7, 0x1F, 0x07, 0x73, 0xC0, 0x1F,
  0x38, 0x00, 0xF7, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xF3, 0xC0, 0x1F, 0x1F, 0x07, 0x70,
  0xFF, 0xE7, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x07,
  0x83, 0x80, 0x3C, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x47, 0x00, 0x07, 0x70, 0x00, 0xE3, 0x80, 0x1C,
  0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF2, 0x00, 0x3F,
  0xFC, 0x00, 0xF0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x38, 0x1C, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x03, 0x80, 0x06, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x81, 0xC0,
  0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x10, 0x00, 0x70, 0xC0, 0x00, 0x73, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x3C, 0x78, 0x01, 0xF0, 0x7F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x1F, 0x83, 0x9F,
  0xF8, 0xEC, 0x0F, 0x3C, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x3F, 0xFF, 0x1F, 0xFF, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x3D, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x03,
  0x83, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x07, 0x80, 0x38,
  0x78, 0x01, 0xC7, 0x80, 0x0E, 0x7E, 0x00, 0x77, 0x70, 0x03, 0xF1, 0xC0,
  0x1F, 0x07, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0xF0, 0x38, 0x03, 0x81, 0xC0,
  0x0E, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x1C,
  0xE0, 0x00, 0x77, 0x00, 0x01, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x83, 0xE3, 0x3F, 0x9F,
  0xCD, 0x0E, 0xC3, 0xB8, 0x1E, 0x06, 0xE0, 0x70, 0x1F, 0x01, 0xC0, 0x7C,
  0x03, 0x01, 0xF0, 0x0C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03,
  0x01, 0xF0, 0x0C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03, 0x01,
  0xF0, 0x0C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03, 0x01, 0xF0,
  0x0C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x7C, 0x03, 0x01, 0xF0, 0x0C,
  0x07, 0xE1, 0xF8, 0x39, 0xFF, 0x8E, 0xC0, 0xF3, 0xC0, 0x1E, 0xE0, 0x03,
  0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xC0, 0xF0, 0x38, 0x03, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x39, 0xC0,
  0x00, 0xCE, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00,
  0x07, 0x60, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0C, 0x60, 0x00, 0xE3,
  0x80, 0x0E, 0x0E, 0x00, 0xF0, 0x3C, 0x0F, 0x00, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0xE1, 0xF8, 0x1C, 0xFF, 0xC3, 0xB0, 0x3C, 0x7C, 0x01, 0xCF, 0x00,
  0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xEF, 0x00, 0x1D, 0xF0, 0x07, 0x3B, 0x03, 0xC7, 0x3F, 0xF0, 0xE1, 0xF8,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x70, 0xFF,
  0xE7, 0x1F, 0x07, 0x73, 0xC0, 0x1F, 0x38, 0x00, 0xF7, 0x00, 0x07, 0x70,
  0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00,
  0xF3, 0xC0, 0x1F, 0x1F, 0x07, 0x70, 0xFF, 0xE7, 0x03, 0xF8, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F,
  0xF0, 0x1C, 0xC0, 0x00, 0x74, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0x80, 0xF8, 0x38, 0x01, 0xE3,
  0x80, 0x03, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x40, 0x00, 0x7F, 0x00, 0x03, 0x1C, 0x00, 0x38, 0x7C,
  0x07, 0x81, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x03, 0xDC, 0x01,
  0xF3, 0xC1, 0xDC, 0x7F, 0xE7, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x0C, 0x60, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30,
  0x60, 0x03, 0x83, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x80,
  0x60, 0x0C, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0x80, 0x0C, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x00, 0x01, 0x98,
  0x00, 0x0D, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xC0,
  0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x07, 0xE0,
  0x6C, 0x06, 0xE0, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60,
  0xC6, 0x0E, 0x60, 0xC6, 0x0E, 0x60, 0xC3, 0x0C, 0x70, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x31, 0x83, 0x0C, 0x31, 0x81, 0x8C, 0x31, 0x81, 0x9C, 0x31,
  0x81, 0x98, 0x39, 0x01, 0x98, 0x1B, 0x01, 0x98, 0x1B, 0x00, 0xD8, 0x1B,
  0x00, 0xD8, 0x1B, 0x00, 0xD8, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0xF0,
  0x00, 0x39, 0xC0, 0x03, 0x8F, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x1C,
  0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xCE, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00,
  0x07, 0x70, 0x00, 0x31, 0xC0, 0x03, 0x87, 0x00, 0x38, 0x3C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xDE,
  0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x0C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x01, 0x80, 0xE0, 0x07,
  0x03, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x01, 0x8E,
  0x00, 0x07, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0xF0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07,
  0x80, 0x06, 0x3F, 0x80, 0x0C, 0x63, 0x80, 0x39, 0x83, 0x80, 0x63, 0x03,
  0x80, 0xCC, 0x03, 0x83, 0x98, 0x03, 0x8E, 0x30, 0x03, 0xF8, 0xE0, 0x01,
  0xE0,
};

const GFXglyph IBMPlexMono_Light46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 5, 32, 28, 11, -32 },
  { 21, 10, 12, 28, 9, -34 },
  { 36, 26, 32, 28, 1, -32 },
  { 140, 22, 44, 28, 3, -38 },
  { 261, 26, 34, 28, 1, -33 },
  { 372, 25, 34, 28, 1, -33 },
  { 479, 2, 12, 28, 13, -34 },
  { 482, 12, 41, 28, 10, -35 },
  { 544, 13, 41, 28, 5, -35 },
  { 611, 24, 23, 28, 2, -25 },
  { 680, 22, 22, 28, 3, -25 },
  { 741, 7, 12, 28, 10, -5 },
  { 752, 13, 2, 28, 7, -15 },
  { 756, 5, 5, 28, 11, -5 },
  { 760, 19, 41, 28, 4, -35 },
  { 858, 22, 34, 28, 3, -33 },
  { 952, 22, 32, 28, 3, -32 },
  { 1040, 21, 33, 28, 3, -33 },
  { 1127, 20, 34, 28, 3, -33 },
  { 1212, 24, 32, 28, 2, -32 },
  { 1308, 20, 33, 28, 4, -32 },
  { 1391, 21, 33, 28, 3, -32 },
  { 1478, 21, 32, 28, 3, -32 },
  { 1562, 22, 34, 28, 3, -33 },
  { 1656, 21, 33, 28, 3, -33 },
  { 1743, 5, 24, 28, 11, -24 },
  { 1758, 7, 31, 28, 10, -24 },
  { 1786, 20, 26, 28, 4, -27 },
  { 1851, 22, 10, 28, 3, -19 },
  { 1879, 20, 26, 28, 4, -27 },
  { 1944, 19, 33, 28, 4, -33 },
  { 2023, 21, 38, 28, 3, -33 },
  { 2123, 24, 32, 28, 2, -32 },
  { 2219, 20, 32, 28, 4, -32 },
  { 2299, 21, 34, 28, 3, -33 },
  { 2389, 20, 32, 28, 5, -32 },
  { 2469, 20, 32, 28, 4, -32 },
  { 2549, 20, 32, 28, 4, -32 },
  { 2629, 21, 34, 28, 3, -33 },
  { 2719, 20, 32, 28, 4, -32 },
  { 2799, 20, 32, 28, 4, -32 },
  { 2879, 18, 33, 28, 4, -32 },
  { 2954, 22, 32, 28, 4, -32 },
  { 3042, 18, 32, 28, 6, -32 },
  { 3114, 21, 32, 28, 3, -32 },
  { 3198, 20, 32, 28, 4, -32 },
  { 3278, 22, 34, 28, 3, -33 },
  { 3372, 21, 32, 28, 4, -32 },
  { 3456, 22, 39, 28, 3, -33 },
  { 3564, 21, 32, 28, 4, -32 },
  { 3648, 23, 34, 28, 2, -33 },
  { 3746, 25, 32, 28, 1, -32 },
  { 3846, 20, 33, 28, 4, -32 },
  { 3929, 24, 32, 28, 2, -32 },
  { 4025, 24, 32, 28, 2, -32 },
  { 4121, 24, 32, 28, 2, -32 },
  { 4217, 26, 32, 28, 1, -32 },
  { 4321, 23, 32, 28, 2, -32 },
  { 4413, 12, 41, 28, 11, -35 },
  { 4475, 19, 41, 28, 4, -35 },
  { 4573, 13, 41, 28, 4, -35 },
  { 4640, 23, 18, 28, 2, -32 },
  { 4692, 22, 2, 28, 3, 5 },
  { 4698, 7, 8, 28, 9, -35 },
  { 4705, 22, 25, 28, 3, -24 },
  { 4774, 19, 35, 28, 5, -34 },
  { 4858, 20, 25, 28, 4, -24 },
  { 4921, 20, 35, 28, 3, -34 },
  { 5009, 20, 25, 28, 4, -24 },
  { 5072, 21, 34, 28, 4, -34 },
  { 5162, 23, 36, 28, 3, -26 },
  { 5266, 18, 34, 28, 5, -34 },
  { 5343, 20, 34, 28, 5, -34 },
  { 5428, 17, 43, 28, 4, -34 },
  { 5520, 21, 34, 28, 5, -34 },
  { 5610, 20, 34, 28, 4, -34 },
  { 5695, 22, 24, 28, 3, -24 },
  { 5761, 18, 24, 28, 5, -24 },
  { 5815, 21, 25, 28, 3, -24 },
  { 5881, 19, 33, 28, 5, -24 },
  { 5960, 20, 33, 28, 3, -24 },
  { 6043, 22, 24, 28, 4, -24 },
  { 6109, 21, 25, 28, 3, -24 },
  { 6175, 22, 32, 28, 2, -32 },
  { 6263, 18, 25, 28, 5, -24 },
  { 6320, 21, 24, 28, 3, -24 },
  { 6383, 24, 24, 28, 2, -24 },
  { 6455, 21, 24, 28, 3, -24 },
  { 6518, 22, 33, 28, 3, -24 },
  { 6609, 19, 24, 28, 4, -24 },
  { 6666, 18, 41, 28, 5, -35 },
  { 6759, 2, 41, 28, 13, -35 },
  { 6770, 18, 41, 28, 5, -35 },
  { 6863, 23, 9, 28, 2, -18 },
};

const GFXfont IBMPlexMono_Light46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_LIGHT46PT7B_H_
