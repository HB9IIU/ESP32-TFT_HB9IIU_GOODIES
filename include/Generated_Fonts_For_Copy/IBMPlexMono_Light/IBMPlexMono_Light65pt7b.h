#ifndef _IBMPLEXMONO_LIGHT65PT7B_H_
#define _IBMPLEXMONO_LIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC1, 0x02, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x3F,
  0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x87, 0x3F, 0xC0, 0xFC,
  0x0E, 0x0F, 0xC1, 0xE0, 0x1C, 0x07, 0xC7, 0x80, 0x38, 0x07, 0xCF, 0x00,
  0x70, 0x07, 0x3C, 0x00, 0xE0, 0x08, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x03,
  0x80, 0x01, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x3E, 0x01, 0xC0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x7E, 0x07, 0x00,
  0x00, 0x7F, 0x8E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xCF, 0xF0,
  0x00, 0x03, 0x83, 0xF0, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80,
  0x00, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xF2, 0x00, 0x1C, 0x01, 0xEE, 0x00,
  0x38, 0x03, 0xFC, 0x00, 0x70, 0x0F, 0x7E, 0x00, 0xE0, 0x3E, 0x7E, 0x01,
  0xC0, 0xF8, 0x7F, 0x03, 0x83, 0xE0, 0x7F, 0x87, 0x3F, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xC3, 0xFF,
  0xE0, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x3C, 0x00, 0x1E,
  0x1C, 0x00, 0xF0, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x0F, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x00, 0x78, 0x1C,
  0x00, 0x38, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x0E, 0x00,
  0x1C, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x1E, 0x07, 0x00,
  0x07, 0xC1, 0xE0, 0x78, 0x00, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0x7F, 0xE0,
  0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0xFF, 0xC0, 0x00, 0x38, 0x1F, 0xFF, 0x00, 0x03,
  0xC0, 0xF0, 0x7C, 0x00, 0x1C, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0xF0, 0x03,
  0x80, 0x1E, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0F, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x70, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x01, 0xC1, 0xC0, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0xE0,
  0x01, 0xE0, 0x07, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x70, 0x00, 0x1E, 0x07,
  0x87, 0x80, 0x00, 0xFF, 0xF8, 0x38, 0x00, 0x01, 0xFF, 0x82, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0x78, 0x00, 0xFF, 0x0F, 0x8F, 0x00,
  0x3F, 0xC7, 0x83, 0xE0, 0x0E, 0x03, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x3C, 0x1C, 0x07, 0x00,
  0x07, 0x87, 0x03, 0xC0, 0x01, 0xF1, 0xC0, 0xF0, 0x00, 0x3C, 0x70, 0x3C,
  0x00, 0x07, 0x9C, 0x0F, 0x00, 0x00, 0xF7, 0x03, 0xC0, 0x00, 0x1F, 0x80,
  0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x06, 0x7C, 0x0F, 0x00, 0x03,
  0x8F, 0x83, 0xF0, 0x01, 0xC1, 0xE0, 0x7F, 0x01, 0xE0, 0x3C, 0x0F, 0xFF,
  0xF0, 0x07, 0x80, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x70, 0x00, 0x4E,
  0x00, 0x38, 0x00, 0xEF, 0xE0, 0x1C, 0x03, 0xFF, 0xFE, 0x0E, 0x0F, 0xFC,
  0x7F, 0xF7, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x30, 0x01, 0xE0, 0x00, 0x20, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07,
  0x86, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0x00, 0x70, 0xFF,
  0xF8, 0x03, 0x8F, 0xFF, 0xF0, 0x1C, 0xE0, 0x1F, 0xC0, 0xEC, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0xFC, 0x00, 0xF0, 0xFF, 0xF8,
  0x07, 0x9F, 0xFF, 0xF0, 0x39, 0xF0, 0x1F, 0xC3, 0xDC, 0x00, 0x1F, 0x1F,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F,
  0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0xEF, 0x0F, 0xE0, 0x3E, 0x70, 0x3F, 0xFF, 0xE7, 0x80, 0x7F, 0xFC, 0x3C,
  0x00, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xF0, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x01, 0xF8,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x1F, 0x87, 0x70, 0x07, 0xFE, 0x7F,
  0x00, 0xFF, 0xF7, 0xF0, 0x1F, 0x03, 0x7F, 0x01, 0xE0, 0x1F, 0xE0, 0x3C,
  0x00, 0xFE, 0x03, 0xC0, 0x07, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0x80, 0x07,
  0xE0, 0x78, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xE0, 0x78, 0x00, 0x7E, 0x07,
  0x80, 0x07, 0xE0, 0x78, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xE0, 0x78, 0x00,
  0x7E, 0x07, 0x80, 0x07, 0xE0, 0x78, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xE0,
  0x38, 0x00, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x3C, 0x00, 0xFF, 0x03, 0xC0,
  0x0F, 0xF0, 0x1E, 0x01, 0xFF, 0x00, 0xF8, 0x77, 0x70, 0x0F, 0xFE, 0x77,
  0x00, 0x3F, 0xC7, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x08, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x02, 0x1E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xE0, 0x01, 0xFC, 0x0F, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x02, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x06, 0xF0, 0x7C, 0x00, 0x73, 0xC0,
  0xFC, 0x07, 0xCF, 0x01, 0xFF, 0xFE, 0x3C, 0x03, 0xFF, 0xE0, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x79, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x81,
  0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x1E, 0x3F,
  0xE0, 0x00, 0x3C, 0xFB, 0xC0, 0x00, 0x7B, 0xE7, 0xC0, 0x00, 0xF7, 0x87,
  0xC0, 0x01, 0xFE, 0x07, 0x80, 0x03, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xBC, 0x00, 0x1E, 0xFC, 0xE0, 0x00, 0xE7, 0xE7, 0x80, 0x0F,
  0x3F, 0x3C, 0x00, 0x71, 0xF8, 0xF0, 0x03, 0x8F, 0xC7, 0x80, 0x38, 0x7E,
  0x1C, 0x01, 0xC3, 0xF0, 0xF0, 0x1E, 0x1F, 0x83, 0x80, 0xE0, 0xFC, 0x1E,
  0x0F, 0x07, 0xE0, 0x70, 0x70, 0x3F, 0x03, 0xC3, 0x81, 0xF8, 0x1E, 0x38,
  0x0F, 0xC0, 0x79, 0xC0, 0x7E, 0x03, 0xDE, 0x03, 0xF0, 0x0E, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x20,
  0x03, 0xF0, 0x01, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xDE, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x3F,
  0x3C, 0x00, 0x07, 0xE7, 0x80, 0x00, 0xFC, 0x78, 0x00, 0x1F, 0x8F, 0x00,
  0x03, 0xF1, 0xE0, 0x00, 0x7E, 0x1E, 0x00, 0x0F, 0xC3, 0xC0, 0x01, 0xF8,
  0x3C, 0x00, 0x3F, 0x07, 0x80, 0x07, 0xE0, 0x78, 0x00, 0xFC, 0x0F, 0x00,
  0x1F, 0x80, 0xF0, 0x03, 0xF0, 0x1E, 0x00, 0x7E, 0x01, 0xE0, 0x0F, 0xC0,
  0x3C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x78, 0x07, 0xE0, 0x0F, 0x00,
  0xFC, 0x00, 0xF0, 0x1F, 0x80, 0x1E, 0x03, 0xF0, 0x01, 0xE0, 0x7E, 0x00,
  0x3C, 0x0F, 0xC0, 0x03, 0xC1, 0xF8, 0x00, 0x78, 0x3F, 0x00, 0x07, 0x87,
  0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x1F, 0x80, 0x01, 0xE3, 0xF0, 0x00,
  0x3C, 0x7E, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x79, 0xF8, 0x00, 0x07, 0xBF,
  0x00, 0x00, 0xF7, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xE0, 0x00,
  0x1F, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0x1F, 0x8F, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x07, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0C,
  0x3C, 0x00, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x00, 0x1E,
  0x30, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x3C,
  0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x3E, 0x00, 0x73, 0x80, 0x1F, 0x00, 0x39, 0xE0, 0x0F, 0x80,
  0x1C, 0xF0, 0x0F, 0xE0, 0x1E, 0x78, 0x07, 0xF0, 0x0F, 0x3C, 0x03, 0xB8,
  0x07, 0x9E, 0x01, 0xDC, 0x03, 0xC7, 0x01, 0xEF, 0x01, 0xC3, 0x80, 0xE3,
  0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0x3C,
  0x78, 0x1C, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x07,
  0x07, 0x03, 0x87, 0x83, 0x83, 0xC3, 0xC3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE1,
  0xC0, 0x70, 0xF0, 0x70, 0xE0, 0x38, 0x78, 0x38, 0x70, 0x1E, 0x38, 0x1C,
  0x78, 0x0F, 0x1C, 0x0E, 0x38, 0x03, 0x8E, 0x07, 0x1C, 0x01, 0xC7, 0x03,
  0x8E, 0x00, 0xF3, 0x81, 0xCF, 0x00, 0x79, 0xC0, 0xE7, 0x00, 0x1C, 0xE0,
  0x7B, 0x80, 0x0E, 0x70, 0x3D, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x0F,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x40, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x20, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x60, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x10, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0xE0, 0x7C, 0x00, 0x03, 0x83, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x6E, 0x07, 0xC0, 0x03, 0xB8,
  0x0F, 0xC0, 0x7C, 0xFF, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x03, 0xF0,
  0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x0F, 0x0F, 0xFF, 0x80,
  0xF1, 0xFF, 0xFC, 0x0F, 0x3C, 0x07, 0xE0, 0xF6, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x8F, 0xC0,
  0x00, 0xF8, 0xF6, 0x00, 0x1F, 0x0F, 0x3C, 0x07, 0xE0, 0xF1, 0xFF, 0xFC,
  0x0F, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x01, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x3E, 0x00,
  0x07, 0x83, 0xE0, 0x01, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0xF0,
  0x1F, 0xFF, 0x0F, 0x03, 0xFF, 0xF8, 0xF0, 0x7E, 0x03, 0xCF, 0x0F, 0x80,
  0x06, 0xF1, 0xF0, 0x00, 0x3F, 0x1E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x06, 0xF0, 0x7E, 0x03, 0xCF,
  0x03, 0xFF, 0xF8, 0xF0, 0x1F, 0xFF, 0x0F, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x0E, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x30, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xDF, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xFF, 0x01, 0xE1,
  0xFF, 0xE0, 0xF1, 0xFF, 0xFC, 0x79, 0xC0, 0x7F, 0x3D, 0x80, 0x0F, 0x9F,
  0x80, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x0F, 0x87, 0x00,
  0x00, 0xF8, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x00, 0x70, 0x01, 0xF0, 0x03, 0x80, 0x1F, 0x00, 0x1C, 0x01, 0xF0, 0x00,
  0xE0, 0x1F, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x38, 0x1F, 0x00, 0x01, 0xC1,
  0xF0, 0x00, 0x0E, 0x1F, 0xC0, 0x00, 0x71, 0xFF, 0x00, 0x03, 0x9E, 0x78,
  0x00, 0x1F, 0xE1, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1F, 0x00, 0x70,
  0x00, 0x7C, 0x03, 0x80, 0x01, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x07, 0xDC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x07,
  0xE1, 0xC7, 0xFC, 0x1F, 0xF3, 0x9F, 0xF8, 0x7F, 0xE7, 0x70, 0xF9, 0x83,
  0xEE, 0x80, 0x76, 0x03, 0xDE, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07,
  0xF8, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F,
  0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC,
  0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0,
  0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00,
  0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07,
  0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0,
  0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1C, 0xF0, 0x3F, 0xC0,
  0x78, 0x7F, 0xF8, 0x3C, 0x7F, 0xFF, 0x1E, 0x70, 0x1F, 0xCF, 0x60, 0x03,
  0xE7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8,
  0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x3E,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0xF0, 0x3F, 0xC0, 0x0F, 0x0F, 0xFF, 0x80, 0xF1, 0xFF,
  0xFC, 0x0F, 0x3C, 0x07, 0xE0, 0xF6, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0xF8,
  0xF6, 0x00, 0x1F, 0x0F, 0x3C, 0x07, 0xE0, 0xF1, 0xFF, 0xFC, 0x0F, 0x0F,
  0xFF, 0x80, 0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0xF0, 0x1F, 0xFF, 0x0F, 0x03, 0xFF, 0xF8, 0xF0, 0x7E,
  0x03, 0xCF, 0x0F, 0x80, 0x06, 0xF1, 0xF0, 0x00, 0x3F, 0x1E, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x06,
  0xF0, 0x7E, 0x03, 0xCF, 0x03, 0xFF, 0xF8, 0xF0, 0x1F, 0xFF, 0x0F, 0x00,
  0x3F, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xE3, 0xC0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x90, 0x00, 0x00, 0x07, 0x40, 0x00,
  0x00, 0x0E, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x81,
  0xF0, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x08, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x0F, 0x83, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0xDE, 0x7F, 0x01, 0xCF, 0x1F, 0xFF, 0xC7, 0x83,
  0xFF, 0xC3, 0xC0, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3D, 0xC0, 0x07, 0xC0, 0x07, 0x38,
  0x00, 0xF8, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x70, 0x03,
  0x9C, 0x00, 0xEE, 0x00, 0x73, 0xC0, 0x1C, 0xC0, 0x1E, 0x38, 0x03, 0x1C,
  0x03, 0x87, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x0E, 0x1C, 0x03,
  0x8E, 0x01, 0xC3, 0x80, 0x60, 0xC0, 0x38, 0x78, 0x1C, 0x1C, 0x07, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x0E, 0x03,
  0x83, 0x80, 0xE1, 0xC0, 0x70, 0xF0, 0x1C, 0x38, 0x06, 0x1C, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x3C, 0xC0, 0x06, 0x38, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x00,
  0x37, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x1F,
  0xF0, 0x00, 0x1C, 0x7F, 0xF0, 0x00, 0x38, 0xF1, 0xF0, 0x00, 0x73, 0xC0,
  0xF0, 0x01, 0xEF, 0x00, 0xF0, 0x03, 0x9C, 0x01, 0xF0, 0x07, 0x38, 0x01,
  0xE0, 0x1E, 0xE0, 0x01, 0xE0, 0x79, 0xC0, 0x01, 0xF1, 0xE3, 0x80, 0x01,
  0xFF, 0xC7, 0x00, 0x01, 0xFF, 0x0E, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_Light65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 7, 45, 39, 16, -45 },
  { 41, 14, 17, 39, 13, -48 },
  { 71, 37, 45, 39, 1, -45 },
  { 280, 31, 61, 39, 4, -53 },
  { 517, 37, 47, 39, 1, -46 },
  { 735, 34, 47, 39, 2, -46 },
  { 935, 3, 17, 39, 18, -48 },
  { 942, 17, 58, 39, 14, -49 },
  { 1066, 17, 58, 39, 8, -49 },
  { 1190, 33, 32, 39, 3, -36 },
  { 1322, 31, 31, 39, 4, -35 },
  { 1443, 10, 17, 39, 14, -7 },
  { 1465, 19, 3, 39, 10, -21 },
  { 1473, 7, 7, 39, 16, -7 },
  { 1480, 27, 58, 39, 6, -49 },
  { 1676, 31, 47, 39, 4, -46 },
  { 1859, 32, 45, 39, 4, -45 },
  { 2039, 30, 46, 39, 5, -46 },
  { 2212, 29, 47, 39, 4, -46 },
  { 2383, 33, 45, 39, 3, -45 },
  { 2569, 29, 46, 39, 5, -45 },
  { 2736, 29, 46, 39, 5, -45 },
  { 2903, 29, 45, 39, 5, -45 },
  { 3067, 31, 47, 39, 4, -46 },
  { 3250, 29, 46, 39, 5, -46 },
  { 3417, 7, 35, 39, 16, -35 },
  { 3448, 10, 45, 39, 14, -35 },
  { 3505, 27, 36, 39, 6, -38 },
  { 3627, 31, 16, 39, 4, -28 },
  { 3689, 27, 36, 39, 6, -38 },
  { 3811, 27, 46, 39, 6, -46 },
  { 3967, 28, 53, 39, 5, -46 },
  { 4153, 33, 45, 39, 3, -45 },
  { 4339, 29, 45, 39, 6, -45 },
  { 4503, 29, 47, 39, 5, -46 },
  { 4674, 29, 45, 39, 6, -45 },
  { 4838, 28, 45, 39, 6, -45 },
  { 4996, 28, 45, 39, 6, -45 },
  { 5154, 30, 47, 39, 4, -46 },
  { 5331, 27, 45, 39, 6, -45 },
  { 5483, 27, 45, 39, 6, -45 },
  { 5635, 26, 46, 39, 5, -45 },
  { 5785, 31, 45, 39, 6, -45 },
  { 5960, 27, 45, 39, 8, -45 },
  { 6112, 29, 45, 39, 5, -45 },
  { 6276, 27, 45, 39, 6, -45 },
  { 6428, 31, 47, 39, 4, -46 },
  { 6611, 29, 45, 39, 6, -45 },
  { 6775, 31, 56, 39, 4, -46 },
  { 6992, 29, 45, 39, 6, -45 },
  { 7156, 32, 47, 39, 3, -46 },
  { 7344, 35, 45, 39, 2, -45 },
  { 7541, 27, 46, 39, 6, -45 },
  { 7697, 33, 45, 39, 3, -45 },
  { 7883, 33, 45, 39, 3, -45 },
  { 8069, 35, 45, 39, 2, -45 },
  { 8266, 37, 45, 39, 1, -45 },
  { 8475, 33, 45, 39, 3, -45 },
  { 8661, 17, 58, 39, 16, -49 },
  { 8785, 27, 58, 39, 6, -49 },
  { 8981, 17, 58, 39, 6, -49 },
  { 9105, 31, 26, 39, 4, -45 },
  { 9206, 31, 3, 39, 4, 7 },
  { 9218, 9, 12, 39, 13, -50 },
  { 9232, 30, 35, 39, 5, -34 },
  { 9364, 28, 49, 39, 7, -48 },
  { 9536, 27, 35, 39, 6, -34 },
  { 9655, 28, 49, 39, 4, -48 },
  { 9827, 29, 35, 39, 5, -34 },
  { 9954, 30, 48, 39, 5, -48 },
  { 10134, 31, 51, 39, 5, -37 },
  { 10332, 25, 48, 39, 7, -48 },
  { 10482, 28, 49, 39, 7, -49 },
  { 10654, 23, 62, 39, 6, -49 },
  { 10833, 29, 48, 39, 8, -48 },
  { 11007, 29, 48, 39, 5, -48 },
  { 11181, 31, 34, 39, 4, -34 },
  { 11313, 25, 34, 39, 7, -34 },
  { 11420, 29, 35, 39, 5, -34 },
  { 11547, 28, 47, 39, 7, -34 },
  { 11712, 28, 47, 39, 4, -34 },
  { 11877, 31, 34, 39, 5, -34 },
  { 12009, 29, 35, 39, 5, -34 },
  { 12136, 32, 45, 39, 2, -45 },
  { 12316, 25, 35, 39, 7, -34 },
  { 12426, 29, 34, 39, 5, -34 },
  { 12550, 35, 34, 39, 2, -34 },
  { 12699, 29, 34, 39, 5, -34 },
  { 12823, 31, 47, 39, 4, -34 },
  { 13006, 27, 34, 39, 6, -34 },
  { 13121, 25, 58, 39, 7, -49 },
  { 13303, 3, 58, 39, 18, -49 },
  { 13325, 25, 58, 39, 7, -49 },
  { 13507, 31, 13, 39, 4, -26 },
};

const GFXfont IBMPlexMono_Light65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_LIGHT65PT7B_H_
