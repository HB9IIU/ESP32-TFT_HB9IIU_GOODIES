#ifndef _IBMPLEXMONO_LIGHT50PT7B_H_
#define _IBMPLEXMONO_LIGHT50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light50pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBF, 0xFF, 0xF7, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x38, 0x03,
  0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x0F, 0xFC,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0x01, 0xC0, 0xE0,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x1F, 0x1C, 0xFC, 0x3C, 0x1C, 0x3E, 0x38, 0x1C, 0x0F, 0x70, 0x1C, 0x06,
  0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x3E, 0x1C, 0x00,
  0x1F, 0xDC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x0F,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x07, 0x60, 0x1C, 0x07, 0xE0, 0x1C, 0x0F, 0xF8, 0x1C, 0x0E,
  0x7C, 0x1C, 0x1E, 0x3F, 0x1C, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0x3F, 0xF8, 0x00, 0xE7, 0x83, 0xC0, 0x0E, 0x70, 0x1C, 0x01, 0xC6,
  0x00, 0xC0, 0x18, 0xE0, 0x0E, 0x03, 0x8E, 0x00, 0xE0, 0x30, 0xE0, 0x0E,
  0x07, 0x0E, 0x00, 0xE0, 0x60, 0xE0, 0x0E, 0x0E, 0x0E, 0x00, 0xE1, 0xC0,
  0x60, 0x0C, 0x1C, 0x07, 0x01, 0xC3, 0x80, 0x78, 0x3C, 0x30, 0x03, 0xFF,
  0x87, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0E, 0x1F, 0xFC, 0x00,
  0xC3, 0xC1, 0xE0, 0x1C, 0x38, 0x0E, 0x03, 0x83, 0x00, 0x60, 0x38, 0x70,
  0x06, 0x07, 0x07, 0x00, 0x70, 0x60, 0x70, 0x07, 0x0E, 0x07, 0x00, 0x70,
  0xC0, 0x70, 0x07, 0x1C, 0x07, 0x00, 0x71, 0x80, 0x30, 0x06, 0x38, 0x03,
  0x80, 0xE7, 0x00, 0x3C, 0x1E, 0x70, 0x01, 0xFF, 0xCE, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x04, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x07, 0xF1, 0xFE, 0x01, 0xFC, 0xF3, 0xC0, 0x7F, 0x38, 0x78, 0x1C,
  0x1C, 0x0F, 0x07, 0x0F, 0x01, 0xE1, 0xC3, 0x80, 0x38, 0x60, 0xE0, 0x07,
  0x18, 0x38, 0x01, 0xE6, 0x0E, 0x00, 0x3D, 0x83, 0x80, 0x07, 0xE0, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x03, 0x70,
  0x78, 0x01, 0x9E, 0x1F, 0x81, 0xE3, 0xC3, 0xFF, 0xF0, 0x78, 0x3F, 0xF8,
  0x0F, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x9F, 0x03, 0x03, 0xEF, 0xF8, 0xC7,
  0xFC, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x70, 0x04, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x1E, 0x38, 0x70, 0xE3, 0x87,
  0x0E, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07,
  0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x81, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x7C, 0x70, 0x00, 0x7C, 0x38, 0x00, 0x7C, 0x1C, 0x00, 0x78, 0x0E,
  0x00, 0x78, 0x07, 0x00, 0x18, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x03, 0x80,
  0x0F, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3C, 0x00, 0xF8, 0xE0, 0x01, 0xE7,
  0x00, 0x03, 0x84, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1D, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0x78,
  0x00, 0xF8, 0xF8, 0x0F, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x03,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC3, 0xF8, 0x07, 0x3F, 0xF8,
  0x1D, 0xFF, 0xF8, 0x7F, 0x03, 0xF1, 0xF0, 0x03, 0xC7, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x40, 0x00, 0x3B, 0x80, 0x00, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0x3E,
  0x03, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC1, 0xF8,
  0x07, 0x1F, 0xF8, 0x1D, 0xFF, 0xF8, 0xE7, 0x03, 0xF3, 0xB0, 0x03, 0xEF,
  0x80, 0x07, 0xBC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x8F,
  0x00, 0x3C, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF1, 0xE0,
  0x01, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0,
  0x0D, 0xCF, 0xC0, 0xF7, 0x1F, 0xFF, 0xB8, 0x1F, 0xF8, 0xE0, 0x1F, 0x83,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x3C, 0xFD, 0xFB, 0xF3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0xCF, 0x1E, 0x7C, 0xF1, 0xE3, 0x87, 0x0E, 0x38, 0x70,
  0xE1, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3E,
  0x07, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07,
  0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0,
  0xF8, 0x1C, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x19, 0x80, 0x00, 0x66, 0x01, 0xF1, 0xB8, 0x0F, 0xE7, 0xE0,
  0x7F, 0xDF, 0x83, 0xC1, 0xFE, 0x0E, 0x03, 0xF8, 0x70, 0x07, 0xC1, 0xC0,
  0x1F, 0x07, 0x00, 0x7C, 0x1C, 0x01, 0xF0, 0x70, 0x07, 0xC1, 0xC0, 0x1F,
  0x07, 0x00, 0x7C, 0x1C, 0x01, 0xF0, 0x70, 0x07, 0xC1, 0xC0, 0x1F, 0x07,
  0x00, 0x7C, 0x0E, 0x01, 0xF8, 0x38, 0x0F, 0xE0, 0xFD, 0xDF, 0x81, 0xFF,
  0x7E, 0x03, 0xF9, 0xD8, 0x01, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1C, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x38, 0x00, 0xF8, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0x78, 0xE0,
  0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x7C, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E, 0x00,
  0x07, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x0A, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x8F, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x1E, 0x00,
  0x1C, 0x1E, 0x00, 0x78, 0x1F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x38, 0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x80, 0x03, 0xCE, 0x00, 0x1E, 0x38, 0x01, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x83,
  0x80, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x78, 0x00, 0x08, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x1F, 0x1E, 0x00, 0x6E, 0x1F, 0x03, 0xDC, 0x1F,
  0xFF, 0x38, 0x1F, 0xFC, 0x70, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0xEF, 0x00,
  0x0E, 0x70, 0x01, 0xE7, 0x80, 0x3C, 0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0x80, 0x01,
  0xE7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0x70, 0x03, 0xC0, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0xF0, 0x07,
  0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x71,
  0xF0, 0x00, 0xE7, 0xF0, 0x01, 0xDE, 0xE0, 0x03, 0xB9, 0xE0, 0x07, 0xE1,
  0xC0, 0x0F, 0x81, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x03,
  0x80, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0x07, 0x00, 0x0F,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0xC0, 0x0F,
  0xFB, 0x80, 0x77, 0xEE, 0x01, 0xDF, 0x9C, 0x06, 0x7E, 0x70, 0x39, 0xF8,
  0xC0, 0xC7, 0xE3, 0x87, 0x1F, 0x86, 0x1C, 0x7E, 0x1C, 0x61, 0xF8, 0x73,
  0x87, 0xE0, 0xCC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07,
  0xE0, 0x78, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x08, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xEE, 0x00, 0x1F, 0xB8, 0x00, 0x7E, 0x70,
  0x01, 0xF9, 0xC0, 0x07, 0xE7, 0x00, 0x1F, 0x8E, 0x00, 0x7E, 0x38, 0x01,
  0xF8, 0x70, 0x07, 0xE1, 0xC0, 0x1F, 0x83, 0x80, 0x7E, 0x0E, 0x01, 0xF8,
  0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x81, 0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x0E,
  0x07, 0xE0, 0x1C, 0x1F, 0x80, 0x70, 0x7E, 0x00, 0xE1, 0xF8, 0x03, 0x87,
  0xE0, 0x07, 0x1F, 0x80, 0x1C, 0x7E, 0x00, 0x39, 0xF8, 0x00, 0xE7, 0xE0,
  0x03, 0x9F, 0x80, 0x07, 0x7E, 0x00, 0x1D, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x81,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x38, 0x00, 0x7C, 0xE0, 0x00, 0x7B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x01, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E,
  0x00, 0x78, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E,
  0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x38, 0x00,
  0x7C, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x01,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xE0, 0x38, 0x03,
  0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0E, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x00, 0xFC, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x04,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x40, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x3F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x80,
  0x07, 0x8F, 0x00, 0x3C, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x01, 0xE0, 0x39, 0xC0, 0x78, 0x0E,
  0x70, 0x1E, 0x03, 0x9C, 0x0F, 0xC0, 0xE7, 0x03, 0xF0, 0x38, 0xC0, 0xCC,
  0x0C, 0x30, 0x33, 0x03, 0x0C, 0x1C, 0xE0, 0xC3, 0x07, 0x38, 0x30, 0xC1,
  0x86, 0x0C, 0x38, 0x61, 0x87, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70,
  0xE3, 0x03, 0x1C, 0x38, 0xC0, 0xC7, 0x0E, 0x70, 0x39, 0xC3, 0x9C, 0x0E,
  0x70, 0x66, 0x01, 0x98, 0x19, 0x80, 0x66, 0x06, 0xE0, 0x1D, 0x81, 0xB8,
  0x07, 0x60, 0x6E, 0x01, 0xD8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF0,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x1C, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xF0,
  0x00, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0E, 0x00,
  0x1C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x78,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80,
  0x03, 0x81, 0xC0, 0x03, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x40, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x61, 0xC1, 0xC3, 0x83, 0x83, 0x87, 0x07, 0x04, 0x03, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xE0, 0x3E, 0x07, 0x00, 0x1E, 0x1C, 0x00,
  0x1C, 0x10, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3E, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x3C,
  0x00, 0xD8, 0x3C, 0x07, 0xBF, 0x7F, 0xFE, 0x7E, 0x7F, 0xF8, 0x7C, 0x1F,
  0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x3F, 0x80, 0xE3,
  0xFF, 0x83, 0x9F, 0xFF, 0x0E, 0xE0, 0x7E, 0x3A, 0x00, 0x7C, 0xF0, 0x00,
  0x73, 0xC0, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0xA0, 0x07, 0xCE,
  0xE0, 0x3E, 0x39, 0xFF, 0xF0, 0xE3, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0x83, 0xC0, 0x0E,
  0x3C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x47, 0x00, 0x03, 0x3C, 0x00, 0x3C, 0xF0, 0x03, 0x83,
  0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x7F, 0x07, 0x07, 0xFF, 0x1C, 0x3F, 0xFE,
  0x71, 0xF0, 0x1D, 0xCF, 0x80, 0x17, 0x38, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDE,
  0x00, 0x0F, 0x38, 0x00, 0x3C, 0xF8, 0x01, 0x71, 0xF0, 0x1D, 0xC3, 0xFF,
  0xE7, 0x07, 0xFF, 0x1C, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xE7,
  0x00, 0x03, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x04, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x87, 0xC0,
  0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1F, 0x03, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x78,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x1F, 0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x38, 0x00, 0x1E, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x7C,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x0F, 0xC0, 0xE3, 0xFF, 0x0E, 0x7F, 0xFC, 0xEE, 0x07, 0xCE, 0x80,
  0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x1E,
  0xE0, 0x00, 0xF3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0,
  0x1E, 0x03, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xE1, 0xE0,
  0x03, 0x8F, 0x00, 0x0E, 0x7E, 0x00, 0x3B, 0xBC, 0x00, 0xFC, 0x78, 0x03,
  0xE0, 0xE0, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0x80,
  0x1E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xE3, 0x80, 0x03,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE3, 0xC0, 0xF8, 0xE7, 0xF1, 0xFC, 0xEF, 0xF3, 0xFE,
  0xF8, 0x7B, 0x0E, 0xF0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07,
  0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0xFC, 0x0E,
  0x3F, 0xF0, 0xE7, 0xFF, 0xCE, 0xE0, 0x7C, 0xE8, 0x01, 0xEF, 0x00, 0x0E,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0,
  0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0xFE, 0x03, 0x8F, 0xFE, 0x0E, 0x7F,
  0xFC, 0x3B, 0x81, 0xF8, 0xE8, 0x01, 0xF3, 0xC0, 0x01, 0xCF, 0x00, 0x07,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xCE, 0x80, 0x1F, 0x3B, 0x80, 0xF8, 0xE7,
  0xFF, 0xC3, 0x8F, 0xFE, 0x0E, 0x0F, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x1C, 0x1F,
  0xFC, 0x70, 0xFF, 0xF9, 0xC7, 0xC0, 0x77, 0x3E, 0x00, 0x5C, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0xDC, 0x00, 0x07, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0xE0, 0x05, 0xC7,
  0xC0, 0x77, 0x0F, 0xFF, 0x9C, 0x1F, 0xFC, 0x70, 0x1F, 0xC1, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0x00, 0xE6, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0xE8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0x80, 0x7E, 0x38, 0x00, 0x79, 0xC0, 0x00, 0x47, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x40, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0x9F, 0x80, 0x7E, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0F,
  0x78, 0x01, 0x73, 0xE0, 0x77, 0x3F, 0xFE, 0x70, 0xFF, 0xC7, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x01, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x18, 0x06, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x03, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x71, 0x80, 0x01, 0xCE, 0x00, 0x03,
  0x30, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x1F, 0x80,
  0x78, 0x07, 0xE0, 0x3B, 0x01, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x06, 0x70, 0x73, 0x81, 0x9C, 0x18, 0x60, 0xE7, 0x06, 0x18,
  0x38, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0xC3, 0x0C, 0x38, 0x70, 0xC3, 0x8C,
  0x0C, 0x30, 0xE3, 0x03, 0x1C, 0x38, 0xC0, 0xC7, 0x06, 0x70, 0x39, 0x81,
  0x98, 0x06, 0x60, 0x66, 0x01, 0x98, 0x19, 0x80, 0x66, 0x07, 0x60, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xE0,
  0x03, 0x87, 0x00, 0x07, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x77, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xC0,
  0x70, 0x03, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0x3B, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01,
  0x81, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0x01, 0xF0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x03, 0x1F, 0xC0, 0x03, 0x3F,
  0xE0, 0x03, 0x38, 0xF0, 0x07, 0x70, 0x78, 0x06, 0x70, 0x3C, 0x0E, 0x60,
  0x1E, 0x0E, 0xE0, 0x0F, 0x1C, 0xC0, 0x07, 0xFC, 0xC0, 0x03, 0xF8, 0xC0,
  0x01, 0xE0,
};

const GFXglyph IBMPlexMono_Light50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 6, 35, 30, 12, -35 },
  { 28, 10, 13, 30, 10, -37 },
  { 45, 28, 35, 30, 1, -35 },
  { 168, 24, 46, 30, 3, -40 },
  { 306, 28, 37, 30, 1, -36 },
  { 436, 26, 37, 30, 2, -36 },
  { 557, 2, 13, 30, 14, -37 },
  { 561, 13, 45, 30, 11, -38 },
  { 635, 13, 45, 30, 6, -38 },
  { 709, 26, 25, 30, 2, -27 },
  { 791, 24, 25, 30, 3, -28 },
  { 866, 7, 14, 30, 11, -6 },
  { 879, 14, 3, 30, 8, -17 },
  { 885, 6, 5, 30, 12, -5 },
  { 889, 20, 45, 30, 5, -38 },
  { 1002, 24, 37, 30, 3, -36 },
  { 1113, 25, 35, 30, 3, -35 },
  { 1223, 23, 36, 30, 4, -36 },
  { 1327, 22, 37, 30, 3, -36 },
  { 1429, 26, 35, 30, 2, -35 },
  { 1543, 22, 36, 30, 4, -35 },
  { 1642, 22, 36, 30, 4, -35 },
  { 1741, 23, 35, 30, 3, -35 },
  { 1842, 24, 37, 30, 3, -36 },
  { 1953, 22, 36, 30, 4, -36 },
  { 2052, 6, 26, 30, 12, -26 },
  { 2072, 7, 34, 30, 11, -26 },
  { 2102, 22, 28, 30, 4, -29 },
  { 2179, 24, 13, 30, 3, -22 },
  { 2218, 22, 28, 30, 4, -29 },
  { 2295, 21, 36, 30, 4, -36 },
  { 2390, 22, 42, 30, 4, -36 },
  { 2506, 26, 35, 30, 2, -35 },
  { 2620, 22, 35, 30, 5, -35 },
  { 2717, 23, 37, 30, 4, -36 },
  { 2824, 22, 35, 30, 5, -35 },
  { 2921, 21, 35, 30, 5, -35 },
  { 3013, 21, 35, 30, 5, -35 },
  { 3105, 23, 37, 30, 3, -36 },
  { 3212, 22, 35, 30, 4, -35 },
  { 3309, 22, 35, 30, 4, -35 },
  { 3406, 20, 36, 30, 4, -35 },
  { 3496, 23, 35, 30, 5, -35 },
  { 3597, 21, 35, 30, 6, -35 },
  { 3689, 22, 35, 30, 4, -35 },
  { 3786, 22, 35, 30, 4, -35 },
  { 3883, 24, 37, 30, 3, -36 },
  { 3994, 22, 35, 30, 5, -35 },
  { 4091, 24, 45, 30, 3, -36 },
  { 4226, 22, 35, 30, 5, -35 },
  { 4323, 24, 37, 30, 3, -36 },
  { 4434, 26, 35, 30, 2, -35 },
  { 4548, 22, 36, 30, 4, -35 },
  { 4647, 26, 35, 30, 2, -35 },
  { 4761, 26, 35, 30, 2, -35 },
  { 4875, 26, 35, 30, 2, -35 },
  { 4989, 28, 35, 30, 1, -35 },
  { 5112, 26, 35, 30, 2, -35 },
  { 5226, 13, 45, 30, 12, -38 },
  { 5300, 20, 45, 30, 5, -38 },
  { 5413, 13, 45, 30, 5, -38 },
  { 5487, 24, 20, 30, 3, -35 },
  { 5547, 24, 3, 30, 3, 5 },
  { 5556, 7, 9, 30, 10, -39 },
  { 5564, 23, 27, 30, 4, -26 },
  { 5642, 22, 38, 30, 5, -37 },
  { 5747, 21, 27, 30, 5, -26 },
  { 5818, 22, 38, 30, 3, -37 },
  { 5923, 22, 27, 30, 4, -26 },
  { 5998, 23, 37, 30, 4, -37 },
  { 6105, 24, 40, 30, 4, -29 },
  { 6225, 20, 37, 30, 5, -37 },
  { 6318, 22, 38, 30, 5, -38 },
  { 6423, 18, 48, 30, 5, -38 },
  { 6531, 22, 37, 30, 6, -37 },
  { 6633, 22, 37, 30, 4, -37 },
  { 6735, 24, 26, 30, 3, -26 },
  { 6813, 20, 26, 30, 5, -26 },
  { 6878, 22, 27, 30, 4, -26 },
  { 6953, 22, 36, 30, 5, -26 },
  { 7052, 22, 36, 30, 3, -26 },
  { 7151, 24, 26, 30, 4, -26 },
  { 7229, 22, 27, 30, 4, -26 },
  { 7304, 24, 35, 30, 2, -35 },
  { 7409, 20, 27, 30, 5, -26 },
  { 7477, 22, 26, 30, 4, -26 },
  { 7549, 26, 26, 30, 2, -26 },
  { 7634, 22, 26, 30, 4, -26 },
  { 7706, 24, 36, 30, 3, -26 },
  { 7814, 20, 26, 30, 5, -26 },
  { 7879, 20, 45, 30, 5, -38 },
  { 7992, 2, 45, 30, 14, -38 },
  { 8004, 20, 45, 30, 5, -38 },
  { 8117, 24, 11, 30, 3, -21 },
};

const GFXfont IBMPlexMono_Light50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_LIGHT50PT7B_H_
