#ifndef _IBMPLEXMONO_LIGHT13PT7B_H_
#define _IBMPLEXMONO_LIGHT13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA0, 0xC0, 0xB6, 0x80, 0x14, 0x14, 0x24, 0x67, 0x28, 0xE6,
  0x28, 0x28, 0x48, 0x21, 0xEA, 0x68, 0xA1, 0xE2, 0x49, 0xA5, 0xE2, 0x00,
  0x73, 0x92, 0x94, 0x74, 0x00, 0x2E, 0x52, 0x52, 0x8E, 0x38, 0x91, 0x11,
  0x07, 0x32, 0xA3, 0x22, 0x7A, 0xE0, 0x2A, 0x49, 0x24, 0x91, 0x10, 0x89,
  0x12, 0x49, 0x29, 0x40, 0x20, 0x8A, 0x5E, 0x31, 0x20, 0x20, 0x82, 0x3F,
  0x20, 0x82, 0x00, 0xE8, 0xF0, 0xC0, 0x0C, 0x20, 0x84, 0x10, 0x82, 0x08,
  0x41, 0x08, 0x20, 0x7A, 0x28, 0x61, 0xB6, 0x18, 0x62, 0x78, 0x31, 0x49,
  0x24, 0x10, 0x41, 0x04, 0xFC, 0x7A, 0x28, 0x83, 0x08, 0x42, 0x30, 0xFC,
  0x7A, 0x20, 0x82, 0x70, 0x20, 0x62, 0x78, 0x0C, 0x28, 0x51, 0x24, 0x48,
  0xBF, 0x82, 0x04, 0x7A, 0x08, 0x2E, 0xCC, 0x10, 0x62, 0x78, 0x10, 0x84,
  0x2E, 0xCE, 0x18, 0x62, 0x78, 0xFE, 0x28, 0x82, 0x10, 0x42, 0x08, 0x40,
  0x7A, 0x18, 0x62, 0x73, 0x38, 0x61, 0x78, 0x7A, 0x38, 0x61, 0x8D, 0xE0,
  0x84, 0x60, 0xC0, 0x0C, 0xC0, 0x0E, 0x80, 0x04, 0x66, 0x20, 0x60, 0x40,
  0xC0, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x7A, 0x28,
  0x42, 0x30, 0x80, 0x00, 0x20, 0x7A, 0x28, 0x6F, 0xA6, 0x9A, 0x6F, 0x41,
  0xE0, 0x18, 0x30, 0xA1, 0x22, 0x44, 0x9F, 0x21, 0xC2, 0xFA, 0x28, 0x62,
  0xFA, 0x18, 0x61, 0xF8, 0x79, 0x18, 0xA0, 0x82, 0x08, 0x91, 0x78, 0xFA,
  0x28, 0x61, 0x86, 0x18, 0x62, 0xF8, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20,
  0xFC, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x80, 0x72, 0x28, 0xE0, 0x9E,
  0x18, 0x63, 0x74, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xFC, 0x82,
  0x08, 0x20, 0x82, 0x08, 0xFC, 0x78, 0x42, 0x10, 0x84, 0x31, 0x70, 0x86,
  0x29, 0x28, 0xE2, 0x48, 0xA2, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8,
  0x87, 0x3D, 0x6D, 0xB6, 0x98, 0x61, 0x84, 0x87, 0x1C, 0x69, 0xA6, 0x59,
  0x63, 0x8C, 0x7A, 0x28, 0x61, 0x86, 0x18, 0x62, 0x78, 0xFA, 0x18, 0x61,
  0xFA, 0x08, 0x20, 0x80, 0x7A, 0x28, 0x61, 0x86, 0x18, 0x62, 0x78, 0x81,
  0x80, 0xFA, 0x18, 0x61, 0xFA, 0x49, 0x22, 0x84, 0x7A, 0x18, 0x20, 0x78,
  0x10, 0x61, 0x78, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x62, 0x78, 0x86, 0x18, 0xA2, 0x49, 0x25, 0x0C,
  0x30, 0x86, 0x1A, 0x6D, 0xB7, 0x5D, 0x73, 0xC8, 0x42, 0x88, 0x90, 0xC1,
  0x03, 0x09, 0x22, 0xC2, 0x83, 0x42, 0x24, 0x24, 0x18, 0x10, 0x10, 0x10,
  0x10, 0xFC, 0x10, 0x84, 0x21, 0x04, 0x20, 0xFC, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x8F, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x83, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x1F, 0x31, 0x44, 0xA2, 0x84, 0xFC, 0xC0, 0x72,
  0x20, 0x9E, 0x8A, 0x27, 0x40, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0xC6,
  0xE0, 0x79, 0x28, 0x60, 0x81, 0x37, 0x80, 0x08, 0x42, 0xF8, 0xC6, 0x31,
  0x8B, 0xC0, 0x7A, 0x28, 0x7F, 0x82, 0x17, 0x80, 0x1C, 0x82, 0x3F, 0x20,
  0x82, 0x08, 0x23, 0xF0, 0x0D, 0xE8, 0xA2, 0x48, 0xCC, 0x1F, 0x86, 0x17,
  0x80, 0x84, 0x21, 0x7C, 0xC6, 0x31, 0x8C, 0x40, 0x10, 0x00, 0x3C, 0x10,
  0x41, 0x04, 0x13, 0xF0, 0x08, 0x01, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x1F,
  0x00, 0x84, 0x21, 0x1B, 0x62, 0x92, 0x94, 0x40, 0xE0, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x23, 0xF0, 0xEE, 0xDA, 0x69, 0xA6, 0x9A, 0x40, 0xBE, 0x63,
  0x18, 0xC6, 0x20, 0x7A, 0x28, 0x61, 0x86, 0x27, 0x80, 0xBB, 0x18, 0x61,
  0x87, 0x1B, 0xA0, 0x82, 0x00, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0x40,
  0xEC, 0xC2, 0x08, 0x20, 0x8F, 0xC0, 0x7A, 0x38, 0x1E, 0x06, 0x17, 0x80,
  0x10, 0x23, 0xF8, 0x81, 0x02, 0x04, 0x08, 0x1E, 0x8C, 0x63, 0x18, 0xCD,
  0xE0, 0x86, 0x24, 0x92, 0x50, 0xC3, 0x00, 0x93, 0x36, 0x6B, 0x56, 0xAC,
  0x99, 0x00, 0x8D, 0x23, 0x08, 0x31, 0x28, 0x40, 0x86, 0x24, 0x92, 0x50,
  0xC2, 0x08, 0x23, 0x00, 0xF8, 0x21, 0x08, 0x42, 0x0F, 0xC0, 0x39, 0x08,
  0x21, 0x70, 0x42, 0x21, 0x08, 0x70, 0xFF, 0xF0, 0xF0, 0x88, 0x42, 0x0C,
  0x84, 0x20, 0x85, 0xE0, 0x66, 0xD9, 0x80,
};

const GFXglyph IBMPlexMono_Light13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 3, 3, 8, 2, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 11, 8, 1, -10 },
  { 24, 8, 9, 8, 0, -9 },
  { 33, 7, 9, 8, 0, -9 },
  { 41, 1, 3, 8, 3, -10 },
  { 42, 3, 12, 8, 3, -10 },
  { 47, 3, 12, 8, 2, -10 },
  { 52, 6, 6, 8, 1, -7 },
  { 57, 6, 7, 8, 1, -7 },
  { 63, 2, 3, 8, 3, -1 },
  { 64, 4, 1, 8, 2, -4 },
  { 65, 2, 1, 8, 3, -1 },
  { 66, 6, 12, 8, 1, -10 },
  { 75, 6, 9, 8, 1, -9 },
  { 82, 6, 9, 8, 1, -9 },
  { 89, 6, 9, 8, 1, -9 },
  { 96, 6, 9, 8, 1, -9 },
  { 103, 7, 9, 8, 0, -9 },
  { 111, 6, 9, 8, 1, -9 },
  { 118, 6, 9, 8, 1, -9 },
  { 125, 6, 9, 8, 1, -9 },
  { 132, 6, 9, 8, 1, -9 },
  { 139, 6, 9, 8, 1, -9 },
  { 146, 2, 7, 8, 3, -7 },
  { 148, 2, 9, 8, 3, -7 },
  { 151, 6, 7, 8, 1, -7 },
  { 157, 6, 4, 8, 1, -6 },
  { 160, 6, 7, 8, 1, -7 },
  { 166, 6, 9, 8, 1, -9 },
  { 173, 6, 10, 8, 1, -9 },
  { 181, 7, 9, 8, 0, -9 },
  { 189, 6, 9, 8, 1, -9 },
  { 196, 6, 9, 8, 1, -9 },
  { 203, 6, 9, 8, 1, -9 },
  { 210, 6, 9, 8, 1, -9 },
  { 217, 6, 9, 8, 1, -9 },
  { 224, 6, 9, 8, 1, -9 },
  { 231, 6, 9, 8, 1, -9 },
  { 238, 6, 9, 8, 1, -9 },
  { 245, 5, 9, 8, 1, -9 },
  { 251, 6, 9, 8, 1, -9 },
  { 258, 5, 9, 8, 2, -9 },
  { 264, 6, 9, 8, 1, -9 },
  { 271, 6, 9, 8, 1, -9 },
  { 278, 6, 9, 8, 1, -9 },
  { 285, 6, 9, 8, 1, -9 },
  { 292, 6, 11, 8, 1, -9 },
  { 301, 6, 9, 8, 1, -9 },
  { 308, 6, 9, 8, 1, -9 },
  { 315, 7, 9, 8, 0, -9 },
  { 323, 6, 9, 8, 1, -9 },
  { 330, 6, 9, 8, 1, -9 },
  { 337, 6, 9, 8, 1, -9 },
  { 344, 7, 9, 8, 0, -9 },
  { 352, 8, 9, 8, 0, -9 },
  { 361, 6, 9, 8, 1, -9 },
  { 368, 4, 12, 8, 3, -10 },
  { 374, 6, 12, 8, 1, -10 },
  { 383, 4, 12, 8, 1, -10 },
  { 389, 6, 5, 8, 1, -9 },
  { 393, 6, 1, 8, 1, 1 },
  { 394, 1, 2, 8, 3, -11 },
  { 395, 6, 7, 8, 1, -7 },
  { 401, 6, 10, 8, 1, -10 },
  { 409, 6, 7, 8, 1, -7 },
  { 415, 5, 10, 8, 1, -10 },
  { 422, 6, 7, 8, 1, -7 },
  { 428, 6, 10, 8, 1, -10 },
  { 436, 6, 11, 8, 1, -8 },
  { 445, 5, 10, 8, 1, -10 },
  { 452, 6, 10, 8, 1, -10 },
  { 460, 5, 13, 8, 1, -10 },
  { 469, 5, 10, 8, 2, -10 },
  { 476, 6, 10, 8, 1, -10 },
  { 484, 6, 7, 8, 1, -7 },
  { 490, 5, 7, 8, 1, -7 },
  { 495, 6, 7, 8, 1, -7 },
  { 501, 6, 10, 8, 1, -7 },
  { 509, 5, 10, 8, 1, -7 },
  { 516, 6, 7, 8, 1, -7 },
  { 522, 6, 7, 8, 1, -7 },
  { 528, 7, 9, 8, 0, -9 },
  { 536, 5, 7, 8, 1, -7 },
  { 541, 6, 7, 8, 1, -7 },
  { 547, 7, 7, 8, 0, -7 },
  { 554, 6, 7, 8, 1, -7 },
  { 560, 6, 10, 8, 1, -7 },
  { 568, 6, 7, 8, 1, -7 },
  { 574, 5, 12, 8, 1, -10 },
  { 582, 1, 12, 8, 3, -10 },
  { 584, 5, 12, 8, 1, -10 },
  { 592, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_Light13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_LIGHT13PT7B_H_
