#ifndef _IBMPLEXMONO_LIGHT68PT7B_H_
#define _IBMPLEXMONO_LIGHT68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light68pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x3C,
  0xFF, 0x81, 0xF8, 0x1E, 0x0F, 0xE0, 0xF8, 0x0F, 0x01, 0xF0, 0xF8, 0x07,
  0x80, 0x7C, 0x78, 0x03, 0xC0, 0x1C, 0x3C, 0x01, 0xE0, 0x04, 0x3C, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x7F,
  0x80, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x79, 0x00, 0x0F, 0x00, 0x3D, 0xC0, 0x07,
  0x80, 0x3D, 0xF0, 0x03, 0xC0, 0x1E, 0x7C, 0x01, 0xE0, 0x1F, 0x3F, 0x80,
  0xF0, 0x1F, 0x0F, 0xE0, 0x78, 0x3F, 0x81, 0xFE, 0x3C, 0x7F, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x03, 0x87, 0xC1,
  0xF0, 0x00, 0x1E, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x03,
  0xC7, 0x80, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x70, 0x00,
  0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x07, 0x00, 0x78,
  0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x07, 0xC1, 0xF0, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0xE0, 0x00,
  0x1F, 0xFC, 0x04, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x03,
  0xFF, 0xE0, 0x00, 0x70, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0x0E, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x70,
  0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x07, 0x01,
  0xC0, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x38, 0x03, 0xC0,
  0x01, 0xC1, 0xE0, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x3C,
  0x00, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x80,
  0x1E, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x07, 0xC7, 0x80,
  0x00, 0x7F, 0xFE, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0xF8, 0xF0, 0x01, 0xFF, 0x0F, 0x07,
  0x80, 0x1C, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x3C, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x1F, 0x01, 0xC0, 0x78, 0x00, 0xF8, 0x1C, 0x07, 0x80, 0x07, 0x81,
  0xC0, 0x78, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0xF0, 0x00,
  0x0F, 0x38, 0x0F, 0x00, 0x00, 0x7B, 0x80, 0xF0, 0x00, 0x07, 0xF8, 0x0F,
  0x00, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x01, 0xFC, 0x07, 0x80, 0x00, 0x1B, 0xC0, 0x3C, 0x00,
  0x03, 0x1E, 0x03, 0xE0, 0x00, 0x70, 0xF0, 0x1F, 0x00, 0x0E, 0x0F, 0x80,
  0xFE, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x3F, 0xFF, 0x00,
  0x1F, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x70, 0x00, 0x67, 0xC0, 0x0E, 0x00, 0x7D,
  0xFF, 0x01, 0xC0, 0x7F, 0xDF, 0xFC, 0x38, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x0F, 0xC0, 0x1F, 0xF8, 0x07,
  0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xDE, 0x00, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x0F,
  0xC3, 0xC0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x01, 0x80, 0x07, 0x80, 0x00, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x03, 0xC1, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x3E, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78,
  0x20, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF2, 0x00, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x01, 0xE1, 0xFF,
  0xF0, 0x03, 0xCF, 0xFF, 0xF8, 0x07, 0xBF, 0xFF, 0xF8, 0x0F, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC4, 0x00, 0x00, 0x07, 0x8C,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x3F, 0xE0, 0x01, 0xE1, 0xFF, 0xF0, 0x07, 0x8F, 0xFF, 0xF8, 0x0F,
  0x3F, 0xFF, 0xF8, 0x1E, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0xF6,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF7, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x80, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xEE, 0x1F, 0x80, 0x03, 0xBC, 0x3F,
  0xE0, 0x1F, 0x78, 0x3F, 0xFF, 0xFC, 0xF0, 0x1F, 0xFF, 0xE3, 0xC0, 0x1F,
  0xFF, 0x87, 0x80, 0x07, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x3E, 0x1F, 0x0F, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xE0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x0F, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0xF7, 0x00, 0x0F, 0xC3, 0xDC, 0x00, 0xFF, 0xCF, 0x70, 0x07, 0xFF, 0xBD,
  0xC0, 0x3F, 0x06, 0xFF, 0x00, 0xF0, 0x07, 0xFC, 0x07, 0x80, 0x1F, 0xF0,
  0x1C, 0x00, 0x3F, 0xC0, 0x70, 0x00, 0xFF, 0x03, 0xC0, 0x03, 0xFC, 0x0F,
  0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0xFF, 0x03, 0xC0,
  0x03, 0xFC, 0x0F, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x3F, 0xC0, 0xF0, 0x00,
  0xFF, 0x03, 0xC0, 0x03, 0xFC, 0x0F, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x3F,
  0xC0, 0xF0, 0x00, 0xFF, 0x03, 0xC0, 0x03, 0xFC, 0x07, 0x00, 0x0F, 0xF0,
  0x1E, 0x00, 0x3D, 0xC0, 0x78, 0x01, 0xF7, 0x00, 0xF0, 0x0F, 0xDC, 0x03,
  0xF0, 0xEF, 0x70, 0x07, 0xFF, 0xBD, 0xE0, 0x0F, 0xFC, 0xF7, 0x80, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x78, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x1F, 0x8F,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0xC3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x0F, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x0F,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xF0,
  0x00, 0xFF, 0x03, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xFC, 0x3C, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x07,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x0E, 0xF0, 0x7F, 0x80, 0xF9, 0xE0,
  0x7F, 0xFF, 0xF3, 0xC0, 0x7F, 0xFF, 0xC7, 0x80, 0x3F, 0xFE, 0x0F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE3, 0xE0, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0xF0, 0x7F, 0x00,
  0x00, 0xF0, 0xFF, 0x80, 0x00, 0xF1, 0xE7, 0x80, 0x00, 0xF3, 0xE7, 0xC0,
  0x00, 0xF7, 0xC3, 0xE0, 0x00, 0xFF, 0x81, 0xE0, 0x00, 0xFF, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x77, 0xFB,
  0xC0, 0x01, 0xEF, 0xF7, 0x80, 0x03, 0x9F, 0xE7, 0x00, 0x07, 0x3F, 0xCF,
  0x00, 0x1E, 0x7F, 0x8E, 0x00, 0x38, 0xFF, 0x1E, 0x00, 0xF1, 0xFE, 0x3C,
  0x01, 0xC3, 0xFC, 0x3C, 0x07, 0x87, 0xF8, 0x78, 0x0E, 0x0F, 0xF0, 0x70,
  0x1C, 0x1F, 0xE0, 0xF0, 0x78, 0x3F, 0xC0, 0xE0, 0xE0, 0x7F, 0x81, 0xE3,
  0xC0, 0xFF, 0x03, 0xC7, 0x01, 0xFE, 0x03, 0xDE, 0x03, 0xFC, 0x07, 0xBC,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0x80,
  0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0xFF, 0x00, 0x38, 0x01,
  0xFE, 0x00, 0x70, 0x03, 0xFC, 0x00, 0x40, 0x07, 0xF8, 0x00, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xDE, 0x00, 0x01,
  0xFE, 0xF0, 0x00, 0x0F, 0xF7, 0xC0, 0x00, 0x7F, 0x9E, 0x00, 0x03, 0xFC,
  0xF8, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0xFF, 0x1E, 0x00, 0x07, 0xF8, 0x78,
  0x00, 0x3F, 0xC3, 0xC0, 0x01, 0xFE, 0x0F, 0x00, 0x0F, 0xF0, 0x78, 0x00,
  0x7F, 0x81, 0xE0, 0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0xFF,
  0x01, 0xE0, 0x07, 0xF8, 0x0F, 0x80, 0x3F, 0xC0, 0x3C, 0x01, 0xFE, 0x01,
  0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x3C, 0x03, 0xFC, 0x00, 0xF0,
  0x1F, 0xE0, 0x07, 0x80, 0xFF, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0xF0, 0x3F,
  0xC0, 0x03, 0xC1, 0xFE, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0xF8, 0x7F, 0x80,
  0x03, 0xC3, 0xFC, 0x00, 0x1F, 0x1F, 0xE0, 0x00, 0x78, 0xFF, 0x00, 0x03,
  0xC7, 0xF8, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x79, 0xFE, 0x00, 0x01, 0xEF,
  0xF0, 0x00, 0x0F, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x01, 0xFB, 0xC0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x3F,
  0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0x04, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x20, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x3C, 0xF0, 0x03, 0xE0, 0x07, 0x9E, 0x00, 0x7C, 0x00,
  0xF3, 0xC0, 0x0F, 0x80, 0x1C, 0x78, 0x03, 0xF8, 0x03, 0x87, 0x00, 0x7F,
  0x00, 0x70, 0xE0, 0x0E, 0xE0, 0x0E, 0x1C, 0x01, 0xDC, 0x01, 0xC3, 0x80,
  0x7B, 0xC0, 0x38, 0x70, 0x0E, 0x78, 0x0F, 0x0F, 0x01, 0xC7, 0x01, 0xE1,
  0xE0, 0x38, 0xE0, 0x3C, 0x3C, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xC3, 0xC0,
  0xF0, 0xF0, 0x38, 0x38, 0x1E, 0x1E, 0x07, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE1,
  0xE0, 0x38, 0x38, 0x1C, 0x3C, 0x07, 0x87, 0x03, 0x87, 0x00, 0xF1, 0xE0,
  0x78, 0xE0, 0x0E, 0x3C, 0x0F, 0x3C, 0x01, 0xC7, 0x81, 0xE7, 0x80, 0x3C,
  0xF0, 0x3C, 0xE0, 0x07, 0x9E, 0x07, 0x9C, 0x00, 0x73, 0x80, 0xF7, 0x80,
  0x0E, 0x70, 0x0E, 0xF0, 0x01, 0xEE, 0x01, 0xDC, 0x00, 0x3D, 0xC0, 0x3B,
  0x80, 0x03, 0xB8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x3E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x06, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xE0, 0x7E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x05,
  0xE0, 0x78, 0x00, 0x0D, 0xE0, 0x7C, 0x00, 0x19, 0xE0, 0x3F, 0x80, 0xF9,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x80, 0x1E, 0x0F, 0xFF, 0x80, 0xF1,
  0xFF, 0xFE, 0x07, 0x9E, 0x01, 0xF8, 0x3D, 0xC0, 0x03, 0xE1, 0xEC, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x3E, 0x7B, 0x00, 0x03, 0xE3,
  0xDC, 0x00, 0x3E, 0x1E, 0x78, 0x07, 0xE0, 0xF1, 0xFF, 0xFE, 0x07, 0x83,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x41, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0x01, 0xE0, 0x3F, 0xFE, 0x0F, 0x03, 0xFF, 0xF8, 0x78, 0x7F,
  0x01, 0xF3, 0xC7, 0xE0, 0x01, 0x9E, 0x3E, 0x00, 0x06, 0xF3, 0xE0, 0x00,
  0x1F, 0x9E, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xBC, 0x7E, 0x00, 0x19, 0xE1,
  0xFC, 0x07, 0xCF, 0x03, 0xFF, 0xF8, 0x78, 0x0F, 0xFF, 0x83, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x41, 0xE0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x30, 0x00, 0x07, 0xFF, 0xD8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7C,
  0x00, 0x01, 0xFC, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x07, 0xF8, 0x07, 0x87, 0xFF, 0xC0, 0xF1, 0xFF, 0xFE, 0x1E, 0x78,
  0x0F, 0xE3, 0xDC, 0x00, 0x7E, 0x7B, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x0F,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x1F,
  0xC0, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0x79, 0xEF, 0x80, 0x00, 0xF7, 0x8F,
  0x80, 0x01, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x79, 0xFF, 0x03, 0xFE, 0x3D, 0xFF, 0xC3, 0xFF, 0x9E, 0xC1,
  0xF3, 0x87, 0xCF, 0xC0, 0x7B, 0x00, 0xF7, 0xC0, 0x1F, 0x00, 0x7B, 0xC0,
  0x0F, 0x80, 0x1D, 0xE0, 0x07, 0x80, 0x0E, 0xF0, 0x01, 0xC0, 0x07, 0xF8,
  0x00, 0xE0, 0x03, 0xFC, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x38, 0x00, 0xFF,
  0x00, 0x1C, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x1F,
  0xE0, 0x03, 0x80, 0x0F, 0xF0, 0x01, 0xC0, 0x07, 0xF8, 0x00, 0xE0, 0x03,
  0xFC, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x38, 0x00, 0xFF, 0x00, 0x1C, 0x00,
  0x7F, 0x80, 0x0E, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x1F, 0xE0, 0x03, 0x80,
  0x0F, 0xF0, 0x01, 0xC0, 0x07, 0xF8, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0x70,
  0x01, 0xFE, 0x00, 0x38, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x0E,
  0x00, 0x3F, 0xC0, 0x07, 0x00, 0x1F, 0xE0, 0x03, 0x80, 0x0F, 0xF0, 0x01,
  0xC0, 0x07, 0xF8, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0x70, 0x01, 0xFE, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x1E, 0x1F, 0xFF, 0x03, 0xC7, 0xFF,
  0xF8, 0x79, 0xE0, 0x3F, 0x8F, 0x70, 0x01, 0xF9, 0xEC, 0x00, 0x0F, 0x3F,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0x83, 0xFF, 0xE0,
  0x3C, 0x7F, 0xFF, 0x81, 0xE7, 0x80, 0x7E, 0x0F, 0x70, 0x00, 0xF8, 0x7B,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x9E, 0xC0, 0x00,
  0xF8, 0xF7, 0x00, 0x0F, 0x87, 0x9E, 0x01, 0xF8, 0x3C, 0x7F, 0xFF, 0x81,
  0xE0, 0xFF, 0xF8, 0x0F, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0x83, 0xC0, 0xFF, 0xFE, 0x1E, 0x1F, 0xC0, 0x7C, 0xF1, 0xF8, 0x00,
  0x67, 0x8F, 0x80, 0x01, 0xBC, 0xF8, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x6F, 0x1F, 0x80, 0x06, 0x78, 0x7F, 0x01, 0xF3, 0xC0, 0xFF,
  0xFE, 0x1E, 0x03, 0xFF, 0xE0, 0xF0, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xC7,
  0xFF, 0xF0, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x7B,
  0x00, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x20, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1E, 0x1F, 0x80,
  0x01, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xDC,
  0xF8, 0x00, 0x67, 0x1F, 0xC0, 0x79, 0xC3, 0xFF, 0xFC, 0x70, 0x7F, 0xFC,
  0x1C, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0x80,
  0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xC0, 0x03, 0x9C, 0x00, 0x3E, 0x00, 0x1C, 0xE0, 0x03,
  0xF0, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x0F, 0x3C, 0x00, 0xEE, 0x00, 0x79,
  0xE0, 0x07, 0x70, 0x03, 0x87, 0x00, 0x3B, 0x80, 0x1C, 0x38, 0x03, 0x8E,
  0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0x78,
  0x07, 0x1C, 0x03, 0xC3, 0xC0, 0x70, 0x60, 0x1C, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x1C, 0x06,
  0x07, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x1E, 0x07, 0x83, 0x80, 0xE0, 0xE0,
  0x1C, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x00,
  0xC1, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F,
  0x1C, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x78, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x03, 0xFE,
  0x00, 0x01, 0xC3, 0xFF, 0x80, 0x01, 0xE3, 0xC3, 0xE0, 0x00, 0xF3, 0xC0,
  0xF8, 0x00, 0x71, 0xC0, 0x3E, 0x00, 0x39, 0xE0, 0x0F, 0x80, 0x3C, 0xE0,
  0x03, 0xC0, 0x1C, 0x70, 0x00, 0xF8, 0x1E, 0x78, 0x00, 0x3E, 0x1E, 0x38,
  0x00, 0x0F, 0xFE, 0x1C, 0x00, 0x03, 0xFE, 0x0E, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Light68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 8, 47, 41, 16, -47 },
  { 48, 15, 18, 41, 13, -50 },
  { 82, 39, 47, 41, 1, -47 },
  { 312, 33, 63, 41, 4, -55 },
  { 572, 38, 49, 41, 1, -48 },
  { 805, 36, 49, 41, 2, -48 },
  { 1026, 4, 18, 41, 18, -50 },
  { 1035, 18, 61, 41, 15, -52 },
  { 1173, 18, 61, 41, 8, -52 },
  { 1311, 35, 34, 41, 3, -37 },
  { 1460, 33, 33, 41, 4, -37 },
  { 1597, 10, 18, 41, 15, -8 },
  { 1620, 19, 4, 41, 11, -23 },
  { 1630, 8, 7, 41, 16, -7 },
  { 1637, 27, 61, 41, 7, -52 },
  { 1843, 33, 49, 41, 4, -48 },
  { 2046, 33, 47, 41, 5, -47 },
  { 2240, 31, 48, 41, 5, -48 },
  { 2426, 30, 49, 41, 4, -48 },
  { 2610, 35, 47, 41, 3, -47 },
  { 2816, 31, 48, 41, 5, -47 },
  { 3002, 31, 48, 41, 5, -47 },
  { 3188, 31, 47, 41, 5, -47 },
  { 3371, 33, 49, 41, 4, -48 },
  { 3574, 31, 48, 41, 5, -48 },
  { 3760, 8, 36, 41, 16, -36 },
  { 3796, 10, 46, 41, 15, -36 },
  { 3854, 29, 38, 41, 6, -40 },
  { 3992, 33, 16, 41, 4, -29 },
  { 4058, 29, 38, 41, 6, -40 },
  { 4196, 28, 48, 41, 6, -48 },
  { 4364, 30, 55, 41, 5, -48 },
  { 4571, 35, 47, 41, 3, -47 },
  { 4777, 30, 47, 41, 6, -47 },
  { 4954, 31, 49, 41, 5, -48 },
  { 5144, 30, 47, 41, 7, -47 },
  { 5321, 28, 47, 41, 7, -47 },
  { 5486, 29, 47, 41, 7, -47 },
  { 5657, 31, 49, 41, 4, -48 },
  { 5847, 29, 47, 41, 6, -47 },
  { 6018, 29, 47, 41, 6, -47 },
  { 6189, 26, 48, 41, 6, -47 },
  { 6345, 32, 47, 41, 6, -47 },
  { 6533, 27, 47, 41, 9, -47 },
  { 6692, 31, 47, 41, 5, -47 },
  { 6875, 29, 47, 41, 6, -47 },
  { 7046, 33, 49, 41, 4, -48 },
  { 7249, 29, 47, 41, 7, -47 },
  { 7420, 33, 59, 41, 4, -48 },
  { 7664, 30, 47, 41, 7, -47 },
  { 7841, 32, 49, 41, 4, -48 },
  { 8037, 37, 47, 41, 2, -47 },
  { 8255, 29, 48, 41, 6, -47 },
  { 8429, 35, 47, 41, 3, -47 },
  { 8635, 35, 47, 41, 3, -47 },
  { 8841, 36, 47, 41, 2, -47 },
  { 9053, 38, 47, 41, 1, -47 },
  { 9277, 35, 47, 41, 3, -47 },
  { 9483, 18, 61, 41, 16, -52 },
  { 9621, 27, 61, 41, 7, -52 },
  { 9827, 17, 61, 41, 7, -52 },
  { 9957, 33, 27, 41, 4, -47 },
  { 10069, 33, 4, 41, 4, 7 },
  { 10086, 10, 12, 41, 13, -52 },
  { 10101, 32, 37, 41, 5, -36 },
  { 10249, 29, 51, 41, 7, -50 },
  { 10434, 29, 37, 41, 6, -36 },
  { 10569, 29, 51, 41, 5, -50 },
  { 10754, 31, 37, 41, 5, -36 },
  { 10898, 32, 50, 41, 5, -50 },
  { 11098, 33, 53, 41, 5, -39 },
  { 11317, 27, 50, 41, 7, -50 },
  { 11486, 30, 50, 41, 7, -50 },
  { 11674, 25, 64, 41, 6, -50 },
  { 11874, 31, 50, 41, 8, -50 },
  { 12068, 29, 50, 41, 6, -50 },
  { 12250, 33, 36, 41, 4, -36 },
  { 12399, 27, 36, 41, 7, -36 },
  { 12521, 31, 37, 41, 5, -36 },
  { 12665, 29, 50, 41, 7, -36 },
  { 12847, 29, 50, 41, 5, -36 },
  { 13029, 33, 35, 41, 5, -35 },
  { 13174, 30, 37, 41, 5, -36 },
  { 13313, 33, 47, 41, 3, -47 },
  { 13507, 26, 36, 41, 7, -35 },
  { 13624, 31, 35, 41, 5, -35 },
  { 13760, 37, 35, 41, 2, -35 },
  { 13922, 31, 35, 41, 5, -35 },
  { 14058, 32, 49, 41, 4, -35 },
  { 14254, 29, 35, 41, 6, -35 },
  { 14381, 26, 61, 41, 7, -52 },
  { 14580, 3, 61, 41, 19, -52 },
  { 14603, 26, 61, 41, 7, -52 },
  { 14802, 33, 13, 41, 4, -27 },
};

const GFXfont IBMPlexMono_Light68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_LIGHT68PT7B_H_
