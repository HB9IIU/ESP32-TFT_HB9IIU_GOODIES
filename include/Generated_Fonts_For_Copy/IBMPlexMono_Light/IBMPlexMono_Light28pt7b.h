#ifndef _IBMPLEXMONO_LIGHT28PT7B_H_
#define _IBMPLEXMONO_LIGHT28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light28pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x00, 0x1F, 0xF0, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x40, 0x01, 0x08, 0x01, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x02, 0x18, 0x02, 0x10, 0x3E, 0x1F, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x04, 0x20, 0xFC, 0x3E, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x08, 0x40, 0x08, 0x40, 0x18, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x3F, 0x83, 0x27, 0x31, 0x0F, 0x08, 0x18, 0x40, 0xC2, 0x06, 0x10, 0x18,
  0x80, 0xE4, 0x01, 0xF8, 0x01, 0xF0, 0x08, 0xC0, 0x43, 0x02, 0x18, 0x10,
  0x40, 0x87, 0x04, 0x3C, 0x21, 0x39, 0x38, 0x7F, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x3C, 0x06, 0x8C, 0x0A, 0x08, 0x34, 0x18, 0x48, 0x31, 0x90,
  0x62, 0x20, 0xCC, 0x41, 0x10, 0x46, 0x40, 0x78, 0x00, 0x01, 0xE0, 0x06,
  0x20, 0xD8, 0x63, 0x20, 0x44, 0x40, 0x98, 0x81, 0x21, 0x02, 0x83, 0x0F,
  0x03, 0x14, 0x03, 0xC0, 0x0F, 0x80, 0x31, 0x80, 0xC1, 0x81, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x38, 0x00, 0x98,
  0x7A, 0x10, 0x8C, 0x11, 0x18, 0x32, 0x30, 0x34, 0x60, 0x38, 0xC0, 0x30,
  0x80, 0xB1, 0x82, 0x20, 0xF8, 0x70, 0xFE, 0x07, 0x0C, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x07, 0xE0, 0x30, 0x10, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x30, 0xE0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x08, 0x10, 0x5E, 0x23, 0x8F, 0xFE, 0x83, 0xC0,
  0x03, 0x80, 0x0D, 0x80, 0x31, 0x80, 0xC1, 0x01, 0x83, 0x06, 0x02, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x77, 0x66,
  0x4C, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x00, 0x0F, 0x81, 0x83, 0x18, 0x08, 0x80, 0x6C, 0x01,
  0x60, 0x0F, 0x00, 0x78, 0x03, 0xC7, 0x1E, 0x38, 0xF1, 0xC7, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x02, 0x40, 0x33, 0x01, 0x0C, 0x18, 0x1F,
  0x00, 0x07, 0x00, 0x78, 0x06, 0xC0, 0x66, 0x0C, 0x30, 0x41, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xF0, 0x1F, 0x83,
  0x86, 0x18, 0x19, 0x80, 0x64, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0xFF, 0xF0, 0x1F, 0x87, 0x0C, 0xC0, 0x64,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC1, 0xF0, 0x00, 0xC0,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x02, 0x60, 0xC3,
  0xF8, 0x00, 0x70, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x46,
  0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x60, 0x40, 0xC1, 0x81, 0x86,
  0x03, 0x0C, 0x06, 0x30, 0x0C, 0x7F, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x3F, 0xF3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x4F, 0x82, 0x83, 0x18, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x02, 0x40, 0x36, 0x01, 0x9C, 0x18, 0x3F, 0x00,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x6F, 0x86, 0x83, 0x38, 0x0D, 0x80, 0x2C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x40, 0x13, 0x01, 0x8C, 0x18, 0x1F, 0x00, 0xFF, 0xFC, 0x00,
  0xE0, 0x0D, 0x00, 0x68, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x1F, 0x81, 0x83, 0x18, 0x0C, 0x80,
  0x2C, 0x01, 0x60, 0x09, 0x00, 0xCC, 0x06, 0x30, 0x60, 0x7C, 0x0C, 0x18,
  0x80, 0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1A, 0x01, 0x9C,
  0x18, 0x3F, 0x00, 0x0F, 0x81, 0x83, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0x60,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x01, 0xCC, 0x14, 0x3F, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x38, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x77, 0x66, 0x4C, 0xC0, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01,
  0xC0, 0x30, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x08, 0x00, 0x1F, 0x83, 0x06, 0x60, 0x34, 0x03, 0xC0, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0xE0, 0x7C, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x83,
  0x06, 0x20, 0x26, 0x03, 0x40, 0x14, 0x01, 0xC3, 0xDC, 0x63, 0xC4, 0x1C,
  0xC1, 0xCC, 0x1C, 0xC1, 0xCC, 0x1C, 0xC1, 0xCC, 0x1C, 0x43, 0xC3, 0xD4,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x80, 0x0F, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0A, 0x00, 0x36, 0x00, 0x4C, 0x00, 0x88, 0x03, 0x18, 0x06, 0x30,
  0x08, 0x20, 0x30, 0x40, 0x60, 0xC0, 0x80, 0x83, 0xFF, 0x06, 0x03, 0x08,
  0x06, 0x30, 0x04, 0x60, 0x0C, 0xC0, 0x19, 0x00, 0x16, 0x00, 0x30, 0xFF,
  0x88, 0x0C, 0x80, 0x68, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x06, 0x80,
  0xCF, 0xF0, 0x80, 0xC8, 0x06, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x06, 0x80, 0xCF, 0xF8, 0x0F, 0xC0, 0xC3, 0x8C, 0x0C, 0xC0, 0x34,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x19, 0x01, 0x86, 0x1C,
  0x1F, 0x80, 0xFF, 0x08, 0x18, 0x80, 0x48, 0x06, 0x80, 0x28, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x02, 0x80, 0x68, 0x04, 0x81, 0xCF, 0xF0, 0xFF, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0xC1, 0x83, 0x18,
  0x0C, 0xC0, 0x2C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x87, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x60, 0x3B,
  0x01, 0xCC, 0x16, 0x1F, 0x30, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xFF, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF,
  0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x0F, 0xFF, 0x3F, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x03, 0xC0, 0x6C, 0x09, 0xC3, 0x0F, 0x80, 0x80, 0x3C, 0x03,
  0x20, 0x19, 0x01, 0x88, 0x18, 0x41, 0x82, 0x18, 0x11, 0x80, 0x8C, 0x04,
  0xE0, 0x2D, 0x81, 0xC6, 0x0C, 0x30, 0x40, 0xC2, 0x06, 0x10, 0x18, 0x80,
  0x64, 0x03, 0x20, 0x0D, 0x00, 0x30, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xE0, 0xFD, 0x05, 0xEC, 0x6F, 0x63, 0x79, 0x13, 0xCD,
  0x9E, 0x28, 0xF1, 0xC7, 0x8C, 0x3C, 0x21, 0xE1, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x30, 0xE0, 0x1E, 0x01, 0xF0, 0x1D,
  0x01, 0xD8, 0x1C, 0x81, 0xCC, 0x1C, 0xC1, 0xC6, 0x1C, 0x61, 0xC2, 0x1C,
  0x31, 0xC1, 0x1C, 0x19, 0xC0, 0x9C, 0x0D, 0xC0, 0xDC, 0x07, 0xC0, 0x7C,
  0x03, 0x0F, 0x81, 0x83, 0x18, 0x08, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x02, 0x40, 0x33, 0x01, 0x0C, 0x18, 0x1F, 0x00, 0xFF, 0x88,
  0x06, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28,
  0x06, 0xFF, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x0F, 0x81, 0x83, 0x18, 0x08, 0x80, 0x6C, 0x01,
  0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x02, 0x40, 0x33, 0x01, 0x0C, 0x18, 0x1F,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7E, 0xFF, 0x88, 0x06, 0x80, 0x28,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x06, 0xFF, 0x88,
  0x60, 0x83, 0x08, 0x30, 0x81, 0x88, 0x08, 0x80, 0xC8, 0x06, 0x80, 0x68,
  0x03, 0x0F, 0xE0, 0xE0, 0xE3, 0x00, 0xD8, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x40, 0x0F, 0x80, 0x63, 0x83, 0x03, 0xF8,
  0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40,
  0x14, 0x03, 0x60, 0x36, 0x03, 0x30, 0x61, 0xF8, 0xC0, 0x06, 0x80, 0x19,
  0x80, 0x33, 0x00, 0x62, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x08, 0x10,
  0x30, 0x30, 0x60, 0x60, 0x80, 0x43, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x10,
  0x03, 0x60, 0x06, 0xC0, 0x0D, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x07,
  0x80, 0x0B, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0xE1, 0x21,
  0xC6, 0x42, 0x8C, 0xC5, 0x19, 0x9B, 0x33, 0x26, 0x66, 0x44, 0xCC, 0x89,
  0x1B, 0x1A, 0x16, 0x34, 0x28, 0x28, 0x50, 0x50, 0xE0, 0xE1, 0xC1, 0xC0,
  0xE0, 0x0E, 0xC0, 0x18, 0xC0, 0x61, 0x80, 0x81, 0x83, 0x01, 0x8C, 0x03,
  0x18, 0x03, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x36, 0x00, 0x6C,
  0x01, 0x8C, 0x06, 0x08, 0x0C, 0x18, 0x30, 0x18, 0x40, 0x31, 0x80, 0x36,
  0x00, 0x30, 0xC0, 0x07, 0x80, 0x19, 0x80, 0x31, 0x80, 0xC3, 0x01, 0x83,
  0x06, 0x06, 0x08, 0x06, 0x30, 0x04, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x7F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x3F, 0xFF, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFE, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFE, 0x07, 0x00,
  0x38, 0x03, 0x60, 0x31, 0x01, 0x8C, 0x18, 0x20, 0x81, 0x8C, 0x06, 0x40,
  0x36, 0x00, 0xE0, 0x02, 0xFF, 0xF8, 0x47, 0x08, 0x61, 0x80, 0x1F, 0x03,
  0x06, 0x30, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xFF, 0x8C, 0x0C, 0xC0,
  0x66, 0x03, 0x30, 0x19, 0x81, 0x46, 0x0A, 0x1F, 0x9C, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xF0, 0xCC, 0x06,
  0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02,
  0xC0, 0x6E, 0x0C, 0xDF, 0x80, 0x1F, 0x86, 0x19, 0x01, 0xE0, 0x28, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x01, 0x20, 0x33, 0x0C, 0x3F,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x31,
  0xF3, 0x30, 0xF6, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x60, 0x33, 0x0F, 0x1F, 0x30, 0x0F, 0x81, 0x83,
  0x18, 0x0C, 0x80, 0x2C, 0x01, 0x60, 0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x04, 0xC0, 0x63, 0x06, 0x07, 0xC0, 0x03, 0xF8, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x3F, 0x03, 0x06,
  0x08, 0x08, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x08, 0x30, 0x60, 0x7E,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80, 0x01, 0xFF, 0x18, 0x06, 0xC0,
  0x0B, 0x00, 0x3C, 0x00, 0x98, 0x0E, 0x3F, 0xE0, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x78, 0xF0, 0xD8, 0x0B, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x06, 0x06, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x01, 0x80, 0x70,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x6F, 0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x06, 0xC0, 0xE6, 0x0C, 0x30,
  0xC1, 0x8C, 0x0C, 0xC0, 0x6F, 0x03, 0xCC, 0x18, 0x60, 0xC1, 0x86, 0x06,
  0x30, 0x19, 0x80, 0x6C, 0x01, 0x80, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0xFF, 0xF0, 0xBC, 0xF6, 0x38, 0xE0, 0x87, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1,
  0x04, 0xCF, 0x1E, 0x1B, 0x01, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x0F, 0x81, 0x83,
  0x18, 0x0C, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x90, 0x0C, 0xC0, 0x63, 0x06, 0x07, 0xC0, 0xCF, 0x8F, 0x0C, 0xC0,
  0x6C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x2C, 0x06, 0xE0, 0xCD, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x1F, 0x33, 0x0F, 0x60, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x03, 0x30, 0xF1, 0xF3, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFC, 0x7C, 0x16, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x03, 0xFF, 0xC0, 0x1F, 0xC1, 0x83,
  0x98, 0x04, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x80, 0x27, 0x07, 0x0F, 0xE0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x0F, 0xFF, 0xC1, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x36,
  0x1E, 0x7C, 0xC0, 0xC0, 0x1A, 0x00, 0x98, 0x0C, 0xC0, 0x42, 0x06, 0x18,
  0x30, 0x41, 0x02, 0x18, 0x18, 0xC0, 0x44, 0x03, 0x60, 0x1A, 0x00, 0x50,
  0x03, 0x80, 0x83, 0x07, 0x87, 0x0F, 0x0A, 0x12, 0x14, 0x24, 0x68, 0x48,
  0x98, 0x91, 0x13, 0x32, 0x26, 0x64, 0x48, 0x58, 0x90, 0xA0, 0xA1, 0x41,
  0x42, 0x82, 0x87, 0x07, 0x00, 0xC0, 0x3B, 0x01, 0x8C, 0x18, 0x31, 0x80,
  0x98, 0x06, 0x80, 0x1C, 0x00, 0xE0, 0x0D, 0x80, 0xC4, 0x04, 0x30, 0x60,
  0xC6, 0x03, 0x60, 0x0C, 0xC0, 0x1E, 0x00, 0x90, 0x0C, 0xC0, 0x62, 0x02,
  0x18, 0x30, 0xC1, 0x03, 0x18, 0x18, 0xC0, 0x44, 0x03, 0x60, 0x0A, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x01, 0xF0,
  0x00, 0xFF, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xFF, 0xC0, 0x0F, 0xE1, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x0F, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x3E, 0x18, 0x06, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFC, 0x00, 0x38,
  0x0A, 0x20, 0x70, 0x87, 0x02, 0x28, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_Light28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 20, 17, 7, -20 },
  { 9, 6, 7, 17, 5, -21 },
  { 15, 16, 20, 17, 0, -20 },
  { 55, 13, 26, 17, 2, -23 },
  { 98, 15, 20, 17, 1, -20 },
  { 136, 15, 20, 17, 1, -20 },
  { 174, 1, 7, 17, 8, -21 },
  { 175, 8, 25, 17, 6, -21 },
  { 200, 8, 25, 17, 3, -21 },
  { 225, 15, 14, 17, 1, -15 },
  { 252, 13, 13, 17, 2, -15 },
  { 274, 4, 7, 17, 6, -3 },
  { 278, 8, 1, 17, 4, -9 },
  { 279, 3, 3, 17, 7, -3 },
  { 281, 11, 25, 17, 3, -21 },
  { 316, 13, 20, 17, 2, -20 },
  { 349, 13, 20, 17, 2, -20 },
  { 382, 13, 20, 17, 2, -20 },
  { 415, 12, 20, 17, 2, -20 },
  { 445, 15, 20, 17, 1, -20 },
  { 483, 13, 20, 17, 2, -20 },
  { 516, 13, 20, 17, 2, -20 },
  { 549, 13, 20, 17, 2, -20 },
  { 582, 13, 20, 17, 2, -20 },
  { 615, 13, 20, 17, 2, -20 },
  { 648, 3, 15, 17, 7, -15 },
  { 654, 4, 19, 17, 6, -15 },
  { 664, 12, 16, 17, 2, -17 },
  { 688, 13, 7, 17, 2, -12 },
  { 700, 12, 16, 17, 2, -17 },
  { 724, 12, 20, 17, 2, -20 },
  { 754, 12, 23, 17, 2, -20 },
  { 789, 15, 20, 17, 1, -20 },
  { 827, 12, 20, 17, 3, -20 },
  { 857, 13, 20, 17, 2, -20 },
  { 890, 12, 20, 17, 3, -20 },
  { 920, 12, 20, 17, 3, -20 },
  { 950, 12, 20, 17, 3, -20 },
  { 980, 13, 20, 17, 2, -20 },
  { 1013, 12, 20, 17, 2, -20 },
  { 1043, 12, 20, 17, 2, -20 },
  { 1073, 11, 20, 17, 2, -20 },
  { 1101, 13, 20, 17, 3, -20 },
  { 1134, 11, 20, 17, 4, -20 },
  { 1162, 13, 20, 17, 2, -20 },
  { 1195, 12, 20, 17, 2, -20 },
  { 1225, 13, 20, 17, 2, -20 },
  { 1258, 12, 20, 17, 3, -20 },
  { 1288, 13, 24, 17, 2, -20 },
  { 1327, 12, 20, 17, 3, -20 },
  { 1357, 14, 20, 17, 1, -20 },
  { 1392, 15, 20, 17, 1, -20 },
  { 1430, 12, 20, 17, 2, -20 },
  { 1460, 15, 20, 17, 1, -20 },
  { 1498, 15, 20, 17, 1, -20 },
  { 1536, 15, 20, 17, 1, -20 },
  { 1574, 15, 20, 17, 1, -20 },
  { 1612, 14, 20, 17, 1, -20 },
  { 1647, 7, 25, 17, 7, -21 },
  { 1669, 11, 25, 17, 3, -21 },
  { 1704, 7, 25, 17, 3, -21 },
  { 1726, 13, 11, 17, 2, -20 },
  { 1744, 13, 1, 17, 2, 3 },
  { 1746, 5, 5, 17, 5, -22 },
  { 1750, 13, 14, 17, 2, -14 },
  { 1773, 12, 21, 17, 3, -21 },
  { 1805, 11, 14, 17, 3, -14 },
  { 1825, 12, 21, 17, 2, -21 },
  { 1857, 13, 14, 17, 2, -14 },
  { 1880, 13, 21, 17, 2, -21 },
  { 1915, 14, 21, 17, 2, -15 },
  { 1952, 11, 21, 17, 3, -21 },
  { 1981, 12, 21, 17, 3, -21 },
  { 2013, 10, 27, 17, 3, -21 },
  { 2047, 13, 21, 17, 3, -21 },
  { 2082, 12, 21, 17, 2, -21 },
  { 2114, 13, 14, 17, 2, -14 },
  { 2137, 11, 14, 17, 3, -14 },
  { 2157, 13, 14, 17, 2, -14 },
  { 2180, 12, 20, 17, 3, -14 },
  { 2210, 12, 20, 17, 2, -14 },
  { 2240, 14, 14, 17, 2, -14 },
  { 2265, 13, 14, 17, 2, -14 },
  { 2288, 14, 20, 17, 1, -20 },
  { 2323, 11, 14, 17, 3, -14 },
  { 2343, 13, 14, 17, 2, -14 },
  { 2366, 15, 14, 17, 1, -14 },
  { 2393, 13, 14, 17, 2, -14 },
  { 2416, 13, 20, 17, 2, -14 },
  { 2449, 11, 14, 17, 3, -14 },
  { 2469, 11, 25, 17, 3, -21 },
  { 2504, 1, 25, 17, 8, -21 },
  { 2508, 11, 25, 17, 3, -21 },
  { 2543, 13, 5, 17, 2, -11 },
};

const GFXfont IBMPlexMono_Light28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_LIGHT28PT7B_H_
