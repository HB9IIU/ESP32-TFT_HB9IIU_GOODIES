#ifndef _IBMPLEXMONO_LIGHT52PT7B_H_
#define _IBMPLEXMONO_LIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light52pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC3, 0x0C, 0x30, 0x82, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBE, 0xFF, 0xFF, 0x9E, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F,
  0xF8, 0x0F, 0xFC, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x03, 0xFF, 0x81, 0xFF, 0x9F,
  0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE0, 0x0E, 0x03, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x1F, 0x8C, 0x7E, 0x1F, 0x06, 0x0F, 0x8E, 0x03, 0x01, 0xEF, 0x01, 0x80,
  0x67, 0x00, 0xC0, 0x23, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x3C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x81,
  0x80, 0x01, 0xF0, 0xC0, 0x00, 0xFF, 0x60, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x06, 0xFF, 0x00, 0x03, 0x0F, 0x80,
  0x01, 0x81, 0xE0, 0x00, 0xC0, 0x78, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0E,
  0x00, 0x18, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00,
  0xEC, 0x01, 0x80, 0x7F, 0x00, 0xC0, 0x7B, 0xC0, 0x60, 0x78, 0xF0, 0x30,
  0x7C, 0x3F, 0x18, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xCF, 0xFE, 0x00, 0x0C, 0x78, 0x78, 0x00, 0xE7, 0x00, 0xE0, 0x0E, 0x30,
  0x07, 0x00, 0x71, 0x80, 0x18, 0x07, 0x1C, 0x00, 0xC0, 0x30, 0xE0, 0x06,
  0x03, 0x87, 0x00, 0x30, 0x18, 0x38, 0x01, 0x81, 0xC0, 0xC0, 0x0C, 0x1C,
  0x06, 0x00, 0xE0, 0xE0, 0x38, 0x07, 0x0E, 0x00, 0xF0, 0xF0, 0x70, 0x07,
  0xFF, 0x07, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x3F,
  0xE0, 0x03, 0x83, 0xFF, 0x80, 0x18, 0x3C, 0x1E, 0x01, 0xC1, 0xC0, 0x70,
  0x0C, 0x1C, 0x01, 0x80, 0xE0, 0xE0, 0x0E, 0x0E, 0x06, 0x00, 0x70, 0x70,
  0x30, 0x03, 0x87, 0x01, 0x80, 0x1C, 0x30, 0x0C, 0x00, 0xE3, 0x80, 0x70,
  0x07, 0x18, 0x03, 0x80, 0x31, 0xC0, 0x0E, 0x03, 0x8C, 0x00, 0x78, 0x3C,
  0xE0, 0x01, 0xFF, 0xCE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x08, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x8F, 0x78, 0x07, 0xF3, 0xC7, 0x80, 0xE0, 0xF0, 0x78,
  0x1C, 0x1C, 0x07, 0x83, 0x87, 0x80, 0x78, 0x60, 0xE0, 0x07, 0x0C, 0x1C,
  0x00, 0x71, 0x83, 0x80, 0x0F, 0x30, 0x70, 0x00, 0xFE, 0x0E, 0x00, 0x0F,
  0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xE0, 0x70,
  0x00, 0xFE, 0x0F, 0x00, 0x39, 0xE0, 0xF8, 0x1E, 0x1E, 0x0F, 0xFF, 0x81,
  0xE0, 0xFF, 0xE0, 0x1E, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x40, 0x0E, 0x00, 0x4F, 0x01, 0xC0, 0x3B, 0xFC, 0x38,
  0x7F, 0x9F, 0xF7, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x80, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0x40, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0xF0,
  0x00, 0x78, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0E, 0x01,
  0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x3F, 0x80, 0xE0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x78, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F,
  0x80, 0x1E, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF8,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x00, 0x80, 0x3C, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0x03, 0xF0,
  0x3C, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x1C, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0xFC, 0x0F, 0xC1, 0xE0, 0x07, 0x87, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x08,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0xF8, 0x00, 0xF0, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x1F, 0xC0, 0x18, 0xFF, 0xE0, 0x33, 0xFF, 0xF0, 0x6E, 0x03, 0xF1, 0xF0,
  0x01, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE4, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x78, 0x7E, 0x03, 0xE0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x1F,
  0xC0, 0x38, 0xFF, 0xE0, 0x73, 0xFF, 0xF1, 0xEE, 0x03, 0xF3, 0xB0, 0x01,
  0xF7, 0x40, 0x01, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x1C,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00,
  0x0F, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xF0,
  0x1F, 0x81, 0xE0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0xC0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x07,
  0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83,
  0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00,
  0x1E, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xB9, 0xF8, 0x0E, 0x71, 0xFF, 0xF9,
  0xC0, 0xFF, 0xE3, 0x80, 0x7F, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7B,
  0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xBE, 0xFF, 0xFF, 0x9E, 0x1E, 0x3E, 0x3F, 0x3F,
  0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0x7C,
  0x3E, 0x00, 0x78, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x07, 0xF0,
  0x00, 0x1C, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07,
  0x0E, 0x00, 0x0F, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x7C, 0x7E, 0x03, 0xFC, 0xFC, 0x0F, 0xFD, 0xF8,
  0x1E, 0x0B, 0xF0, 0x78, 0x0F, 0xE0, 0xE0, 0x0F, 0xC1, 0x80, 0x1F, 0x83,
  0x00, 0x3F, 0x0E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x38, 0x01, 0xF8, 0x70,
  0x03, 0xF0, 0xE0, 0x07, 0xE1, 0xC0, 0x0F, 0xC1, 0x80, 0x1F, 0x83, 0x80,
  0x3F, 0x07, 0x00, 0xFE, 0x0F, 0x01, 0xFC, 0x0F, 0xDD, 0xF8, 0x0F, 0xFB,
  0xB0, 0x0F, 0xE7, 0x60, 0x02, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x70, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0x00, 0x0F,
  0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x00, 0x07, 0x8E, 0x00,
  0x07, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0xF9,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x3C,
  0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x05,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x04, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x1F, 0x00, 0x3C, 0x0F, 0xC0, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0x00, 0x3F, 0x0E, 0x00, 0x1F, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEE,
  0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00, 0xF8, 0xE0,
  0x07, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x06, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x37, 0x0F,
  0xC0, 0xE7, 0x07, 0xFF, 0xE7, 0x03, 0xFF, 0xC7, 0x00, 0x7F, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF2, 0x00, 0x07, 0x78, 0x00, 0x39,
  0xC0, 0x01, 0xCF, 0x00, 0x1E, 0x3C, 0x01, 0xE1, 0xF0, 0x3E, 0x07, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0F,
  0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xF0, 0x00, 0xE7, 0xF8,
  0x00, 0xEF, 0x38, 0x00, 0xEE, 0x3C, 0x00, 0xFC, 0x1C, 0x00, 0xF8, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0D, 0xFB,
  0x80, 0x3B, 0xF7, 0x00, 0x77, 0xE7, 0x00, 0xCF, 0xCE, 0x03, 0x9F, 0x8E,
  0x06, 0x3F, 0x1C, 0x1C, 0x7E, 0x18, 0x30, 0xFC, 0x38, 0xE1, 0xF8, 0x71,
  0xC3, 0xF0, 0x73, 0x07, 0xE0, 0xEE, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0,
  0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x03, 0x01, 0xF8, 0x04, 0x03,
  0xF0, 0x08, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xDC, 0x00, 0x1F, 0x70, 0x00, 0x7C, 0xE0, 0x01, 0xF3, 0x80, 0x07,
  0xC7, 0x00, 0x1F, 0x1C, 0x00, 0x7C, 0x38, 0x01, 0xF0, 0xE0, 0x07, 0xC3,
  0xC0, 0x1F, 0x07, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x38, 0x07, 0xC0, 0xF0,
  0x1F, 0x01, 0xC0, 0x7C, 0x07, 0x01, 0xF0, 0x0E, 0x07, 0xC0, 0x38, 0x1F,
  0x00, 0x70, 0x7C, 0x01, 0xC1, 0xF0, 0x03, 0x87, 0xC0, 0x0E, 0x1F, 0x00,
  0x3C, 0x7C, 0x00, 0x71, 0xF0, 0x01, 0xE7, 0xC0, 0x03, 0x9F, 0x00, 0x0E,
  0x7C, 0x00, 0x1D, 0xF0, 0x00, 0x77, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0,
  0xF0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xB8,
  0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1C,
  0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC7, 0x00, 0x07, 0xCE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70,
  0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x01, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x1F,
  0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x80, 0x1E, 0x03, 0xE0,
  0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0x00, 0x07, 0xCE,
  0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x3D, 0xC0, 0x01, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x1C, 0x07, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0F, 0x01,
  0xC0, 0x0E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x79, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0x77, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1,
  0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x08, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x0F, 0xE0, 0x1F, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEF,
  0x00, 0x07, 0x9C, 0x00, 0x1C, 0x78, 0x00, 0xF0, 0xF8, 0x0F, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06,
  0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x3C, 0x07, 0x38, 0x07,
  0x80, 0xE7, 0x01, 0xF0, 0x1C, 0xE0, 0x3E, 0x03, 0x8C, 0x06, 0xE0, 0x71,
  0x81, 0xDC, 0x0E, 0x30, 0x3B, 0x81, 0x87, 0x07, 0x30, 0x30, 0xE0, 0xC7,
  0x06, 0x1C, 0x38, 0xE0, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E,
  0x18, 0x38, 0xE1, 0xC7, 0x07, 0x1C, 0x38, 0xE0, 0xE3, 0x87, 0x1C, 0x0C,
  0x70, 0x63, 0x01, 0xCE, 0x0C, 0xE0, 0x39, 0xC1, 0x9C, 0x07, 0x30, 0x3B,
  0x80, 0x66, 0x07, 0x60, 0x0E, 0xC0, 0xFC, 0x01, 0xD8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x70, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x38, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01,
  0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x74, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x60, 0xF0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x03,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3E, 0x03, 0xE0, 0x70,
  0x01, 0xE0, 0x60, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7C, 0x00, 0x70, 0xF0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0x7C,
  0x07, 0x3F, 0x3F, 0xFE, 0x3F, 0x1F, 0xFC, 0x1F, 0x07, 0xF0, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x3F, 0x00, 0xE3, 0xFF, 0x83, 0x9F,
  0xFF, 0x0E, 0xE0, 0x7E, 0x3E, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0x80, 0x01,
  0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0xC0, 0x03, 0xCF, 0x80, 0x1E, 0x3B,
  0x81, 0xF8, 0xE7, 0xFF, 0xC3, 0x8F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0x78, 0x3C, 0x00,
  0xF0, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x08, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x11, 0xE0, 0x00, 0x73,
  0x80, 0x03, 0x8F, 0x00, 0x1C, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x7E,
  0x07, 0x07, 0xFE, 0x1C, 0x7F, 0xFE, 0x73, 0xF0, 0x39, 0xCF, 0x00, 0x37,
  0x78, 0x00, 0x7D, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0,
  0x01, 0xF3, 0xC0, 0x0D, 0xCF, 0xC0, 0xE7, 0x1F, 0xFF, 0x9C, 0x1F, 0xF8,
  0x70, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFC, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x0E, 0x00, 0x07, 0x8F, 0x00,
  0x1E, 0x1F, 0x80, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xCC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3C, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x70,
  0x0F, 0x80, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0xC0, 0x00, 0xF8, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0xF3, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F, 0xC0, 0xE3, 0xFF,
  0x0E, 0x7F, 0xF8, 0xEE, 0x07, 0xCF, 0x80, 0x1E, 0xF0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00,
  0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE1, 0xE0, 0x00,
  0xE3, 0xE0, 0x00, 0xE7, 0x70, 0x00, 0xEE, 0x78, 0x00, 0xFC, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80,
  0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE3, 0xE0, 0x7C, 0x73, 0xF8, 0x7F, 0x3B, 0xFE, 0x7F, 0xDD,
  0x0F, 0x61, 0xEF, 0x03, 0xA0, 0x7F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F,
  0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00,
  0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70,
  0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07,
  0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80,
  0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8,
  0x07, 0x00, 0xE0, 0xE0, 0xFC, 0x0E, 0x3F, 0xF0, 0xE7, 0xFF, 0x8E, 0xE0,
  0x7C, 0xF8, 0x01, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83, 0xC0,
  0x07, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0xFC, 0x03, 0x8F,
  0xFE, 0x0E, 0x7F, 0xFC, 0x3B, 0x81, 0xF8, 0xF8, 0x01, 0xE3, 0xC0, 0x03,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xCF, 0x00, 0x0F, 0x3E,
  0x00, 0x78, 0xEE, 0x07, 0xE3, 0x9F, 0xFF, 0x0E, 0x3F, 0xF8, 0x38, 0x3F,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x1C, 0x1F, 0xF8, 0x71, 0xFF, 0xF9, 0xCF, 0xC0,
  0xE7, 0x3C, 0x00, 0xDD, 0xE0, 0x01, 0xF7, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3D,
  0xC0, 0x00, 0xF7, 0x80, 0x07, 0xCF, 0x00, 0x37, 0x3F, 0x03, 0x9C, 0x7F,
  0xFE, 0x70, 0x7F, 0xE1, 0xC0, 0x7E, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x1C, 0xE0, 0x00, 0x0E, 0x40, 0x00,
  0x07, 0x40, 0x00, 0x03, 0xA0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC3, 0xC0, 0x03, 0xC7,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x3F, 0x00, 0xF8, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xE0, 0x03, 0xEF,
  0x80, 0x37, 0x3E, 0x07, 0xB8, 0xFF, 0xF9, 0xC3, 0xFF, 0x8E, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03,
  0x81, 0x80, 0x07, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x0E, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0D, 0x80, 0x7E, 0x01, 0xB0, 0x0E,
  0xC0, 0x37, 0x01, 0xD8, 0x0E, 0x60, 0x33, 0x81, 0xCC, 0x06, 0x70, 0x31,
  0x80, 0xCE, 0x06, 0x38, 0x39, 0xC0, 0xC7, 0x07, 0x18, 0x38, 0x60, 0xE3,
  0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0E, 0x18, 0x38, 0x61, 0xC7, 0x03,
  0x1C, 0x38, 0xE0, 0x63, 0x83, 0x18, 0x0C, 0x70, 0x63, 0x01, 0xCC, 0x0C,
  0x60, 0x39, 0x81, 0xDC, 0x03, 0x30, 0x3B, 0x00, 0x66, 0x07, 0x60, 0x0D,
  0xC0, 0x6C, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x07, 0x01, 0xC0,
  0x07, 0x83, 0xC0, 0x03, 0xC3, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x83, 0x80,
  0x07, 0x83, 0xC0, 0x07, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x3C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x01,
  0x8F, 0xF0, 0x00, 0xC7, 0xFC, 0x00, 0xE7, 0x0F, 0x00, 0x77, 0x03, 0xC0,
  0x33, 0x80, 0xF0, 0x39, 0x80, 0x38, 0x1D, 0xC0, 0x1F, 0x1C, 0xE0, 0x07,
  0xFE, 0x60, 0x01, 0xFE, 0x30, 0x00, 0x3C, 0x00,
};

const GFXglyph IBMPlexMono_Light52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 6, 36, 31, 13, -36 },
  { 28, 11, 14, 31, 10, -38 },
  { 48, 29, 36, 31, 1, -36 },
  { 179, 25, 48, 31, 3, -42 },
  { 329, 29, 38, 31, 1, -37 },
  { 467, 27, 38, 31, 2, -37 },
  { 596, 3, 14, 31, 14, -38 },
  { 602, 14, 47, 31, 11, -40 },
  { 685, 14, 47, 31, 6, -40 },
  { 768, 27, 26, 31, 2, -29 },
  { 856, 25, 25, 31, 3, -28 },
  { 935, 8, 14, 31, 11, -6 },
  { 949, 15, 3, 31, 8, -17 },
  { 955, 6, 6, 31, 13, -6 },
  { 960, 21, 47, 31, 5, -40 },
  { 1084, 25, 38, 31, 3, -37 },
  { 1203, 26, 36, 31, 3, -36 },
  { 1320, 24, 37, 31, 4, -37 },
  { 1431, 23, 38, 31, 3, -37 },
  { 1541, 27, 36, 31, 2, -36 },
  { 1663, 23, 37, 31, 4, -36 },
  { 1770, 23, 37, 31, 4, -36 },
  { 1877, 23, 36, 31, 4, -36 },
  { 1981, 25, 38, 31, 3, -37 },
  { 2100, 23, 37, 31, 4, -37 },
  { 2207, 6, 28, 31, 13, -28 },
  { 2228, 8, 36, 31, 11, -28 },
  { 2264, 23, 29, 31, 4, -30 },
  { 2348, 25, 13, 31, 3, -22 },
  { 2389, 23, 29, 31, 4, -30 },
  { 2473, 22, 37, 31, 4, -37 },
  { 2575, 23, 43, 31, 4, -37 },
  { 2699, 27, 36, 31, 2, -36 },
  { 2821, 23, 36, 31, 5, -36 },
  { 2925, 24, 38, 31, 4, -37 },
  { 3039, 23, 36, 31, 5, -36 },
  { 3143, 22, 36, 31, 5, -36 },
  { 3242, 22, 36, 31, 5, -36 },
  { 3341, 24, 38, 31, 3, -37 },
  { 3455, 22, 36, 31, 5, -36 },
  { 3554, 22, 36, 31, 5, -36 },
  { 3653, 21, 37, 31, 4, -36 },
  { 3751, 24, 36, 31, 5, -36 },
  { 3859, 21, 36, 31, 7, -36 },
  { 3954, 23, 36, 31, 4, -36 },
  { 4058, 22, 36, 31, 5, -36 },
  { 4157, 25, 38, 31, 3, -37 },
  { 4276, 23, 36, 31, 5, -36 },
  { 4380, 25, 46, 31, 3, -37 },
  { 4524, 23, 36, 31, 5, -36 },
  { 4628, 25, 38, 31, 3, -37 },
  { 4747, 28, 36, 31, 2, -36 },
  { 4873, 22, 37, 31, 5, -36 },
  { 4975, 27, 36, 31, 2, -36 },
  { 5097, 27, 36, 31, 2, -36 },
  { 5219, 27, 36, 31, 2, -36 },
  { 5341, 29, 36, 31, 1, -36 },
  { 5472, 27, 36, 31, 2, -36 },
  { 5594, 13, 47, 31, 13, -40 },
  { 5671, 21, 47, 31, 5, -40 },
  { 5795, 14, 47, 31, 5, -40 },
  { 5878, 25, 21, 31, 3, -36 },
  { 5944, 25, 3, 31, 3, 5 },
  { 5954, 8, 9, 31, 10, -40 },
  { 5963, 24, 28, 31, 4, -27 },
  { 6047, 22, 39, 31, 6, -38 },
  { 6155, 22, 28, 31, 5, -27 },
  { 6232, 22, 39, 31, 4, -38 },
  { 6340, 23, 28, 31, 4, -27 },
  { 6421, 24, 38, 31, 4, -38 },
  { 6535, 25, 41, 31, 4, -30 },
  { 6664, 20, 38, 31, 6, -38 },
  { 6759, 22, 39, 31, 6, -39 },
  { 6867, 18, 49, 31, 5, -39 },
  { 6978, 24, 38, 31, 6, -38 },
  { 7092, 23, 38, 31, 4, -38 },
  { 7202, 25, 27, 31, 3, -27 },
  { 7287, 20, 27, 31, 6, -27 },
  { 7355, 23, 28, 31, 4, -27 },
  { 7436, 22, 37, 31, 6, -27 },
  { 7538, 22, 37, 31, 4, -27 },
  { 7640, 25, 27, 31, 4, -27 },
  { 7725, 23, 28, 31, 4, -27 },
  { 7806, 25, 36, 31, 2, -36 },
  { 7919, 21, 28, 31, 5, -27 },
  { 7993, 23, 27, 31, 4, -27 },
  { 8071, 27, 27, 31, 2, -27 },
  { 8163, 24, 27, 31, 4, -27 },
  { 8244, 25, 37, 31, 3, -27 },
  { 8360, 21, 27, 31, 5, -27 },
  { 8431, 20, 47, 31, 6, -40 },
  { 8549, 3, 47, 31, 14, -40 },
  { 8567, 20, 47, 31, 6, -40 },
  { 8685, 25, 11, 31, 3, -21 },
};

const GFXfont IBMPlexMono_Light52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_LIGHT52PT7B_H_
