#ifndef _IBMPLEXMONO_LIGHT34PT7B_H_
#define _IBMPLEXMONO_LIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light34pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x22, 0x22, 0x00, 0x00, 0x7F,
  0xF7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00,
  0xC3, 0x03, 0xF8, 0x7F, 0x7F, 0x0F, 0xE0, 0x41, 0x80, 0x18, 0x20, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x07, 0xE0, 0xFE, 0xFC,
  0x1F, 0xC1, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x10,
  0x60, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x07, 0xF0, 0x1F, 0xFC, 0x38, 0x9E, 0x70, 0x87, 0x60, 0x82, 0x60, 0x80,
  0x60, 0x80, 0x60, 0x80, 0x60, 0x80, 0x70, 0x80, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x8E, 0x00, 0x87, 0x00, 0x83, 0x00, 0x83, 0x00, 0x83,
  0x80, 0x83, 0xC0, 0x83, 0x60, 0x87, 0x78, 0x8E, 0x1F, 0xFC, 0x07, 0xF0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x1E, 0x00, 0x6F, 0xE0, 0x19, 0x86,
  0x06, 0x60, 0x40, 0xCC, 0x0C, 0x31, 0x81, 0x86, 0x30, 0x31, 0x86, 0x06,
  0x20, 0xC0, 0x8C, 0x0C, 0x31, 0x01, 0xFC, 0x40, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x01, 0x9C, 0x70, 0x63, 0x06, 0x0C, 0x40, 0x43, 0x08,
  0x08, 0x61, 0x01, 0x98, 0x20, 0x22, 0x06, 0x0C, 0xC0, 0xE3, 0x90, 0x0F,
  0xE6, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xFC, 0x01, 0xC3, 0x80, 0x60, 0x60,
  0x30, 0x14, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x7C, 0x0F, 0x3B, 0x07, 0xDC, 0x61, 0x86, 0x0C,
  0x63, 0x03, 0x98, 0xC0, 0x76, 0x30, 0x0F, 0x8C, 0x01, 0xC3, 0x00, 0x30,
  0x60, 0x16, 0x1E, 0x0C, 0xC3, 0xFE, 0x18, 0x3E, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0x81, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0xE0,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x04, 0x06, 0x03, 0x03, 0x03, 0x01, 0x81, 0x83, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x04, 0x0C, 0x0B, 0x86,
  0x1E, 0xFB, 0x7E, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00,
  0x63, 0x00, 0x61, 0xC0, 0x60, 0x60, 0x70, 0x18, 0x10, 0x08, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x39, 0xCC, 0xE7, 0x31, 0x88,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x70, 0x06, 0x60,
  0x06, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC1,
  0xC3, 0xC1, 0xC3, 0xC1, 0xC3, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60,
  0x03, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07,
  0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xB0, 0x03, 0x98, 0x03, 0x8C, 0x03,
  0x86, 0x03, 0x83, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01,
  0xFF, 0xFE, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xE1, 0xC1, 0xE7, 0x00, 0xCC,
  0x01, 0xD8, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0x66, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x3F, 0x80, 0x7F, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0xCF, 0x07, 0x8F, 0xFE, 0x07, 0xF0, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x18, 0xC0, 0x04, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x40, 0xC0, 0x30,
  0x30, 0x18, 0x0C, 0x04, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x7F, 0xFC, 0xFF, 0xF9, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x8F, 0xC1, 0x7F,
  0xC3, 0xC1, 0xC6, 0x01, 0xD0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x3E, 0x00, 0x6E, 0x01, 0xCE, 0x07, 0x0F, 0xFC, 0x07,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x33, 0xF0, 0x67, 0xF8, 0x6C,
  0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x0C, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x38, 0x1E, 0x70, 0x06, 0x60, 0x06, 0x60,
  0x07, 0x60, 0x06, 0x60, 0x06, 0x30, 0x06, 0x38, 0x1C, 0x0F, 0xF0, 0x0F,
  0xF8, 0x38, 0x1C, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0x70, 0x06, 0x38, 0x1E, 0x1F, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x7F, 0xE1, 0xE0, 0xE3, 0x00, 0xEC, 0x00, 0xD8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0xB7,
  0x83, 0xE7, 0xFD, 0x83, 0xE3, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0xF7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x3B, 0xDE, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE7, 0x33, 0x9C, 0xC6, 0x23, 0x00, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01,
  0x80, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x83, 0x98, 0x07, 0xE0,
  0x0F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x07, 0x01,
  0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xC0,
  0x7F, 0xC3, 0x83, 0x98, 0x06, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x79,
  0xC3, 0xF6, 0x1C, 0x58, 0x60, 0xE1, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x01, 0x84, 0x06, 0x18, 0x18, 0x60, 0xF0, 0xFD, 0xC3, 0xE7, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0x81, 0xFE, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x31, 0x80, 0x08, 0x60, 0x06, 0x18, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x60, 0x7F, 0xF8, 0x1F,
  0xFF, 0x0E, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x70, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE1, 0xFF, 0xE3, 0x00, 0xE6, 0x00,
  0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33,
  0x00, 0xE7, 0xFF, 0x0F, 0xFF, 0x18, 0x03, 0xB0, 0x03, 0x60, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xD8, 0x03, 0xBF, 0xFE,
  0x7F, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0x66, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x1B, 0x00, 0x37, 0x00, 0xC7, 0x07, 0x07, 0xFC, 0x03, 0xF0, 0xFF,
  0xC1, 0xFF, 0xE3, 0x01, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00,
  0x6C, 0x01, 0xD8, 0x0F, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0xD8, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0xFF, 0xEF, 0xFF, 0xD8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1C, 0x1C, 0x30, 0x0E, 0x70, 0x06,
  0x60, 0x07, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0x60, 0x03, 0x60, 0x07, 0x70, 0x07, 0x30, 0x0B, 0x3C, 0x1B, 0x1F, 0xF3,
  0x07, 0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xD0, 0x07, 0x80, 0x3E, 0x03,
  0x38, 0x38, 0xFF, 0x83, 0xF0, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0,
  0x18, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xE0, 0xC1, 0xC0, 0xC3, 0x80, 0xC3,
  0x00, 0xC7, 0x00, 0xCF, 0x00, 0xD9, 0x80, 0xF1, 0xC0, 0xF0, 0xC0, 0xE0,
  0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x0C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7D, 0x80, 0xFB, 0x03, 0x73, 0x06, 0xE6, 0x09,
  0xC4, 0x33, 0x8C, 0x47, 0x19, 0x8E, 0x1B, 0x1C, 0x3C, 0x38, 0x38, 0x70,
  0x60, 0xE0, 0x41, 0xC1, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xD8, 0x07, 0x60, 0x1C, 0xC0, 0x73, 0x01, 0xC6, 0x07,
  0x18, 0x1C, 0x70, 0x70, 0xC1, 0xC3, 0x07, 0x06, 0x1C, 0x18, 0x70, 0x31,
  0xC0, 0xC7, 0x01, 0x9C, 0x06, 0x70, 0x0D, 0xC0, 0x37, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0x60, 0x03, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8,
  0x07, 0xE0, 0xFF, 0xF1, 0xFF, 0xF3, 0x00, 0x76, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0xEF, 0xFF, 0x9F, 0xFE, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60,
  0x06, 0x70, 0x06, 0x30, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0xFF, 0xF1, 0xFF,
  0xF3, 0x00, 0x76, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xEF, 0xFF, 0x9F, 0xFC, 0x30,
  0x60, 0x60, 0x60, 0xC0, 0xE1, 0x80, 0xC3, 0x00, 0xC6, 0x01, 0x8C, 0x01,
  0x98, 0x03, 0xB0, 0x03, 0x60, 0x03, 0x07, 0xF0, 0x1F, 0xFC, 0x38, 0x1E,
  0x70, 0x07, 0x60, 0x02, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x78, 0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x60,
  0x1D, 0xC0, 0xE3, 0xFF, 0x03, 0xF8, 0xE0, 0x00, 0xD8, 0x00, 0x66, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x30, 0x60, 0x0C,
  0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x0C, 0x01,
  0x83, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x26, 0x00, 0x09, 0x83, 0x82, 0x60, 0xE1, 0x98, 0x78, 0x66, 0x1A,
  0x19, 0x86, 0xC6, 0x21, 0x31, 0x88, 0xCC, 0x63, 0x31, 0x18, 0xCC, 0x66,
  0x32, 0x19, 0x8D, 0x86, 0x43, 0x61, 0x90, 0xD8, 0x34, 0x34, 0x0F, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x1C, 0x60, 0x01, 0xCC, 0x00, 0x63, 0x00,
  0x30, 0x60, 0x0C, 0x1C, 0x06, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x1C, 0x60,
  0x03, 0x38, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x06, 0x18, 0x03, 0x83, 0x00, 0xC0,
  0xE0, 0x60, 0x18, 0x38, 0x03, 0x0C, 0x00, 0xE6, 0x00, 0x1B, 0x80, 0x03,
  0xC0, 0x00, 0xEC, 0x00, 0x39, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x80, 0x30,
  0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x60, 0x06, 0x1C, 0x00, 0xE3, 0x00,
  0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00,
  0xCC, 0x00, 0x63, 0x00, 0x61, 0x80, 0x60, 0x60, 0x30, 0x18, 0x30, 0x0C,
  0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x6C, 0x00, 0x34, 0x00, 0x14, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC6, 0x18, 0x43, 0x0C, 0x0F, 0xC0, 0x1F, 0xF0, 0x38,
  0x38, 0x60, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x0F,
  0xFC, 0x3F, 0xFC, 0x70, 0x0C, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0x60,
  0x1C, 0x70, 0x2C, 0x3F, 0xCF, 0x1F, 0x87, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0xF0, 0xDF, 0xE3, 0xC1,
  0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1B, 0x00, 0xEF, 0x07, 0x37,
  0xFC, 0xCF, 0xC0, 0x07, 0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x03, 0x60, 0x0D,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x17, 0x00, 0xCE, 0x0E, 0x1F, 0xF0, 0x1F, 0x80, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x83, 0xE3, 0x1F, 0xE6, 0x70, 0x6D, 0xC0, 0x3B, 0x00, 0x36, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1B, 0x00,
  0x36, 0x00, 0x6E, 0x01, 0xCE, 0x0D, 0x8F, 0xF3, 0x0F, 0xC6, 0x07, 0xC0,
  0x3F, 0xE0, 0xE0, 0xE3, 0x00, 0xEC, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x98, 0x03, 0x1C, 0x1C, 0x1F, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x07, 0xFC,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x0F,
  0xD0, 0x1F, 0xF0, 0x38, 0x38, 0x60, 0x18, 0x60, 0x18, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x18, 0x60, 0x18, 0x38, 0x38, 0x1F, 0xF0, 0x0F, 0xC0, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x60, 0x06, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x7F, 0xFC, 0x1F,
  0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0xF8, 0xDF, 0xE7, 0x83, 0xB8, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x18, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x7F,
  0xE7, 0xFE, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x0E, 0xC0, 0x39, 0x80, 0xE3, 0x03, 0x86, 0x0E,
  0x0C, 0x38, 0x18, 0xE0, 0x33, 0x80, 0x6D, 0x80, 0xF3, 0x81, 0xC3, 0x83,
  0x03, 0x06, 0x03, 0x0C, 0x07, 0x18, 0x07, 0x30, 0x06, 0x60, 0x06, 0xC0,
  0x06, 0xFF, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0xCE, 0x1E, 0xDF, 0x3F, 0xE3, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x81,
  0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81,
  0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81,
  0xC7, 0xC6, 0xFF, 0x3C, 0x1D, 0xC0, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xE0, 0xE3,
  0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0x98, 0x07, 0x3C, 0x1C,
  0x3F, 0xF0, 0x1F, 0x80, 0xC7, 0xC3, 0x7F, 0x8F, 0x07, 0x30, 0x0E, 0xC0,
  0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x03, 0xBC, 0x1C, 0xDF, 0xF3, 0x3F, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x07, 0xC6, 0x3F, 0xCC, 0xE0, 0xDB, 0x80, 0x76, 0x00, 0x6C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x36, 0x00,
  0x6C, 0x00, 0xDC, 0x03, 0x9C, 0x1B, 0x1F, 0xE6, 0x1F, 0x8C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0xFE,
  0x3F, 0xFE, 0x7F, 0x06, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0xE0, 0x7F, 0xF1, 0xC0, 0xF3, 0x00, 0x64, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x3E, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x03, 0x38, 0x0E, 0x3F, 0xF8, 0x1F, 0xC0, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x0D, 0x80,
  0x36, 0x01, 0xDE, 0x1B, 0x3F, 0xEC, 0x3E, 0x30, 0xC0, 0x07, 0x80, 0x1B,
  0x00, 0x33, 0x00, 0x66, 0x01, 0x84, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x40, 0x61, 0x80, 0x63, 0x00, 0xC4, 0x01, 0x98, 0x01, 0xB0,
  0x03, 0x40, 0x07, 0x80, 0x07, 0x00, 0xC0, 0xC0, 0xF0, 0x38, 0x34, 0x0E,
  0x0D, 0x06, 0x83, 0x61, 0xA0, 0xD8, 0x4C, 0x26, 0x13, 0x09, 0x8C, 0x46,
  0x23, 0x11, 0x88, 0xC4, 0x62, 0x21, 0x98, 0xC8, 0x64, 0x36, 0x09, 0x0D,
  0x82, 0xC3, 0x40, 0xF0, 0x50, 0x3C, 0x1C, 0x0F, 0x07, 0x01, 0x80, 0x60,
  0x07, 0x30, 0x06, 0x38, 0x0C, 0x18, 0x18, 0x0C, 0x38, 0x06, 0x30, 0x07,
  0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x0E,
  0x30, 0x0C, 0x38, 0x18, 0x18, 0x38, 0x0C, 0x30, 0x06, 0xE0, 0x07, 0xC0,
  0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x06,
  0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x7F,
  0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x83, 0xF8, 0x1F, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFC, 0x1F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF8, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x1F, 0xE0, 0x7F, 0x0E, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0x83, 0xF8, 0x00, 0x1C,
  0x01, 0x9F, 0x80, 0x98, 0xE0, 0xC8, 0x38, 0x6C, 0x0E, 0x66, 0x03, 0xF2,
  0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Light34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 4, 24, 20, 8, -24 },
  { 13, 7, 9, 20, 7, -25 },
  { 21, 19, 24, 20, 1, -24 },
  { 78, 16, 30, 20, 2, -27 },
  { 138, 19, 24, 20, 1, -24 },
  { 195, 18, 24, 20, 1, -24 },
  { 249, 2, 9, 20, 9, -25 },
  { 252, 9, 31, 20, 7, -26 },
  { 287, 9, 31, 20, 4, -26 },
  { 322, 17, 17, 20, 2, -19 },
  { 359, 16, 16, 20, 2, -18 },
  { 391, 5, 9, 20, 7, -4 },
  { 397, 10, 2, 20, 5, -11 },
  { 400, 4, 4, 20, 8, -4 },
  { 402, 14, 31, 20, 3, -26 },
  { 457, 16, 24, 20, 2, -24 },
  { 505, 17, 24, 20, 2, -24 },
  { 556, 15, 24, 20, 3, -24 },
  { 601, 15, 24, 20, 2, -24 },
  { 646, 18, 24, 20, 1, -24 },
  { 700, 15, 24, 20, 3, -24 },
  { 745, 16, 24, 20, 2, -24 },
  { 793, 16, 24, 20, 2, -24 },
  { 841, 16, 24, 20, 2, -24 },
  { 889, 15, 24, 20, 3, -24 },
  { 934, 4, 18, 20, 8, -18 },
  { 943, 5, 23, 20, 7, -18 },
  { 958, 15, 19, 20, 3, -20 },
  { 994, 16, 9, 20, 2, -15 },
  { 1012, 15, 19, 20, 3, -20 },
  { 1048, 14, 24, 20, 3, -24 },
  { 1090, 14, 28, 20, 3, -24 },
  { 1139, 18, 24, 20, 1, -24 },
  { 1193, 15, 24, 20, 3, -24 },
  { 1238, 15, 24, 20, 3, -24 },
  { 1283, 15, 24, 20, 3, -24 },
  { 1328, 15, 24, 20, 3, -24 },
  { 1373, 15, 24, 20, 3, -24 },
  { 1418, 16, 24, 20, 2, -24 },
  { 1466, 14, 24, 20, 3, -24 },
  { 1508, 14, 24, 20, 3, -24 },
  { 1550, 13, 24, 20, 3, -24 },
  { 1589, 16, 24, 20, 3, -24 },
  { 1637, 14, 24, 20, 4, -24 },
  { 1679, 15, 24, 20, 3, -24 },
  { 1724, 14, 24, 20, 3, -24 },
  { 1766, 16, 24, 20, 2, -24 },
  { 1814, 15, 24, 20, 3, -24 },
  { 1859, 16, 29, 20, 2, -24 },
  { 1917, 15, 24, 20, 3, -24 },
  { 1962, 16, 24, 20, 2, -24 },
  { 2010, 18, 24, 20, 1, -24 },
  { 2064, 14, 24, 20, 3, -24 },
  { 2106, 18, 24, 20, 1, -24 },
  { 2160, 18, 24, 20, 1, -24 },
  { 2214, 18, 24, 20, 1, -24 },
  { 2268, 19, 24, 20, 1, -24 },
  { 2325, 17, 24, 20, 2, -24 },
  { 2376, 9, 31, 20, 8, -26 },
  { 2411, 14, 31, 20, 3, -26 },
  { 2466, 9, 31, 20, 3, -26 },
  { 2501, 17, 14, 20, 2, -24 },
  { 2531, 16, 2, 20, 2, 3 },
  { 2535, 5, 6, 20, 7, -26 },
  { 2539, 16, 18, 20, 2, -18 },
  { 2575, 14, 25, 20, 4, -25 },
  { 2619, 14, 18, 20, 3, -18 },
  { 2651, 15, 25, 20, 2, -25 },
  { 2698, 15, 18, 20, 3, -18 },
  { 2732, 15, 25, 20, 3, -25 },
  { 2779, 16, 27, 20, 3, -20 },
  { 2833, 13, 25, 20, 4, -25 },
  { 2874, 14, 25, 20, 4, -25 },
  { 2918, 12, 32, 20, 3, -25 },
  { 2966, 15, 25, 20, 4, -25 },
  { 3013, 15, 25, 20, 3, -25 },
  { 3060, 16, 18, 20, 2, -18 },
  { 3096, 13, 18, 20, 4, -18 },
  { 3126, 15, 18, 20, 3, -18 },
  { 3160, 14, 25, 20, 4, -18 },
  { 3204, 15, 25, 20, 2, -18 },
  { 3251, 16, 18, 20, 3, -18 },
  { 3287, 15, 18, 20, 3, -18 },
  { 3321, 17, 24, 20, 1, -24 },
  { 3372, 14, 18, 20, 3, -18 },
  { 3404, 15, 18, 20, 3, -18 },
  { 3438, 18, 18, 20, 1, -18 },
  { 3479, 16, 18, 20, 2, -18 },
  { 3515, 16, 25, 20, 2, -18 },
  { 3565, 14, 18, 20, 3, -18 },
  { 3597, 13, 31, 20, 4, -26 },
  { 3648, 2, 31, 20, 9, -26 },
  { 3656, 13, 31, 20, 4, -26 },
  { 3707, 17, 7, 20, 2, -14 },
};

const GFXfont IBMPlexMono_Light34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_LIGHT34PT7B_H_
