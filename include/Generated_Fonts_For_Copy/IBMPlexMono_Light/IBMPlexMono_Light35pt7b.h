#ifndef _IBMPLEXMONO_LIGHT35PT7B_H_
#define _IBMPLEXMONO_LIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light35pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0x08, 0x42, 0x10, 0x84, 0x00,
  0x00, 0x07, 0x7F, 0xEE, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6,
  0x01, 0x83, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x06, 0x0C, 0x00, 0xC1, 0x03, 0xF8, 0x3F, 0x7F, 0x0F, 0xE0, 0x61, 0x80,
  0x0C, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x07,
  0xF0, 0xFE, 0xFC, 0x1F, 0xC0, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xE3, 0x3C,
  0xE1, 0x86, 0x60, 0xC1, 0xB0, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C,
  0x01, 0xC6, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x67, 0x80,
  0x30, 0xC0, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0D, 0x03, 0x07, 0x81, 0x87,
  0x70, 0xC3, 0x1E, 0x67, 0x87, 0xFF, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x6F, 0xF0, 0x09, 0x86, 0x03,
  0x60, 0x60, 0xCC, 0x0C, 0x19, 0x81, 0x86, 0x30, 0x30, 0xC6, 0x06, 0x30,
  0xC0, 0xC6, 0x0C, 0x31, 0x81, 0xFE, 0x20, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x04, 0x7F, 0x81, 0x8C, 0x30, 0x63, 0x03, 0x0C, 0x60, 0x63, 0x0C, 0x0C,
  0x61, 0x81, 0x98, 0x30, 0x33, 0x06, 0x06, 0xC0, 0x61, 0x90, 0x0F, 0xF6,
  0x00, 0x78, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x70, 0xE0, 0x0C, 0x06, 0x03,
  0x80, 0x80, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x0F, 0x81, 0xE3, 0xB8, 0x3C, 0xE3, 0x86, 0x18,
  0x38, 0xC6, 0x03, 0x10, 0xC0, 0x32, 0x18, 0x03, 0xC3, 0x00, 0x78, 0x70,
  0x07, 0x06, 0x00, 0xF0, 0xF0, 0x67, 0x0F, 0xF8, 0x60, 0x7E, 0x07, 0xFF,
  0x80, 0x03, 0x83, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x20,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x07, 0xE0, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC1,
  0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x03, 0x82, 0x0F, 0xF9, 0x3F, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x6C, 0x00, 0x63, 0x00, 0x70, 0xC0, 0x30, 0x60, 0x30, 0x18, 0x30,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x3C, 0xE3, 0x8C, 0x71, 0xC6, 0x18, 0xC0,
  0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x07,
  0x06, 0x00, 0xC7, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xE0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCE, 0x00,
  0xE3, 0x00, 0x60, 0xE0, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x03, 0xDC, 0x03, 0xCE, 0x03, 0xC7, 0x03, 0xC3, 0x80,
  0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0x0F, 0xC0, 0x3F, 0xF0, 0x78, 0x38, 0x60, 0x1C, 0xC0, 0x0C, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x78, 0x1C, 0x1F, 0xF8, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x60,
  0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x06, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x7F, 0xFC, 0xFF,
  0xF9, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xCF, 0xC1, 0xBF, 0xE2, 0xC1, 0xE6, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x7E, 0x00,
  0xCE, 0x07, 0x8F, 0xFC, 0x07, 0xF0, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xCF,
  0xC3, 0x3F, 0xE6, 0xC1, 0xEE, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x36, 0x00, 0xCF, 0x07, 0x87,
  0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x00, 0xE6,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x30, 0x06, 0x0C, 0x0E,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0x80, 0xE3, 0x80, 0x39, 0x80, 0x0D, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xEC, 0x00, 0x67, 0x00, 0x71,
  0xC0, 0x70, 0x7F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xF1, 0xE0, 0xF3,
  0x00, 0x6C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x77, 0x83, 0x67, 0xFC, 0xC3, 0xF3, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xFF, 0xDC, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x38, 0xE3, 0x1C, 0x71, 0x86, 0x30, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xE0, 0xF3, 0x80, 0x6E, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x1F, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3,
  0x80, 0x66, 0x00, 0xC8, 0x00, 0xF0, 0x01, 0xE0, 0xF3, 0xC3, 0xF7, 0x8E,
  0x1F, 0x18, 0x1E, 0x30, 0x38, 0x60, 0x70, 0xC0, 0xE1, 0x81, 0xC3, 0x03,
  0x86, 0x07, 0x8C, 0x0F, 0x1C, 0x3E, 0x1F, 0xFC, 0x1F, 0x78, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x30, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x07, 0x00, 0x70, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00,
  0x1C, 0xC0, 0x01, 0x98, 0x00, 0x37, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0xC0, 0x3C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xFF, 0xF0, 0xFF, 0xF8, 0xC0, 0x1C,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3C, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x60, 0x07,
  0x70, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0,
  0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E,
  0xE0, 0x1C, 0xE0, 0x38, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xDC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1C, 0x1C, 0x38, 0x06, 0x70, 0x07,
  0x60, 0x03, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x1B, 0x0F, 0xF3,
  0x07, 0xE3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x74, 0x01, 0xB0, 0x06, 0xE0, 0x39, 0xC1, 0xC3, 0xFE,
  0x03, 0xF0, 0xC0, 0x03, 0xE0, 0x03, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x03,
  0x86, 0x03, 0x83, 0x03, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x61, 0x80, 0x31,
  0xC0, 0x19, 0xF0, 0x0D, 0xD8, 0x07, 0xC6, 0x03, 0xC3, 0x81, 0xC0, 0xC0,
  0xC0, 0x30, 0x60, 0x1C, 0x30, 0x06, 0x18, 0x03, 0x8C, 0x00, 0xE6, 0x00,
  0x33, 0x00, 0x1D, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFB, 0x06, 0xF6, 0x0D,
  0xE6, 0x13, 0xCC, 0x67, 0x88, 0x8F, 0x1B, 0x1E, 0x36, 0x3C, 0x38, 0x78,
  0x70, 0xF0, 0x41, 0xE0, 0x83, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3D, 0x80, 0x7B, 0x80, 0xF3, 0x01, 0xE6, 0x03, 0xC6,
  0x07, 0x8C, 0x0F, 0x0C, 0x1E, 0x18, 0x3C, 0x18, 0x78, 0x30, 0xF0, 0x31,
  0xE0, 0x63, 0xC0, 0x67, 0x80, 0xCF, 0x01, 0xDE, 0x01, 0xBC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x07, 0x06,
  0x00, 0xC7, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xE0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCE, 0x00, 0xE3,
  0x00, 0x60, 0xE0, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC,
  0xE0, 0x1E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFC,
  0x07, 0x07, 0x06, 0x00, 0xC7, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x06, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xCE, 0x00, 0xE3, 0x00, 0x60, 0xE0, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0xFF, 0xF0,
  0xFF, 0xFC, 0xE0, 0x1E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x1E, 0xFF, 0xFC,
  0xFF, 0xF0, 0xE1, 0xC0, 0xE0, 0xC0, 0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x30,
  0xE0, 0x18, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x06, 0xE0, 0x07, 0x07, 0xF0,
  0x0F, 0xFE, 0x0E, 0x03, 0x8E, 0x00, 0xE6, 0x00, 0x13, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x67, 0x00, 0x71, 0xC0, 0x70, 0x7F, 0xF0, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3B, 0x00, 0x66,
  0x00, 0xCF, 0x07, 0x8F, 0xFE, 0x07, 0xF0, 0xE0, 0x00, 0xEC, 0x00, 0x19,
  0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0xC0,
  0xC0, 0x18, 0x18, 0x03, 0x03, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x00,
  0xE0, 0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x38, 0x60, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0,
  0xE0, 0xF0, 0xD8, 0x68, 0x6C, 0x24, 0x36, 0x13, 0x11, 0x19, 0x98, 0xCC,
  0xCC, 0x66, 0x66, 0x33, 0x32, 0x09, 0x9B, 0x06, 0xCD, 0x83, 0x66, 0xC1,
  0xB3, 0x40, 0x58, 0xE0, 0x3C, 0x70, 0x1C, 0x60, 0x00, 0xE6, 0x00, 0x38,
  0xE0, 0x06, 0x0C, 0x01, 0x80, 0xC0, 0x70, 0x1C, 0x0C, 0x01, 0x83, 0x00,
  0x18, 0xE0, 0x03, 0x98, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x60, 0x00, 0x6E, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x00,
  0xC1, 0xC0, 0x30, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x60, 0x03, 0x1C,
  0x00, 0x77, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x19, 0xC0, 0x07, 0x18,
  0x00, 0xC1, 0x80, 0x30, 0x38, 0x06, 0x03, 0x01, 0x80, 0x70, 0x70, 0x06,
  0x0C, 0x00, 0x63, 0x00, 0x0E, 0xE0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xCE, 0x00, 0x63, 0x00, 0x60,
  0xC0, 0x30, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x03, 0x18, 0x00, 0xCC,
  0x00, 0x6C, 0x00, 0x1A, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7,
  0x18, 0x61, 0x0C, 0x0F, 0xE0, 0x0F, 0xFC, 0x0E, 0x0E, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x0F, 0xFC, 0x1F, 0xFE,
  0x1C, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xC7, 0x00, 0x61, 0x80, 0x30, 0xE0,
  0x78, 0x3F, 0xE7, 0x8F, 0xC3, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC7, 0xC1, 0xBF,
  0xE3, 0xC1, 0xE7, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB8,
  0x06, 0x78, 0x3C, 0xDF, 0xF1, 0x8F, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xE0,
  0x71, 0x80, 0x66, 0x00, 0x6C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xCC, 0x03, 0x1E,
  0x0E, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x07, 0xC6, 0x3F, 0xEC,
  0xF0, 0x7B, 0x80, 0x76, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xDC, 0x03,
  0x9E, 0x0F, 0x1F, 0xF6, 0x0F, 0x8C, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3,
  0x00, 0x64, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x9C, 0x03, 0x9C, 0x0E,
  0x1F, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x1F,
  0x07, 0xD0, 0x1F, 0xF0, 0x38, 0x38, 0x70, 0x1C, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x70, 0x1C, 0x38, 0x38, 0x1F, 0xF0, 0x0F, 0xC0,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x20, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x7F, 0xFC,
  0x1F, 0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC7, 0xC6, 0xFF, 0xB4, 0x1D, 0xC0, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x19, 0xFF, 0xCF, 0xFC,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60,
  0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xCF, 0x00, 0xDB, 0x00, 0xF1, 0x80,
  0xE0, 0xC0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xCE, 0x1E, 0x6F, 0x9F, 0xB8, 0x68, 0xF8,
  0x38, 0x3C, 0x0C, 0x1E, 0x04, 0x0F, 0x02, 0x07, 0x81, 0x03, 0xC0, 0x81,
  0xE0, 0x40, 0xF0, 0x20, 0x78, 0x10, 0x3C, 0x08, 0x1E, 0x04, 0x0F, 0x02,
  0x07, 0x81, 0x03, 0xC0, 0x81, 0xE0, 0x40, 0xC0, 0xC7, 0xC6, 0xFF, 0xB4,
  0x1D, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x00, 0x6E, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x01, 0xD8, 0x03, 0x1C, 0x1C, 0x1F, 0xF0, 0x1F, 0x80,
  0xC7, 0xC1, 0xBF, 0xE3, 0xC1, 0xE7, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0,
  0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x6C, 0x00,
  0xD8, 0x01, 0xB8, 0x06, 0x78, 0x3C, 0xDF, 0xF1, 0x8F, 0x83, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x07,
  0xC6, 0x3F, 0xEC, 0xF0, 0x7B, 0x80, 0x76, 0x00, 0x6C, 0x00, 0xD8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C,
  0x00, 0xDC, 0x03, 0x9E, 0x0F, 0x1F, 0xF6, 0x0F, 0x8C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0xFE, 0x1F,
  0xFF, 0x3F, 0xC1, 0x90, 0x00, 0xD0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xFF, 0xFE, 0x7F, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xC0, 0x73, 0x00, 0x36, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xBC, 0x0E, 0x3F, 0xF8, 0x1F, 0xC0, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0xEE, 0x0F, 0x7F, 0xD8, 0xFC, 0xC0, 0xC0, 0x07, 0x80, 0x0D,
  0x80, 0x33, 0x00, 0x66, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x18,
  0x30, 0x30, 0x60, 0x60, 0xC0, 0x63, 0x00, 0xC6, 0x00, 0x88, 0x01, 0xB0,
  0x03, 0x60, 0x03, 0x80, 0x07, 0x00, 0xC0, 0xE0, 0x78, 0x1C, 0x0D, 0x02,
  0x81, 0x20, 0x50, 0x26, 0x1B, 0x0C, 0xC3, 0x61, 0x98, 0x44, 0x33, 0x08,
  0x86, 0x23, 0x18, 0x84, 0x63, 0x10, 0xCC, 0x66, 0x19, 0x04, 0xC3, 0x20,
  0xD8, 0x6C, 0x1B, 0x05, 0x83, 0x40, 0xA0, 0x28, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0xC0, 0x06, 0x60, 0x0C, 0x30, 0x18, 0x38, 0x38, 0x18, 0x30, 0x0C,
  0x60, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x0E,
  0xE0, 0x0C, 0x60, 0x18, 0x30, 0x30, 0x18, 0x70, 0x1C, 0x60, 0x0C, 0xC0,
  0x07, 0xE0, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x60,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x0E, 0x1F, 0xC0, 0xFE, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x38, 0x00, 0x7F, 0x03, 0xF8, 0x70, 0x03, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x83, 0xFC, 0x1F, 0xE0, 0x1E, 0x01, 0x9F, 0x80, 0xD8, 0xE0, 0x6C,
  0x38, 0x6C, 0x0E, 0x36, 0x03, 0xF3, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Light35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 24, 21, 8, -24 },
  { 16, 7, 9, 21, 7, -26 },
  { 24, 19, 24, 21, 1, -24 },
  { 81, 17, 32, 21, 2, -28 },
  { 149, 19, 24, 21, 1, -24 },
  { 206, 19, 24, 21, 1, -24 },
  { 263, 1, 9, 21, 10, -26 },
  { 265, 9, 32, 21, 8, -27 },
  { 301, 9, 32, 21, 4, -27 },
  { 337, 17, 17, 21, 2, -19 },
  { 374, 17, 18, 21, 2, -20 },
  { 413, 6, 9, 21, 7, -4 },
  { 420, 9, 2, 21, 6, -12 },
  { 423, 5, 4, 21, 8, -4 },
  { 426, 15, 32, 21, 3, -27 },
  { 486, 17, 24, 21, 2, -24 },
  { 537, 17, 24, 21, 2, -24 },
  { 588, 16, 24, 21, 3, -24 },
  { 636, 16, 24, 21, 2, -24 },
  { 684, 19, 24, 21, 1, -24 },
  { 741, 15, 24, 21, 3, -24 },
  { 786, 15, 24, 21, 3, -24 },
  { 831, 16, 24, 21, 2, -24 },
  { 879, 17, 24, 21, 2, -24 },
  { 930, 15, 24, 21, 3, -24 },
  { 975, 5, 19, 21, 8, -19 },
  { 987, 6, 24, 21, 7, -19 },
  { 1005, 15, 20, 21, 3, -21 },
  { 1043, 17, 9, 21, 2, -15 },
  { 1063, 15, 20, 21, 3, -21 },
  { 1101, 15, 24, 21, 3, -24 },
  { 1146, 15, 28, 21, 3, -24 },
  { 1199, 19, 24, 21, 1, -24 },
  { 1256, 16, 24, 21, 3, -24 },
  { 1304, 16, 24, 21, 3, -24 },
  { 1352, 16, 24, 21, 3, -24 },
  { 1400, 15, 24, 21, 3, -24 },
  { 1445, 15, 24, 21, 3, -24 },
  { 1490, 16, 24, 21, 2, -24 },
  { 1538, 15, 24, 21, 3, -24 },
  { 1583, 15, 24, 21, 3, -24 },
  { 1628, 14, 24, 21, 3, -24 },
  { 1670, 17, 24, 21, 3, -24 },
  { 1721, 14, 24, 21, 5, -24 },
  { 1763, 15, 24, 21, 3, -24 },
  { 1808, 15, 24, 21, 3, -24 },
  { 1853, 17, 24, 21, 2, -24 },
  { 1904, 16, 24, 21, 3, -24 },
  { 1952, 17, 29, 21, 2, -24 },
  { 2014, 16, 24, 21, 3, -24 },
  { 2062, 17, 24, 21, 2, -24 },
  { 2113, 19, 24, 21, 1, -24 },
  { 2170, 15, 24, 21, 3, -24 },
  { 2215, 19, 24, 21, 1, -24 },
  { 2272, 17, 24, 21, 2, -24 },
  { 2323, 19, 24, 21, 1, -24 },
  { 2380, 19, 24, 21, 1, -24 },
  { 2437, 17, 24, 21, 2, -24 },
  { 2488, 10, 32, 21, 8, -27 },
  { 2528, 15, 32, 21, 3, -27 },
  { 2588, 10, 32, 21, 3, -27 },
  { 2628, 17, 14, 21, 2, -24 },
  { 2658, 17, 2, 21, 2, 4 },
  { 2663, 5, 6, 21, 7, -27 },
  { 2667, 17, 18, 21, 2, -18 },
  { 2706, 15, 26, 21, 4, -26 },
  { 2755, 15, 18, 21, 3, -18 },
  { 2789, 15, 26, 21, 2, -26 },
  { 2838, 15, 18, 21, 3, -18 },
  { 2872, 16, 26, 21, 3, -26 },
  { 2924, 16, 27, 21, 3, -20 },
  { 2978, 13, 26, 21, 4, -26 },
  { 3021, 15, 25, 21, 4, -25 },
  { 3068, 13, 32, 21, 3, -25 },
  { 3120, 16, 26, 21, 4, -26 },
  { 3172, 15, 26, 21, 3, -26 },
  { 3221, 17, 18, 21, 2, -18 },
  { 3260, 13, 18, 21, 4, -18 },
  { 3290, 15, 18, 21, 3, -18 },
  { 3324, 15, 25, 21, 4, -18 },
  { 3371, 15, 25, 21, 2, -18 },
  { 3418, 17, 18, 21, 3, -18 },
  { 3457, 15, 18, 21, 3, -18 },
  { 3491, 17, 24, 21, 1, -24 },
  { 3542, 13, 18, 21, 4, -18 },
  { 3572, 15, 18, 21, 3, -18 },
  { 3606, 19, 18, 21, 1, -18 },
  { 3649, 16, 18, 21, 3, -18 },
  { 3685, 17, 25, 21, 2, -18 },
  { 3739, 15, 18, 21, 3, -18 },
  { 3773, 13, 32, 21, 4, -27 },
  { 3825, 1, 32, 21, 10, -27 },
  { 3829, 13, 32, 21, 4, -27 },
  { 3881, 17, 7, 21, 2, -14 },
};

const GFXfont IBMPlexMono_Light35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_LIGHT35PT7B_H_
