#ifndef _IBMPLEXMONO_LIGHT44PT7B_H_
#define _IBMPLEXMONO_LIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light44pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0x42, 0x00, 0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xC0, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x60, 0x1F, 0xF0, 0x3F, 0xEF, 0xF8,
  0x1F, 0xF0, 0x0C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x1F,
  0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE0, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xF1, 0x9F, 0x07, 0x06, 0x1E, 0x38,
  0x18, 0x3C, 0xC0, 0x60, 0x47, 0x01, 0x80, 0x1C, 0x06, 0x00, 0x70, 0x18,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x18, 0x00,
  0x3E, 0x60, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x63, 0xC0, 0x01, 0x83, 0x80, 0x06, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x60,
  0x70, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x40, 0x18, 0x1D, 0x80, 0x60, 0x6F,
  0x01, 0x83, 0x8F, 0x06, 0x1C, 0x1F, 0x19, 0xF0, 0x3F, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0x80, 0x03, 0x3F, 0xE0, 0x07, 0x70, 0xF0, 0x06, 0x60, 0x30,
  0x0C, 0x60, 0x30, 0x0C, 0xC0, 0x18, 0x18, 0xC0, 0x18, 0x18, 0xC0, 0x18,
  0x30, 0xC0, 0x18, 0x70, 0xC0, 0x18, 0x60, 0x60, 0x30, 0xE0, 0x60, 0x30,
  0xC0, 0x70, 0x71, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xC7, 0x0E, 0x03, 0x8E,
  0x06, 0x03, 0x0C, 0x03, 0x07, 0x0C, 0x03, 0x06, 0x0C, 0x03, 0x0C, 0x0C,
  0x03, 0x0C, 0x0C, 0x03, 0x18, 0x0C, 0x03, 0x38, 0x0C, 0x03, 0x30, 0x0C,
  0x03, 0x70, 0x0E, 0x06, 0x60, 0x07, 0x0E, 0xE0, 0x03, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x07, 0x80, 0x0E, 0x03,
  0x80, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0,
  0x3E, 0x1C, 0xE0, 0x3E, 0x38, 0x70, 0x30, 0x30, 0x30, 0x30, 0x70, 0x18,
  0x30, 0x60, 0x1C, 0x70, 0x60, 0x0E, 0x60, 0xE0, 0x07, 0x60, 0xE0, 0x03,
  0xE0, 0xE0, 0x01, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x01, 0xF0, 0x70, 0x01,
  0x78, 0x38, 0x03, 0x38, 0x3E, 0x0E, 0x1C, 0x0F, 0xFC, 0x0E, 0x03, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x18,
  0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x38, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x30, 0x0C, 0x03, 0xF8, 0x30, 0x7D, 0xFC, 0xCF,
  0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x0C, 0xE0, 0x00, 0x71, 0x80, 0x03, 0x87, 0x00, 0x0C, 0x0E, 0x00, 0x70,
  0x1C, 0x03, 0x80, 0x30, 0x1C, 0x00, 0xE0, 0x20, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x1E, 0x78, 0xF1, 0xE3,
  0x87, 0x1E, 0x38, 0x70, 0xC1, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0x81, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x01,
  0x8C, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xC0, 0xFC, 0x1E, 0x07,
  0xE0, 0xF0, 0x3F, 0x03, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0x60, 0x00, 0x73,
  0x80, 0x03, 0x1C, 0x00, 0x38, 0x70, 0x01, 0x81, 0xC0, 0x1C, 0x0F, 0x03,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xEE, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xE0,
  0x1E, 0x07, 0x00, 0xE0, 0x38, 0x02, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83,
  0x80, 0x3C, 0x70, 0x01, 0xC6, 0x00, 0x0E, 0xE0, 0x00, 0xE2, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0xF8, 0x3E, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0x40, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1D,
  0x00, 0x03, 0xF0, 0x00, 0xEF, 0x00, 0x3C, 0xF8, 0x1F, 0x07, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0C, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x0F, 0xC0, 0x33, 0xFF, 0x03, 0x60, 0x7C,
  0x38, 0x01, 0xC3, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x60, 0x00, 0xEF, 0x00, 0x0E, 0x78, 0x01, 0xC3, 0xE0, 0x78, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0xFC,
  0x07, 0x3F, 0xF0, 0x6E, 0x07, 0x87, 0x80, 0x1C, 0x70, 0x00, 0xEF, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x63,
  0x00, 0x0E, 0x38, 0x01, 0xC1, 0xE0, 0x78, 0x07, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xEC, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0x81, 0xF0, 0x70, 0x03, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x31, 0x80, 0x01,
  0xCC, 0x00, 0x0E, 0x60, 0x00, 0x73, 0x00, 0x03, 0x9C, 0x00, 0x18, 0x60,
  0x01, 0xC3, 0x80, 0x1C, 0x0F, 0x03, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x1E, 0x03, 0x81, 0xC0, 0x07, 0x1C, 0x00, 0x19, 0xC0, 0x00, 0xEE, 0x00,
  0x03, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x80, 0x1E, 0x1F, 0x01,
  0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1E,
  0x07, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x80, 0x1F, 0x1E, 0x07,
  0x70, 0xFF, 0xE6, 0x03, 0xF8, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xEF, 0xFF, 0xFE, 0x3C, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC7, 0x8F, 0x1C,
  0x38, 0xF1, 0xC3, 0x86, 0x0C, 0x38, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0xF1, 0xE0, 0x0E, 0x70, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1D, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xC3, 0x00,
  0x0E, 0x30, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x66, 0x03, 0xE6, 0x60,
  0x7F, 0x76, 0x0E, 0x1F, 0xE1, 0xC0, 0x7E, 0x18, 0x07, 0xE1, 0x80, 0x7E,
  0x18, 0x07, 0xE1, 0x80, 0x7E, 0x18, 0x07, 0xE1, 0x80, 0x7E, 0x18, 0x07,
  0xE1, 0x80, 0x7E, 0x18, 0x07, 0xE1, 0x80, 0x7E, 0x1C, 0x07, 0x60, 0xE0,
  0xF6, 0x0F, 0xFF, 0x60, 0x7F, 0x76, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xE3, 0x00, 0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0C, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x70, 0x03,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x18, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x80, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x0E, 0x3F, 0xFF, 0x07, 0xFF, 0xF8,
  0xE0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x39, 0xFF, 0xFE, 0x3F, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0x03, 0xC1, 0xE0, 0x0E, 0x1C, 0x00,
  0x63, 0x80, 0x07, 0x30, 0x00, 0x37, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x03, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x1E, 0x00,
  0xE0, 0xF0, 0x3C, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0,
  0x00, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00,
  0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00,
  0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x0F, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0x07, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xE3, 0x00, 0x06, 0x70, 0x00, 0x76,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0xF3, 0x80, 0x0F, 0x1C, 0x01, 0xF1, 0xF0, 0x77, 0x07, 0xFE, 0x70,
  0x1F, 0x80, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xA0,
  0x01, 0xF8, 0x00, 0xDC, 0x00, 0xE7, 0x00, 0xE3, 0xC0, 0xF0, 0x7F, 0xE0,
  0x0F, 0xC0, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x38, 0x00, 0x79, 0xC0, 0x03,
  0x8E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x03, 0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00,
  0x71, 0xE0, 0x03, 0x9F, 0x00, 0x1D, 0xDC, 0x00, 0xEC, 0x70, 0x07, 0xE3,
  0x80, 0x3E, 0x0E, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x03,
  0x80, 0x3C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00,
  0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xBE, 0xC0, 0x3B, 0xEC, 0x03, 0x3E,
  0x60, 0x33, 0xE6, 0x07, 0x3E, 0x70, 0x63, 0xE3, 0x0E, 0x3E, 0x38, 0xC3,
  0xE1, 0x9C, 0x3E, 0x19, 0x83, 0xE1, 0xD8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0x3E, 0x07, 0x03, 0xE0, 0x60, 0x3E, 0x02, 0x03, 0xE0, 0x40, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x30,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7D, 0xC0, 0x0F,
  0xB8, 0x01, 0xF3, 0x00, 0x3E, 0x70, 0x07, 0xC6, 0x00, 0xF8, 0xE0, 0x1F,
  0x0C, 0x03, 0xE1, 0xC0, 0x7C, 0x18, 0x0F, 0x83, 0x81, 0xF0, 0x70, 0x3E,
  0x07, 0x07, 0xC0, 0xE0, 0xF8, 0x0C, 0x1F, 0x01, 0xC3, 0xE0, 0x18, 0x7C,
  0x03, 0x8F, 0x80, 0x31, 0xF0, 0x07, 0x3E, 0x00, 0xE7, 0xC0, 0x0E, 0xF8,
  0x01, 0xDF, 0x00, 0x1B, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x78, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0x81, 0xE0, 0x38, 0x03,
  0x83, 0x80, 0x0C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x70, 0x00, 0x1B,
  0x80, 0x01, 0xDC, 0x00, 0x0E, 0x60, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00,
  0x38, 0x70, 0x01, 0x81, 0xC0, 0x1C, 0x0F, 0x03, 0xC0, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00,
  0x1C, 0xE0, 0x03, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0x81, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0C, 0x38, 0x00, 0x71,
  0xC0, 0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xB8, 0x00,
  0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x6E, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xCC, 0x00, 0x0E, 0x70,
  0x00, 0x63, 0x80, 0x07, 0x0E, 0x00, 0x30, 0x38, 0x03, 0x81, 0xE0, 0x78,
  0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07,
  0x0E, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x0E, 0xE0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xF0, 0x1F,
  0x07, 0x00, 0x1E, 0x38, 0x00, 0x38, 0xC0, 0x00, 0x47, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1D, 0x00, 0x00, 0x66, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0x7C, 0x07, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x37,
  0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x39, 0x80, 0x07, 0x38, 0x00, 0xC7,
  0x00, 0x38, 0x78, 0x1E, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x80, 0x00, 0xC7, 0x00, 0x03, 0x86,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x70, 0x01, 0x80, 0xE0, 0x07, 0x00, 0xC0, 0x0E, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x03, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x0E, 0x03,
  0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0xE0,
  0x00, 0x61, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0xCE, 0x00, 0x01, 0x9C, 0x00,
  0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x1D, 0x80, 0xE0, 0x76, 0x07, 0x81, 0xD8, 0x1E, 0x07,
  0x60, 0x7C, 0x19, 0x81, 0xB0, 0x66, 0x0E, 0xC1, 0x9C, 0x33, 0x06, 0x70,
  0xCE, 0x19, 0xC3, 0x18, 0x63, 0x1C, 0x61, 0x8C, 0x61, 0x86, 0x31, 0x87,
  0x38, 0xC6, 0x0C, 0xE3, 0x38, 0x33, 0x8C, 0xC0, 0xCC, 0x33, 0x03, 0xB0,
  0xCC, 0x06, 0xC3, 0x70, 0x1B, 0x0F, 0x80, 0x6C, 0x3E, 0x01, 0xF0, 0xF8,
  0x03, 0xC1, 0xE0, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0xE1, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x30, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x06, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0,
  0x01, 0xC7, 0x00, 0x03, 0x8C, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01,
  0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x1C, 0x00,
  0x38, 0x30, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x38, 0x07, 0x00, 0xC0,
  0x0E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x03,
  0x9C, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x21, 0xE1, 0xC1, 0xC1, 0x81, 0x83, 0x82, 0x03, 0xF8, 0x00, 0x7F, 0xF0,
  0x07, 0x03, 0xC0, 0x70, 0x0F, 0x07, 0x00, 0x38, 0x10, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x87,
  0x00, 0x7C, 0x3C, 0x0E, 0xFC, 0xFF, 0xE3, 0xE1, 0xFC, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x3F, 0x83, 0x3F,
  0xF0, 0xDC, 0x1F, 0x34, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xB8, 0x00, 0xED, 0x00, 0x73, 0x70, 0x7C, 0xCF, 0xFC,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xE0, 0x78, 0xF0, 0x0E,
  0x38, 0x01, 0xDC, 0x00, 0x26, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C, 0xE0, 0x03,
  0x38, 0x01, 0xC7, 0x81, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x0F, 0xC3, 0x87,
  0xFE, 0x71, 0xE0, 0x6E, 0x70, 0x07, 0xDC, 0x00, 0x7B, 0x80, 0x07, 0x60,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xB0, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03, 0xCE, 0x00, 0xF8, 0xF0,
  0x37, 0x0F, 0xFC, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0x07, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0E, 0x70, 0x00, 0x66,
  0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x43, 0x80, 0x06, 0x1C, 0x00, 0xE0, 0xF0,
  0x3C, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x40, 0x0F, 0xFE, 0x00, 0xE0, 0x78, 0x0E, 0x00,
  0xC0, 0xE0, 0x07, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0xC0, 0x38, 0x1E,
  0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC,
  0x18, 0x00, 0x73, 0x80, 0x01, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xEF, 0x80, 0x1E, 0x1F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0xFC, 0x19, 0xFF, 0x8D, 0xC1, 0xE6, 0x80, 0x3B, 0x80, 0x1D, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x7F, 0xFC, 0x7F, 0xF8, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01,
  0xEE, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x7C, 0x00, 0xEF,
  0xC0, 0x0F, 0xCE, 0x00, 0xF8, 0x70, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x8E, 0x00, 0x38,
  0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC7, 0x83, 0xC6, 0xFE, 0x7F, 0xB4, 0x3A, 0x1D, 0xC1,
  0xE0, 0x6C, 0x07, 0x03, 0xE0, 0x30, 0x1F, 0x01, 0x80, 0xF8, 0x0C, 0x07,
  0xC0, 0x60, 0x3E, 0x03, 0x01, 0xF0, 0x18, 0x0F, 0x80, 0xC0, 0x7C, 0x06,
  0x03, 0xE0, 0x30, 0x1F, 0x01, 0x80, 0xF8, 0x0C, 0x07, 0xC0, 0x60, 0x3E,
  0x03, 0x01, 0xF0, 0x18, 0x0F, 0x80, 0xC0, 0x7C, 0x06, 0x03, 0xE0, 0x30,
  0x1F, 0x01, 0x80, 0xE0, 0xC3, 0xF0, 0x67, 0xFE, 0x37, 0x07, 0x9A, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0E, 0x07,
  0x81, 0xC0, 0x1C, 0x38, 0x00, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00,
  0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77,
  0x00, 0x06, 0x70, 0x00, 0xE3, 0x80, 0x0C, 0x1C, 0x01, 0xC1, 0xE0, 0x78,
  0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xC3, 0xF8, 0x33, 0xFF, 0x0D, 0xC1, 0xF3,
  0x40, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1B,
  0x80, 0x0E, 0xD0, 0x07, 0x37, 0x07, 0xCC, 0xFF, 0xC3, 0x0F, 0xC0, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0xE1, 0xFF, 0x9C, 0x78, 0x1B,
  0x9C, 0x01, 0xF7, 0x00, 0x1E, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEC, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0xF3, 0x80, 0x3E, 0x3C, 0x0D, 0xC3, 0xFF, 0x38,
  0x1F, 0x87, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xF0, 0x0C, 0xC0, 0x00, 0x34, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1E, 0x03, 0xC3, 0x80, 0x0E, 0x30,
  0x00, 0x43, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x40, 0x00,
  0x7E, 0x00, 0x07, 0x78, 0x00, 0xE3, 0xE0, 0x3C, 0x0F, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x60,
  0x01, 0xD8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x38, 0x07, 0xCF, 0x03,
  0x71, 0xFF, 0x9C, 0x1F, 0x80, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00,
  0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0x80,
  0x18, 0x1C, 0x01, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x30, 0x06,
  0x07, 0x00, 0x70, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x8C, 0x00,
  0x19, 0xC0, 0x01, 0x98, 0x00, 0x1D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x60, 0x3C, 0x03, 0x60, 0x3C, 0x07,
  0x60, 0x34, 0x06, 0x60, 0x36, 0x06, 0x70, 0x26, 0x06, 0x30, 0x66, 0x06,
  0x30, 0x66, 0x06, 0x30, 0x63, 0x0E, 0x30, 0x63, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x0C, 0x18, 0xC1, 0x8C, 0x18, 0xC1, 0x8C,
  0x19, 0x81, 0x98, 0x19, 0x81, 0x98, 0x19, 0x80, 0xD8, 0x1D, 0x80, 0xD8,
  0x0D, 0x00, 0xD8, 0x0F, 0x00, 0xD8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0xF0, 0x00, 0x77, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xDC, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0x9C, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x81,
  0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xE0, 0x00, 0xC3, 0x00, 0x0E, 0x1C,
  0x00, 0x60, 0xE0, 0x07, 0x03, 0x00, 0x38, 0x1C, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x83, 0x00, 0x0C,
  0x38, 0x00, 0x71, 0x80, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x76, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0x80,
  0x0C, 0x7F, 0x00, 0x33, 0x8E, 0x01, 0xCC, 0x1C, 0x06, 0x70, 0x38, 0x19,
  0x80, 0x60, 0xE6, 0x00, 0xE7, 0x18, 0x01, 0xF8, 0xC0, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Light44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 5, 31, 26, 11, -31 },
  { 21, 10, 12, 26, 8, -33 },
  { 36, 25, 31, 26, 1, -31 },
  { 133, 22, 39, 26, 2, -35 },
  { 241, 24, 32, 26, 1, -31 },
  { 337, 24, 32, 26, 1, -31 },
  { 433, 2, 12, 26, 12, -33 },
  { 436, 11, 39, 26, 10, -33 },
  { 490, 12, 39, 26, 5, -33 },
  { 549, 22, 22, 26, 2, -24 },
  { 610, 21, 22, 26, 3, -24 },
  { 668, 7, 12, 26, 9, -5 },
  { 679, 12, 2, 26, 7, -14 },
  { 682, 5, 5, 26, 11, -5 },
  { 686, 18, 39, 26, 4, -33 },
  { 774, 21, 32, 26, 3, -31 },
  { 858, 21, 31, 26, 3, -31 },
  { 940, 20, 31, 26, 3, -31 },
  { 1018, 19, 32, 26, 3, -31 },
  { 1094, 23, 31, 26, 2, -31 },
  { 1184, 20, 32, 26, 3, -31 },
  { 1264, 20, 32, 26, 3, -31 },
  { 1344, 20, 31, 26, 3, -31 },
  { 1422, 21, 32, 26, 3, -31 },
  { 1506, 20, 31, 26, 3, -31 },
  { 1584, 5, 24, 26, 11, -24 },
  { 1599, 7, 31, 26, 9, -24 },
  { 1627, 19, 25, 26, 4, -26 },
  { 1687, 21, 11, 26, 3, -19 },
  { 1716, 19, 25, 26, 4, -26 },
  { 1776, 18, 31, 26, 4, -31 },
  { 1846, 20, 36, 26, 3, -31 },
  { 1936, 23, 31, 26, 2, -31 },
  { 2026, 19, 31, 26, 4, -31 },
  { 2100, 20, 32, 26, 3, -31 },
  { 2180, 20, 31, 26, 4, -31 },
  { 2258, 19, 31, 26, 4, -31 },
  { 2332, 19, 31, 26, 4, -31 },
  { 2406, 20, 32, 26, 3, -31 },
  { 2486, 19, 31, 26, 4, -31 },
  { 2560, 19, 31, 26, 4, -31 },
  { 2634, 17, 32, 26, 4, -31 },
  { 2702, 21, 31, 26, 4, -31 },
  { 2784, 17, 31, 26, 6, -31 },
  { 2850, 20, 31, 26, 3, -31 },
  { 2928, 19, 31, 26, 4, -31 },
  { 3002, 21, 32, 26, 3, -31 },
  { 3086, 20, 31, 26, 4, -31 },
  { 3164, 21, 37, 26, 3, -31 },
  { 3262, 20, 31, 26, 4, -31 },
  { 3340, 22, 32, 26, 2, -31 },
  { 3428, 24, 31, 26, 1, -31 },
  { 3521, 19, 32, 26, 4, -31 },
  { 3597, 23, 31, 26, 2, -31 },
  { 3687, 22, 31, 26, 2, -31 },
  { 3773, 23, 31, 26, 2, -31 },
  { 3863, 24, 31, 26, 1, -31 },
  { 3956, 22, 31, 26, 2, -31 },
  { 4042, 11, 39, 26, 11, -33 },
  { 4096, 18, 39, 26, 4, -33 },
  { 4184, 12, 39, 26, 4, -33 },
  { 4243, 22, 17, 26, 2, -31 },
  { 4290, 21, 2, 26, 3, 5 },
  { 4296, 7, 8, 26, 8, -34 },
  { 4303, 21, 24, 26, 3, -23 },
  { 4366, 18, 34, 26, 5, -33 },
  { 4443, 18, 24, 26, 4, -23 },
  { 4497, 19, 34, 26, 3, -33 },
  { 4578, 20, 24, 26, 3, -23 },
  { 4638, 21, 33, 26, 3, -33 },
  { 4725, 21, 34, 26, 3, -25 },
  { 4815, 17, 33, 26, 5, -33 },
  { 4886, 19, 33, 26, 5, -33 },
  { 4965, 16, 42, 26, 4, -33 },
  { 5049, 20, 33, 26, 5, -33 },
  { 5132, 19, 33, 26, 4, -33 },
  { 5211, 21, 23, 26, 3, -23 },
  { 5272, 17, 23, 26, 5, -23 },
  { 5321, 20, 24, 26, 3, -23 },
  { 5381, 18, 32, 26, 5, -23 },
  { 5453, 19, 32, 26, 3, -23 },
  { 5529, 22, 23, 26, 3, -23 },
  { 5593, 20, 24, 26, 3, -23 },
  { 5653, 21, 31, 26, 2, -31 },
  { 5735, 18, 24, 26, 4, -23 },
  { 5789, 20, 23, 26, 3, -23 },
  { 5847, 24, 23, 26, 1, -23 },
  { 5916, 20, 23, 26, 3, -23 },
  { 5974, 21, 32, 26, 3, -23 },
  { 6058, 18, 23, 26, 4, -23 },
  { 6110, 17, 39, 26, 5, -33 },
  { 6193, 2, 39, 26, 12, -33 },
  { 6203, 17, 39, 26, 5, -33 },
  { 6286, 22, 9, 26, 2, -18 },
};

const GFXfont IBMPlexMono_Light44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_LIGHT44PT7B_H_
