#ifndef _IBMPLEXMONO_LIGHT39PT7B_H_
#define _IBMPLEXMONO_LIGHT39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light39pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x63, 0x18, 0x84, 0x21,
  0x00, 0x00, 0x00, 0x0E, 0xFF, 0xDC, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0xE1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x38, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x01, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xC0, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0xFF, 0x07, 0xF3, 0xFC, 0x3F, 0xC0, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0x99, 0xE1,
  0xC3, 0x0E, 0x70, 0x60, 0xEC, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x07,
  0x06, 0x00, 0xE0, 0xC0, 0x0E, 0x18, 0x00, 0xF3, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x31, 0xE0, 0x06, 0x0E, 0x00, 0xC1, 0xC0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x68, 0x0C, 0x0F, 0x81, 0x83, 0xBC,
  0x30, 0xE3, 0xE6, 0x78, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x1C, 0xFF, 0x00,
  0x67, 0x0C, 0x03, 0x38, 0x18, 0x0C, 0xC0, 0x60, 0x63, 0x01, 0x83, 0x0C,
  0x06, 0x0C, 0x30, 0x18, 0x60, 0xC0, 0x61, 0x83, 0x81, 0x8C, 0x07, 0x0C,
  0x30, 0x0F, 0xF1, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xC3, 0xFC, 0x03, 0x1C, 0x30, 0x18, 0x60, 0x60, 0x63, 0x01, 0x83,
  0x0C, 0x06, 0x1C, 0x30, 0x18, 0x60, 0xC0, 0x63, 0x03, 0x01, 0x8C, 0x06,
  0x06, 0x60, 0x1C, 0x31, 0x80, 0x3F, 0xCC, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0xE0, 0x03, 0x83, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x8F, 0xC0, 0x7C, 0xE7,
  0x03, 0x0E, 0x1C, 0x30, 0x60, 0x71, 0x83, 0x01, 0xCC, 0x38, 0x07, 0x61,
  0xC0, 0x1F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00,
  0xB8, 0x3C, 0x1C, 0xE0, 0xFF, 0x83, 0x81, 0xF8, 0x0E, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x80, 0x60, 0x2F, 0x06, 0x1E, 0x7E, 0x6F, 0xF0, 0xFF, 0xF0, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xB8, 0x00, 0x39, 0x80, 0x07, 0x0C, 0x00, 0x60,
  0xE0, 0x0C, 0x06, 0x01, 0xC0, 0x30, 0x18, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3C, 0xF3, 0x8E,
  0x71, 0xC7, 0x18, 0x63, 0x00, 0xFF, 0xFF, 0xFC, 0x77, 0xFE, 0xE0, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x78, 0x3C, 0x0C, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x9C,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xF0,
  0x70, 0x7E, 0x0F, 0x0F, 0xC1, 0xE1, 0xF8, 0x38, 0x3F, 0x00, 0x07, 0x60,
  0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x67, 0x00, 0x0C, 0x60,
  0x03, 0x8E, 0x00, 0x60, 0xC0, 0x1C, 0x1E, 0x0F, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x03,
  0xC6, 0x00, 0xF0, 0xC0, 0x3C, 0x18, 0x07, 0x03, 0x00, 0x40, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0x03,
  0xC1, 0xE1, 0xC0, 0x1C, 0x60, 0x07, 0x38, 0x00, 0xC4, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xC0, 0xF0, 0xE0, 0x0C, 0x70, 0x03, 0x88, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xD0, 0x00, 0x7E, 0x00, 0x19,
  0xC0, 0x0E, 0x3C, 0x0F, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0xFC, 0x0C, 0xFF, 0x86, 0xC1, 0xE3, 0x80, 0x38, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1A, 0x00, 0x1F, 0x80, 0x0C, 0xE0, 0x0E, 0x38, 0x1E, 0x0F, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x3F, 0x01, 0x9F, 0xF0, 0xFC, 0x0F, 0x34, 0x01, 0xCE, 0x00,
  0x3B, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x06,
  0xC0, 0x01, 0xB8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x1C, 0x3C, 0x0E, 0x07,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x19, 0x80, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x1E, 0x1C, 0x01, 0xC3,
  0x00, 0x1C, 0xE0, 0x01, 0x9C, 0x00, 0x33, 0x80, 0x06, 0x70, 0x00, 0xC6,
  0x00, 0x38, 0xE0, 0x0E, 0x0F, 0x03, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x07,
  0x01, 0xC1, 0xC0, 0x0E, 0x70, 0x00, 0xCC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x06, 0xC0, 0x01, 0xDC, 0x00, 0x33, 0xC0, 0x0E, 0x3C,
  0x07, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x03,
  0xC0, 0xE1, 0xC0, 0x1C, 0x60, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x03,
  0x9C, 0x01, 0xE3, 0xC0, 0xD8, 0x7F, 0xEE, 0x07, 0xE3, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x77, 0xFE, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xBF, 0xF7, 0x00, 0x39, 0xF7,
  0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3,
  0xCE, 0x39, 0xC7, 0x1C, 0x61, 0x8C, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x18, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0x07, 0x86,
  0x00, 0xE7, 0x00, 0x33, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x07, 0x87, 0x00, 0xE3,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x03, 0xC0, 0x79, 0xE0, 0xFE,
  0xF0, 0xE0, 0xF8, 0x60, 0x3C, 0x30, 0x1E, 0x18, 0x0F, 0x0C, 0x07, 0x8E,
  0x03, 0xC3, 0x01, 0xE1, 0x80, 0xF0, 0xC0, 0x78, 0x60, 0x3C, 0x38, 0x3E,
  0x0F, 0xEF, 0x03, 0xF6, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1B, 0x00, 0x01, 0xB8, 0x00, 0x39, 0x80,
  0x03, 0x18, 0x00, 0x31, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0E,
  0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x70, 0x0C, 0x07, 0x01, 0xC0,
  0x30, 0x18, 0x03, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0x00, 0x18, 0x30,
  0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0E, 0xE0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x70, 0xFF, 0xF0, 0x7F, 0xFC, 0x30, 0x07, 0x18,
  0x01, 0xCC, 0x00, 0x66, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x07,
  0x60, 0x03, 0x30, 0x03, 0x98, 0x03, 0x8F, 0xFF, 0x07, 0xFF, 0xC3, 0x00,
  0x39, 0x80, 0x0E, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x0E, 0xC0, 0x0E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0, 0x0E,
  0x30, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x11, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x01, 0x1C, 0x00, 0x73, 0x00, 0x18, 0xE0, 0x0E, 0x1E, 0x0F, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x0F, 0x18, 0x01,
  0xCC, 0x00, 0x66, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00,
  0x36, 0x00, 0x3B, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x3C, 0x7F, 0xFC, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xE0, 0x70, 0x70, 0x0E, 0x38,
  0x01, 0xCC, 0x00, 0x37, 0x00, 0x11, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF,
  0x80, 0xFF, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x70,
  0x00, 0xCC, 0x00, 0x33, 0x80, 0x1C, 0x70, 0x0F, 0x1E, 0x06, 0xC3, 0xFF,
  0x30, 0x3F, 0x0C, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB8, 0x06, 0x38, 0x3C, 0x3F, 0xF0,
  0x1F, 0x80, 0xC0, 0x01, 0xF0, 0x00, 0xEC, 0x00, 0x73, 0x00, 0x38, 0xC0,
  0x1C, 0x30, 0x0E, 0x0C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x70,
  0x0C, 0x38, 0x03, 0x1C, 0x00, 0xCF, 0x80, 0x37, 0x60, 0x0D, 0x9C, 0x03,
  0xC3, 0x80, 0xE0, 0x60, 0x38, 0x1C, 0x0C, 0x03, 0x83, 0x00, 0x60, 0xC0,
  0x1C, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00,
  0xEC, 0x00, 0x1C, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFD, 0x80, 0x5E, 0xC0, 0x6F, 0x30, 0x37,
  0x98, 0x33, 0xC6, 0x19, 0xE3, 0x18, 0xF1, 0xCC, 0x78, 0x6C, 0x3C, 0x36,
  0x1E, 0x0F, 0x0F, 0x07, 0x07, 0x81, 0x83, 0xC0, 0x81, 0xE0, 0x40, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0x60, 0x0F, 0xB8, 0x07, 0xCC, 0x03,
  0xE7, 0x01, 0xF1, 0x80, 0xF8, 0xE0, 0x7C, 0x30, 0x3E, 0x18, 0x1F, 0x0E,
  0x0F, 0x83, 0x07, 0xC1, 0xC3, 0xE0, 0x61, 0xF0, 0x38, 0xF8, 0x0C, 0x7C,
  0x07, 0x3E, 0x01, 0x9F, 0x00, 0xEF, 0x80, 0x37, 0xC0, 0x1B, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x78, 0x3C,
  0x0C, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x9C, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1D,
  0x80, 0x03, 0xB0, 0x00, 0x67, 0x00, 0x0C, 0x60, 0x03, 0x8E, 0x00, 0x60,
  0xC0, 0x1C, 0x1E, 0x0F, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xF8,
  0x7F, 0xFE, 0x30, 0x03, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEC,
  0x00, 0xE7, 0xFF, 0xF3, 0xFF, 0xE1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xC0, 0x78, 0x3C, 0x0C, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x9C, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00,
  0xEC, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x67, 0x00, 0x0C, 0x60, 0x03,
  0x8E, 0x00, 0x60, 0xC0, 0x1C, 0x1E, 0x0F, 0x01, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x30, 0x03, 0x98, 0x00, 0xEC,
  0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0x83,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x1C, 0x18, 0x06, 0x0C, 0x03, 0x86,
  0x00, 0xE3, 0x00, 0x31, 0x80, 0x1C, 0xC0, 0x06, 0x60, 0x03, 0xB0, 0x00,
  0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xF0, 0x1E, 0x1C, 0x00, 0xE7, 0x00,
  0x0E, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x80, 0x01, 0xF8, 0x00, 0x33, 0x80, 0x0E, 0x3C, 0x07,
  0x83, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x76,
  0x00, 0x3B, 0x00, 0x1D, 0xC0, 0x0C, 0x60, 0x0E, 0x3C, 0x0E, 0x0F, 0xFE,
  0x01, 0xFC, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x66, 0x00,
  0x0E, 0x70, 0x00, 0xC7, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x18, 0x38,
  0x01, 0x81, 0x80, 0x38, 0x18, 0x03, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x0E, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x39, 0x80, 0x01, 0xB8,
  0x00, 0x1B, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x0E, 0x06, 0xE0, 0xE0, 0x66, 0x0F, 0x06,
  0x60, 0xB0, 0x66, 0x1B, 0x06, 0x61, 0xB0, 0x66, 0x19, 0x86, 0x61, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0xCC, 0x63, 0x0C, 0xC6, 0x60,
  0xCC, 0x76, 0x0C, 0xC3, 0x60, 0x6C, 0x36, 0x06, 0xC3, 0xC0, 0x6C, 0x3C,
  0x06, 0xC3, 0xC0, 0x38, 0x3C, 0x03, 0x80, 0x70, 0x00, 0x39, 0x80, 0x03,
  0x8E, 0x00, 0x18, 0x38, 0x01, 0x80, 0xC0, 0x1C, 0x07, 0x00, 0xC0, 0x1C,
  0x0E, 0x00, 0x60, 0xE0, 0x03, 0x86, 0x00, 0x0E, 0x70, 0x00, 0x37, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x1B,
  0x80, 0x01, 0xCC, 0x00, 0x0C, 0x70, 0x00, 0xC1, 0xC0, 0x0E, 0x06, 0x00,
  0x60, 0x38, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x03, 0x00, 0x1C, 0x38, 0x00,
  0x63, 0x80, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xE7,
  0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x60, 0x06, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x38, 0x60,
  0x00, 0x63, 0x80, 0x01, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x06, 0xC0, 0x01, 0xCC, 0x00, 0x31, 0xC0,
  0x0E, 0x18, 0x01, 0x83, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x03, 0x00, 0x60,
  0xE0, 0x06, 0x18, 0x00, 0xE7, 0x00, 0x0C, 0xC0, 0x01, 0xF0, 0x00, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC6, 0x18, 0xE3, 0x0C, 0x60, 0x0F, 0xE0,
  0x0F, 0xFE, 0x07, 0x83, 0xC1, 0x80, 0x38, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xC0,
  0x18, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xE0, 0x0E,
  0x1C, 0x0D, 0x83, 0xFE, 0x7C, 0x7E, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x61, 0xF8, 0x33, 0xFF, 0x1B, 0x03, 0xCD, 0x00, 0xE7, 0x00,
  0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xE0, 0x07,
  0x68, 0x07, 0x36, 0x07, 0x99, 0xFF, 0x8C, 0x3F, 0x00, 0x07, 0xF0, 0x1F,
  0xF8, 0x3C, 0x1C, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x02, 0x60, 0x03, 0x70, 0x06, 0x3C, 0x1E, 0x1F, 0xF8, 0x07,
  0xF0, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xE3, 0x1F, 0xF3, 0x3C,
  0x1B, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0x60, 0x03, 0x70, 0x07, 0x3C, 0x1B, 0x1F, 0xF3, 0x07, 0xC3, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0x03, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x04, 0xE0, 0x07, 0x38, 0x07, 0x1E,
  0x07, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xD0, 0x07, 0xFE, 0x01, 0xC1, 0xE0,
  0x70, 0x0C, 0x0C, 0x01, 0xC3, 0x80, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x60,
  0xC0, 0x1C, 0x1C, 0x03, 0x03, 0xC1, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xF8, 0x60, 0x03, 0x98, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1B, 0x80, 0x07, 0x38, 0x01, 0xC3, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x87, 0xC3, 0x3F, 0xE6, 0xC1, 0xED, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xBF, 0xFC,
  0xFF, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x03, 0xB0,
  0x03, 0x98, 0x03, 0x0C, 0x07, 0x06, 0x07, 0x03, 0x07, 0x01, 0x87, 0x00,
  0xC7, 0x00, 0x67, 0x80, 0x36, 0xE0, 0x1E, 0x38, 0x0E, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0xC1, 0x80, 0x70, 0xC0, 0x1C, 0x60, 0x06, 0x30, 0x03, 0x98,
  0x00, 0xEC, 0x00, 0x38, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xCF, 0x87, 0x9B, 0xF9, 0xFB, 0x43,
  0x43, 0xF0, 0x70, 0x3E, 0x06, 0x07, 0x80, 0xC0, 0xF0, 0x18, 0x1E, 0x03,
  0x03, 0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x01, 0x81, 0xE0, 0x30, 0x3C, 0x06,
  0x07, 0x80, 0xC0, 0xF0, 0x18, 0x1E, 0x03, 0x03, 0xC0, 0x60, 0x78, 0x0C,
  0x0F, 0x01, 0x81, 0xE0, 0x30, 0x30, 0xC3, 0xE1, 0x9F, 0xF3, 0x60, 0xF6,
  0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x30, 0x03, 0xF0, 0x0F, 0xFE,
  0x0F, 0x07, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x1F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0D, 0x80, 0x0E, 0xC0, 0x06, 0x30, 0x07, 0x1E, 0x07, 0x07, 0xFF,
  0x00, 0xFE, 0x00, 0xC3, 0xF0, 0x67, 0xFE, 0x36, 0x07, 0x9A, 0x01, 0xCE,
  0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x0D, 0xC0,
  0x0E, 0xD0, 0x0E, 0x6C, 0x0F, 0x33, 0xFF, 0x18, 0x7E, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xE3, 0x1F, 0xF3, 0x3C, 0x1B, 0x70, 0x07, 0x60,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x70,
  0x07, 0x3C, 0x1B, 0x1F, 0xF3, 0x07, 0xC3, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFC, 0x0E, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x07,
  0xF8, 0x0F, 0xFF, 0x0E, 0x03, 0xCE, 0x00, 0x76, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x80, 0x03, 0xE0, 0x03, 0xBE,
  0x03, 0x87, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x07, 0x60, 0x0E, 0xF0, 0x6C, 0xFF, 0x98, 0x7E,
  0x30, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x30, 0xE0, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x07,
  0x01, 0x83, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x06, 0x60, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x38, 0x00, 0xC0, 0x70, 0x1B, 0x03,
  0x80, 0xD8, 0x1E, 0x06, 0xC0, 0xB0, 0x36, 0x0D, 0x83, 0x30, 0x64, 0x19,
  0x83, 0x20, 0xC4, 0x11, 0x86, 0x30, 0x8C, 0x31, 0x8C, 0x61, 0x8C, 0x61,
  0x08, 0x63, 0x0C, 0xC3, 0x10, 0x66, 0x09, 0x83, 0x30, 0x6C, 0x09, 0x83,
  0x60, 0x6C, 0x1A, 0x03, 0x40, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xE0, 0x01, 0x9C, 0x00, 0xC3, 0x80, 0x70, 0x60, 0x38, 0x1C, 0x0C,
  0x03, 0x86, 0x00, 0x63, 0x80, 0x0D, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x01, 0x8E, 0x00, 0xC1, 0xC0, 0x70,
  0x30, 0x38, 0x0E, 0x0C, 0x01, 0xC6, 0x00, 0x3B, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x70, 0x03, 0x0C, 0x01, 0xC3,
  0x00, 0x60, 0x60, 0x18, 0x18, 0x0C, 0x07, 0x03, 0x00, 0xC1, 0xC0, 0x30,
  0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x0D, 0xC0, 0x03, 0x60,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0xFF,
  0x01, 0xFE, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC1, 0xFF, 0x83,
  0xFE, 0x00, 0x0E, 0x00, 0x67, 0xF0, 0x0C, 0xC7, 0x01, 0xB0, 0x70, 0x36,
  0x06, 0x0C, 0x80, 0x73, 0xB0, 0x07, 0xE6, 0x00, 0x78,
};

const GFXglyph IBMPlexMono_Light39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 27, 23, 9, -27 },
  { 18, 8, 10, 23, 8, -29 },
  { 28, 22, 27, 23, 1, -27 },
  { 103, 19, 35, 23, 2, -31 },
  { 187, 22, 27, 23, 1, -27 },
  { 262, 21, 27, 23, 1, -27 },
  { 333, 2, 10, 23, 11, -29 },
  { 336, 11, 35, 23, 8, -30 },
  { 385, 10, 35, 23, 5, -30 },
  { 429, 20, 19, 23, 2, -21 },
  { 477, 19, 20, 23, 2, -22 },
  { 525, 6, 10, 23, 8, -4 },
  { 533, 11, 2, 23, 6, -13 },
  { 536, 5, 4, 23, 9, -4 },
  { 539, 16, 35, 23, 4, -30 },
  { 609, 19, 27, 23, 2, -27 },
  { 674, 19, 27, 23, 3, -27 },
  { 739, 18, 27, 23, 3, -27 },
  { 800, 18, 27, 23, 2, -27 },
  { 861, 20, 27, 23, 2, -27 },
  { 929, 17, 27, 23, 3, -27 },
  { 987, 18, 27, 23, 3, -27 },
  { 1048, 17, 27, 23, 3, -27 },
  { 1106, 19, 27, 23, 2, -27 },
  { 1171, 18, 27, 23, 3, -27 },
  { 1232, 5, 21, 23, 9, -21 },
  { 1246, 6, 27, 23, 8, -21 },
  { 1267, 17, 22, 23, 3, -23 },
  { 1314, 19, 10, 23, 2, -17 },
  { 1338, 17, 22, 23, 3, -23 },
  { 1385, 17, 27, 23, 3, -27 },
  { 1443, 17, 31, 23, 3, -27 },
  { 1509, 20, 27, 23, 2, -27 },
  { 1577, 17, 27, 23, 4, -27 },
  { 1635, 18, 27, 23, 3, -27 },
  { 1696, 17, 27, 23, 4, -27 },
  { 1754, 16, 27, 23, 4, -27 },
  { 1808, 16, 27, 23, 4, -27 },
  { 1862, 18, 27, 23, 2, -27 },
  { 1923, 17, 27, 23, 3, -27 },
  { 1981, 17, 27, 23, 3, -27 },
  { 2039, 15, 27, 23, 3, -27 },
  { 2090, 18, 27, 23, 4, -27 },
  { 2151, 16, 27, 23, 5, -27 },
  { 2205, 17, 27, 23, 3, -27 },
  { 2263, 17, 27, 23, 3, -27 },
  { 2321, 19, 27, 23, 2, -27 },
  { 2386, 17, 27, 23, 4, -27 },
  { 2444, 19, 33, 23, 2, -27 },
  { 2523, 17, 27, 23, 4, -27 },
  { 2581, 19, 27, 23, 2, -27 },
  { 2646, 21, 27, 23, 1, -27 },
  { 2717, 17, 27, 23, 3, -27 },
  { 2775, 20, 27, 23, 2, -27 },
  { 2843, 20, 27, 23, 2, -27 },
  { 2911, 21, 27, 23, 1, -27 },
  { 2982, 22, 27, 23, 1, -27 },
  { 3057, 20, 27, 23, 2, -27 },
  { 3125, 11, 35, 23, 9, -30 },
  { 3174, 16, 35, 23, 4, -30 },
  { 3244, 10, 35, 23, 4, -30 },
  { 3288, 19, 15, 23, 2, -27 },
  { 3324, 19, 2, 23, 2, 4 },
  { 3329, 5, 7, 23, 8, -30 },
  { 3334, 18, 20, 23, 3, -20 },
  { 3379, 17, 29, 23, 4, -29 },
  { 3441, 16, 20, 23, 4, -20 },
  { 3481, 16, 29, 23, 3, -29 },
  { 3539, 17, 20, 23, 3, -20 },
  { 3582, 18, 29, 23, 3, -29 },
  { 3648, 19, 30, 23, 3, -22 },
  { 3720, 15, 29, 23, 4, -29 },
  { 3775, 17, 29, 23, 4, -29 },
  { 3837, 14, 37, 23, 4, -29 },
  { 3902, 17, 29, 23, 5, -29 },
  { 3964, 17, 29, 23, 3, -29 },
  { 4026, 19, 20, 23, 2, -20 },
  { 4074, 15, 20, 23, 4, -20 },
  { 4112, 17, 20, 23, 3, -20 },
  { 4155, 17, 28, 23, 4, -20 },
  { 4215, 16, 28, 23, 3, -20 },
  { 4271, 19, 20, 23, 3, -20 },
  { 4319, 17, 20, 23, 3, -20 },
  { 4362, 19, 27, 23, 1, -27 },
  { 4427, 15, 20, 23, 4, -20 },
  { 4465, 17, 20, 23, 3, -20 },
  { 4508, 21, 20, 23, 1, -20 },
  { 4561, 18, 20, 23, 3, -20 },
  { 4606, 18, 28, 23, 3, -20 },
  { 4669, 16, 20, 23, 4, -20 },
  { 4709, 15, 35, 23, 4, -30 },
  { 4775, 2, 35, 23, 11, -30 },
  { 4784, 15, 35, 23, 4, -30 },
  { 4850, 19, 8, 23, 2, -16 },
};

const GFXfont IBMPlexMono_Light39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_LIGHT39PT7B_H_
