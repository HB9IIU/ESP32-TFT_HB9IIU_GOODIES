#ifndef _IBMPLEXMONO_LIGHT62PT7B_H_
#define _IBMPLEXMONO_LIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light62pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x30,
  0x60, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xF9, 0xFF,
  0xF0, 0x0F, 0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE3, 0x9F, 0xE0, 0x3E, 0x07, 0x07, 0xE0, 0xF8, 0x0E, 0x03,
  0xE1, 0xE0, 0x1C, 0x03, 0xC7, 0x80, 0x38, 0x03, 0x0F, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F,
  0x81, 0xC0, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x73, 0xFC, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x03,
  0x80, 0xF8, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0,
  0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0xC0, 0x07, 0x00,
  0xF3, 0xC0, 0x0E, 0x01, 0xEF, 0xC0, 0x1C, 0x07, 0x87, 0xC0, 0x38, 0x1F,
  0x07, 0xE0, 0x70, 0x7C, 0x07, 0xF8, 0xE7, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3C, 0x7F, 0xFC, 0x00, 0x07, 0x1F, 0x07, 0xC0, 0x01,
  0xC3, 0x80, 0x38, 0x00, 0x38, 0xF0, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x1E, 0x0E, 0x00,
  0x38, 0x03, 0x81, 0xC0, 0x07, 0x80, 0xF0, 0x38, 0x00, 0xF0, 0x1C, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x70, 0x38,
  0x03, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x07, 0xC1, 0xF0,
  0x78, 0x00, 0x7F, 0xFC, 0x0E, 0x00, 0x07, 0xFF, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x81, 0xFF,
  0xC0, 0x00, 0xE0, 0x7F, 0xFC, 0x00, 0x1C, 0x1F, 0x07, 0xC0, 0x07, 0x03,
  0xC0, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0x0F,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x3C,
  0x0E, 0x01, 0xC0, 0x07, 0x83, 0x80, 0x38, 0x00, 0xF0, 0x70, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0xE0, 0x03, 0x87, 0x80, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0xC0, 0x0E, 0x3C, 0x00, 0x3C, 0x03, 0x87, 0x00, 0x07, 0xC1, 0xF1, 0xC0,
  0x00, 0x7F, 0xFC, 0x38, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x1E,
  0x3C, 0x01, 0xFE, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xE0, 0x38, 0x0F, 0x00, 0x78, 0x1C, 0x07, 0x00, 0x1E, 0x0E, 0x07,
  0x80, 0x07, 0x87, 0x03, 0xC0, 0x01, 0xE3, 0x81, 0xE0, 0x00, 0x79, 0xC0,
  0xF0, 0x00, 0x3C, 0xC0, 0x78, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x03, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3F,
  0x01, 0xE0, 0x00, 0x33, 0xC0, 0xF8, 0x00, 0x38, 0xF0, 0x3E, 0x00, 0x38,
  0x7C, 0x0F, 0xC0, 0x78, 0x1F, 0x03, 0xFF, 0xF8, 0x07, 0x80, 0xFF, 0xF8,
  0x01, 0xE0, 0x0F, 0xF0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x1C,
  0x01, 0xFF, 0xF8, 0x38, 0x1F, 0xEF, 0xFE, 0x73, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x0F, 0x00, 0xFF, 0x00, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0x3F,
  0x01, 0xFE, 0x01, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFB, 0xC0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x3C, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xE0, 0x3F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x1F, 0x00,
  0x01, 0xF1, 0xC0, 0x00, 0x1E, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x7E, 0x00, 0x0F, 0x87, 0xF0, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x03, 0xFC, 0x00, 0xE3, 0xFF, 0xE0,
  0x1C, 0xFF, 0xFF, 0x03, 0xBC, 0x07, 0xF0, 0x7C, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x90, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x7E, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x81, 0xFE, 0x00, 0x78, 0xFF, 0xF8, 0x07, 0x1F, 0xFF, 0xE0, 0xF3,
  0xC0, 0x7F, 0x0F, 0x70, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3C, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x00, 0x7C,
  0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F,
  0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x6E, 0x3F, 0x00, 0x0E, 0xE1, 0xFC,
  0x07, 0xDE, 0x0F, 0xFF, 0xF9, 0xE0, 0x3F, 0xFE, 0x1C, 0x00, 0x7F, 0x83,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0x00,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xFE,
  0x3F, 0x00, 0xFF, 0xE7, 0xE0, 0x3E, 0x06, 0xFC, 0x07, 0x80, 0x7F, 0x81,
  0xE0, 0x07, 0xF0, 0x3C, 0x00, 0xFE, 0x07, 0x00, 0x0F, 0xC0, 0xE0, 0x01,
  0xF8, 0x1C, 0x00, 0x3F, 0x03, 0x80, 0x07, 0xE0, 0x70, 0x00, 0xFC, 0x0E,
  0x00, 0x1F, 0x81, 0xC0, 0x03, 0xF0, 0x38, 0x00, 0x7E, 0x07, 0x00, 0x0F,
  0xC0, 0xE0, 0x01, 0xF8, 0x1C, 0x00, 0x3F, 0x03, 0x80, 0x0F, 0xE0, 0x78,
  0x01, 0xFC, 0x07, 0x00, 0x3F, 0x80, 0xF0, 0x0B, 0xF0, 0x0F, 0xCF, 0x7E,
  0x01, 0xFF, 0xCF, 0xE0, 0x0F, 0xF1, 0xDC, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01,
  0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x70,
  0x00, 0x3F, 0x0E, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F,
  0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0x03, 0xC3, 0x80, 0x01, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x38, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x7C, 0xE0, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0xE7, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F,
  0x80, 0x0F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x78, 0x00, 0xFE, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x3E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x3E, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0x70, 0xF0, 0x00,
  0x37, 0x0F, 0x80, 0x0E, 0x70, 0x7E, 0x03, 0xE7, 0x03, 0xFF, 0xFC, 0x70,
  0x0F, 0xFF, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x10, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F,
  0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x3C,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE3, 0xF8, 0x00, 0x0F,
  0x1F, 0xE0, 0x00, 0x79, 0xEF, 0x00, 0x03, 0xDE, 0x3C, 0x00, 0x1F, 0xE1,
  0xF0, 0x00, 0xFE, 0x07, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x3F, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xEE,
  0x00, 0x0E, 0xFE, 0xF0, 0x00, 0xEF, 0xE7, 0x00, 0x1C, 0xFE, 0x78, 0x01,
  0xCF, 0xE3, 0x80, 0x38, 0xFE, 0x38, 0x03, 0x8F, 0xE3, 0xC0, 0x78, 0xFE,
  0x1C, 0x07, 0x0F, 0xE1, 0xE0, 0x70, 0xFE, 0x0E, 0x0E, 0x0F, 0xE0, 0xF0,
  0xE0, 0xFE, 0x07, 0x1C, 0x0F, 0xE0, 0x79, 0xC0, 0xFE, 0x03, 0xBC, 0x0F,
  0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0xFE, 0x01,
  0xF0, 0x0F, 0xE0, 0x0E, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x06, 0x00,
  0xFE, 0x00, 0x40, 0x0F, 0xE0, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFD, 0xE0, 0x00, 0x7F, 0xBC, 0x00, 0x0F,
  0xF3, 0xC0, 0x01, 0xFE, 0x78, 0x00, 0x3F, 0xC7, 0x00, 0x07, 0xF8, 0xF0,
  0x00, 0xFF, 0x0E, 0x00, 0x1F, 0xE1, 0xE0, 0x03, 0xFC, 0x3C, 0x00, 0x7F,
  0x83, 0xC0, 0x0F, 0xF0, 0x78, 0x01, 0xFE, 0x07, 0x80, 0x3F, 0xC0, 0xF0,
  0x07, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC,
  0x03, 0xC0, 0x7F, 0x80, 0x38, 0x0F, 0xF0, 0x07, 0x81, 0xFE, 0x00, 0x70,
  0x3F, 0xC0, 0x0F, 0x07, 0xF8, 0x01, 0xE0, 0xFF, 0x00, 0x1E, 0x1F, 0xE0,
  0x03, 0xC3, 0xFC, 0x00, 0x3C, 0x7F, 0x80, 0x07, 0x8F, 0xF0, 0x00, 0x79,
  0xFE, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xE7, 0xF8, 0x00, 0x1E, 0xFF, 0x00,
  0x01, 0xDF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x78,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xEF, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x7C,
  0x01, 0xCE, 0x00, 0xF8, 0x03, 0x9C, 0x01, 0xF0, 0x07, 0x38, 0x03, 0xF0,
  0x0E, 0x70, 0x0F, 0xE0, 0x1C, 0xF0, 0x1D, 0xC0, 0x39, 0xE0, 0x3B, 0x80,
  0x73, 0xC0, 0x73, 0x80, 0xE3, 0x81, 0xC7, 0x01, 0xC7, 0x03, 0x8E, 0x07,
  0x8E, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE1, 0xC1, 0xC1, 0xE1, 0xC3,
  0x87, 0x81, 0xC3, 0x87, 0x8E, 0x03, 0x87, 0x0F, 0x1C, 0x07, 0x0E, 0x1E,
  0x38, 0x0F, 0x1C, 0x1C, 0xF0, 0x0E, 0x38, 0x39, 0xC0, 0x1C, 0xF0, 0x73,
  0x80, 0x39, 0xC0, 0xE7, 0x00, 0x7B, 0x81, 0xDE, 0x00, 0x77, 0x03, 0xB8,
  0x00, 0xEE, 0x07, 0x70, 0x01, 0xDC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x78, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x30, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x04, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1B, 0x80, 0xF0, 0x00, 0xCE,
  0x03, 0xF0, 0x0F, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0x81, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0F,
  0xE0, 0x0E, 0x1F, 0xFE, 0x03, 0x8F, 0xFF, 0xE0, 0xE7, 0x80, 0xFC, 0x3B,
  0x80, 0x0F, 0x8F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x8E, 0xE0, 0x03, 0xE3,
  0x9E, 0x03, 0xF0, 0xE3, 0xFF, 0xF8, 0x38, 0x7F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0xE0, 0x00, 0x0C, 0x78, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x43, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87,
  0xC0, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0xFF, 0x03, 0xC0, 0x7F, 0xF8, 0x78, 0x3F, 0xFF, 0x8F, 0x0F, 0xE0,
  0x79, 0xE3, 0xF0, 0x01, 0xBC, 0x78, 0x00, 0x1F, 0x9E, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0xFC, 0x7C, 0x00, 0x37, 0x87, 0xF0, 0x1C, 0xF0, 0x7F, 0xFF, 0x1E,
  0x03, 0xFF, 0xC3, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x10, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x98, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x3F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x38, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1F, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x7F, 0x80, 0xE1,
  0xFF, 0xE0, 0xE3, 0xFF, 0xF0, 0xE7, 0x81, 0xF8, 0xEC, 0x00, 0x7C, 0xE8,
  0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0xF3,
  0xFE, 0x00, 0x0F, 0x79, 0xE0, 0x00, 0xFF, 0x0F, 0x00, 0x0F, 0xE0, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF0, 0x0F, 0xC7, 0x3F, 0xE0, 0xFF, 0x39, 0xFF, 0x8F,
  0xFD, 0xD8, 0x3C, 0xC1, 0xEF, 0x80, 0xEC, 0x07, 0xF8, 0x07, 0xC0, 0x3F,
  0x80, 0x1E, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00,
  0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70,
  0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07,
  0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0,
  0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C,
  0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01,
  0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0,
  0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x7F, 0x80, 0xE1, 0xFF, 0xE0, 0xE3, 0xFF, 0xF0, 0xE7,
  0x81, 0xF8, 0xEC, 0x00, 0x7C, 0xE8, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x38, 0x7F, 0xF8, 0x0E, 0x3F,
  0xFF, 0x83, 0x9E, 0x03, 0xF0, 0xEE, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3C, 0xF8,
  0x00, 0x1E, 0x3B, 0x80, 0x0F, 0x8E, 0x78, 0x0F, 0xC3, 0x8F, 0xFF, 0xE0,
  0xE1, 0xFF, 0xE0, 0x38, 0x1F, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFC, 0x3C, 0x1F, 0xFF, 0xC7, 0x87, 0xF0, 0x3C, 0xF1, 0xF8, 0x00, 0xDE,
  0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x1B,
  0xC3, 0xF8, 0x0E, 0x78, 0x3F, 0xFF, 0x8F, 0x01, 0xFF, 0xE1, 0xE0, 0x0F,
  0xF0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xC0, 0x0E, 0x3C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC1, 0xE0, 0x00, 0xFC, 0x78, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0x87, 0xF0, 0x0F, 0xE0,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x17, 0x3E, 0x00, 0x37, 0x1F, 0x80, 0xE7, 0x0F, 0xFF,
  0xC7, 0x07, 0xFF, 0x87, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xEE,
  0x00, 0x7C, 0x00, 0xF7, 0x00, 0x37, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x39,
  0xC0, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x0E, 0x78, 0x06, 0x38, 0x07,
  0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC3, 0x01,
  0xC3, 0x80, 0xE1, 0x80, 0xE1, 0xC0, 0x60, 0xE0, 0x70, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0C, 0x1C, 0x0E, 0x0C, 0x07,
  0x0E, 0x07, 0x0E, 0x03, 0x87, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xC3, 0x80,
  0x61, 0xC0, 0x71, 0xC0, 0x30, 0xE0, 0x38, 0xC0, 0x1C, 0x60, 0x1C, 0xE0,
  0x0E, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x38, 0x01, 0x9C, 0x03, 0x98,
  0x00, 0xEE, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x7E, 0x00, 0x3B, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x38, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x1C, 0x3F, 0xF0,
  0x00, 0x70, 0xF0, 0xF0, 0x00, 0xE1, 0xC0, 0xF0, 0x01, 0xC7, 0x00, 0xF0,
  0x07, 0x8E, 0x00, 0xF0, 0x0E, 0x38, 0x00, 0xF0, 0x3C, 0x70, 0x00, 0xF8,
  0xF0, 0xE0, 0x00, 0xFF, 0xC3, 0x80, 0x00, 0xFF, 0x03, 0x00, 0x00, 0x7C,
  0x00,
};

const GFXglyph IBMPlexMono_Light62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 7, 43, 37, 15, -43 },
  { 39, 13, 16, 37, 12, -46 },
  { 65, 35, 43, 37, 1, -43 },
  { 254, 31, 57, 37, 3, -50 },
  { 475, 35, 45, 37, 1, -44 },
  { 672, 33, 45, 37, 2, -44 },
  { 858, 3, 16, 37, 17, -46 },
  { 864, 16, 56, 37, 14, -47 },
  { 976, 17, 56, 37, 7, -47 },
  { 1095, 31, 31, 37, 3, -34 },
  { 1216, 29, 31, 37, 4, -34 },
  { 1329, 10, 16, 37, 13, -7 },
  { 1349, 17, 3, 37, 10, -20 },
  { 1356, 7, 7, 37, 15, -7 },
  { 1363, 25, 56, 37, 6, -47 },
  { 1538, 29, 45, 37, 4, -44 },
  { 1702, 30, 43, 37, 4, -43 },
  { 1864, 28, 44, 37, 5, -44 },
  { 2018, 27, 45, 37, 4, -44 },
  { 2170, 33, 43, 37, 2, -43 },
  { 2348, 27, 44, 37, 5, -43 },
  { 2497, 28, 44, 37, 5, -43 },
  { 2651, 28, 43, 37, 4, -43 },
  { 2802, 29, 45, 37, 4, -44 },
  { 2966, 28, 44, 37, 5, -44 },
  { 3120, 7, 33, 37, 15, -33 },
  { 3149, 10, 42, 37, 13, -33 },
  { 3202, 27, 35, 37, 5, -36 },
  { 3321, 29, 14, 37, 4, -26 },
  { 3372, 27, 35, 37, 5, -36 },
  { 3491, 26, 44, 37, 5, -44 },
  { 3634, 27, 51, 37, 5, -44 },
  { 3807, 33, 43, 37, 2, -43 },
  { 3985, 27, 43, 37, 6, -43 },
  { 4131, 28, 45, 37, 5, -44 },
  { 4289, 27, 43, 37, 6, -43 },
  { 4435, 26, 43, 37, 6, -43 },
  { 4575, 27, 43, 37, 6, -43 },
  { 4721, 28, 45, 37, 4, -44 },
  { 4879, 27, 43, 37, 5, -43 },
  { 5025, 27, 43, 37, 5, -43 },
  { 5171, 24, 44, 37, 5, -43 },
  { 5303, 29, 43, 37, 6, -43 },
  { 5459, 25, 43, 37, 8, -43 },
  { 5594, 28, 43, 37, 5, -43 },
  { 5745, 27, 43, 37, 5, -43 },
  { 5891, 29, 45, 37, 4, -44 },
  { 6055, 27, 43, 37, 6, -43 },
  { 6201, 29, 54, 37, 4, -44 },
  { 6397, 27, 43, 37, 6, -43 },
  { 6543, 30, 45, 37, 3, -44 },
  { 6712, 33, 43, 37, 2, -43 },
  { 6890, 27, 44, 37, 5, -43 },
  { 7039, 32, 43, 37, 3, -43 },
  { 7211, 31, 43, 37, 3, -43 },
  { 7378, 33, 43, 37, 2, -43 },
  { 7556, 35, 43, 37, 1, -43 },
  { 7745, 31, 43, 37, 3, -43 },
  { 7912, 16, 56, 37, 15, -47 },
  { 8024, 25, 56, 37, 6, -47 },
  { 8199, 16, 56, 37, 6, -47 },
  { 8311, 31, 25, 37, 3, -43 },
  { 8408, 29, 3, 37, 4, 7 },
  { 8419, 9, 11, 37, 12, -48 },
  { 8432, 30, 34, 37, 4, -33 },
  { 8560, 26, 47, 37, 7, -46 },
  { 8713, 26, 34, 37, 6, -33 },
  { 8824, 27, 47, 37, 4, -46 },
  { 8983, 27, 34, 37, 5, -33 },
  { 9098, 28, 46, 37, 5, -46 },
  { 9259, 29, 49, 37, 5, -36 },
  { 9437, 24, 46, 37, 7, -46 },
  { 9575, 27, 47, 37, 7, -47 },
  { 9734, 22, 59, 37, 6, -47 },
  { 9897, 28, 46, 37, 7, -46 },
  { 10058, 27, 46, 37, 5, -46 },
  { 10214, 29, 33, 37, 4, -33 },
  { 10334, 24, 33, 37, 7, -33 },
  { 10433, 28, 34, 37, 5, -33 },
  { 10552, 26, 45, 37, 7, -33 },
  { 10699, 27, 45, 37, 4, -33 },
  { 10851, 30, 32, 37, 5, -32 },
  { 10971, 27, 34, 37, 5, -33 },
  { 11086, 30, 43, 37, 2, -43 },
  { 11248, 24, 33, 37, 6, -32 },
  { 11347, 28, 32, 37, 5, -32 },
  { 11459, 33, 32, 37, 2, -32 },
  { 11591, 29, 32, 37, 4, -32 },
  { 11707, 29, 44, 37, 4, -32 },
  { 11867, 26, 32, 37, 6, -32 },
  { 11971, 23, 56, 37, 7, -47 },
  { 12132, 3, 56, 37, 17, -47 },
  { 12153, 23, 56, 37, 7, -47 },
  { 12314, 31, 12, 37, 3, -25 },
};

const GFXfont IBMPlexMono_Light62pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light62pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light62pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _IBMPLEXMONO_LIGHT62PT7B_H_
