#ifndef _IBMPLEXMONO_LIGHT40PT7B_H_
#define _IBMPLEXMONO_LIGHT40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light40pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x70, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60,
  0x01, 0x83, 0x81, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xC0, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80, 0x03, 0x06,
  0x03, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x81, 0xC1, 0x80, 0x06, 0x0E, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1E, 0x63,
  0xC3, 0x86, 0x0E, 0x30, 0x60, 0x67, 0x06, 0x04, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x38, 0x60, 0x03, 0xC6, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x06, 0x3C, 0x00, 0x60, 0xE0,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07,
  0x60, 0x60, 0x6E, 0x06, 0x0E, 0x78, 0x60, 0xE3, 0xE6, 0x3C, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x1F, 0x00, 0x0C, 0xFF, 0x00, 0x67, 0x0E, 0x01, 0x98, 0x18, 0x0C,
  0xC0, 0x60, 0x33, 0x00, 0x81, 0x8C, 0x03, 0x0E, 0x30, 0x0C, 0x30, 0xC0,
  0x31, 0x83, 0x01, 0x86, 0x06, 0x06, 0x30, 0x1C, 0x38, 0xC0, 0x3F, 0xC4,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x03, 0x9C, 0x38,
  0x0C, 0x60, 0x60, 0x61, 0x80, 0xC1, 0x8C, 0x03, 0x0C, 0x30, 0x0C, 0x70,
  0xC0, 0x31, 0x83, 0x00, 0xCC, 0x06, 0x03, 0x30, 0x18, 0x19, 0x80, 0x70,
  0xE6, 0x00, 0xFF, 0x30, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x03,
  0x83, 0x80, 0x18, 0x0E, 0x01, 0xC0, 0x20, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x7C, 0x77, 0x03, 0xE7, 0x1C, 0x18,
  0x70, 0x70, 0xC3, 0x01, 0xC6, 0x38, 0x06, 0x31, 0xC0, 0x39, 0x0E, 0x00,
  0xF8, 0x70, 0x03, 0xC3, 0x80, 0x0E, 0x0C, 0x00, 0x78, 0x70, 0x04, 0xE1,
  0xE0, 0xE3, 0x07, 0xFE, 0x1C, 0x0F, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0x01,
  0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x60, 0x1F, 0x06,
  0x0F, 0xFE, 0x67, 0xF1, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x19, 0x80, 0x03, 0x0C, 0x00, 0x70, 0xE0, 0x0E, 0x07, 0x00,
  0xC0, 0x30, 0x18, 0x01, 0x80, 0x80, 0x10, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x3D, 0xE7, 0x9C,
  0x71, 0xCE, 0x38, 0xC3, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3,
  0x00, 0x0C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0xE0, 0x6E, 0x0F, 0x07, 0xE0, 0xF0,
  0x76, 0x0F, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x1C,
  0x03, 0x80, 0xE0, 0x70, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x01, 0xC6, 0x00, 0x70, 0xC0, 0x1C,
  0x18, 0x07, 0x03, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x01, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xC1, 0xE1, 0xC0,
  0x1C, 0x60, 0x03, 0x38, 0x00, 0xEC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xE0, 0xF0, 0xE0, 0x0E, 0x70, 0x01, 0x88, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x1F, 0x80,
  0x07, 0x70, 0x03, 0x8F, 0x03, 0xC1, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x03, 0xB0, 0x00, 0x33, 0x00, 0x06,
  0x30, 0x00, 0xE3, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00, 0x38, 0x30, 0x03,
  0x03, 0x00, 0x60, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03,
  0x80, 0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x8F, 0xE0, 0x67,
  0xFE, 0x1B, 0x03, 0xC7, 0x00, 0x38, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x74, 0x00, 0x1B,
  0x80, 0x0E, 0x70, 0x07, 0x0F, 0x03, 0xC1, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x87, 0xE0, 0x67, 0xFE, 0x3B, 0x03, 0xCF, 0x00, 0x3B, 0x80, 0x06, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x76, 0x00, 0x1D, 0x80, 0x06, 0x30, 0x03, 0x0F, 0x03, 0xC0, 0xFF, 0xC0,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x06, 0xC0,
  0x03, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1E, 0x07,
  0x83, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x70, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE6,
  0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x76, 0x00, 0x06,
  0x60, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xE0, 0x78, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xC0, 0xF0, 0xC0, 0x0C,
  0x70, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0xDC, 0x00, 0xB3, 0xC0,
  0xDC, 0x7F, 0xE6, 0x07, 0xF1, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xE7, 0x9C, 0x71, 0xCE, 0x38, 0xC3,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x0F,
  0x03, 0xC7, 0x00, 0xE7, 0x00, 0x3B, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0x03, 0x87, 0x00, 0xE3, 0x00, 0x3B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x79, 0xE0, 0x7E, 0xF0, 0x70, 0xF8, 0x70, 0x3C, 0x30, 0x1E, 0x18,
  0x0F, 0x0C, 0x07, 0x86, 0x03, 0xC3, 0x01, 0xE1, 0x80, 0xF0, 0xC0, 0x78,
  0x60, 0x3C, 0x30, 0x1E, 0x0C, 0x1F, 0x07, 0xFE, 0xC1, 0xFB, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x9C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x70, 0xE0, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x07, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00,
  0xE6, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x30, 0x07, 0x98, 0x00, 0xCC, 0x00, 0x76,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01,
  0xD8, 0x00, 0xCC, 0x01, 0xC7, 0xFF, 0xC3, 0xFF, 0xF1, 0x80, 0x1C, 0xC0,
  0x03, 0x60, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x07, 0xBF, 0xFF, 0x9F, 0xFF,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0x70, 0xE0, 0x0E, 0x30, 0x01,
  0xDC, 0x00, 0x36, 0x00, 0x09, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x27, 0x00, 0x0C, 0xC0, 0x07, 0x38, 0x03, 0x87, 0x81, 0xC0,
  0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0C, 0x03, 0xC3, 0x00,
  0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0E, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x0E,
  0x30, 0x0F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0xFB, 0xFF, 0xFD, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0xFB, 0xFF, 0xFD, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01,
  0xE0, 0xF0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x17, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0xC0,
  0x0F, 0x38, 0x07, 0xC7, 0x03, 0x70, 0xFF, 0x9C, 0x0F, 0xC7, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0,
  0xC0, 0x01, 0xD8, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0xE1,
  0x80, 0x38, 0x30, 0x0E, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x38, 0x03,
  0x06, 0x00, 0x61, 0xC0, 0x0C, 0x78, 0x01, 0x9F, 0x00, 0x37, 0x70, 0x07,
  0xC7, 0x00, 0xF0, 0x60, 0x1C, 0x0E, 0x03, 0x00, 0xE0, 0x60, 0x1C, 0x0C,
  0x01, 0xC1, 0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x38, 0xC0, 0x03, 0x18,
  0x00, 0x73, 0x00, 0x07, 0x60, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xD8, 0x06, 0xF6, 0x01, 0xBC, 0xC0, 0xEF, 0x30, 0x33, 0xCE, 0x1C, 0xF1,
  0x86, 0x3C, 0x61, 0x8F, 0x0C, 0xC3, 0xC3, 0x30, 0xF0, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x08, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFB, 0x00, 0x7E, 0xE0, 0x1F, 0x98, 0x07,
  0xE7, 0x01, 0xF8, 0xC0, 0x7E, 0x38, 0x1F, 0x86, 0x07, 0xE1, 0xC1, 0xF8,
  0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x87, 0xE0, 0x61, 0xF8, 0x1C, 0x7E, 0x03,
  0x1F, 0x80, 0xE7, 0xE0, 0x19, 0xF8, 0x07, 0x7E, 0x00, 0xDF, 0x80, 0x3F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x80,
  0xE0, 0x70, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0x30,
  0x03, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x36, 0x00,
  0x7B, 0xFF, 0xF9, 0xFF, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x0E, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x70,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8C, 0x00, 0xF3, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0,
  0x03, 0x30, 0x03, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xC0, 0xC0, 0x30, 0x38,
  0x0C, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01, 0xC3,
  0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xCC, 0x00, 0x3B, 0x00, 0x07, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x1F, 0x1C, 0x00, 0xF7, 0x00, 0x06, 0xE0,
  0x01, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xD0, 0x00, 0x1F, 0x00, 0x07, 0x78, 0x01, 0xC7, 0xC0,
  0xF8, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03, 0x0F, 0x03, 0xC1, 0xFF, 0xE0,
  0x1F, 0xE0, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x01,
  0xC1, 0x80, 0x18, 0x18, 0x01, 0x81, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x06, 0x06, 0x00, 0x70, 0x60, 0x07,
  0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x39, 0xC0, 0x01, 0x98, 0x00,
  0x19, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x70, 0x76, 0x0F,
  0x06, 0x60, 0xF0, 0x66, 0x0F, 0x06, 0x60, 0xD8, 0x66, 0x19, 0x86, 0x61,
  0x98, 0x66, 0x19, 0x86, 0x61, 0x9C, 0x66, 0x30, 0xC6, 0x63, 0x0C, 0x67,
  0x30, 0xC6, 0x33, 0x0E, 0xC3, 0x60, 0x6C, 0x36, 0x06, 0xC3, 0x60, 0x6C,
  0x36, 0x07, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x0C, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x87, 0x00, 0x07,
  0x18, 0x00, 0x0C, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x38, 0x00,
  0x18, 0x70, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x80, 0x18, 0x06, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x38, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC7, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x67, 0x00, 0x03, 0x8E,
  0x00, 0x1C, 0x18, 0x00, 0x60, 0x70, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x80,
  0x70, 0x07, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x70, 0x00, 0x61, 0x80,
  0x01, 0xCE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x19, 0x80, 0x03, 0x1C,
  0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0xE0, 0x70, 0x0C, 0x03, 0x01, 0xC0,
  0x38, 0x18, 0x01, 0x83, 0x00, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0xE0,
  0x00, 0x74, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x86, 0x0C,
  0x38, 0x60, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x01, 0xE0, 0x70, 0x30, 0x07,
  0x04, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3C, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E,
  0x30, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x1C, 0x01, 0xE1, 0xC0, 0xCC,
  0x1F, 0xF9, 0xF0, 0xFC, 0x3E, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x71, 0xF8, 0x3B, 0xFF, 0x1F, 0x83, 0xCF, 0x00, 0x77, 0x00, 0x1B, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xBC, 0x01, 0xDF, 0x83, 0xCE, 0xFF, 0xC7, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xFC, 0x3C, 0x1E, 0x30, 0x07, 0x60, 0x03, 0x60, 0x04, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x02, 0x60, 0x03, 0x30, 0x07, 0x3C, 0x1E, 0x1F,
  0xFC, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x83, 0xF1,
  0xC7, 0xFE, 0xE7, 0x83, 0xF7, 0x00, 0x7B, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x01,
  0xE7, 0x83, 0xF1, 0xFF, 0xB8, 0x3F, 0x1C, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xC0, 0xE0, 0xE0, 0x1C, 0x70, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x06, 0x70, 0x01, 0x8E, 0x00, 0xE1,
  0xC0, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x0F, 0xD8, 0x07, 0xFF, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x70, 0x03, 0x8E, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x83,
  0x80, 0x70, 0x38, 0x1C, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x8C,
  0x00, 0x73, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x77, 0x80, 0x3C, 0x7F, 0xFF, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE3, 0xF0, 0xE7, 0xFC, 0xEC, 0x1C, 0xF0, 0x0E, 0xE0,
  0x06, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xEF, 0xFF,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0xFF, 0xFB, 0xFF, 0xC0,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x01, 0xEC, 0x00,
  0xE3, 0x00, 0x70, 0xC0, 0x38, 0x30, 0x1C, 0x0C, 0x0E, 0x03, 0x07, 0x00,
  0xC3, 0x80, 0x31, 0xC0, 0x0D, 0xF8, 0x03, 0xE7, 0x00, 0xF0, 0xC0, 0x38,
  0x38, 0x0C, 0x07, 0x03, 0x00, 0xE0, 0xC0, 0x1C, 0x30, 0x07, 0x0C, 0x00,
  0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0x70, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x87, 0x8E, 0xFC, 0xFE, 0xF0, 0xD8, 0xEE,
  0x0F, 0x06, 0xE0, 0x60, 0x6E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07,
  0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60,
  0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06,
  0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x70, 0xE3, 0xF0, 0xE7,
  0xFC, 0xEC, 0x1C, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x1C,
  0x70, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1D, 0x80, 0x06, 0x70, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0xE0, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0xE3, 0xF0, 0x77, 0xFE, 0x3F, 0x07, 0x9E, 0x00, 0xEE,
  0x00, 0x37, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0x78, 0x03, 0xBF, 0x07, 0x9D, 0xFF, 0x8E, 0x3F, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE3, 0x8F, 0xFD, 0xCF, 0x07, 0xEE,
  0x00, 0xF6, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0x60, 0x03, 0xB8, 0x03, 0xCF, 0x07, 0xE3, 0xFF, 0x70,
  0x7E, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0xFF, 0x87, 0xFF, 0xF3, 0xFC,
  0x06, 0xC0, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xC0, 0xF0, 0xC0, 0x0E, 0x70, 0x01, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x40, 0x01, 0xFC,
  0x00, 0x63, 0xC0, 0x78, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0x60, 0x07, 0x70, 0x0F, 0x78, 0x37, 0x3F, 0xF7, 0x0F, 0xC7, 0xC0, 0x00,
  0xD8, 0x00, 0x66, 0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC3,
  0x80, 0x70, 0x60, 0x18, 0x18, 0x06, 0x07, 0x03, 0x80, 0xC0, 0xC0, 0x30,
  0x30, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x30,
  0x0D, 0x81, 0xE0, 0x66, 0x07, 0x81, 0x98, 0x1E, 0x06, 0x60, 0x48, 0x19,
  0x81, 0x30, 0x66, 0x0C, 0xC1, 0x8C, 0x33, 0x04, 0x30, 0xCC, 0x30, 0xC2,
  0x10, 0xC3, 0x18, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x30, 0x44, 0x08,
  0x81, 0x90, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81,
  0xA0, 0x16, 0x03, 0x80, 0x78, 0x0E, 0x01, 0xC0, 0xE0, 0x01, 0xDC, 0x00,
  0xE3, 0x80, 0x30, 0x60, 0x18, 0x1C, 0x0E, 0x03, 0x87, 0x00, 0x71, 0x80,
  0x0C, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x01, 0xCE, 0x00, 0x61, 0x80, 0x38, 0x70, 0x1C, 0x0E, 0x0E, 0x01,
  0xC3, 0x00, 0x31, 0xC0, 0x0E, 0xE0, 0x01, 0xC0, 0xC0, 0x00, 0xF8, 0x00,
  0x36, 0x00, 0x19, 0x80, 0x06, 0x70, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x30,
  0x60, 0x18, 0x18, 0x06, 0x07, 0x03, 0x80, 0xC0, 0xC0, 0x38, 0x30, 0x06,
  0x18, 0x01, 0x86, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x01, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0x00, 0x31, 0xF8, 0x03, 0x31, 0xC0,
  0x66, 0x0E, 0x06, 0x60, 0x70, 0x66, 0x03, 0x8C, 0xC0, 0x1F, 0x8C, 0x00,
  0xF0,
};

const GFXglyph IBMPlexMono_Light40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 4, 28, 24, 10, -28 },
  { 15, 8, 11, 24, 8, -30 },
  { 26, 22, 28, 24, 1, -28 },
  { 103, 20, 36, 24, 2, -32 },
  { 193, 22, 28, 24, 1, -28 },
  { 270, 21, 28, 24, 1, -28 },
  { 344, 2, 11, 24, 11, -30 },
  { 347, 10, 36, 24, 9, -30 },
  { 392, 10, 36, 24, 5, -30 },
  { 437, 20, 20, 24, 2, -22 },
  { 487, 20, 20, 24, 2, -22 },
  { 537, 6, 11, 24, 9, -5 },
  { 546, 12, 2, 24, 6, -13 },
  { 549, 4, 4, 24, 10, -4 },
  { 551, 16, 36, 24, 4, -30 },
  { 623, 20, 28, 24, 2, -28 },
  { 693, 19, 28, 24, 3, -28 },
  { 760, 18, 28, 24, 3, -28 },
  { 823, 18, 28, 24, 2, -28 },
  { 886, 20, 28, 24, 2, -28 },
  { 956, 18, 28, 24, 3, -28 },
  { 1019, 18, 28, 24, 3, -28 },
  { 1082, 18, 28, 24, 3, -28 },
  { 1145, 20, 28, 24, 2, -28 },
  { 1215, 18, 28, 24, 3, -28 },
  { 1278, 4, 21, 24, 10, -21 },
  { 1289, 6, 27, 24, 9, -21 },
  { 1310, 18, 22, 24, 3, -23 },
  { 1360, 20, 10, 24, 2, -17 },
  { 1385, 18, 22, 24, 3, -23 },
  { 1435, 17, 28, 24, 3, -28 },
  { 1495, 17, 32, 24, 3, -28 },
  { 1563, 20, 28, 24, 2, -28 },
  { 1633, 17, 28, 24, 4, -28 },
  { 1693, 18, 28, 24, 3, -28 },
  { 1756, 18, 28, 24, 4, -28 },
  { 1819, 17, 28, 24, 4, -28 },
  { 1879, 17, 28, 24, 4, -28 },
  { 1939, 18, 28, 24, 3, -28 },
  { 2002, 18, 28, 24, 3, -28 },
  { 2065, 18, 28, 24, 3, -28 },
  { 2128, 16, 28, 24, 3, -28 },
  { 2184, 19, 28, 24, 4, -28 },
  { 2251, 16, 28, 24, 5, -28 },
  { 2307, 18, 28, 24, 3, -28 },
  { 2370, 18, 28, 24, 3, -28 },
  { 2433, 20, 28, 24, 2, -28 },
  { 2503, 17, 28, 24, 4, -28 },
  { 2563, 20, 34, 24, 2, -28 },
  { 2648, 18, 28, 24, 4, -28 },
  { 2711, 19, 28, 24, 2, -28 },
  { 2778, 22, 28, 24, 1, -28 },
  { 2855, 18, 28, 24, 3, -28 },
  { 2918, 20, 28, 24, 2, -28 },
  { 2988, 20, 28, 24, 2, -28 },
  { 3058, 22, 28, 24, 1, -28 },
  { 3135, 22, 28, 24, 1, -28 },
  { 3212, 20, 28, 24, 2, -28 },
  { 3282, 10, 36, 24, 10, -30 },
  { 3327, 16, 36, 24, 4, -30 },
  { 3399, 10, 36, 24, 4, -30 },
  { 3444, 20, 16, 24, 2, -28 },
  { 3484, 20, 2, 24, 2, 4 },
  { 3489, 6, 7, 24, 8, -31 },
  { 3495, 19, 21, 24, 3, -21 },
  { 3545, 17, 30, 24, 4, -30 },
  { 3609, 16, 21, 24, 4, -21 },
  { 3651, 17, 30, 24, 3, -30 },
  { 3715, 18, 21, 24, 3, -21 },
  { 3763, 19, 30, 24, 3, -30 },
  { 3835, 19, 31, 24, 3, -23 },
  { 3909, 16, 30, 24, 4, -30 },
  { 3969, 18, 30, 24, 4, -30 },
  { 4037, 14, 38, 24, 4, -30 },
  { 4104, 18, 30, 24, 5, -30 },
  { 4172, 18, 30, 24, 3, -30 },
  { 4240, 20, 21, 24, 2, -21 },
  { 4293, 16, 21, 24, 4, -21 },
  { 4335, 18, 21, 24, 3, -21 },
  { 4383, 17, 29, 24, 4, -21 },
  { 4445, 17, 29, 24, 3, -21 },
  { 4507, 19, 21, 24, 3, -21 },
  { 4557, 18, 21, 24, 3, -21 },
  { 4605, 19, 28, 24, 2, -28 },
  { 4672, 16, 21, 24, 4, -21 },
  { 4714, 18, 21, 24, 3, -21 },
  { 4762, 22, 21, 24, 1, -21 },
  { 4820, 18, 21, 24, 3, -21 },
  { 4868, 18, 29, 24, 3, -21 },
  { 4934, 16, 21, 24, 4, -21 },
  { 4976, 16, 36, 24, 4, -30 },
  { 5048, 2, 36, 24, 11, -30 },
  { 5057, 16, 36, 24, 4, -30 },
  { 5129, 20, 8, 24, 2, -16 },
};

const GFXfont IBMPlexMono_Light40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_LIGHT40PT7B_H_
