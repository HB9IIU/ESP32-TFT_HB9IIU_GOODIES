#ifndef _IBMPLEXMONO_LIGHT17PT7B_H_
#define _IBMPLEXMONO_LIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light17pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x6A, 0x0F, 0x99, 0x99, 0x90, 0x09, 0x02, 0x40, 0x90, 0x44,
  0x73, 0xC4, 0x81, 0x23, 0xCE, 0x12, 0x09, 0x02, 0x40, 0x90, 0x08, 0x08,
  0x3E, 0x4B, 0x8A, 0x88, 0x48, 0x78, 0x0E, 0x09, 0x09, 0x89, 0xCB, 0x3E,
  0x08, 0x08, 0x70, 0x52, 0x28, 0x92, 0x24, 0x4A, 0x1C, 0x00, 0x38, 0x51,
  0x24, 0x49, 0x14, 0x47, 0x0E, 0x38, 0x22, 0x10, 0x08, 0x04, 0x01, 0x1B,
  0x49, 0x14, 0x8E, 0x43, 0x21, 0x8F, 0x30, 0xF8, 0x12, 0x48, 0x88, 0x88,
  0x88, 0x88, 0x42, 0x10, 0xC1, 0x08, 0x21, 0x08, 0x41, 0x10, 0x84, 0x22,
  0x13, 0x00, 0x08, 0x08, 0x08, 0xCB, 0x3C, 0x18, 0x24, 0x42, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08, 0xFA, 0x80, 0xF0, 0xF0, 0x06,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x00, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x99, 0x99, 0x81, 0x81, 0x41, 0x42,
  0x3C, 0x18, 0x28, 0x48, 0x88, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x7F, 0x3C, 0x42, 0x82, 0x03, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFF, 0x3C, 0x42, 0x82, 0x02, 0x02, 0x3C, 0x06, 0x02, 0x01, 0x83, 0xC2,
  0x3C, 0x06, 0x0A, 0x12, 0x12, 0x22, 0x42, 0x42, 0x82, 0xFF, 0x02, 0x02,
  0x02, 0x7E, 0x40, 0x40, 0x40, 0x7C, 0x42, 0x01, 0x01, 0x01, 0x81, 0x42,
  0x3C, 0x0C, 0x10, 0x20, 0x40, 0x5C, 0xE2, 0xC1, 0x81, 0x81, 0x41, 0x42,
  0x3C, 0xFF, 0x81, 0x82, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x3C, 0x42, 0xC1, 0x81, 0x42, 0x3C, 0x62, 0x81, 0x81, 0x81, 0x43,
  0x3C, 0x3C, 0x42, 0x41, 0x81, 0x81, 0xC1, 0x43, 0x3E, 0x02, 0x04, 0x08,
  0x30, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xEA, 0x01, 0x06, 0x08, 0x30, 0xC0,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x03, 0x0C, 0x18, 0x60, 0x80, 0x3C, 0x42, 0x43, 0x81, 0x02,
  0x1C, 0x10, 0x10, 0x00, 0x00, 0x18, 0x18, 0x3C, 0x62, 0x41, 0x8D, 0x93,
  0x91, 0x91, 0x91, 0x91, 0x9F, 0x80, 0x40, 0x60, 0x3E, 0x18, 0x0C, 0x05,
  0x04, 0x82, 0x41, 0x11, 0x08, 0xFC, 0x42, 0x40, 0xA0, 0x50, 0x30, 0xF9,
  0x0A, 0x1C, 0x38, 0x5F, 0x21, 0xC1, 0x83, 0x06, 0x1F, 0xE0, 0x3C, 0x62,
  0x41, 0x40, 0x80, 0x80, 0x80, 0x80, 0x40, 0x41, 0x62, 0x3C, 0xF9, 0x0A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x17, 0xC0, 0xFF, 0x02, 0x04,
  0x08, 0x1F, 0xE0, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08,
  0x1F, 0xA0, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3C, 0x62, 0x41, 0x80, 0x80,
  0x80, 0x8F, 0x81, 0x81, 0x41, 0x43, 0x3D, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFF, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x3E, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x03, 0x05, 0x19, 0xE0, 0x83, 0x84, 0x88, 0x98, 0xB0, 0xB0,
  0xD0, 0x88, 0x88, 0x84, 0x86, 0x83, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x07, 0xF0, 0xC3, 0xC3, 0xA3, 0xA5, 0xA5, 0x99, 0x99,
  0x89, 0x91, 0x81, 0x81, 0x81, 0xC1, 0xA1, 0xA1, 0xA1, 0x91, 0x91, 0x89,
  0x89, 0x85, 0x85, 0x83, 0x83, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x42, 0x3C, 0xFD, 0x0E, 0x0C, 0x18, 0x30, 0xFF, 0x40,
  0x81, 0x02, 0x04, 0x00, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x42, 0x3C, 0x08, 0x08, 0x0E, 0xFD, 0x0E, 0x0C, 0x18, 0x30,
  0xFF, 0x48, 0x89, 0x1A, 0x14, 0x10, 0x3C, 0x43, 0x82, 0x80, 0x40, 0x78,
  0x06, 0x01, 0x01, 0x81, 0xC3, 0x3C, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x43, 0x42, 0x3C, 0x81, 0x81, 0xC1, 0x42,
  0x42, 0x42, 0x24, 0x24, 0x24, 0x14, 0x18, 0x18, 0x81, 0x81, 0x81, 0x99,
  0x99, 0x99, 0x95, 0xA5, 0xA5, 0xA5, 0x65, 0x42, 0x81, 0x21, 0x98, 0x84,
  0x81, 0x40, 0xC0, 0x60, 0x68, 0x24, 0x21, 0x10, 0x50, 0x30, 0xC0, 0xD0,
  0x22, 0x10, 0xC4, 0x12, 0x03, 0x80, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0xFF, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80,
  0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x81,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x81,
  0x80, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x18, 0x24,
  0x22, 0x42, 0x81, 0x81, 0xFF, 0xC8, 0x80, 0x3C, 0x46, 0x82, 0x02, 0x7E,
  0xC2, 0x82, 0xC6, 0x7B, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83,
  0x06, 0x0E, 0x2B, 0x80, 0x79, 0x8A, 0x1C, 0x08, 0x10, 0x21, 0x63, 0x78,
  0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1, 0x83, 0x06, 0x0A, 0x13, 0xE0,
  0x3C, 0x42, 0x41, 0x81, 0xFF, 0x80, 0x40, 0x43, 0x3E, 0x0F, 0x08, 0x08,
  0x08, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x03, 0x3C,
  0x42, 0x42, 0x42, 0x42, 0x3C, 0x40, 0x40, 0x7F, 0x81, 0xC1, 0x7E, 0x82,
  0x08, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x10, 0x30, 0x00,
  0x0F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x0C, 0x30, 0x00,
  0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xBE, 0x80, 0x80, 0x80,
  0x80, 0x86, 0x8C, 0x98, 0xA0, 0xD0, 0x88, 0x84, 0x86, 0x83, 0xF8, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0xB7,
  0xD9, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xBB, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C,
  0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xE2, 0xB9, 0x02, 0x04, 0x00, 0x3A,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xA1, 0x3E, 0x04, 0x08, 0x10, 0xF7, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x3C, 0x43, 0x40, 0x40, 0x3E,
  0x03, 0x01, 0xC3, 0x3E, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x1F, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x81,
  0x42, 0x42, 0x42, 0x24, 0x24, 0x14, 0x18, 0x18, 0x98, 0xCC, 0xA6, 0x53,
  0x2A, 0x55, 0x2A, 0x94, 0xCC, 0x42, 0x00, 0xC3, 0x62, 0x24, 0x18, 0x08,
  0x18, 0x24, 0x42, 0xC3, 0x81, 0x42, 0x42, 0x22, 0x24, 0x24, 0x18, 0x18,
  0x08, 0x10, 0x10, 0xE0, 0xFC, 0x08, 0x20, 0x83, 0x04, 0x10, 0x40, 0xFE,
  0x3C, 0x82, 0x08, 0x10, 0x41, 0xB8, 0x10, 0x61, 0x08, 0x20, 0x83, 0xC0,
  0xFF, 0xFE, 0xF0, 0x41, 0x04, 0x20, 0x82, 0x07, 0x30, 0x82, 0x04, 0x10,
  0x4F, 0x00, 0x61, 0x91, 0x89, 0x86,
};

const GFXglyph IBMPlexMono_Light17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -13 },
  { 7, 10, 12, 10, 0, -12 },
  { 22, 8, 16, 10, 1, -14 },
  { 38, 10, 12, 10, 0, -12 },
  { 53, 9, 12, 10, 1, -12 },
  { 67, 1, 5, 10, 5, -13 },
  { 68, 4, 15, 10, 4, -13 },
  { 76, 5, 15, 10, 2, -13 },
  { 86, 8, 8, 10, 1, -9 },
  { 94, 8, 9, 10, 1, -10 },
  { 103, 2, 5, 10, 4, -2 },
  { 105, 4, 1, 10, 3, -6 },
  { 106, 2, 2, 10, 4, -2 },
  { 107, 7, 15, 10, 2, -13 },
  { 121, 8, 12, 10, 1, -12 },
  { 133, 8, 12, 10, 1, -12 },
  { 145, 8, 12, 10, 1, -12 },
  { 157, 8, 12, 10, 1, -12 },
  { 169, 8, 12, 10, 1, -12 },
  { 181, 8, 12, 10, 1, -12 },
  { 193, 8, 12, 10, 1, -12 },
  { 205, 8, 12, 10, 1, -12 },
  { 217, 8, 12, 10, 1, -12 },
  { 229, 8, 12, 10, 1, -12 },
  { 241, 2, 9, 10, 4, -9 },
  { 244, 2, 12, 10, 4, -9 },
  { 247, 8, 10, 10, 1, -10 },
  { 257, 8, 4, 10, 1, -7 },
  { 261, 8, 10, 10, 1, -10 },
  { 271, 8, 12, 10, 1, -12 },
  { 283, 8, 14, 10, 1, -12 },
  { 297, 9, 12, 10, 1, -12 },
  { 311, 7, 12, 10, 2, -12 },
  { 322, 8, 12, 10, 1, -12 },
  { 334, 7, 12, 10, 2, -12 },
  { 345, 7, 12, 10, 2, -12 },
  { 356, 7, 12, 10, 2, -12 },
  { 367, 8, 12, 10, 1, -12 },
  { 379, 8, 12, 10, 1, -12 },
  { 391, 8, 12, 10, 1, -12 },
  { 403, 7, 12, 10, 1, -12 },
  { 414, 8, 12, 10, 2, -12 },
  { 426, 7, 12, 10, 2, -12 },
  { 437, 8, 12, 10, 1, -12 },
  { 449, 8, 12, 10, 1, -12 },
  { 461, 8, 12, 10, 1, -12 },
  { 473, 7, 12, 10, 2, -12 },
  { 484, 8, 15, 10, 1, -12 },
  { 499, 7, 12, 10, 2, -12 },
  { 510, 8, 12, 10, 1, -12 },
  { 522, 9, 12, 10, 1, -12 },
  { 536, 8, 12, 10, 1, -12 },
  { 548, 8, 12, 10, 1, -12 },
  { 560, 8, 12, 10, 1, -12 },
  { 572, 9, 12, 10, 1, -12 },
  { 586, 10, 12, 10, 0, -12 },
  { 601, 8, 12, 10, 1, -12 },
  { 613, 5, 15, 10, 4, -13 },
  { 623, 7, 15, 10, 2, -13 },
  { 637, 4, 15, 10, 2, -13 },
  { 645, 8, 7, 10, 1, -12 },
  { 652, 8, 1, 10, 1, 2 },
  { 653, 3, 3, 10, 3, -13 },
  { 655, 8, 9, 10, 1, -9 },
  { 664, 7, 13, 10, 2, -13 },
  { 676, 7, 9, 10, 2, -9 },
  { 684, 7, 13, 10, 1, -13 },
  { 696, 8, 9, 10, 1, -9 },
  { 705, 8, 13, 10, 1, -13 },
  { 718, 8, 13, 10, 1, -10 },
  { 731, 6, 13, 10, 2, -13 },
  { 741, 7, 13, 10, 2, -13 },
  { 753, 6, 16, 10, 2, -13 },
  { 765, 8, 13, 10, 2, -13 },
  { 778, 8, 13, 10, 1, -13 },
  { 791, 8, 9, 10, 1, -9 },
  { 800, 6, 9, 10, 2, -9 },
  { 807, 8, 9, 10, 1, -9 },
  { 816, 7, 12, 10, 2, -9 },
  { 827, 7, 12, 10, 1, -9 },
  { 838, 8, 9, 10, 1, -9 },
  { 847, 8, 9, 10, 1, -9 },
  { 856, 8, 12, 10, 1, -12 },
  { 868, 6, 9, 10, 2, -9 },
  { 875, 8, 9, 10, 1, -9 },
  { 884, 9, 9, 10, 1, -9 },
  { 895, 8, 9, 10, 1, -9 },
  { 904, 8, 12, 10, 1, -9 },
  { 916, 7, 9, 10, 2, -9 },
  { 924, 6, 15, 10, 2, -13 },
  { 936, 1, 15, 10, 5, -13 },
  { 938, 6, 15, 10, 2, -13 },
  { 950, 8, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Light17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_LIGHT17PT7B_H_
