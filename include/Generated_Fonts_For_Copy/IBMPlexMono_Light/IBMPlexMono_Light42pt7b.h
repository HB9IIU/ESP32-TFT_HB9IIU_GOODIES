#ifndef _IBMPLEXMONO_LIGHT42PT7B_H_
#define _IBMPLEXMONO_LIGHT42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light42pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0x84, 0x21,
  0x08, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x00, 0x70, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00,
  0x1C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0xFF,
  0x83, 0xFD, 0xFF, 0x07, 0xF8, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x70, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x06,
  0x03, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xE0, 0x30, 0x70, 0x00, 0xE0, 0xC0,
  0x01, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00,
  0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0x07, 0xFF,
  0xC0, 0x78, 0xCF, 0x87, 0x06, 0x1E, 0x30, 0x30, 0x3B, 0x81, 0x81, 0x1C,
  0x0C, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x18, 0x18, 0x00, 0xE0, 0xC0,
  0x07, 0x86, 0x00, 0x1F, 0x30, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xC0, 0xC0, 0x06, 0x07,
  0x00, 0x30, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x0E, 0xC0, 0x60, 0x6F, 0x03,
  0x07, 0x3C, 0x18, 0x78, 0x78, 0xCF, 0x81, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x80, 0x06, 0x7F, 0x80, 0x19, 0xC3, 0x80, 0x33, 0x03, 0x80, 0xCC, 0x03,
  0x01, 0x98, 0x06, 0x06, 0x30, 0x0C, 0x1C, 0x60, 0x18, 0x30, 0xC0, 0x30,
  0xE1, 0x80, 0x61, 0x81, 0x81, 0xC6, 0x03, 0x87, 0x0C, 0x03, 0xFC, 0x30,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x87, 0xF8,
  0x07, 0x1C, 0x38, 0x0C, 0x30, 0x30, 0x30, 0xC0, 0x30, 0x61, 0x80, 0x61,
  0x83, 0x00, 0xC3, 0x06, 0x01, 0x8C, 0x0C, 0x03, 0x38, 0x18, 0x06, 0x60,
  0x18, 0x19, 0xC0, 0x38, 0x73, 0x00, 0x3F, 0xCC, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x0C, 0x70, 0x3E, 0x30, 0x70, 0x60,
  0xE0, 0x70, 0xC1, 0x80, 0x61, 0x83, 0x00, 0xE3, 0x0E, 0x00, 0xEC, 0x1C,
  0x00, 0xF8, 0x38, 0x00, 0xF0, 0x30, 0x00, 0xE0, 0x70, 0x03, 0xE0, 0xE0,
  0x0C, 0xE0, 0xF0, 0x30, 0xC0, 0xFF, 0xC1, 0xC0, 0x7E, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18,
  0x07, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x06, 0x07, 0xFC,
  0x31, 0xF9, 0xFD, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x6E, 0x00, 0x06, 0x30, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x00, 0x30,
  0x1C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x80, 0x80, 0x08, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x3C, 0xF3, 0x8E, 0x79, 0xC7, 0x18, 0xE3, 0x8C, 0x00, 0xFF, 0xFF, 0xFC,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x0F, 0x03, 0x80, 0x38, 0x30,
  0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0xE0, 0x7C, 0x0F, 0x07,
  0xC0, 0xF0, 0x7C, 0x0E, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x60, 0x00, 0xC7, 0x00,
  0x0C, 0x30, 0x01, 0xC3, 0x80, 0x38, 0x1E, 0x0F, 0x00, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xB0, 0x00, 0xF3, 0x00,
  0x1E, 0x30, 0x03, 0xC3, 0x00, 0x70, 0x30, 0x0E, 0x03, 0x00, 0x40, 0x30,
  0x08, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xF0, 0x3C, 0x1C, 0x01,
  0xC7, 0x00, 0x19, 0xC0, 0x03, 0xB8, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x1C, 0x00, 0xE3, 0x00, 0x1C,
  0x20, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x19, 0x00, 0x07, 0xE0, 0x00, 0xEF,
  0x00, 0x38, 0xF0, 0x1E, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x37, 0x00, 0x03, 0xB8, 0x00, 0x19,
  0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x0C, 0x1C, 0x00,
  0xE0, 0xE0, 0x06, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0x70, 0x38, 0x03, 0x81, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0,
  0x07, 0x0C, 0x00, 0x38, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0xFE, 0x03, 0x7F, 0xF0, 0xF8, 0x0F, 0x1E,
  0x00, 0xE1, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3B, 0x00, 0x06, 0xE0,
  0x01, 0xCE, 0x00, 0x70, 0xF0, 0x3C, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0xFE, 0x06, 0x7F, 0xF0, 0xDC, 0x0F, 0x3E, 0x00, 0xF7, 0x80,
  0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x06, 0x70, 0x01, 0xC7, 0x00,
  0x70, 0x78, 0x1C, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00,
  0xE6, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x3C, 0x07,
  0x87, 0x80, 0x3C, 0x70, 0x01, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00,
  0x0E, 0x60, 0x00, 0xE6, 0x00, 0x0C, 0x70, 0x01, 0xC3, 0x80, 0x18, 0x1C,
  0x07, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xC0, 0x78, 0x70, 0x01, 0xCE,
  0x00, 0x0E, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xE7, 0x00, 0x1C, 0x3C, 0x07,
  0x81, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78,
  0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0xC0, 0x01, 0xB8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x76, 0x00,
  0x0E, 0xE0, 0x03, 0xCE, 0x00, 0xF9, 0xF0, 0x37, 0x0F, 0xFC, 0xC0, 0x7E,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1D, 0xFF, 0xFD, 0xC0, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x38, 0xE7, 0x9C,
  0x71, 0x8E, 0x38, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x03, 0xCE,
  0x00, 0xEE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x1F, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x78, 0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x06, 0x60, 0x3C, 0xCC, 0x1F, 0xDB, 0x87, 0x87, 0xF0, 0xC0, 0x7C,
  0x18, 0x0F, 0x87, 0x01, 0xF0, 0xC0, 0x3E, 0x18, 0x07, 0xC3, 0x00, 0xF8,
  0x60, 0x1F, 0x0C, 0x03, 0xE1, 0xC0, 0x7C, 0x38, 0x0F, 0x83, 0x01, 0xF0,
  0x70, 0x7F, 0x07, 0xFF, 0x60, 0x7E, 0xEC, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x36, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x70, 0x01, 0xC1,
  0xC0, 0x06, 0x03, 0x00, 0x18, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x38,
  0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x31, 0x80, 0x00, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xC0, 0x00, 0x1C,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8C, 0x00, 0xF3, 0x00, 0x1C, 0xC0, 0x03, 0xB0,
  0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00,
  0x3B, 0x00, 0x1C, 0xC0, 0x0E, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x00, 0x1C,
  0xC0, 0x03, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xEC, 0x00,
  0x73, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3C,
  0x1E, 0x0E, 0x00, 0xE3, 0x80, 0x0E, 0x60, 0x01, 0xDC, 0x00, 0x13, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x11, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x80, 0x38, 0x3C, 0x1E, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0x80, 0x78, 0x70, 0x03,
  0x8E, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x67, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03,
  0x70, 0x00, 0x6E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x67, 0x00, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x78, 0x7F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFB, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x1E, 0x1C, 0x01, 0xC3, 0x00, 0x1C,
  0xE0, 0x01, 0x98, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x80, 0x07, 0x30, 0x01, 0xE7,
  0x00, 0x7C, 0x78, 0x1B, 0x87, 0xFE, 0x70, 0x3F, 0x0E, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x80, 0x0F, 0xC0, 0x07,
  0x70, 0x07, 0x38, 0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xC0,
  0x00, 0xFC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x78, 0xC0, 0x07, 0x0C,
  0x00, 0xE0, 0xC0, 0x1C, 0x0C, 0x03, 0x80, 0xC0, 0x70, 0x0C, 0x0E, 0x00,
  0xC1, 0xC0, 0x0C, 0x1C, 0x00, 0xC3, 0x80, 0x0C, 0x7C, 0x00, 0xCE, 0xC0,
  0x0D, 0xCE, 0x00, 0xF8, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0x38, 0x0C, 0x01,
  0xC0, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xC0,
  0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0xF0,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xBD,
  0x80, 0x37, 0xB8, 0x0C, 0xF3, 0x01, 0x9E, 0x70, 0x33, 0xC6, 0x0C, 0x78,
  0xE1, 0x8F, 0x0C, 0x61, 0xE1, 0xCC, 0x3C, 0x1B, 0x07, 0x83, 0x60, 0xF0,
  0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x08, 0x0F, 0x01, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xD8, 0x01, 0xF7, 0x00,
  0x7C, 0xC0, 0x1F, 0x38, 0x07, 0xC6, 0x01, 0xF1, 0xC0, 0x7C, 0x70, 0x1F,
  0x0E, 0x07, 0xC3, 0x81, 0xF0, 0x60, 0x7C, 0x1C, 0x1F, 0x03, 0x07, 0xC0,
  0xE1, 0xF0, 0x18, 0x7C, 0x07, 0x1F, 0x00, 0xC7, 0xC0, 0x39, 0xF0, 0x06,
  0x7C, 0x01, 0xDF, 0x00, 0x77, 0xC0, 0x0D, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x0F,
  0x03, 0x80, 0x38, 0x30, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00,
  0x0E, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E,
  0x60, 0x00, 0xC7, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80, 0x38, 0x1E, 0x0F,
  0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0x80,
  0x1E, 0x70, 0x00, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00,
  0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0xEE, 0x00,
  0x19, 0xC0, 0x0F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x0F, 0x03, 0x80,
  0x38, 0x30, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0E, 0xE0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x60, 0x00,
  0xE7, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80, 0x38, 0x1E, 0x0F, 0x00, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0x80, 0x1E, 0x70, 0x00, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x37,
  0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0xEE,
  0x00, 0x19, 0xC0, 0x0F, 0x3F, 0xFF, 0xC7, 0xFF, 0xC0, 0xE0, 0xE0, 0x1C,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x01, 0x81, 0xC0, 0x38, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x63, 0x80, 0x0E, 0x70,
  0x00, 0xEE, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0x80, 0xF8,
  0x70, 0x01, 0xE3, 0x00, 0x07, 0x38, 0x00, 0x11, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xCC, 0x00, 0x06, 0xF0, 0x00, 0x73, 0xC0, 0x07,
  0x0F, 0x80, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6E, 0x00,
  0x1B, 0x80, 0x0E, 0x60, 0x03, 0x9C, 0x01, 0xC3, 0x80, 0xF0, 0x7F, 0xF8,
  0x07, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xE0,
  0x00, 0x67, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x87, 0x00, 0x0C,
  0x38, 0x00, 0xE0, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x38, 0x03, 0x80, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x00,
  0x38, 0x38, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xC7,
  0x00, 0x06, 0x30, 0x00, 0x39, 0x80, 0x01, 0xDC, 0x00, 0x06, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x70, 0x3B, 0x03, 0x81, 0xD8, 0x1E,
  0x0C, 0xC1, 0xB0, 0x66, 0x0D, 0x83, 0x30, 0x6C, 0x19, 0x83, 0x30, 0xCC,
  0x31, 0x86, 0x61, 0x8C, 0x33, 0x8C, 0x61, 0x9C, 0x61, 0x8C, 0x66, 0x0C,
  0x63, 0x30, 0x67, 0x19, 0x83, 0x30, 0xCC, 0x0D, 0x86, 0xC0, 0x6C, 0x36,
  0x03, 0x61, 0xB0, 0x1B, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x00, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xE0, 0x03,
  0x80, 0xE0, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x6E, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x00, 0xEF, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x71, 0xC0, 0x01,
  0xC1, 0x80, 0x03, 0x83, 0x80, 0x0E, 0x03, 0x80, 0x18, 0x07, 0x00, 0x70,
  0x07, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x0C, 0x18, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB8, 0x00,
  0x18, 0xE0, 0x01, 0xC3, 0x00, 0x0C, 0x1C, 0x00, 0xC0, 0x60, 0x0E, 0x03,
  0x80, 0x60, 0x0C, 0x07, 0x00, 0x70, 0x30, 0x01, 0xC3, 0x80, 0x06, 0x18,
  0x00, 0x39, 0x80, 0x00, 0xDC, 0x00, 0x07, 0x40, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x43, 0x87, 0x0C, 0x38, 0x60, 0xC3, 0x07, 0xF0, 0x01,
  0xFF, 0xC0, 0x3C, 0x1E, 0x07, 0x00, 0x70, 0x60, 0x03, 0x04, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x0F, 0xFF,
  0x83, 0xFF, 0xF8, 0x78, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x87, 0x81, 0xB8, 0x3F,
  0xF1, 0xF0, 0xFC, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x7E, 0x0E, 0x7F, 0xE3, 0xB0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xEE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x3B, 0xC0, 0x1E, 0xEC, 0x0F, 0x39, 0xFF, 0x8E,
  0x1F, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x00, 0x67, 0x00,
  0x1B, 0x00, 0x09, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0x38, 0x00, 0xCE, 0x00, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0, 0x1F,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC1, 0xF8, 0x70,
  0xFF, 0x9C, 0xF0, 0x37, 0x38, 0x03, 0xDC, 0x00, 0x76, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x77,
  0x00, 0x1C, 0xE0, 0x0F, 0x3C, 0x0D, 0xC7, 0xFE, 0x70, 0x7F, 0x1C, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xC0,
  0x01, 0x98, 0x00, 0x3B, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x04, 0x70, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x0E, 0x0F, 0x03, 0x80, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x03, 0xFA, 0x00, 0xFF, 0xE0, 0x1E, 0x0F, 0x01, 0x80,
  0x38, 0x38, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x00, 0x1C, 0x30,
  0x01, 0x83, 0x80, 0x18, 0x38, 0x03, 0x81, 0xE0, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE3, 0x00, 0x0F, 0x60, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x77, 0x80,
  0x1E, 0x3F, 0xFF, 0xC0, 0x7F, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC7, 0xF0, 0xCF, 0xF8, 0xD8, 0x3C, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFB, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xDF, 0xFF, 0xBF, 0xFE, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x7B, 0x00, 0x1C, 0x60, 0x07,
  0x0C, 0x01, 0xC1, 0x80, 0x70, 0x30, 0x1C, 0x06, 0x07, 0x00, 0xC1, 0xC0,
  0x18, 0xF0, 0x03, 0x3E, 0x00, 0x6E, 0xE0, 0x0F, 0x8E, 0x01, 0xE0, 0xE0,
  0x38, 0x1C, 0x06, 0x01, 0xC0, 0xC0, 0x1C, 0x18, 0x01, 0xC3, 0x00, 0x38,
  0x60, 0x03, 0x8C, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x38, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xCF, 0x07, 0x8D, 0xF8,
  0xFE, 0xF1, 0xD8, 0xEE, 0x0E, 0x06, 0xC0, 0xE0, 0x7C, 0x0E, 0x07, 0xC0,
  0x60, 0x7C, 0x06, 0x07, 0xC0, 0x60, 0x7C, 0x06, 0x07, 0xC0, 0x60, 0x7C,
  0x06, 0x07, 0xC0, 0x60, 0x7C, 0x06, 0x07, 0xC0, 0x60, 0x7C, 0x06, 0x07,
  0xC0, 0x60, 0x7C, 0x06, 0x07, 0xC0, 0x60, 0x7C, 0x06, 0x07, 0xC0, 0x60,
  0x7C, 0x06, 0x07, 0xC7, 0xF0, 0xCF, 0xF8, 0xD8, 0x3C, 0xE0, 0x0E, 0xE0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x3C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xE0,
  0x01, 0x98, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00,
  0x06, 0x70, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x0E, 0x0F, 0x07, 0x80, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0xE1, 0xF8, 0x39, 0xFF, 0x8E, 0xC0, 0xF3, 0xC0,
  0x1E, 0xF0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xB0,
  0x3C, 0xE7, 0xFE, 0x38, 0x7E, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xE1, 0xC3, 0xFE, 0x73, 0xC0, 0xDC, 0xE0, 0x0F, 0x70, 0x01, 0xD8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0x60, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x3C, 0xF0, 0x37, 0x1F, 0xF9, 0xC1,
  0xFC, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0xFF, 0x83, 0xFF, 0xF8,
  0xFF, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x01, 0xA0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x70, 0x1E, 0x1C, 0x00,
  0xE7, 0x00, 0x08, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0xEC, 0x00, 0x1F, 0xC0, 0x07,
  0x1E, 0x03, 0xC1, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xDC,
  0x01, 0xE7, 0x83, 0x71, 0xFF, 0x38, 0x3F, 0x1C, 0xE0, 0x00, 0xEC, 0x00,
  0x1D, 0x80, 0x03, 0x38, 0x00, 0xE3, 0x00, 0x18, 0x70, 0x03, 0x0E, 0x00,
  0xE0, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x07, 0x03,
  0x00, 0x60, 0xE0, 0x0C, 0x18, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x73, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x06, 0xC0, 0x70, 0x1D, 0x80, 0xF0, 0x33, 0x03, 0x60,
  0x66, 0x06, 0xC0, 0xCC, 0x0D, 0x81, 0x9C, 0x19, 0x03, 0x18, 0x23, 0x06,
  0x30, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x18, 0xC3,
  0x08, 0x31, 0x83, 0x30, 0x63, 0x06, 0x60, 0xC4, 0x0C, 0xC0, 0x98, 0x19,
  0x01, 0xB0, 0x36, 0x03, 0x60, 0x6C, 0x06, 0xC0, 0x78, 0x0D, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x38, 0xE0, 0x0E,
  0x0E, 0x01, 0x81, 0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x1C, 0xC0,
  0x03, 0xB8, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00,
  0x07, 0x70, 0x00, 0xC7, 0x00, 0x38, 0x60, 0x0E, 0x0E, 0x03, 0x80, 0xE0,
  0x60, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x1D, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0x7C, 0x00, 0x1D, 0x80, 0x03, 0x38, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03,
  0x0E, 0x00, 0xE0, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18,
  0x07, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0,
  0x01, 0xB8, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0x00, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0x01, 0xFF, 0x07, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0x00, 0x18, 0xFE, 0x00, 0xCE, 0x38, 0x0C, 0xE0,
  0xE0, 0x66, 0x03, 0x87, 0x30, 0x0E, 0x33, 0x00, 0x3F, 0x18, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Light42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 5, 29, 25, 10, -29 },
  { 20, 9, 11, 25, 8, -31 },
  { 33, 23, 29, 25, 1, -29 },
  { 117, 21, 37, 25, 2, -33 },
  { 215, 23, 29, 25, 1, -29 },
  { 299, 23, 29, 25, 1, -29 },
  { 383, 3, 11, 25, 11, -31 },
  { 388, 11, 38, 25, 9, -32 },
  { 441, 11, 38, 25, 5, -32 },
  { 494, 21, 21, 25, 2, -23 },
  { 550, 20, 20, 25, 3, -23 },
  { 600, 6, 11, 25, 9, -5 },
  { 609, 11, 2, 25, 7, -14 },
  { 612, 5, 5, 25, 10, -5 },
  { 616, 17, 38, 25, 4, -32 },
  { 697, 20, 29, 25, 3, -29 },
  { 770, 20, 29, 25, 3, -29 },
  { 843, 19, 29, 25, 3, -29 },
  { 912, 19, 29, 25, 2, -29 },
  { 981, 21, 29, 25, 2, -29 },
  { 1058, 19, 29, 25, 3, -29 },
  { 1127, 19, 29, 25, 3, -29 },
  { 1196, 19, 29, 25, 3, -29 },
  { 1265, 20, 29, 25, 3, -29 },
  { 1338, 19, 29, 25, 3, -29 },
  { 1407, 5, 23, 25, 10, -23 },
  { 1422, 6, 29, 25, 9, -23 },
  { 1444, 18, 24, 25, 4, -25 },
  { 1498, 20, 10, 25, 3, -18 },
  { 1523, 18, 24, 25, 4, -25 },
  { 1577, 17, 29, 25, 4, -29 },
  { 1639, 19, 34, 25, 3, -29 },
  { 1720, 22, 29, 25, 2, -29 },
  { 1800, 18, 29, 25, 4, -29 },
  { 1866, 19, 29, 25, 3, -29 },
  { 1935, 19, 29, 25, 4, -29 },
  { 2004, 18, 29, 25, 4, -29 },
  { 2070, 18, 29, 25, 4, -29 },
  { 2136, 19, 29, 25, 3, -29 },
  { 2205, 18, 29, 25, 4, -29 },
  { 2271, 18, 29, 25, 4, -29 },
  { 2337, 17, 29, 25, 3, -29 },
  { 2399, 20, 29, 25, 4, -29 },
  { 2472, 17, 29, 25, 5, -29 },
  { 2534, 19, 29, 25, 3, -29 },
  { 2603, 18, 29, 25, 4, -29 },
  { 2669, 20, 29, 25, 3, -29 },
  { 2742, 19, 29, 25, 4, -29 },
  { 2811, 20, 35, 25, 3, -29 },
  { 2899, 19, 29, 25, 4, -29 },
  { 2968, 21, 29, 25, 2, -29 },
  { 3045, 23, 29, 25, 1, -29 },
  { 3129, 18, 29, 25, 4, -29 },
  { 3195, 21, 29, 25, 2, -29 },
  { 3272, 21, 29, 25, 2, -29 },
  { 3349, 23, 29, 25, 1, -29 },
  { 3433, 23, 29, 25, 1, -29 },
  { 3517, 21, 29, 25, 2, -29 },
  { 3594, 11, 38, 25, 10, -32 },
  { 3647, 17, 38, 25, 4, -32 },
  { 3728, 11, 38, 25, 4, -32 },
  { 3781, 21, 17, 25, 2, -29 },
  { 3826, 20, 2, 25, 3, 5 },
  { 3831, 6, 8, 25, 8, -33 },
  { 3837, 20, 22, 25, 3, -22 },
  { 3892, 18, 31, 25, 4, -31 },
  { 3962, 17, 22, 25, 4, -22 },
  { 4009, 18, 31, 25, 3, -31 },
  { 4079, 19, 22, 25, 3, -22 },
  { 4132, 20, 31, 25, 3, -31 },
  { 4210, 20, 32, 25, 3, -24 },
  { 4290, 16, 31, 25, 5, -31 },
  { 4352, 18, 31, 25, 5, -31 },
  { 4422, 15, 39, 25, 4, -31 },
  { 4496, 19, 31, 25, 5, -31 },
  { 4570, 18, 31, 25, 4, -31 },
  { 4640, 20, 22, 25, 3, -22 },
  { 4695, 16, 22, 25, 5, -22 },
  { 4739, 19, 22, 25, 3, -22 },
  { 4792, 18, 30, 25, 4, -22 },
  { 4860, 18, 30, 25, 3, -22 },
  { 4928, 20, 22, 25, 3, -22 },
  { 4983, 19, 22, 25, 3, -22 },
  { 5036, 20, 29, 25, 2, -29 },
  { 5109, 17, 22, 25, 4, -22 },
  { 5156, 19, 22, 25, 3, -22 },
  { 5209, 23, 22, 25, 1, -22 },
  { 5273, 19, 22, 25, 3, -22 },
  { 5326, 19, 30, 25, 3, -22 },
  { 5398, 17, 22, 25, 4, -22 },
  { 5445, 16, 38, 25, 5, -32 },
  { 5521, 2, 38, 25, 12, -32 },
  { 5531, 16, 38, 25, 5, -32 },
  { 5607, 21, 8, 25, 2, -17 },
};

const GFXfont IBMPlexMono_Light42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_LIGHT42PT7B_H_
