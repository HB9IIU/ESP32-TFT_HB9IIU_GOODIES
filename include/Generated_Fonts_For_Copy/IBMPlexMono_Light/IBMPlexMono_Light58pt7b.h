#ifndef _IBMPLEXMONO_LIGHT58PT7B_H_
#define _IBMPLEXMONO_LIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light58pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x20,
  0x40, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xBE,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF,
  0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F, 0xFF,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x31, 0xFC, 0x1F, 0x03, 0x07,
  0xE1, 0xE0, 0x30, 0x1F, 0x3C, 0x03, 0x00, 0xF3, 0x80, 0x30, 0x04, 0x38,
  0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x3C, 0x03, 0x00, 0x03,
  0xC0, 0x30, 0x00, 0x1F, 0x03, 0x00, 0x00, 0xF8, 0x30, 0x00, 0x07, 0xFB,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0x7F, 0x80, 0x00, 0x30, 0xFC, 0x00, 0x03, 0x03, 0xE0, 0x00,
  0x30, 0x1E, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00,
  0x03, 0x00, 0x72, 0x00, 0x30, 0x07, 0x70, 0x03, 0x00, 0xFF, 0x80, 0x30,
  0x0E, 0x7C, 0x03, 0x01, 0xE3, 0xF0, 0x30, 0x7C, 0x1F, 0xC3, 0x1F, 0x80,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xC7, 0xFF, 0x80, 0x01, 0xC7, 0xC3, 0xE0, 0x01, 0xC3,
  0x80, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0xE0,
  0xE0, 0x07, 0x00, 0x70, 0x60, 0x03, 0x80, 0x70, 0x30, 0x01, 0xC0, 0x38,
  0x18, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x38, 0x1C,
  0x03, 0x80, 0x1C, 0x0E, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x0E, 0x0E,
  0x00, 0x3C, 0x1F, 0x07, 0x00, 0x0F, 0xFF, 0x07, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x78,
  0x3F, 0xFC, 0x00, 0x38, 0x3E, 0x1F, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x38, 0x0E,
  0x03, 0x00, 0x1C, 0x07, 0x01, 0x80, 0x0E, 0x07, 0x00, 0xC0, 0x07, 0x07,
  0x00, 0x60, 0x03, 0x83, 0x80, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x00, 0x71, 0xC0, 0x03, 0x80, 0x70, 0xE0, 0x01, 0xF0, 0xF8,
  0xE0, 0x00, 0x7F, 0xF8, 0x70, 0x00, 0x1F, 0xF8, 0x40, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xC0, 0x03, 0x80, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x3C, 0xF0, 0x07, 0xF1,
  0xE3, 0xC0, 0x1F, 0xCF, 0x07, 0x80, 0x70, 0x78, 0x0F, 0x01, 0xC1, 0xC0,
  0x1E, 0x0E, 0x0F, 0x00, 0x3C, 0x38, 0x3C, 0x00, 0x78, 0xE0, 0xE0, 0x00,
  0xE3, 0x83, 0x80, 0x03, 0xCE, 0x0E, 0x00, 0x07, 0xB0, 0x38, 0x00, 0x0F,
  0xC0, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8,
  0x1C, 0x00, 0x06, 0xF0, 0x78, 0x00, 0x39, 0xE0, 0xF0, 0x01, 0xC7, 0x83,
  0xF0, 0x1E, 0x0F, 0x07, 0xFF, 0xF0, 0x1E, 0x07, 0xFF, 0x80, 0x3C, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x04, 0x00, 0x38,
  0x00, 0xBC, 0x01, 0xC0, 0x1F, 0xFC, 0x0E, 0x07, 0xF7, 0xFE, 0x73, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E,
  0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0x00, 0xFE, 0x01, 0xF0,
  0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x07, 0xC0, 0x7F, 0x00, 0xF0, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x03, 0xF0,
  0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0xF8,
  0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x60, 0x07, 0x80, 0x04, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xC0, 0x7E, 0x01, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x60, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1E,
  0x7C, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x3F, 0xC0, 0x0E, 0x3F, 0xFE,
  0x03, 0x9F, 0xFF, 0xC0, 0xEF, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xE1, 0x80, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x20, 0x00,
  0x03, 0xCC, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x1F,
  0xC0, 0x07, 0x1F, 0xFF, 0x01, 0xE7, 0xFF, 0xF0, 0x3D, 0xE0, 0x3F, 0x07,
  0x60, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x1E, 0x0E, 0x00, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x38, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0x3F, 0x01,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xE0, 0x1F, 0x81, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0,
  0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x0F, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x1E,
  0x00, 0x02, 0xE1, 0xF0, 0x01, 0xDC, 0x3F, 0x80, 0xF7, 0x81, 0xFF, 0xFC,
  0xF0, 0x1F, 0xFF, 0x1C, 0x00, 0x7F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC7,
  0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x03,
  0x81, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3E,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x0F, 0x70, 0x03, 0xE1, 0xDC, 0x03, 0xFE, 0x77,
  0x01, 0xFF, 0xDD, 0xC0, 0xF8, 0x37, 0x70, 0x3C, 0x07, 0xFC, 0x1E, 0x00,
  0xFE, 0x07, 0x00, 0x1F, 0x81, 0xC0, 0x07, 0xE0, 0x70, 0x01, 0xF8, 0x1C,
  0x00, 0x7E, 0x07, 0x00, 0x1F, 0x81, 0xC0, 0x07, 0xE0, 0x70, 0x01, 0xF8,
  0x1C, 0x00, 0x7E, 0x07, 0x00, 0x1F, 0x81, 0xC0, 0x07, 0xE0, 0x70, 0x01,
  0xF8, 0x1C, 0x00, 0x77, 0x07, 0x80, 0x3D, 0xC0, 0xE0, 0x0F, 0x70, 0x3C,
  0x05, 0xDC, 0x07, 0xEF, 0x77, 0x01, 0xFF, 0x9D, 0xC0, 0x1F, 0xC7, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xF0, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x3C,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x87,
  0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x0F, 0x87, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0x0E, 0x00,
  0x3F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x01, 0xF8,
  0x0F, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x47, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x0D, 0xC7,
  0xC0, 0x07, 0x70, 0xFC, 0x07, 0x9C, 0x1F, 0xFF, 0xC7, 0x01, 0xFF, 0xE1,
  0xC0, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xDE, 0x00, 0x1E, 0x7C, 0x00, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF1, 0xFC,
  0x00, 0x0F, 0x3D, 0xE0, 0x00, 0xF3, 0x9E, 0x00, 0x0F, 0x78, 0xF0, 0x00,
  0xFF, 0x0F, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0xFC, 0x03, 0xC0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xDF, 0xDC, 0x00, 0x77,
  0xF7, 0x80, 0x39, 0xFC, 0xE0, 0x0E, 0x7F, 0x38, 0x03, 0x9F, 0xC7, 0x01,
  0xC7, 0xF1, 0xC0, 0x71, 0xFC, 0x78, 0x38, 0x7F, 0x0E, 0x0E, 0x1F, 0xC3,
  0xC7, 0x07, 0xF0, 0x71, 0xC1, 0xFC, 0x1C, 0x70, 0x7F, 0x03, 0xB8, 0x1F,
  0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x01, 0xE0,
  0x1F, 0xC0, 0x38, 0x07, 0xF0, 0x0E, 0x01, 0xFC, 0x01, 0x00, 0x7F, 0x00,
  0x40, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0x78, 0x00, 0x1F, 0xBC, 0x00, 0x0F, 0xCE, 0x00, 0x07, 0xE7, 0x80, 0x03,
  0xF1, 0xC0, 0x01, 0xF8, 0xF0, 0x00, 0xFC, 0x38, 0x00, 0x7E, 0x1E, 0x00,
  0x3F, 0x07, 0x00, 0x1F, 0x83, 0xC0, 0x0F, 0xC0, 0xE0, 0x07, 0xE0, 0x78,
  0x03, 0xF0, 0x3C, 0x01, 0xF8, 0x0E, 0x00, 0xFC, 0x07, 0x80, 0x7E, 0x01,
  0xC0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0x38, 0x0F, 0xC0, 0x1E, 0x07, 0xE0,
  0x07, 0x03, 0xF0, 0x03, 0xC1, 0xF8, 0x00, 0xE0, 0xFC, 0x00, 0x78, 0x7E,
  0x00, 0x1C, 0x3F, 0x00, 0x0F, 0x1F, 0x80, 0x07, 0x8F, 0xC0, 0x01, 0xC7,
  0xE0, 0x00, 0xF3, 0xF0, 0x00, 0x39, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x03, 0xF0, 0x1F,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1C, 0x00, 0x0F, 0xCE,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x9F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x3C,
  0x03, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x1C, 0x00, 0x0F, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x38, 0x00, 0x1F, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xF8,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x04, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x1F,
  0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xC7, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1C, 0xE0, 0x1F, 0x00, 0xE7, 0x00,
  0xF8, 0x07, 0x38, 0x07, 0xC0, 0x39, 0xC0, 0x3E, 0x01, 0xCE, 0x03, 0xB8,
  0x0E, 0x70, 0x1D, 0xC0, 0x73, 0x80, 0xEE, 0x03, 0x9C, 0x06, 0x70, 0x1C,
  0xE0, 0x71, 0xC0, 0xE7, 0x03, 0x8E, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0,
  0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x83,
  0x87, 0x0E, 0x18, 0x1C, 0x38, 0x71, 0xC0, 0x71, 0xC3, 0x8E, 0x03, 0x8E,
  0x1C, 0x70, 0x1C, 0x70, 0xE3, 0x80, 0xE3, 0x87, 0x38, 0x03, 0x9C, 0x39,
  0xC0, 0x1D, 0xC1, 0xCE, 0x00, 0xEE, 0x07, 0x70, 0x07, 0x70, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF8, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x38,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xF0, 0x1F,
  0x80, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xC0, 0x30, 0x00, 0x1E, 0x01,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0xE0, 0x7C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x2E, 0x07, 0x80, 0x06,
  0xE0, 0x3E, 0x03, 0xCF, 0xF1, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0xF8, 0x07, 0x8F, 0xFF, 0x03, 0xCF,
  0xFF, 0xC1, 0xEF, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3B,
  0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xFC, 0x00, 0xF8, 0xF7, 0x81, 0xF8, 0x79,
  0xFF, 0xF8, 0x3C, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x08,
  0x38, 0x00, 0x03, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC1, 0xE0, 0x03,
  0xC0, 0xFC, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x78, 0x1F, 0xFE, 0x3C, 0x1F, 0xFF, 0x9E,
  0x1F, 0x81, 0xEF, 0x1E, 0x00, 0x37, 0x9E, 0x00, 0x0F, 0xCF, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x7C,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0x0F, 0xC0, 0xF7, 0x83, 0xFF, 0xF3,
  0xC0, 0xFF, 0xF1, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x7C, 0x07, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x3C,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x00,
  0xFC, 0x07, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x06, 0x00, 0x03,
  0xE1, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x07, 0xF0, 0x1E,
  0x3F, 0xF8, 0x3C, 0xFF, 0xFC, 0x7B, 0xC0, 0xFC, 0xF4, 0x00, 0x79, 0xF0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xEE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0xE0, 0x00,
  0xF8, 0x38, 0x00, 0x7C, 0x0E, 0x00, 0x3E, 0x03, 0x80, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0x38, 0xFC, 0x00, 0x0E, 0x7F, 0x80, 0x03, 0xBC, 0xF0,
  0x00, 0xFE, 0x1E, 0x00, 0x3F, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xF8, 0x0E, 0x00, 0x1E, 0x03,
  0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x7C, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0x1C, 0xFF, 0x0F, 0xF3,
  0xBF, 0xF3, 0xFF, 0x7C, 0x1E, 0xE1, 0xEF, 0x01, 0xD0, 0x1F, 0xC0, 0x3E,
  0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC,
  0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0,
  0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0,
  0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00,
  0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00,
  0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03,
  0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03,
  0x80, 0x38, 0x00, 0x7F, 0x01, 0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0xC7, 0xBC,
  0x0F, 0xCF, 0x40, 0x07, 0x9F, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x0F, 0xC0, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x78, 0xFF, 0xF0, 0x3C, 0xFF,
  0xFC, 0x1E, 0xF0, 0x3F, 0x0F, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x9F, 0xC0, 0x0F, 0x8F, 0x78, 0x1F, 0x87, 0x9F,
  0xFF, 0x83, 0xC7, 0xFF, 0x81, 0xE0, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xE3, 0xC1, 0xFF, 0xF9, 0xE1, 0xF8, 0x1E, 0xF1, 0xE0, 0x03, 0x79, 0xE0,
  0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0x9C, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE3, 0xE0, 0x07, 0xF0, 0xFC,
  0x0F, 0x78, 0x3F, 0xFF, 0x3C, 0x0F, 0xFF, 0x1E, 0x01, 0xFC, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0x39, 0xE0, 0x00,
  0x07, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x3E, 0x01, 0xFC, 0x1E, 0x00, 0x0F, 0x87, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x10, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x20, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x38, 0xF8, 0x00, 0x3E, 0x1F,
  0xC0, 0x3F, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x0F, 0xCF, 0xC0,
  0xF7, 0x1F, 0xFF, 0x9C, 0x3F, 0xFC, 0x70, 0x3F, 0xC0, 0x00, 0xF0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x8F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C,
  0x1E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x37,
  0x00, 0x36, 0x00, 0xE7, 0x00, 0x6C, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0x9C,
  0x03, 0xB8, 0x07, 0x38, 0x06, 0x30, 0x0E, 0x70, 0x0C, 0x60, 0x18, 0xE0,
  0x38, 0xC0, 0x30, 0xE0, 0x71, 0xC0, 0xE1, 0xC0, 0xE3, 0x81, 0xC3, 0x81,
  0x83, 0x03, 0x87, 0x03, 0x06, 0x07, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x30, 0x38, 0x70, 0x38, 0x60, 0x30, 0xE0, 0x71, 0xC0,
  0x71, 0xC0, 0xE3, 0x80, 0xE3, 0x81, 0xC7, 0x01, 0xC6, 0x03, 0x8C, 0x01,
  0x8C, 0x03, 0x18, 0x03, 0x38, 0x07, 0x70, 0x07, 0x70, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1D, 0x80, 0x1D, 0xC0, 0x3B, 0x00, 0x1B, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0F,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x30, 0x7F, 0x80, 0x01, 0xC7, 0xFE, 0x00, 0x0C,
  0x3C, 0x78, 0x00, 0xE3, 0x81, 0xE0, 0x07, 0x1C, 0x07, 0x80, 0x31, 0xC0,
  0x1E, 0x03, 0x8E, 0x00, 0x78, 0x3C, 0x70, 0x01, 0xE3, 0xC7, 0x00, 0x07,
  0xFC, 0x38, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Light58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 7, 40, 35, 14, -40 },
  { 36, 13, 15, 35, 11, -43 },
  { 61, 33, 40, 35, 1, -40 },
  { 226, 28, 54, 35, 3, -47 },
  { 415, 33, 42, 35, 1, -41 },
  { 589, 30, 42, 35, 2, -41 },
  { 747, 3, 15, 35, 16, -43 },
  { 753, 15, 52, 35, 13, -44 },
  { 851, 15, 52, 35, 7, -44 },
  { 949, 29, 29, 35, 3, -32 },
  { 1055, 27, 29, 35, 4, -32 },
  { 1153, 9, 16, 35, 12, -7 },
  { 1171, 17, 3, 35, 9, -19 },
  { 1178, 7, 6, 35, 14, -6 },
  { 1184, 23, 52, 35, 6, -44 },
  { 1334, 27, 42, 35, 4, -41 },
  { 1476, 28, 40, 35, 4, -40 },
  { 1616, 27, 41, 35, 4, -41 },
  { 1755, 26, 42, 35, 3, -41 },
  { 1892, 30, 40, 35, 2, -40 },
  { 2042, 26, 41, 35, 4, -40 },
  { 2176, 27, 41, 35, 4, -40 },
  { 2315, 26, 40, 35, 4, -40 },
  { 2445, 27, 42, 35, 4, -41 },
  { 2587, 27, 41, 35, 4, -41 },
  { 2726, 7, 31, 35, 14, -31 },
  { 2754, 9, 40, 35, 12, -31 },
  { 2799, 25, 32, 35, 5, -34 },
  { 2899, 27, 14, 35, 4, -25 },
  { 2947, 25, 32, 35, 5, -34 },
  { 3047, 24, 41, 35, 5, -41 },
  { 3170, 26, 47, 35, 4, -41 },
  { 3323, 31, 40, 35, 2, -40 },
  { 3478, 26, 40, 35, 5, -40 },
  { 3608, 27, 42, 35, 4, -41 },
  { 3750, 25, 40, 35, 6, -40 },
  { 3875, 24, 40, 35, 6, -40 },
  { 3995, 24, 40, 35, 6, -40 },
  { 4115, 26, 42, 35, 4, -41 },
  { 4252, 25, 40, 35, 5, -40 },
  { 4377, 25, 40, 35, 5, -40 },
  { 4502, 22, 41, 35, 5, -40 },
  { 4615, 28, 40, 35, 5, -40 },
  { 4755, 23, 40, 35, 8, -40 },
  { 4870, 26, 40, 35, 4, -40 },
  { 5000, 25, 40, 35, 5, -40 },
  { 5125, 27, 42, 35, 4, -41 },
  { 5267, 25, 40, 35, 6, -40 },
  { 5392, 27, 50, 35, 4, -41 },
  { 5561, 25, 40, 35, 6, -40 },
  { 5686, 28, 42, 35, 3, -41 },
  { 5833, 31, 40, 35, 2, -40 },
  { 5988, 25, 41, 35, 5, -40 },
  { 6117, 30, 40, 35, 2, -40 },
  { 6267, 29, 40, 35, 3, -40 },
  { 6412, 31, 40, 35, 2, -40 },
  { 6567, 33, 40, 35, 1, -40 },
  { 6732, 29, 40, 35, 3, -40 },
  { 6877, 15, 52, 35, 14, -44 },
  { 6975, 23, 52, 35, 6, -44 },
  { 7125, 15, 52, 35, 6, -44 },
  { 7223, 29, 23, 35, 3, -40 },
  { 7307, 28, 3, 35, 3, 6 },
  { 7318, 9, 11, 35, 11, -45 },
  { 7331, 28, 32, 35, 4, -31 },
  { 7443, 25, 44, 35, 6, -43 },
  { 7581, 25, 32, 35, 5, -31 },
  { 7681, 25, 44, 35, 4, -43 },
  { 7819, 26, 32, 35, 4, -31 },
  { 7923, 27, 43, 35, 4, -43 },
  { 8069, 28, 46, 35, 4, -34 },
  { 8230, 23, 43, 35, 6, -43 },
  { 8354, 25, 43, 35, 6, -43 },
  { 8489, 21, 55, 35, 5, -43 },
  { 8634, 26, 43, 35, 7, -43 },
  { 8774, 25, 43, 35, 5, -43 },
  { 8909, 27, 31, 35, 4, -31 },
  { 9014, 23, 31, 35, 6, -31 },
  { 9104, 26, 32, 35, 4, -31 },
  { 9208, 25, 43, 35, 6, -31 },
  { 9343, 25, 43, 35, 4, -31 },
  { 9478, 27, 30, 35, 5, -30 },
  { 9580, 26, 32, 35, 4, -31 },
  { 9684, 28, 40, 35, 2, -40 },
  { 9824, 22, 31, 35, 6, -30 },
  { 9910, 26, 30, 35, 4, -30 },
  { 10008, 31, 30, 35, 2, -30 },
  { 10125, 27, 30, 35, 4, -30 },
  { 10227, 27, 42, 35, 4, -30 },
  { 10369, 24, 30, 35, 5, -30 },
  { 10459, 22, 52, 35, 6, -44 },
  { 10602, 3, 52, 35, 16, -44 },
  { 10622, 22, 52, 35, 6, -44 },
  { 10765, 29, 12, 35, 3, -24 },
};

const GFXfont IBMPlexMono_Light58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_LIGHT58PT7B_H_
