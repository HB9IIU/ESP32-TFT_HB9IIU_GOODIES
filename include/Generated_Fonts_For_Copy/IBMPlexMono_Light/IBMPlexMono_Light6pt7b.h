#ifndef _IBMPLEXMONO_LIGHT6PT7B_H_
#define _IBMPLEXMONO_LIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x76, 0xE0, 0x5F, 0x3E, 0x80, 0xFF, 0xF0, 0xF3, 0xF0,
  0x80, 0x6A, 0x90, 0xFC, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A,
  0xA0, 0xF6, 0xF0, 0xC9, 0x30, 0xE5, 0x70, 0xE5, 0xF0, 0x3E, 0xB0, 0xE8,
  0xF0, 0x4A, 0xF0, 0xE5, 0x20, 0xF7, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0, 0x69,
  0xFC, 0xA6, 0xDA, 0xFF, 0xE6, 0x55, 0xD0, 0xFF, 0xF2, 0x70, 0xFF, 0xEF,
  0xEE, 0xF2, 0xF0, 0xFF, 0xEB, 0x64, 0xF0, 0xEB, 0xAB, 0xBF, 0xD0, 0xFF,
  0xF6, 0xF0, 0xFA, 0xF6, 0xD6, 0xFB, 0xF1, 0xF0, 0xE9, 0x20, 0xFF, 0xB6,
  0xA0, 0xBF, 0xD0, 0xA9, 0x50, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xB0, 0xAA,
  0xD0, 0xFC, 0x54, 0xE0, 0x80, 0xEF, 0x80, 0xBF, 0xEC, 0x3E, 0xF0, 0xFF,
  0x80, 0x7D, 0x30, 0xF7, 0x70, 0xBF, 0x2B, 0x75, 0xC0, 0xBB, 0xC9, 0x70,
  0xFF, 0x80, 0xFC, 0xF7, 0x80, 0xFE, 0xF6, 0xB0, 0xEB, 0x80, 0xEF, 0x80,
  0x5D, 0x30, 0xFC, 0xB5, 0x00, 0xFE, 0x80, 0xAA, 0x80, 0xB5, 0x20, 0xEC,
  0x6A, 0xB0, 0xFC, 0xAB, 0xA0, 0xE0,
};

const GFXglyph IBMPlexMono_Light6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 1, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -3 },
  { 18, 3, 3, 4, 0, -3 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 2, 6, 4, 1, -5 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 1, 3, 4, 1, -3 },
  { 46, 1, 4, 4, 1, -3 },
  { 47, 2, 4, 4, 1, -4 },
  { 48, 3, 2, 4, 0, -3 },
  { 49, 2, 4, 4, 1, -4 },
  { 50, 2, 4, 4, 1, -4 },
  { 51, 3, 5, 4, 0, -4 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 2, 4, 4, 1, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 2, 4, 4, 1, -4 },
  { 68, 2, 4, 4, 1, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 2, 4, 4, 1, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 2, 4, 4, 1, -4 },
  { 75, 3, 5, 4, 0, -4 },
  { 77, 2, 4, 4, 1, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 2, 4, 4, 1, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 3, 4, 4, 0, -4 },
  { 87, 3, 4, 4, 0, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 3, 4, 4, 0, -4 },
  { 93, 2, 6, 4, 1, -5 },
  { 95, 2, 6, 4, 1, -5 },
  { 97, 1, 6, 4, 1, -5 },
  { 98, 3, 2, 4, 0, -4 },
  { 99, 3, 1, 4, 0, 0 },
  { 100, 1, 1, 4, 1, -5 },
  { 101, 3, 3, 4, 0, -3 },
  { 103, 2, 4, 4, 1, -4 },
  { 104, 2, 3, 4, 1, -3 },
  { 105, 3, 4, 4, 0, -4 },
  { 107, 3, 3, 4, 0, -3 },
  { 109, 3, 4, 4, 0, -4 },
  { 111, 3, 4, 4, 0, -3 },
  { 113, 2, 4, 4, 1, -4 },
  { 114, 2, 4, 4, 1, -4 },
  { 115, 2, 5, 4, 1, -4 },
  { 117, 2, 4, 4, 1, -4 },
  { 118, 3, 4, 4, 0, -4 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 2, 3, 4, 1, -3 },
  { 123, 3, 3, 4, 0, -3 },
  { 125, 2, 4, 4, 1, -3 },
  { 126, 3, 4, 4, 0, -3 },
  { 128, 3, 3, 4, 0, -3 },
  { 130, 3, 3, 4, 0, -3 },
  { 132, 3, 4, 4, 0, -4 },
  { 134, 2, 3, 4, 1, -3 },
  { 135, 3, 3, 4, 0, -3 },
  { 137, 3, 3, 4, 0, -3 },
  { 139, 3, 3, 4, 0, -3 },
  { 141, 3, 4, 4, 0, -3 },
  { 143, 2, 3, 4, 1, -3 },
  { 144, 2, 6, 4, 1, -5 },
  { 146, 1, 6, 4, 1, -5 },
  { 147, 2, 6, 4, 1, -5 },
  { 149, 3, 1, 4, 0, -2 },
};

const GFXfont IBMPlexMono_Light6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_LIGHT6PT7B_H_
