#ifndef _IBMPLEXMONO_LIGHT24PT7B_H_
#define _IBMPLEXMONO_LIGHT24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light24pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0x92, 0x49, 0x00, 0x37, 0xC0, 0x9C, 0xE7, 0x39, 0xCC,
  0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x88, 0x04, 0x60, 0x11, 0x87, 0xC7,
  0xC1, 0x10, 0x0C, 0x40, 0x31, 0x0F, 0x8F, 0x82, 0x20, 0x08, 0x80, 0x62,
  0x01, 0x88, 0x04, 0x20, 0x11, 0x80, 0x02, 0x00, 0x20, 0x1F, 0x83, 0x26,
  0x62, 0x34, 0x20, 0x42, 0x04, 0x20, 0x62, 0x03, 0xA0, 0x0F, 0xC0, 0x26,
  0x02, 0x30, 0x21, 0x02, 0x10, 0x23, 0xC2, 0x37, 0x26, 0x1F, 0x80, 0x20,
  0x02, 0x00, 0x78, 0x1E, 0x20, 0xA1, 0x09, 0x0C, 0x48, 0x64, 0x42, 0x23,
  0x12, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x06, 0xC4, 0x24, 0x32, 0x20, 0xB1,
  0x05, 0x08, 0x78, 0x62, 0x81, 0xE0, 0x1F, 0x03, 0x18, 0x20, 0x86, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x28, 0x74, 0x44, 0xC6, 0x48, 0x34,
  0x81, 0xC8, 0x0C, 0xC1, 0x46, 0x12, 0x3E, 0x30, 0xFC, 0x06, 0x10, 0x41,
  0x02, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x40, 0xC0, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x20, 0xC1, 0x04, 0x10,
  0x41, 0x04, 0x10, 0xC2, 0x08, 0x43, 0x18, 0xC0, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0xC2, 0x33, 0xFE, 0x07, 0x00, 0x70, 0x09, 0x81, 0x88, 0x30,
  0xC2, 0x06, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x76, 0x66, 0x4C, 0x80, 0xFE,
  0xDF, 0x00, 0x00, 0x40, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0x0C, 0x20, 0x66, 0x02, 0x40,
  0x24, 0x03, 0x40, 0x3C, 0x63, 0xC6, 0x3C, 0x03, 0x40, 0x34, 0x03, 0x40,
  0x26, 0x02, 0x20, 0x63, 0x0C, 0x0F, 0x80, 0x0E, 0x03, 0xC0, 0x98, 0x23,
  0x08, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xE0, 0x3F, 0x0C, 0x33, 0x03, 0x40,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0xFF, 0xE0, 0x1F, 0x06, 0x19, 0x81, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x0F, 0x00, 0x18, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x70, 0x1B, 0x06, 0x1F, 0x00, 0x01, 0xC0, 0x1C, 0x02, 0xC0,
  0x6C, 0x04, 0xC0, 0xCC, 0x18, 0xC1, 0x0C, 0x30, 0xC6, 0x0C, 0x40, 0xCC,
  0x0C, 0xFF, 0xF0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7F, 0xC8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0xF8, 0x61, 0x98, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0xB0, 0x33, 0x0C, 0x3F, 0x00, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x02, 0x00, 0x80, 0x10, 0x06, 0xF8, 0xA1, 0x98, 0x1A, 0x01,
  0x40, 0x38, 0x07, 0x00, 0x90, 0x33, 0x0C, 0x1F, 0x00, 0xFF, 0xF0, 0x0A,
  0x03, 0x40, 0x68, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x00, 0x1F, 0x83, 0x0C,
  0x60, 0x66, 0x02, 0x40, 0x26, 0x02, 0x20, 0x63, 0x0C, 0x0F, 0x03, 0x0C,
  0x40, 0x24, 0x03, 0xC0, 0x34, 0x03, 0x60, 0x23, 0x06, 0x1F, 0x80, 0x1F,
  0x0C, 0x33, 0x01, 0x40, 0x28, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0x61, 0xC7,
  0xC8, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x18, 0x00, 0xDF,
  0x00, 0x00, 0x03, 0x7C, 0x67, 0x60, 0x00, 0x00, 0x00, 0x76, 0x66, 0x4C,
  0x80, 0x00, 0x40, 0x30, 0x30, 0x38, 0x38, 0x18, 0x08, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x40, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x04, 0x07,
  0x03, 0x03, 0x03, 0x03, 0x80, 0x80, 0x00, 0x1F, 0x18, 0x6C, 0x0F, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x06, 0x0F, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x70, 0x0C, 0x00, 0x1F, 0x08, 0x64, 0x0D, 0x01, 0x80, 0x61,
  0xD8, 0x8E, 0x21, 0x98, 0x66, 0x19, 0x86, 0x61, 0x98, 0x62, 0x18, 0xFE,
  0x00, 0x40, 0x10, 0x03, 0x00, 0x7E, 0x06, 0x00, 0x70, 0x0D, 0x00, 0xD0,
  0x09, 0x80, 0x98, 0x18, 0x81, 0x0C, 0x10, 0xC3, 0x04, 0x30, 0x43, 0xFE,
  0x60, 0x26, 0x02, 0x40, 0x3C, 0x03, 0xC0, 0x10, 0xFF, 0x18, 0x33, 0x03,
  0x60, 0x2C, 0x05, 0x80, 0xB0, 0x36, 0x0C, 0xFF, 0x18, 0x1B, 0x01, 0x60,
  0x3C, 0x07, 0x80, 0xF0, 0x16, 0x06, 0xFF, 0x80, 0x1F, 0x06, 0x19, 0x81,
  0x20, 0x3C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x98, 0x19, 0x86, 0x1F, 0x00, 0xFF, 0x18, 0x33, 0x03,
  0x60, 0x2C, 0x05, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x05, 0x80, 0xB0, 0x36, 0x0C, 0xFE, 0x00, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xD8, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x18, 0x64, 0x0F, 0x01, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x21, 0xF8, 0x06, 0x01, 0x80, 0x70, 0x14,
  0x0D, 0x85, 0x1E, 0x40, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x40, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC0,
  0x3F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x0C, 0x07, 0x06, 0xC2, 0x3E, 0x00, 0xC0, 0x6C, 0x0C, 0xC0,
  0x8C, 0x18, 0xC3, 0x0C, 0x60, 0xCC, 0x0D, 0xC0, 0xD4, 0x0E, 0x60, 0xC3,
  0x0C, 0x30, 0xC1, 0x8C, 0x08, 0xC0, 0xCC, 0x06, 0xC0, 0x30, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xC0, 0xC0, 0x78, 0x1F, 0x83,
  0xD0, 0xFB, 0x17, 0x26, 0xE4, 0x9C, 0x53, 0x8C, 0x71, 0x8E, 0x11, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0xC0, 0x78, 0x1A, 0x06,
  0xC1, 0x90, 0x66, 0x18, 0x86, 0x21, 0x8C, 0x61, 0x18, 0x66, 0x09, 0x83,
  0x60, 0x58, 0x1E, 0x03, 0x80, 0xC0, 0x0F, 0x83, 0x0C, 0x20, 0x66, 0x02,
  0x40, 0x24, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x34, 0x03,
  0x40, 0x26, 0x02, 0x20, 0x63, 0x0C, 0x0F, 0x80, 0xFF, 0x98, 0x1B, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x06, 0xFF, 0x98, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0x0C, 0x20,
  0x66, 0x02, 0x40, 0x24, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40,
  0x34, 0x03, 0x40, 0x26, 0x02, 0x20, 0x63, 0x0C, 0x0F, 0x80, 0x60, 0x02,
  0x00, 0x3E, 0xFF, 0x98, 0x1B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x06, 0xFF, 0x98, 0xC3, 0x08, 0x61, 0x8C, 0x11, 0x83, 0x30, 0x26, 0x06,
  0xC0, 0x60, 0x1F, 0x83, 0x06, 0x60, 0x34, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x03, 0x80, 0x0F, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xC0,
  0x27, 0x06, 0x1F, 0x80, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x14, 0x0D, 0x86, 0x3F, 0x00, 0xC0, 0x1C, 0x03, 0x40, 0x36, 0x02,
  0x60, 0x22, 0x06, 0x30, 0x43, 0x04, 0x10, 0xC1, 0x08, 0x18, 0x80, 0x98,
  0x09, 0x80, 0xD0, 0x0D, 0x00, 0x70, 0x06, 0x00, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x14, 0x61, 0x46, 0x14, 0x73, 0x45, 0x34, 0x93, 0x49,
  0x24, 0x9A, 0x48, 0xA5, 0x0A, 0x70, 0xA7, 0x0E, 0x70, 0x60, 0xC0, 0x33,
  0x01, 0x08, 0x18, 0x60, 0x81, 0x8C, 0x04, 0xC0, 0x34, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x03, 0x40, 0x31, 0x01, 0x0C, 0x18, 0x21, 0x81, 0x88, 0x06,
  0xC0, 0x18, 0xC0, 0x0D, 0x80, 0x63, 0x01, 0x0C, 0x0C, 0x18, 0x20, 0x21,
  0x80, 0xC4, 0x01, 0x30, 0x06, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0xF0, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xF0, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xFC, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x60, 0x08, 0x02, 0x00, 0x40, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0,
  0x06, 0x00, 0x70, 0x09, 0x01, 0x98, 0x10, 0xC3, 0x04, 0x20, 0x66, 0x02,
  0x40, 0x38, 0x02, 0xFF, 0xF0, 0x99, 0x90, 0x3E, 0x18, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x7F, 0x30, 0x24, 0x04, 0x80, 0x90, 0x33, 0x0A, 0x3E, 0x70,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xE3, 0x8C, 0x80, 0xA0,
  0x28, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0A, 0x02, 0xC3, 0x2F, 0x80, 0x1F,
  0x0C, 0x24, 0x05, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x13,
  0x0C, 0x7C, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xED, 0x87,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0x61, 0xCF,
  0xB0, 0x1F, 0x0C, 0x31, 0x03, 0x60, 0x28, 0x07, 0xFF, 0xE0, 0x04, 0x00,
  0xC0, 0x08, 0x09, 0x83, 0x0F, 0x80, 0x07, 0xE0, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x3F, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x1F, 0xF8, 0x00, 0xE3, 0xF0, 0x86, 0x20,
  0x44, 0x0C, 0x81, 0x90, 0x23, 0x0C, 0x1F, 0x0C, 0x01, 0x00, 0x20, 0x03,
  0xFD, 0x80, 0xE0, 0x0C, 0x01, 0xC0, 0x67, 0xF0, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0xF9, 0x86, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x3F, 0xF0, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x09, 0xFC, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x34, 0x08, 0x86, 0x11, 0x82, 0x60, 0x5C, 0x0E, 0xC1,
  0x0C, 0x20, 0xC4, 0x0C, 0x80, 0x90, 0x0C, 0xFC, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0xDC, 0xEE, 0x53, 0xC6, 0x1C, 0x21,
  0xC2, 0x1C, 0x21, 0xC2, 0x1C, 0x21, 0xC2, 0x1C, 0x21, 0xC2, 0x1C, 0x21,
  0xBE, 0x61, 0xA0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x1F, 0x0C, 0x31, 0x03, 0x60, 0x28, 0x05, 0x00, 0xE0, 0x1C,
  0x02, 0x80, 0x48, 0x19, 0x86, 0x0F, 0x80, 0x9E, 0x38, 0xC8, 0x0A, 0x02,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xA0, 0x2C, 0x32, 0xF8, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x00, 0x3E, 0xD8, 0x7C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x36, 0x1C, 0xFB, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xF9, 0xE1, 0x40, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xE0, 0x3F, 0x0C, 0x19, 0x02,
  0x60, 0x04, 0x00, 0x7C, 0x00, 0xF0, 0x02, 0x00, 0x50, 0x0D, 0x83, 0x1F,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFF, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x07, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x40, 0xD0, 0x36, 0x1C, 0xFB, 0x80, 0x78, 0x09, 0x03, 0x20, 0x46,
  0x08, 0x43, 0x0C, 0x40, 0x98, 0x12, 0x03, 0x40, 0x38, 0x06, 0x00, 0x86,
  0x1C, 0x30, 0xA1, 0x45, 0x8A, 0x24, 0x91, 0x24, 0x89, 0x24, 0x89, 0x14,
  0x58, 0xA3, 0x85, 0x0C, 0x28, 0x60, 0xC0, 0xC0, 0x6C, 0x10, 0x86, 0x09,
  0x81, 0xA0, 0x18, 0x03, 0x80, 0xD0, 0x33, 0x04, 0x31, 0x03, 0x60, 0x30,
  0x80, 0x78, 0x09, 0x03, 0x20, 0x46, 0x08, 0x43, 0x0C, 0x40, 0x98, 0x12,
  0x01, 0x40, 0x38, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0xF0, 0x00,
  0xFF, 0xC0, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0xFF, 0x1F, 0x88, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x04, 0x06, 0x3C, 0x03, 0x80, 0x40, 0x20, 0x30, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x01, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x60, 0x20, 0x08, 0x03, 0xE3, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x0F, 0x80, 0x38, 0x16, 0x41, 0x42, 0x34, 0x32,
  0x81, 0xC0,
};

const GFXglyph IBMPlexMono_Light24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 17, 14, 6, -17 },
  { 8, 5, 6, 14, 5, -18 },
  { 12, 14, 17, 14, 0, -17 },
  { 42, 12, 21, 14, 1, -19 },
  { 74, 13, 17, 14, 1, -17 },
  { 102, 12, 17, 14, 1, -17 },
  { 128, 1, 6, 14, 7, -18 },
  { 129, 7, 21, 14, 5, -18 },
  { 148, 6, 21, 14, 3, -18 },
  { 164, 12, 12, 14, 1, -13 },
  { 182, 12, 11, 14, 1, -13 },
  { 199, 4, 7, 14, 5, -3 },
  { 203, 7, 1, 14, 4, -8 },
  { 204, 3, 3, 14, 6, -3 },
  { 206, 10, 21, 14, 2, -18 },
  { 233, 12, 17, 14, 1, -17 },
  { 259, 11, 17, 14, 2, -17 },
  { 283, 11, 17, 14, 2, -17 },
  { 307, 11, 17, 14, 1, -17 },
  { 331, 12, 17, 14, 1, -17 },
  { 357, 11, 17, 14, 2, -17 },
  { 381, 11, 17, 14, 2, -17 },
  { 405, 11, 17, 14, 2, -17 },
  { 429, 12, 17, 14, 1, -17 },
  { 455, 11, 17, 14, 2, -17 },
  { 479, 3, 13, 14, 6, -13 },
  { 484, 4, 17, 14, 5, -13 },
  { 493, 10, 13, 14, 2, -14 },
  { 510, 12, 5, 14, 1, -10 },
  { 518, 10, 13, 14, 2, -14 },
  { 535, 10, 17, 14, 2, -17 },
  { 557, 10, 20, 14, 2, -17 },
  { 582, 12, 17, 14, 1, -17 },
  { 608, 11, 17, 14, 2, -17 },
  { 632, 11, 17, 14, 2, -17 },
  { 656, 11, 17, 14, 2, -17 },
  { 680, 10, 17, 14, 2, -17 },
  { 702, 11, 17, 14, 2, -17 },
  { 726, 10, 17, 14, 2, -17 },
  { 748, 10, 17, 14, 2, -17 },
  { 770, 10, 17, 14, 2, -17 },
  { 792, 9, 17, 14, 2, -17 },
  { 812, 12, 17, 14, 2, -17 },
  { 838, 10, 17, 14, 3, -17 },
  { 860, 11, 17, 14, 2, -17 },
  { 884, 10, 17, 14, 2, -17 },
  { 906, 12, 17, 14, 1, -17 },
  { 932, 11, 17, 14, 2, -17 },
  { 956, 12, 20, 14, 1, -17 },
  { 986, 11, 17, 14, 2, -17 },
  { 1010, 12, 17, 14, 1, -17 },
  { 1036, 13, 17, 14, 1, -17 },
  { 1064, 10, 17, 14, 2, -17 },
  { 1086, 12, 17, 14, 1, -17 },
  { 1112, 12, 17, 14, 1, -17 },
  { 1138, 13, 17, 14, 1, -17 },
  { 1166, 14, 17, 14, 0, -17 },
  { 1196, 12, 17, 14, 1, -17 },
  { 1222, 6, 21, 14, 6, -18 },
  { 1238, 10, 21, 14, 2, -18 },
  { 1265, 7, 21, 14, 2, -18 },
  { 1284, 12, 10, 14, 1, -17 },
  { 1299, 12, 1, 14, 1, 3 },
  { 1301, 3, 4, 14, 5, -18 },
  { 1303, 11, 12, 14, 2, -12 },
  { 1320, 10, 18, 14, 3, -18 },
  { 1343, 10, 12, 14, 2, -12 },
  { 1358, 10, 18, 14, 2, -18 },
  { 1381, 11, 12, 14, 2, -12 },
  { 1398, 11, 18, 14, 2, -18 },
  { 1423, 11, 18, 14, 2, -13 },
  { 1448, 9, 18, 14, 3, -18 },
  { 1469, 10, 18, 14, 3, -18 },
  { 1492, 9, 23, 14, 2, -18 },
  { 1518, 11, 18, 14, 3, -18 },
  { 1543, 10, 18, 14, 2, -18 },
  { 1566, 12, 12, 14, 1, -12 },
  { 1584, 9, 12, 14, 3, -12 },
  { 1598, 11, 12, 14, 2, -12 },
  { 1615, 10, 17, 14, 3, -12 },
  { 1637, 10, 17, 14, 2, -12 },
  { 1659, 11, 12, 14, 2, -12 },
  { 1676, 11, 12, 14, 2, -12 },
  { 1693, 12, 17, 14, 1, -17 },
  { 1719, 10, 12, 14, 2, -12 },
  { 1734, 11, 12, 14, 2, -12 },
  { 1751, 13, 12, 14, 1, -12 },
  { 1771, 11, 12, 14, 2, -12 },
  { 1788, 11, 17, 14, 2, -12 },
  { 1812, 10, 12, 14, 2, -12 },
  { 1827, 9, 21, 14, 3, -18 },
  { 1851, 1, 21, 14, 7, -18 },
  { 1854, 9, 21, 14, 3, -18 },
  { 1878, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_Light24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_LIGHT24PT7B_H_
