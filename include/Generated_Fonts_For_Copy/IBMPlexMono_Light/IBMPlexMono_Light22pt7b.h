#ifndef _IBMPLEXMONO_LIGHT22PT7B_H_
#define _IBMPLEXMONO_LIGHT22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light22pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x48, 0x01, 0xF8, 0x8C, 0x63, 0x18, 0xC4, 0x06,
  0x60, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x3E, 0x7C, 0x22, 0x01, 0x10,
  0x08, 0x87, 0xC7, 0x86, 0x60, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x00,
  0x04, 0x00, 0x80, 0x7E, 0x32, 0x64, 0x46, 0x88, 0x11, 0x03, 0x20, 0x34,
  0x01, 0xF0, 0x13, 0x02, 0x30, 0x42, 0x08, 0x71, 0x1B, 0x26, 0x1F, 0x80,
  0x80, 0x10, 0x00, 0x3C, 0x1A, 0x20, 0x90, 0x88, 0x84, 0x44, 0x24, 0x22,
  0x20, 0xF2, 0x00, 0x00, 0x08, 0xE0, 0x48, 0x84, 0x86, 0x64, 0x12, 0x21,
  0xA0, 0x8B, 0x03, 0x80, 0x1E, 0x04, 0x61, 0x84, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x03, 0xC7, 0xCC, 0x90, 0x92, 0x0A, 0x40, 0xC8, 0x19, 0x84, 0x8F,
  0x18, 0xFC, 0x0C, 0x42, 0x18, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x04, 0x10, 0x60, 0x81, 0x03, 0x82, 0x08, 0x21, 0x04, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x22, 0x11, 0x11, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0E,
  0x4E, 0x3E, 0x03, 0x80, 0x58, 0x11, 0x06, 0x10, 0x83, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x00, 0x6B, 0x48, 0xFC, 0xFC, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20,
  0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x10, 0x00, 0x1F, 0x06, 0x11, 0x81, 0x20, 0x24, 0x07,
  0x80, 0xF1, 0x9E, 0x33, 0xC0, 0x78, 0x0D, 0x01, 0xA0, 0x26, 0x04, 0x61,
  0x07, 0xC0, 0x0E, 0x03, 0x40, 0xC8, 0x31, 0x0C, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0xF8, 0x3E,
  0x10, 0xC8, 0x1A, 0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x0F, 0xFC, 0x1F, 0x18, 0x64, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x78, 0x01, 0x80, 0x30, 0x04, 0x01, 0xC0, 0xD8, 0x63,
  0xF0, 0x01, 0x80, 0x50, 0x1A, 0x02, 0x40, 0x88, 0x31, 0x04, 0x21, 0x04,
  0x60, 0x88, 0x12, 0x02, 0x7F, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xA0,
  0x10, 0x08, 0x04, 0x06, 0x02, 0x79, 0xC3, 0x00, 0x80, 0x40, 0x20, 0x18,
  0x0E, 0x08, 0xF8, 0x06, 0x06, 0x03, 0x00, 0x80, 0x40, 0x30, 0x09, 0xE3,
  0x86, 0x80, 0xA0, 0x38, 0x0E, 0x02, 0x80, 0x90, 0x43, 0xE0, 0xFF, 0xE0,
  0x28, 0x0A, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0x1F, 0x04, 0x19, 0x01, 0x20, 0x24, 0x04,
  0x80, 0x88, 0x20, 0xF8, 0x30, 0xC8, 0x0F, 0x01, 0xE0, 0x34, 0x06, 0xC1,
  0x87, 0xC0, 0x3E, 0x18, 0x48, 0x0A, 0x02, 0x80, 0xE0, 0x38, 0x0D, 0x86,
  0x3E, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x03, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0D, 0x69, 0x00, 0x00, 0x80, 0xC1, 0x83,
  0x07, 0x06, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x10, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x06, 0x06, 0x0C, 0x18, 0x30, 0x10, 0x00, 0x3E, 0x30, 0xB0, 0x30, 0x10,
  0x08, 0x0C, 0x1C, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x3E, 0x30, 0x90, 0x30, 0x18, 0xEC, 0xCE, 0x43, 0x21, 0x90, 0xC8, 0x64,
  0x33, 0x18, 0xFC, 0x01, 0x00, 0xC0, 0x1F, 0x00, 0x06, 0x01, 0x40, 0x28,
  0x05, 0x81, 0x10, 0x22, 0x04, 0x61, 0x04, 0x20, 0x87, 0xF9, 0x81, 0x20,
  0x24, 0x07, 0x80, 0x60, 0x08, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0xA0,
  0x28, 0x13, 0xF8, 0x81, 0xA0, 0x28, 0x0E, 0x03, 0x80, 0xA0, 0x6F, 0xF0,
  0x1E, 0x18, 0x64, 0x0A, 0x03, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x02, 0x40, 0xD8, 0x61, 0xE0, 0xFE, 0x30, 0xCC, 0x1B, 0x02,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x02, 0xC1, 0xB0,
  0xCF, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0xFF, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x1F, 0x0C, 0x26, 0x05, 0x02, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC3, 0xF0, 0x14, 0x05, 0x01, 0x60, 0x4C, 0x31, 0xF4, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x7F, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x43, 0x3C, 0x80, 0xE0,
  0x68, 0x12, 0x08, 0x84, 0x22, 0x09, 0x82, 0xF0, 0xE4, 0x31, 0x88, 0x32,
  0x04, 0x81, 0xA0, 0x28, 0x04, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0xC0, 0xF0,
  0x7C, 0x1E, 0x8F, 0xA2, 0xEC, 0xB9, 0x4E, 0x73, 0x88, 0xE2, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0xC0, 0xE0, 0x68, 0x34, 0x19, 0x0C, 0x86,
  0x63, 0x11, 0x8C, 0xC2, 0x61, 0xB0, 0x58, 0x3C, 0x0E, 0x06, 0x1F, 0x06,
  0x11, 0x81, 0x20, 0x24, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D,
  0x01, 0xA0, 0x26, 0x04, 0x61, 0x07, 0xC0, 0xFF, 0x20, 0x68, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1B, 0xFC, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x1F, 0x06, 0x11, 0x81, 0x20, 0x24, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0D, 0x01, 0xA0, 0x26, 0x04, 0x61, 0x07, 0xC0, 0x20,
  0x04, 0x00, 0xF8, 0xFF, 0x20, 0x68, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1B,
  0xFC, 0x84, 0x21, 0x88, 0x22, 0x0C, 0x81, 0x20, 0x68, 0x0C, 0x1F, 0x8C,
  0x19, 0x01, 0xA0, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x3C, 0x06, 0xC1, 0x87, 0xC0, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0A, 0x08, 0xF8, 0xC0,
  0x38, 0x0D, 0x01, 0x20, 0x26, 0x04, 0x41, 0x88, 0x21, 0x84, 0x11, 0x82,
  0x20, 0x64, 0x05, 0x80, 0xA0, 0x1C, 0x01, 0x80, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1C, 0x63, 0x9C, 0x52, 0x8A, 0x53, 0x4B, 0x4B, 0x29, 0x45, 0x28,
  0xA5, 0x1C, 0xE1, 0x98, 0x30, 0xC0, 0x6C, 0x08, 0x83, 0x18, 0x41, 0x10,
  0x16, 0x03, 0x80, 0x30, 0x0A, 0x03, 0x60, 0x44, 0x18, 0x46, 0x0C, 0x80,
  0xB0, 0x08, 0xC0, 0x1B, 0x01, 0x88, 0x08, 0x20, 0xC1, 0x84, 0x04, 0x60,
  0x32, 0x00, 0xA0, 0x07, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xFF, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x3F, 0xF8,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x18, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x60, 0x10, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x7F, 0x06, 0x01, 0x40, 0x6C, 0x08, 0x83, 0x08,
  0x41, 0x10, 0x12, 0x03, 0x80, 0x40, 0xFF, 0xE0, 0xC8, 0x90, 0x3C, 0x30,
  0xC8, 0x10, 0x04, 0x01, 0x1F, 0xCC, 0x12, 0x04, 0x81, 0x30, 0xC7, 0xDC,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0x8E, 0x1B, 0x02, 0xC0, 0xB0,
  0x3C, 0x0F, 0x03, 0xC0, 0xB0, 0x2E, 0x1B, 0x78, 0x1E, 0x30, 0xD0, 0x38,
  0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0xB0, 0xC7, 0x80, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x47, 0x92, 0x15, 0x03, 0x40, 0x50, 0x1C, 0x05, 0x01,
  0x40, 0x50, 0x32, 0x14, 0x79, 0x3E, 0x18, 0x4C, 0x0A, 0x02, 0x80, 0xBF,
  0xF8, 0x02, 0x00, 0xC0, 0x98, 0x63, 0xE0, 0x0F, 0xC2, 0x00, 0x80, 0x20,
  0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x83, 0xFE, 0x01, 0xCF, 0xC6, 0x11, 0x06, 0xC1, 0x90, 0x66, 0x10,
  0xF8, 0x40, 0x10, 0x07, 0xF9, 0x03, 0x80, 0x60, 0x1C, 0x0D, 0xFC, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0x85, 0x83, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43,
  0xFF, 0x03, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0xFE, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x68, 0x22, 0x10, 0x98, 0x2C, 0x0E, 0x82, 0x30,
  0x86, 0x20, 0x88, 0x12, 0x03, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0xF9,
  0xD8, 0xCF, 0x10, 0xE2, 0x1C, 0x43, 0x88, 0x71, 0x0E, 0x21, 0xC4, 0x38,
  0x87, 0x10, 0x80, 0xDE, 0x70, 0xB0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x20, 0x3E, 0x18, 0x4C, 0x0A, 0x02, 0x80, 0xA0, 0x38,
  0x0A, 0x02, 0xC0, 0x98, 0x43, 0xE0, 0xDE, 0x38, 0x6C, 0x0B, 0x02, 0xC0,
  0xF0, 0x3C, 0x0F, 0x02, 0xC0, 0xB8, 0x6D, 0xE3, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x1E, 0x48, 0x54, 0x0D, 0x01, 0x40, 0x70, 0x14, 0x05, 0x01, 0x40,
  0xC8, 0x51, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x04, 0xFB, 0xC7, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x0F, 0xF8, 0x3E, 0x20,
  0xF0, 0x18, 0x06, 0x01, 0xF8, 0x06, 0x01, 0x80, 0xE0, 0xCF, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xF8, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xB1, 0x4F, 0x20, 0x80, 0xE0, 0x24,
  0x19, 0x04, 0x61, 0x08, 0x82, 0x20, 0xC8, 0x14, 0x05, 0x00, 0xC0, 0x84,
  0x30, 0xC6, 0x28, 0xC5, 0x1C, 0xA2, 0x92, 0x54, 0x52, 0x8A, 0x51, 0x4A,
  0x18, 0x83, 0x00, 0xC0, 0xD0, 0x42, 0x30, 0xD8, 0x1C, 0x02, 0x01, 0x40,
  0xC8, 0x63, 0x10, 0x48, 0x0C, 0xC0, 0x68, 0x08, 0x83, 0x10, 0x43, 0x08,
  0x22, 0x04, 0x40, 0x58, 0x0A, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x1C, 0x00, 0xFF, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60,
  0x60, 0x3F, 0xE0, 0x0F, 0x8C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08,
  0x04, 0x7C, 0x03, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x18, 0x0C, 0x06,
  0x01, 0xF0, 0xFF, 0xFF, 0xF0, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x18, 0x03, 0xC6, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x04,
  0x02, 0x01, 0x1F, 0x80, 0x38, 0x29, 0x85, 0x19, 0x41, 0xC0,
};

const GFXglyph IBMPlexMono_Light22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 5, 6, 13, 4, -16 },
  { 11, 13, 15, 13, 0, -15 },
  { 36, 11, 19, 13, 1, -17 },
  { 63, 13, 15, 13, 0, -15 },
  { 88, 11, 15, 13, 1, -15 },
  { 109, 1, 6, 13, 6, -16 },
  { 110, 6, 20, 13, 5, -17 },
  { 125, 5, 20, 13, 3, -17 },
  { 138, 11, 11, 13, 1, -12 },
  { 154, 11, 11, 13, 1, -12 },
  { 170, 3, 5, 13, 5, -2 },
  { 172, 6, 1, 13, 4, -7 },
  { 173, 3, 2, 13, 5, -2 },
  { 174, 9, 20, 13, 2, -17 },
  { 197, 11, 15, 13, 1, -15 },
  { 218, 11, 15, 13, 1, -15 },
  { 239, 10, 15, 13, 2, -15 },
  { 258, 10, 15, 13, 1, -15 },
  { 277, 11, 15, 13, 1, -15 },
  { 298, 9, 15, 13, 2, -15 },
  { 315, 10, 15, 13, 2, -15 },
  { 334, 10, 15, 13, 2, -15 },
  { 353, 11, 15, 13, 1, -15 },
  { 374, 10, 15, 13, 2, -15 },
  { 393, 3, 11, 13, 5, -11 },
  { 398, 3, 14, 13, 5, -11 },
  { 404, 9, 12, 13, 2, -13 },
  { 418, 11, 5, 13, 1, -9 },
  { 425, 9, 12, 13, 2, -13 },
  { 439, 9, 15, 13, 2, -15 },
  { 456, 9, 17, 13, 2, -15 },
  { 476, 11, 15, 13, 1, -15 },
  { 497, 10, 15, 13, 2, -15 },
  { 516, 10, 15, 13, 2, -15 },
  { 535, 10, 15, 13, 2, -15 },
  { 554, 9, 15, 13, 2, -15 },
  { 571, 10, 15, 13, 2, -15 },
  { 590, 10, 15, 13, 1, -15 },
  { 609, 9, 15, 13, 2, -15 },
  { 626, 9, 15, 13, 2, -15 },
  { 643, 8, 15, 13, 2, -15 },
  { 658, 10, 15, 13, 2, -15 },
  { 677, 9, 15, 13, 3, -15 },
  { 694, 10, 15, 13, 2, -15 },
  { 713, 9, 15, 13, 2, -15 },
  { 730, 11, 15, 13, 1, -15 },
  { 751, 10, 15, 13, 2, -15 },
  { 770, 11, 18, 13, 1, -15 },
  { 795, 10, 15, 13, 2, -15 },
  { 814, 11, 15, 13, 1, -15 },
  { 835, 12, 15, 13, 1, -15 },
  { 858, 9, 15, 13, 2, -15 },
  { 875, 11, 15, 13, 1, -15 },
  { 896, 11, 15, 13, 1, -15 },
  { 917, 11, 15, 13, 1, -15 },
  { 938, 13, 15, 13, 0, -15 },
  { 963, 11, 15, 13, 1, -15 },
  { 984, 6, 20, 13, 5, -17 },
  { 999, 9, 20, 13, 2, -17 },
  { 1022, 6, 20, 13, 2, -17 },
  { 1037, 11, 9, 13, 1, -15 },
  { 1050, 11, 1, 13, 1, 2 },
  { 1052, 3, 4, 13, 4, -17 },
  { 1054, 10, 11, 13, 2, -11 },
  { 1068, 10, 16, 13, 2, -16 },
  { 1088, 9, 11, 13, 2, -11 },
  { 1101, 10, 16, 13, 1, -16 },
  { 1121, 10, 11, 13, 2, -11 },
  { 1135, 10, 16, 13, 2, -16 },
  { 1155, 10, 16, 13, 2, -12 },
  { 1175, 9, 16, 13, 2, -16 },
  { 1193, 10, 16, 13, 2, -16 },
  { 1213, 8, 20, 13, 2, -16 },
  { 1233, 10, 16, 13, 3, -16 },
  { 1253, 9, 16, 13, 2, -16 },
  { 1271, 11, 11, 13, 1, -11 },
  { 1287, 9, 11, 13, 2, -11 },
  { 1300, 10, 11, 13, 2, -11 },
  { 1314, 10, 15, 13, 2, -11 },
  { 1333, 10, 15, 13, 1, -11 },
  { 1352, 10, 11, 13, 2, -11 },
  { 1366, 9, 11, 13, 2, -11 },
  { 1379, 11, 15, 13, 1, -15 },
  { 1400, 9, 11, 13, 2, -11 },
  { 1413, 10, 11, 13, 2, -11 },
  { 1427, 11, 11, 13, 1, -11 },
  { 1443, 10, 11, 13, 2, -11 },
  { 1457, 11, 15, 13, 1, -11 },
  { 1478, 9, 11, 13, 2, -11 },
  { 1491, 9, 20, 13, 2, -17 },
  { 1514, 1, 20, 13, 6, -17 },
  { 1517, 9, 20, 13, 2, -17 },
  { 1540, 11, 4, 13, 1, -9 },
};

const GFXfont IBMPlexMono_Light22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_LIGHT22PT7B_H_
