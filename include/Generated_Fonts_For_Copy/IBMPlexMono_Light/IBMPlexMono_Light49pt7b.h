#ifndef _IBMPLEXMONO_LIGHT49PT7B_H_
#define _IBMPLEXMONO_LIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light49pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x30, 0xC3, 0x0C, 0x30, 0x82, 0x08, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xBF, 0xF9, 0xE0, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x00, 0x1C, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x3F, 0xF0, 0x3F, 0xF3,
  0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xF0, 0x06, 0x07, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0x01, 0x81, 0xC0,
  0x00, 0x18, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x18, 0xF8, 0x3C,
  0x18, 0x3C, 0x78, 0x18, 0x1E, 0x70, 0x18, 0x0C, 0x70, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x3E, 0x18, 0x00, 0x1F, 0xD8, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1B, 0xF8, 0x00,
  0x18, 0x7C, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x40,
  0x18, 0x0E, 0xE0, 0x18, 0x0E, 0xF0, 0x18, 0x1E, 0x7C, 0x18, 0x3C, 0x3F,
  0x18, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0xFF, 0xE0, 0x03,
  0xBC, 0x1C, 0x00, 0xE7, 0x01, 0xC0, 0x18, 0xC0, 0x18, 0x07, 0x38, 0x03,
  0x00, 0xC7, 0x00, 0x60, 0x38, 0xE0, 0x0C, 0x06, 0x1C, 0x01, 0x81, 0xC3,
  0x80, 0x30, 0x70, 0x30, 0x06, 0x0C, 0x07, 0x01, 0xC3, 0x80, 0xF0, 0x70,
  0x60, 0x0F, 0xFE, 0x1C, 0x00, 0xFF, 0x83, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x0F,
  0xF0, 0x01, 0x83, 0xFF, 0x00, 0x70, 0xF0, 0xF0, 0x1C, 0x18, 0x06, 0x03,
  0x07, 0x00, 0xE0, 0xE0, 0xE0, 0x0C, 0x18, 0x18, 0x01, 0x87, 0x03, 0x00,
  0x30, 0xC0, 0x60, 0x06, 0x38, 0x0E, 0x00, 0xC6, 0x01, 0xC0, 0x39, 0xC0,
  0x18, 0x06, 0x70, 0x03, 0xC3, 0xCC, 0x00, 0x3F, 0xF3, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x02, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x87, 0xF0, 0x0F,
  0xC7, 0xB8, 0x07, 0xE7, 0x0E, 0x03, 0x07, 0x07, 0x81, 0x83, 0x81, 0xE0,
  0xC3, 0x80, 0x78, 0x61, 0xC0, 0x1E, 0x70, 0xE0, 0x07, 0x38, 0x60, 0x01,
  0xD8, 0x30, 0x00, 0x7C, 0x18, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0xC3, 0xC0, 0x02, 0xF0, 0xF0, 0x07, 0x3C, 0x7C, 0x07, 0x0E, 0x1F,
  0xFF, 0x03, 0x87, 0xFF, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x60, 0x1C, 0x01, 0xFE, 0x0E, 0x0F, 0xDF, 0xE7, 0x3F,
  0xC1, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x07,
  0x0E, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x01, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8F, 0x00, 0x0E,
  0x0F, 0x00, 0x38, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xEE, 0x00, 0x07, 0xCE, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x0E, 0x00,
  0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0x81, 0xF8, 0x78, 0x01, 0xE1, 0xC0,
  0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3C, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0x00, 0x03, 0x88, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x40, 0x00, 0x3F, 0x80, 0x00, 0xEF, 0x00, 0x07, 0x9E,
  0x00, 0x3C, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x73, 0x80, 0x00, 0x31, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xC0,
  0x06, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x00, 0x1C,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC3, 0xF8, 0x07, 0x3F, 0xF8, 0x1D, 0xFF, 0xF0, 0x7E, 0x03, 0xE1, 0xE0,
  0x03, 0xC7, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x90, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0xC0, 0x01, 0xC7, 0x80,
  0x0F, 0x0F, 0x80, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC3, 0xF8, 0x07, 0x3F, 0xF8, 0x39, 0xFF, 0xF8, 0xEE, 0x03, 0xE3,
  0xE0, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xC3,
  0x80, 0x0F, 0x0F, 0x80, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0xF8, 0x0F, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x9E, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x1E, 0x07,
  0x80, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0xF8,
  0x0F, 0x83, 0xC0, 0x03, 0x8F, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDE, 0x00, 0x07, 0x3E, 0x00, 0x1E,
  0x3F, 0x01, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x38,
  0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x7D, 0xE0,
  0x03, 0x63, 0xE0, 0x3F, 0x87, 0xFF, 0xEE, 0x0F, 0xFE, 0x38, 0x0F, 0xE1,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xBF, 0xF9, 0xE0, 0x1E, 0x3E, 0x3F,
  0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3E, 0x07, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00,
  0x07, 0x60, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC3, 0xC0,
  0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x60, 0x00, 0x3B,
  0x00, 0x01, 0xF8, 0x07, 0xCF, 0xC0, 0xFF, 0x3E, 0x0F, 0xFD, 0xE0, 0x78,
  0x2F, 0x07, 0x80, 0xF8, 0x38, 0x07, 0xC1, 0xC0, 0x3E, 0x0C, 0x00, 0xF0,
  0x60, 0x07, 0x83, 0x00, 0x3C, 0x18, 0x01, 0xE0, 0xC0, 0x0F, 0x06, 0x00,
  0x78, 0x30, 0x03, 0xC1, 0xC0, 0x3E, 0x0E, 0x01, 0xF0, 0x38, 0x17, 0xC1,
  0xFF, 0xBE, 0x07, 0xF9, 0xF0, 0x1F, 0x8D, 0x80, 0x30, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x98, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF1, 0x80, 0x0F, 0x8C, 0x00, 0x1E, 0x60, 0x00, 0x73,
  0x00, 0x03, 0xD8, 0x00, 0x1E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00,
  0x1D, 0x80, 0x01, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0xE3, 0x00, 0x0F, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x30, 0x00, 0x79, 0x80, 0x01,
  0xEC, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0x60, 0x00, 0x7B, 0x00, 0x07, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE0,
  0x78, 0x1E, 0x00, 0x70, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x07,
  0x70, 0x00, 0x11, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x04, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0xE3, 0xC0, 0x03, 0x87, 0x80, 0x1C, 0x1F, 0x81, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xC0, 0x1F, 0x8E, 0x00, 0x3E, 0x70, 0x00, 0xF3, 0x80, 0x03, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x1E, 0x70, 0x01, 0xF3,
  0x80, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFE, 0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x11, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x70, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x78,
  0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x02, 0xC7, 0x80, 0x1B, 0x0F, 0x81,
  0xCC, 0x3F, 0xFF, 0x30, 0x3F, 0xF0, 0xC0, 0x3F, 0x80, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x03, 0x9E, 0x00, 0xF1, 0xF0,
  0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x78, 0x38, 0x01, 0xE0, 0x70, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x3C,
  0x00, 0x38, 0xF0, 0x00, 0x71, 0xF0, 0x00, 0xE7, 0xF0, 0x01, 0xDC, 0xE0,
  0x03, 0xF1, 0xE0, 0x07, 0xC1, 0xC0, 0x0F, 0x81, 0xC0, 0x1E, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x03,
  0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x38,
  0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xD8,
  0x00, 0xFF, 0x70, 0x03, 0x7C, 0xC0, 0x1D, 0xF3, 0x80, 0x67, 0xCE, 0x03,
  0x9F, 0x1C, 0x0C, 0x7C, 0x70, 0x71, 0xF0, 0xC1, 0xC7, 0xC3, 0x86, 0x1F,
  0x06, 0x38, 0x7C, 0x1C, 0xC1, 0xF0, 0x37, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x1C, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0x80,
  0x7C, 0x02, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF7,
  0x00, 0x1F, 0xB8, 0x00, 0xFC, 0xE0, 0x07, 0xE7, 0x00, 0x3F, 0x1C, 0x01,
  0xF8, 0xE0, 0x0F, 0xC3, 0x80, 0x7E, 0x1C, 0x03, 0xF0, 0x70, 0x1F, 0x83,
  0x80, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x0E, 0x0F,
  0xC0, 0x70, 0x7E, 0x01, 0xC3, 0xF0, 0x0E, 0x1F, 0x80, 0x38, 0xFC, 0x01,
  0xC7, 0xE0, 0x07, 0x3F, 0x00, 0x39, 0xF8, 0x00, 0xEF, 0xC0, 0x07, 0x7E,
  0x00, 0x3B, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x07, 0x0E, 0x00, 0x0F,
  0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0xE7, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x0F, 0x00, 0x38,
  0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xC0, 0x03, 0xEE, 0x00,
  0x0F, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0xE0, 0x01, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E,
  0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x73,
  0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x07,
  0xC0, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xC0, 0x03, 0xEE, 0x00, 0x0F, 0x70,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1E, 0xE0, 0x01, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0E, 0x07, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1E, 0xE0, 0x00,
  0x77, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC1, 0xF8, 0x07, 0xC3, 0xC0, 0x03, 0xCF, 0x00, 0x03, 0xDC, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x74, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x3E, 0x00, 0x1E,
  0x3F, 0x00, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x3C, 0x00, 0x38, 0xE0, 0x03,
  0xC7, 0xC0, 0x7C, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB8, 0x0F, 0x01, 0x9C, 0x07, 0x80, 0xCE, 0x07, 0xC0, 0x67,
  0x03, 0xE0, 0x33, 0x81, 0xB8, 0x19, 0xC0, 0xDC, 0x1C, 0xE0, 0xE6, 0x0E,
  0x30, 0x73, 0x07, 0x18, 0x31, 0xC3, 0x8C, 0x18, 0xE1, 0xC6, 0x1C, 0x70,
  0xE3, 0x0E, 0x18, 0x61, 0xC6, 0x0C, 0x30, 0xE3, 0x07, 0x18, 0x73, 0x83,
  0x8C, 0x39, 0xC0, 0xC6, 0x1C, 0xC0, 0x63, 0x0E, 0x60, 0x3B, 0x83, 0x30,
  0x1D, 0xC1, 0xB8, 0x06, 0xE0, 0xDC, 0x03, 0x70, 0x6C, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0x9E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1E, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x0F, 0x00,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x1C, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xC7, 0x00, 0x01,
  0xC7, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x20, 0xF0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x3E, 0x03, 0xE0, 0x38,
  0x01, 0xE0, 0x70, 0x00, 0xE0, 0x20, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7E, 0x00, 0x70, 0x78,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x01, 0xF0, 0x7C, 0x07, 0x7F, 0x3F,
  0xFE, 0x3F, 0x1F, 0xFC, 0x3F, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x3F,
  0x01, 0xC7, 0xFE, 0x0E, 0x7F, 0xFC, 0x77, 0x03, 0xE3, 0xE0, 0x07, 0x9E,
  0x00, 0x1E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF8, 0x01, 0xE7, 0x70,
  0x3E, 0x39, 0xFF, 0xF1, 0xC7, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x3C, 0x3C, 0x01, 0xE7, 0x80,
  0x0E, 0x70, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x04,
  0x70, 0x00, 0x77, 0x80, 0x07, 0x3C, 0x00, 0xE1, 0xF0, 0x3C, 0x1F, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x7E, 0x0E, 0x0F,
  0xFC, 0x70, 0xFF, 0xF3, 0x8F, 0x81, 0xDC, 0xF0, 0x03, 0xE7, 0x00, 0x0F,
  0x78, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x1D, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x3C, 0x00, 0xF8, 0xF8, 0x1D, 0xC3,
  0xFF, 0xCE, 0x0F, 0xFC, 0x70, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x01,
  0xC7, 0x00, 0x03, 0x98, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x6E,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x04, 0x70, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x07,
  0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xE4, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0xF8, 0x1E, 0x00,
  0x70, 0x38, 0x00, 0xF0, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x70,
  0x1F, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE3, 0x80,
  0x03, 0xCC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x83, 0xF0, 0x71, 0xFF, 0x8E,
  0x7F, 0xF9, 0xDC, 0x0F, 0xBA, 0x00, 0x77, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x1E, 0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x78,
  0x38, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38,
  0x38, 0x00, 0xE3, 0xC0, 0x03, 0x9F, 0x00, 0x0E, 0xFE, 0x00, 0x3F, 0x3C,
  0x00, 0xF8, 0x78, 0x03, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0xE0, 0x0F, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF9,
  0xDF, 0xC3, 0xFB, 0xBF, 0xCF, 0xFF, 0xC3, 0xB0, 0xFF, 0x03, 0x40, 0xFC,
  0x07, 0x01, 0xF8, 0x0E, 0x01, 0xF0, 0x1C, 0x03, 0xE0, 0x38, 0x07, 0xC0,
  0x70, 0x0F, 0x80, 0xE0, 0x1F, 0x01, 0xC0, 0x3E, 0x03, 0x80, 0x7C, 0x07,
  0x00, 0xF8, 0x0E, 0x01, 0xF0, 0x1C, 0x03, 0xE0, 0x38, 0x07, 0xC0, 0x70,
  0x0F, 0x80, 0xE0, 0x1F, 0x01, 0xC0, 0x3E, 0x03, 0x80, 0x7C, 0x07, 0x00,
  0xF8, 0x0E, 0x01, 0xF0, 0x1C, 0x03, 0xE0, 0x38, 0x07, 0xC0, 0x70, 0x0C,
  0x00, 0xFC, 0x1C, 0x7F, 0xE3, 0x9F, 0xFE, 0x77, 0x03, 0xEE, 0x80, 0x1D,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0C, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xC0,
  0xF8, 0x3C, 0x00, 0xE1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x79,
  0xE0, 0x01, 0xC3, 0xC0, 0x0E, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0x1F, 0xF8, 0x39, 0xFF,
  0xF1, 0xDC, 0x0F, 0x8F, 0x80, 0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xEF, 0x00, 0x07,
  0x78, 0x00, 0x7B, 0xE0, 0x07, 0x9D, 0xC0, 0xF8, 0xE7, 0xFF, 0xC7, 0x1F,
  0xF8, 0x38, 0x3F, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF1, 0xC3, 0xFF, 0xCE,
  0x3E, 0x07, 0x73, 0xC0, 0x0F, 0x9C, 0x00, 0x3D, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x80, 0x03, 0x9C,
  0x00, 0x3C, 0xF0, 0x03, 0xE3, 0xE0, 0x77, 0x0F, 0xFF, 0x38, 0x3F, 0xF1,
  0xC0, 0x7E, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF8,
  0x07, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F,
  0x80, 0xFC, 0x38, 0x00, 0x79, 0xC0, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x40, 0x00,
  0x1B, 0x80, 0x00, 0xEF, 0x80, 0x07, 0x9F, 0x80, 0x7C, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x77,
  0x00, 0x1E, 0xF0, 0x07, 0xDF, 0x03, 0xB9, 0xFF, 0xF7, 0x1F, 0xFC, 0xE0,
  0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x9C, 0x00,
  0x0C, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x60, 0x0E,
  0x03, 0x80, 0x18, 0x0E, 0x00, 0x70, 0x30, 0x01, 0xC1, 0xC0, 0x03, 0x07,
  0x00, 0x0E, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCC, 0x00,
  0x03, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xC0,
  0x1C, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1B, 0x80, 0xD8, 0x06,
  0xE0, 0x36, 0x01, 0x98, 0x0D, 0xC0, 0xE6, 0x03, 0x30, 0x39, 0x81, 0xCC,
  0x0E, 0x60, 0x63, 0x03, 0x1C, 0x18, 0xC0, 0xC7, 0x06, 0x18, 0x30, 0xC1,
  0x86, 0x0C, 0x30, 0xC1, 0x87, 0x0C, 0x30, 0x61, 0xC3, 0x0C, 0x1C, 0x60,
  0xE3, 0x03, 0x18, 0x39, 0xC0, 0xC6, 0x06, 0x60, 0x31, 0x81, 0x98, 0x0C,
  0xE0, 0x66, 0x01, 0xB8, 0x19, 0x80, 0x6C, 0x06, 0xC0, 0x1B, 0x01, 0xF0,
  0x06, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3D,
  0xC0, 0x01, 0xE3, 0x80, 0x07, 0x0F, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x38,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x8F, 0x00, 0x1C, 0x1C, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xF0, 0x1C, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x07,
  0x1C, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x87, 0x00, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x60, 0x00, 0xC1, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x7C, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x0F, 0x80, 0x07, 0x1F, 0xC0, 0x07, 0x3F, 0xE0, 0x06, 0x78, 0xF0,
  0x06, 0x70, 0x78, 0x0E, 0x60, 0x3C, 0x0C, 0xE0, 0x1E, 0x1C, 0xC0, 0x0F,
  0xF8, 0xC0, 0x07, 0xF0, 0xC0, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_Light49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 6, 34, 29, 12, -34 },
  { 27, 11, 13, 29, 9, -36 },
  { 45, 28, 34, 29, 1, -34 },
  { 164, 24, 46, 29, 3, -40 },
  { 302, 27, 36, 29, 1, -35 },
  { 424, 25, 36, 29, 2, -35 },
  { 537, 3, 13, 29, 13, -36 },
  { 542, 13, 44, 29, 11, -37 },
  { 614, 13, 44, 29, 6, -37 },
  { 686, 25, 24, 29, 2, -27 },
  { 761, 23, 25, 29, 3, -27 },
  { 833, 8, 14, 29, 10, -6 },
  { 847, 14, 3, 29, 8, -16 },
  { 853, 6, 5, 29, 12, -5 },
  { 857, 20, 44, 29, 5, -37 },
  { 967, 23, 36, 29, 3, -35 },
  { 1071, 24, 34, 29, 3, -34 },
  { 1173, 22, 35, 29, 4, -35 },
  { 1270, 22, 36, 29, 3, -35 },
  { 1369, 25, 34, 29, 2, -34 },
  { 1476, 22, 35, 29, 4, -34 },
  { 1573, 22, 35, 29, 4, -34 },
  { 1670, 23, 34, 29, 3, -34 },
  { 1768, 23, 36, 29, 3, -35 },
  { 1872, 22, 35, 29, 4, -35 },
  { 1969, 6, 26, 29, 12, -26 },
  { 1989, 8, 34, 29, 10, -26 },
  { 2023, 21, 27, 29, 4, -28 },
  { 2094, 23, 12, 29, 3, -21 },
  { 2129, 21, 27, 29, 4, -28 },
  { 2200, 21, 35, 29, 4, -35 },
  { 2292, 21, 40, 29, 4, -35 },
  { 2397, 25, 34, 29, 2, -34 },
  { 2504, 21, 34, 29, 5, -34 },
  { 2594, 22, 36, 29, 4, -35 },
  { 2693, 21, 34, 29, 5, -34 },
  { 2783, 20, 34, 29, 5, -34 },
  { 2868, 21, 34, 29, 5, -34 },
  { 2958, 22, 36, 29, 3, -35 },
  { 3057, 21, 34, 29, 4, -34 },
  { 3147, 21, 34, 29, 4, -34 },
  { 3237, 19, 35, 29, 4, -34 },
  { 3321, 23, 34, 29, 5, -34 },
  { 3419, 20, 34, 29, 6, -34 },
  { 3504, 22, 34, 29, 4, -34 },
  { 3598, 21, 34, 29, 4, -34 },
  { 3688, 23, 36, 29, 3, -35 },
  { 3792, 21, 34, 29, 5, -34 },
  { 3882, 23, 43, 29, 3, -35 },
  { 4006, 21, 34, 29, 5, -34 },
  { 4096, 23, 36, 29, 3, -35 },
  { 4200, 26, 34, 29, 2, -34 },
  { 4311, 21, 35, 29, 4, -34 },
  { 4403, 25, 34, 29, 2, -34 },
  { 4510, 25, 34, 29, 2, -34 },
  { 4617, 26, 34, 29, 2, -34 },
  { 4728, 27, 34, 29, 1, -34 },
  { 4843, 25, 34, 29, 2, -34 },
  { 4950, 13, 44, 29, 12, -37 },
  { 5022, 20, 44, 29, 5, -37 },
  { 5132, 13, 44, 29, 5, -37 },
  { 5204, 24, 19, 29, 3, -34 },
  { 5261, 23, 3, 29, 3, 5 },
  { 5270, 8, 9, 29, 9, -38 },
  { 5279, 24, 27, 29, 3, -26 },
  { 5360, 21, 37, 29, 5, -36 },
  { 5458, 20, 27, 29, 5, -26 },
  { 5526, 21, 37, 29, 3, -36 },
  { 5624, 22, 27, 29, 4, -26 },
  { 5699, 22, 36, 29, 4, -36 },
  { 5798, 23, 39, 29, 4, -29 },
  { 5911, 19, 36, 29, 5, -36 },
  { 5997, 22, 37, 29, 5, -37 },
  { 6099, 17, 47, 29, 5, -37 },
  { 6199, 22, 36, 29, 6, -36 },
  { 6298, 21, 36, 29, 4, -36 },
  { 6393, 23, 26, 29, 3, -26 },
  { 6468, 19, 26, 29, 5, -26 },
  { 6530, 22, 27, 29, 4, -26 },
  { 6605, 21, 36, 29, 5, -26 },
  { 6700, 21, 36, 29, 3, -26 },
  { 6795, 23, 25, 29, 4, -25 },
  { 6867, 22, 27, 29, 4, -26 },
  { 6942, 24, 34, 29, 2, -34 },
  { 7044, 19, 26, 29, 5, -25 },
  { 7106, 22, 25, 29, 4, -25 },
  { 7175, 26, 25, 29, 2, -25 },
  { 7257, 22, 25, 29, 4, -25 },
  { 7326, 23, 35, 29, 3, -25 },
  { 7427, 20, 25, 29, 5, -25 },
  { 7490, 19, 44, 29, 5, -37 },
  { 7595, 3, 44, 29, 13, -37 },
  { 7612, 19, 44, 29, 5, -37 },
  { 7717, 24, 10, 29, 3, -20 },
};

const GFXfont IBMPlexMono_Light49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_LIGHT49PT7B_H_
