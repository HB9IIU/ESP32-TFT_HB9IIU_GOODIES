#ifndef _IBMPLEXMONO_LIGHT30PT7B_H_
#define _IBMPLEXMONO_LIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light30pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x44, 0x00, 0x00, 0x6F, 0x60,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18,
  0x02, 0x18, 0x06, 0x10, 0x06, 0x10, 0x7E, 0x1F, 0x7E, 0x3F, 0x04, 0x30,
  0x04, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x20, 0xFC, 0x7E, 0xF8, 0x7E,
  0x08, 0x60, 0x08, 0x60, 0x18, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x03, 0xF0, 0x3F, 0xF1, 0xC4, 0xE6, 0x10,
  0xF0, 0x42, 0xC1, 0x03, 0x04, 0x06, 0x10, 0x1C, 0x40, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0x80, 0x47, 0x01, 0x0C, 0x04, 0x30, 0x10, 0xF0, 0x43, 0xE1,
  0x0D, 0xC4, 0xE3, 0xFF, 0x03, 0xF8, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x3C, 0x03, 0x7E, 0x03, 0xC3, 0x06, 0x81, 0x04, 0x81, 0x0C, 0x81, 0x08,
  0x81, 0x18, 0xC3, 0x10, 0x7E, 0x30, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x0C, 0x7E, 0x08, 0xC3, 0x18, 0x81, 0x10, 0x81, 0x30, 0x81, 0x20, 0x81,
  0x60, 0xC3, 0xC0, 0x7E, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0xC0, 0x38, 0x60,
  0x30, 0x30, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x0F, 0x3E, 0x0F, 0x77, 0x08, 0x63, 0x88, 0xC1, 0xC8, 0xC0, 0xF8,
  0xC0, 0x78, 0xC0, 0x30, 0xC0, 0x38, 0x70, 0x6C, 0x3F, 0xC6, 0x1F, 0x07,
  0xFF, 0xFF, 0x06, 0x18, 0x61, 0x82, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x18, 0xC0, 0xC0, 0xC0, 0xC0, 0x81, 0x81, 0x02, 0x06, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x30,
  0xC3, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x61, 0x86, 0xFD, 0xBF, 0x0F, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x60,
  0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x10, 0x08, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x39, 0x9C, 0xE6, 0x31, 0x18, 0xFF, 0xFF, 0x6F, 0x60, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x18, 0x06, 0x60, 0x1B, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x19, 0x80, 0x63, 0x87, 0x07,
  0xF8, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x76, 0x01, 0xCC, 0x07, 0x18,
  0x1C, 0x30, 0x30, 0x60, 0x40, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x03, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0x07,
  0x18, 0x0E, 0xC0, 0x19, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0xFF, 0x1C,
  0x1C, 0xC0, 0x74, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x7E,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1E,
  0x01, 0xDC, 0x1C, 0x7F, 0xC0, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xD0, 0x00, 0x90, 0x01, 0x90, 0x03, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04,
  0x10, 0x08, 0x10, 0x18, 0x10, 0x10, 0x10, 0x20, 0x10, 0x60, 0x10, 0x40,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x3F, 0xF8, 0xFF, 0xE2, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x67, 0xC1, 0xFF, 0xC7, 0x07, 0x98, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x40, 0x1B, 0x80, 0x67, 0x07, 0x07, 0xF8,
  0x0F, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x19, 0xF0, 0x6F, 0xF1, 0x61, 0xEE, 0x01, 0xB0, 0x06, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x19, 0x80, 0x63, 0x87, 0x07,
  0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xB0, 0x06, 0xC0, 0x13,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x98, 0x06, 0x30, 0x30, 0x7F, 0x81, 0xFE, 0x1C,
  0x0E, 0x60, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x77,
  0x03, 0x8F, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0xC3, 0x03, 0x18, 0x06,
  0x40, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x77, 0x03,
  0xCF, 0xFA, 0x0F, 0x98, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x06, 0xF6, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xCE,
  0x73, 0x18, 0x8C, 0x00, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x0E, 0x00, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x10, 0x07, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x80, 0x00, 0x0F, 0x83,
  0xFE, 0x70, 0x6C, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x3C, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xC0,
  0x36, 0x01, 0xA0, 0x05, 0x07, 0x38, 0x7D, 0xC6, 0x1E, 0x20, 0x71, 0x03,
  0x88, 0x1C, 0x40, 0xE2, 0x07, 0x10, 0x38, 0xC3, 0xC7, 0xEA, 0x1F, 0x50,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x7F, 0xC0, 0xFE, 0x01, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x06, 0x60, 0x04, 0x20, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F,
  0xF8, 0x3F, 0xFC, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x03, 0x60,
  0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x67, 0xFE, 0x3F, 0xF9, 0x80, 0xEC, 0x01,
  0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1D, 0xFF, 0xCF,
  0xFC, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x8C, 0x06, 0x60, 0x0D, 0x80,
  0x24, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x02, 0x60, 0x0C, 0xC0, 0x63, 0x83, 0x87,
  0xFC, 0x07, 0xC0, 0xFF, 0x87, 0xFE, 0x30, 0x39, 0x80, 0xEC, 0x03, 0x60,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x36, 0x03, 0xB0, 0x39, 0xFF, 0x8F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xBF, 0xFD, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0xFF, 0xBF, 0xFD, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x18, 0x06, 0x60, 0x1B, 0x00, 0x4C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x7F, 0xC1, 0xFF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x60, 0x0D, 0x80, 0x73, 0x82, 0xC7, 0xFB, 0x0F,
  0x8C, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x36, 0x03, 0x70, 0xE3, 0xFC, 0x0F,
  0x80, 0xC0, 0x1F, 0x00, 0xEC, 0x03, 0x30, 0x18, 0xC0, 0xC3, 0x06, 0x0C,
  0x30, 0x31, 0x80, 0xCE, 0x03, 0x38, 0x0D, 0xE0, 0x3C, 0xC0, 0xE3, 0x83,
  0x06, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x63, 0x00, 0xCC, 0x03, 0x30, 0x06,
  0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F,
  0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xD0, 0x2F, 0x61, 0xBC, 0x84, 0xF3, 0x33,
  0xCC, 0xCF, 0x1A, 0x3C, 0x78, 0xF0, 0xC3, 0xC3, 0x0F, 0x08, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xC0,
  0x1E, 0x01, 0xE0, 0x1B, 0x01, 0xB0, 0x19, 0x81, 0x98, 0x18, 0xC1, 0x8C,
  0x18, 0x41, 0x86, 0x18, 0x21, 0x83, 0x18, 0x31, 0x81, 0x98, 0x19, 0x80,
  0xD8, 0x0D, 0x80, 0x78, 0x07, 0x80, 0x30, 0x0F, 0xC0, 0x7F, 0x83, 0x87,
  0x18, 0x06, 0x60, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60,
  0x19, 0x80, 0x63, 0x87, 0x07, 0xF8, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0xB0,
  0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xBF, 0xFD, 0xFF, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87,
  0x18, 0x06, 0x60, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60,
  0x19, 0x80, 0x63, 0x87, 0x07, 0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0xF8, 0x07, 0xE0, 0xFF, 0xC7, 0xFF, 0xB0, 0x0D, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xBF, 0xF9, 0xFF,
  0x8C, 0x30, 0x60, 0x83, 0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03, 0x30, 0x0D,
  0x80, 0x6C, 0x01, 0x80, 0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0x98, 0x03, 0xC0,
  0x0B, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x77,
  0x03, 0x8F, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x60, 0x67, 0xFE, 0x1F, 0x80, 0xC0, 0x03, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x18,
  0x18, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x41, 0x82, 0x61, 0x86, 0x63, 0xC6, 0x63, 0xC6, 0x62, 0x46, 0x62,
  0x46, 0x66, 0x66, 0x66, 0x66, 0x24, 0x24, 0x24, 0x24, 0x2C, 0x34, 0x2C,
  0x34, 0x28, 0x14, 0x38, 0x1C, 0x38, 0x1C, 0xE0, 0x07, 0x60, 0x06, 0x30,
  0x0C, 0x18, 0x08, 0x18, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x60, 0x0C,
  0x30, 0x0C, 0x30, 0x18, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFE, 0x7F, 0xFE, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0xFF, 0xFF, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF,
  0x03, 0x00, 0x1E, 0x00, 0x48, 0x03, 0x30, 0x18, 0x60, 0x61, 0x83, 0x03,
  0x0C, 0x0C, 0x60, 0x19, 0x00, 0x2C, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC4, 0x63, 0x10, 0x1F, 0x81, 0xFF, 0x84, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC1, 0xFF, 0x1F, 0xFC, 0x60, 0x33, 0x00, 0xCC, 0x03, 0x30,
  0x0C, 0x60, 0xF1, 0xFE, 0x71, 0xF1, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x19, 0xF0, 0xDF, 0xE7, 0x83, 0xB0,
  0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0D, 0xE0, 0xED, 0xFE, 0x67, 0xC0, 0x0F, 0x83, 0xFC, 0x70, 0x66,
  0x03, 0xC0, 0x2C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x16,
  0x03, 0x70, 0x63, 0xFE, 0x0F, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x61, 0xF3, 0x3F, 0xDB, 0x83, 0xD8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD8,
  0x06, 0xE0, 0xF3, 0xFD, 0x8F, 0xCC, 0x0F, 0xC0, 0x7F, 0x83, 0x03, 0x18,
  0x06, 0x40, 0x0B, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x02, 0x38, 0x38, 0x7F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x7C, 0x3F, 0x80, 0xFF, 0x03, 0x83, 0x04, 0x02, 0x18,
  0x06, 0x30, 0x0C, 0x20, 0x10, 0x70, 0x60, 0x7F, 0x80, 0x7E, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0xC0, 0x1B, 0x00, 0x1E,
  0x00, 0x3E, 0x01, 0xCF, 0xFF, 0x07, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xED, 0x0E, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1B, 0xFF, 0x7F, 0xC0, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x06, 0x80, 0xE4, 0x0C,
  0x20, 0xC1, 0x0C, 0x08, 0xC0, 0x4E, 0x02, 0xD8, 0x18, 0x60, 0x83, 0x84,
  0x0C, 0x20, 0x31, 0x00, 0xC8, 0x03, 0x40, 0x0C, 0xFE, 0x0F, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x9C, 0x7A, 0xFB, 0xFC, 0x68, 0xF0, 0xC3,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xCF, 0x8D, 0xFE, 0xD0,
  0xEE, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x0F, 0xC0, 0xFF, 0x83, 0x87,
  0x18, 0x06, 0x60, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x34, 0x01, 0x98, 0x06, 0x38, 0x70, 0xFF, 0xC0, 0xFC, 0x00, 0xCF, 0x86,
  0xFF, 0x3C, 0x1D, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x6F, 0x07, 0x6F, 0xF3, 0x3E, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0x99, 0xFE,
  0xDC, 0x1E, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x06, 0xC0, 0x37, 0x07, 0x9F, 0xEC, 0x7E, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0xFE, 0x3F, 0xFD, 0xFC,
  0x1A, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1F, 0xFF, 0x3F, 0xFE,
  0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0x98, 0x04, 0x60, 0x01, 0xC0, 0x03,
  0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x30, 0x00, 0xD0, 0x03, 0xF0, 0x38,
  0xFF, 0xC0, 0xFC, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x70, 0xF7, 0xFB, 0x1F, 0x30, 0xC0, 0x0D, 0x80, 0x66, 0x01,
  0x88, 0x04, 0x30, 0x30, 0xC0, 0xC1, 0x02, 0x06, 0x18, 0x18, 0x60, 0x21,
  0x00, 0xCC, 0x01, 0x20, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC1, 0x83,
  0xC1, 0x83, 0xC3, 0xC3, 0x43, 0x42, 0x42, 0x42, 0x42, 0x42, 0x66, 0x66,
  0x66, 0x66, 0x64, 0x26, 0x24, 0x24, 0x24, 0x34, 0x2C, 0x34, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0xE0, 0x1D, 0x80, 0x63, 0x03, 0x06, 0x18, 0x0C,
  0xC0, 0x1A, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x80, 0x33, 0x00, 0x84, 0x06,
  0x18, 0x30, 0x31, 0x80, 0x6E, 0x01, 0xC0, 0xC0, 0x0D, 0x00, 0x26, 0x01,
  0x98, 0x06, 0x30, 0x30, 0xC0, 0xC1, 0x02, 0x06, 0x18, 0x08, 0x60, 0x33,
  0x00, 0xCC, 0x01, 0x20, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0xFF, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0xFE, 0x0F, 0xE0, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xF0, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x07, 0xF0, 0x7F, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xF0, 0xFE, 0x00,
  0x38, 0x05, 0xF8, 0x16, 0x60, 0xF0, 0xC3, 0xC1, 0x9A, 0x07, 0xE8, 0x07,
  0x00,
};

const GFXglyph IBMPlexMono_Light30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 21, 18, 7, -21 },
  { 12, 6, 8, 18, 6, -22 },
  { 18, 16, 21, 18, 1, -21 },
  { 60, 14, 27, 18, 2, -24 },
  { 108, 16, 21, 18, 1, -21 },
  { 150, 16, 21, 18, 1, -21 },
  { 192, 2, 8, 18, 8, -22 },
  { 194, 7, 27, 18, 7, -23 },
  { 218, 7, 27, 18, 4, -23 },
  { 242, 16, 15, 18, 1, -16 },
  { 272, 14, 16, 18, 2, -17 },
  { 300, 5, 8, 18, 6, -3 },
  { 305, 8, 2, 18, 5, -10 },
  { 307, 4, 3, 18, 7, -3 },
  { 309, 12, 27, 18, 3, -23 },
  { 350, 14, 21, 18, 2, -21 },
  { 387, 15, 21, 18, 2, -21 },
  { 427, 14, 21, 18, 2, -21 },
  { 464, 13, 21, 18, 2, -21 },
  { 499, 16, 21, 18, 1, -21 },
  { 541, 14, 21, 18, 2, -21 },
  { 578, 14, 21, 18, 2, -21 },
  { 615, 14, 21, 18, 2, -21 },
  { 652, 14, 21, 18, 2, -21 },
  { 689, 14, 21, 18, 2, -21 },
  { 726, 4, 16, 18, 7, -16 },
  { 734, 5, 21, 18, 6, -16 },
  { 748, 12, 17, 18, 3, -18 },
  { 774, 14, 8, 18, 2, -13 },
  { 788, 12, 17, 18, 3, -18 },
  { 814, 12, 21, 18, 3, -21 },
  { 846, 13, 24, 18, 2, -21 },
  { 885, 16, 21, 18, 1, -21 },
  { 927, 13, 21, 18, 3, -21 },
  { 962, 14, 21, 18, 2, -21 },
  { 999, 13, 21, 18, 3, -21 },
  { 1034, 13, 21, 18, 3, -21 },
  { 1069, 13, 21, 18, 3, -21 },
  { 1104, 14, 21, 18, 2, -21 },
  { 1141, 12, 21, 18, 3, -21 },
  { 1173, 12, 21, 18, 3, -21 },
  { 1205, 12, 21, 18, 2, -21 },
  { 1237, 14, 21, 18, 3, -21 },
  { 1274, 12, 21, 18, 4, -21 },
  { 1306, 14, 21, 18, 2, -21 },
  { 1343, 12, 21, 18, 3, -21 },
  { 1375, 14, 21, 18, 2, -21 },
  { 1412, 13, 21, 18, 3, -21 },
  { 1447, 14, 26, 18, 2, -21 },
  { 1493, 13, 21, 18, 3, -21 },
  { 1528, 14, 21, 18, 2, -21 },
  { 1565, 16, 21, 18, 1, -21 },
  { 1607, 12, 21, 18, 3, -21 },
  { 1639, 16, 21, 18, 1, -21 },
  { 1681, 16, 21, 18, 1, -21 },
  { 1723, 16, 21, 18, 1, -21 },
  { 1765, 16, 21, 18, 1, -21 },
  { 1807, 16, 21, 18, 1, -21 },
  { 1849, 8, 27, 18, 7, -23 },
  { 1876, 12, 27, 18, 3, -23 },
  { 1917, 8, 27, 18, 3, -23 },
  { 1944, 14, 12, 18, 2, -21 },
  { 1965, 14, 2, 18, 2, 3 },
  { 1969, 4, 5, 18, 6, -23 },
  { 1972, 14, 15, 18, 2, -15 },
  { 1999, 13, 22, 18, 3, -22 },
  { 2035, 12, 15, 18, 3, -15 },
  { 2058, 13, 22, 18, 2, -22 },
  { 2094, 14, 15, 18, 2, -15 },
  { 2121, 14, 22, 18, 2, -22 },
  { 2160, 15, 23, 18, 2, -17 },
  { 2204, 12, 22, 18, 3, -22 },
  { 2237, 13, 22, 18, 3, -22 },
  { 2273, 11, 28, 18, 3, -22 },
  { 2312, 13, 22, 18, 4, -22 },
  { 2348, 12, 22, 18, 3, -22 },
  { 2381, 14, 15, 18, 2, -15 },
  { 2408, 12, 15, 18, 3, -15 },
  { 2431, 14, 15, 18, 2, -15 },
  { 2458, 13, 21, 18, 3, -15 },
  { 2493, 13, 21, 18, 2, -15 },
  { 2528, 15, 15, 18, 2, -15 },
  { 2557, 14, 15, 18, 2, -15 },
  { 2584, 15, 21, 18, 1, -21 },
  { 2624, 12, 15, 18, 3, -15 },
  { 2647, 14, 15, 18, 2, -15 },
  { 2674, 16, 15, 18, 1, -15 },
  { 2704, 14, 15, 18, 2, -15 },
  { 2731, 14, 21, 18, 2, -15 },
  { 2768, 12, 15, 18, 3, -15 },
  { 2791, 12, 27, 18, 3, -23 },
  { 2832, 2, 27, 18, 8, -23 },
  { 2839, 12, 27, 18, 3, -23 },
  { 2880, 14, 7, 18, 2, -12 },
};

const GFXfont IBMPlexMono_Light30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_LIGHT30PT7B_H_
