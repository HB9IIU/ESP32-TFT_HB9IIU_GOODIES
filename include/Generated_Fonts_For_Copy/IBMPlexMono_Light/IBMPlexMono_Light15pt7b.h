#ifndef _IBMPLEXMONO_LIGHT15PT7B_H_
#define _IBMPLEXMONO_LIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0xB6, 0xD0, 0x12, 0x09, 0x04, 0x8E, 0x71, 0x41, 0x23,
  0x9C, 0x48, 0x24, 0x14, 0x00, 0x10, 0x21, 0xF6, 0x99, 0x12, 0x1E, 0x0F,
  0x13, 0x27, 0x4B, 0xE1, 0x02, 0x00, 0x71, 0xC4, 0xA2, 0x91, 0x47, 0x40,
  0xB8, 0xA4, 0x91, 0x49, 0x43, 0x80, 0x38, 0x24, 0x40, 0x20, 0x33, 0x5A,
  0x8A, 0x86, 0x46, 0x39, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x84, 0x42, 0x10,
  0x84, 0x22, 0x21, 0x11, 0x22, 0x24, 0x80, 0x10, 0x22, 0x4B, 0xE1, 0x05,
  0x11, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x56, 0xF8, 0xC0,
  0x06, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x00,
  0x38, 0x8A, 0x0C, 0x18, 0x32, 0x60, 0xC1, 0x44, 0x70, 0x30, 0xE3, 0x44,
  0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x38, 0x8A, 0x10, 0x30, 0x41, 0x04,
  0x10, 0x41, 0xFC, 0x38, 0x8A, 0x10, 0x23, 0x81, 0x80, 0x81, 0x84, 0xF0,
  0x0C, 0x28, 0x51, 0x24, 0x50, 0xA1, 0x7F, 0x04, 0x08, 0x7C, 0x81, 0x04,
  0x0B, 0xC8, 0xC0, 0x81, 0xC4, 0x70, 0x18, 0x41, 0x82, 0x0B, 0xD8, 0xE0,
  0xC1, 0x44, 0x78, 0xFF, 0x06, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40,
  0x7D, 0x8E, 0x0A, 0x23, 0x98, 0xE0, 0xC1, 0xC6, 0xF8, 0x38, 0x8A, 0x0C,
  0x1C, 0x6F, 0x41, 0x06, 0x08, 0x60, 0xC3, 0x50, 0x05, 0x60, 0x02, 0x18,
  0xC6, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60,
  0x30, 0x63, 0x18, 0x40, 0x3C, 0x8A, 0x08, 0x21, 0x82, 0x00, 0x00, 0x30,
  0x60, 0x38, 0x8A, 0x0C, 0xDA, 0x74, 0x68, 0xD1, 0x9F, 0x01, 0x01, 0xE0,
  0x10, 0x50, 0xA1, 0x44, 0x48, 0x9F, 0x41, 0x83, 0x04, 0xFD, 0x0A, 0x0C,
  0x2F, 0x90, 0xE0, 0xC1, 0x83, 0xF8, 0x38, 0x8A, 0x0C, 0x08, 0x10, 0x20,
  0x41, 0x44, 0x70, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0xF0,
  0xFF, 0x02, 0x04, 0x0F, 0xF0, 0x20, 0x40, 0x81, 0xFC, 0xFF, 0x02, 0x04,
  0x0F, 0xD0, 0x20, 0x40, 0x81, 0x00, 0x38, 0x8A, 0x0C, 0x08, 0x11, 0xE0,
  0xC1, 0x46, 0x74, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x04,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x7C, 0x10, 0x41,
  0x04, 0x10, 0x61, 0x45, 0xE0, 0x83, 0x0A, 0x24, 0x8B, 0x1A, 0x32, 0x42,
  0x85, 0x04, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xC3, 0x8F,
  0x2D, 0x5B, 0x32, 0x64, 0xC1, 0x83, 0x04, 0xC3, 0x86, 0x8D, 0x19, 0x32,
  0x62, 0xC5, 0x87, 0x0C, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44,
  0x70, 0xFD, 0x06, 0x0C, 0x18, 0x3F, 0xA0, 0x40, 0x81, 0x00, 0x38, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0x70, 0x40, 0xE0, 0xFD, 0x06, 0x0C,
  0x18, 0x3F, 0xA2, 0x44, 0x85, 0x04, 0x7D, 0x8E, 0x04, 0x07, 0x01, 0x80,
  0xC1, 0xC2, 0xF8, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0xF8,
  0x83, 0x06, 0x0A, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x20, 0x83, 0x06, 0x0C,
  0x9B, 0x35, 0x6A, 0xD5, 0xC6, 0x88, 0x82, 0x89, 0x11, 0x41, 0x02, 0x0A,
  0x22, 0x45, 0x04, 0xC1, 0xA0, 0x88, 0x82, 0x81, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0xFE, 0x04, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0xFC,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x81, 0x01, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x60, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x10, 0x51, 0x22, 0x28, 0x30, 0x40, 0xFE, 0xA4, 0x79, 0x08,
  0x13, 0xE8, 0x50, 0xA1, 0x3F, 0x82, 0x08, 0x3E, 0x8A, 0x18, 0x61, 0x86,
  0x2F, 0x80, 0x38, 0x8A, 0x0C, 0x08, 0x10, 0x11, 0x9C, 0x04, 0x10, 0x5F,
  0x4E, 0x18, 0x61, 0x85, 0x37, 0xC0, 0x38, 0x8A, 0x0F, 0xF8, 0x10, 0x10,
  0x9E, 0x1E, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x06,
  0x79, 0x12, 0x24, 0x48, 0x9E, 0x20, 0x7F, 0x06, 0x0B, 0xE0, 0x84, 0x21,
  0xE8, 0xC6, 0x31, 0x8C, 0x62, 0x30, 0x00, 0x38, 0x20, 0x82, 0x08, 0x20,
  0x8F, 0xC0, 0x0C, 0x00, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x09,
  0xE0, 0x81, 0x02, 0x04, 0x29, 0x94, 0x38, 0x48, 0x89, 0x12, 0x18, 0xF0,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0xEF, 0x26, 0x4C,
  0x99, 0x32, 0x64, 0xC9, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x38, 0x8A, 0x0C,
  0x18, 0x30, 0x51, 0x1C, 0xFA, 0x28, 0x61, 0x86, 0x18, 0xBE, 0x82, 0x08,
  0x00, 0x7D, 0x38, 0x61, 0x86, 0x14, 0xDF, 0x04, 0x10, 0x40, 0xEE, 0x60,
  0x41, 0x02, 0x04, 0x08, 0x7F, 0x7C, 0x8E, 0x03, 0x80, 0xC0, 0x70, 0xBE,
  0x20, 0x43, 0xF9, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7C, 0x8C, 0x63, 0x18,
  0xC6, 0x6F, 0x82, 0x89, 0x12, 0x22, 0x85, 0x0A, 0x08, 0x89, 0xAC, 0x95,
  0x4A, 0xA5, 0x53, 0x29, 0x98, 0x44, 0xC2, 0x88, 0xA0, 0x81, 0x05, 0x11,
  0x41, 0x83, 0x09, 0x12, 0x22, 0x85, 0x0C, 0x08, 0x10, 0x43, 0x80, 0x7C,
  0x08, 0x20, 0x82, 0x04, 0x10, 0x7F, 0x3A, 0x10, 0x41, 0x0B, 0x86, 0x11,
  0x10, 0x83, 0x80, 0xFF, 0xF8, 0xE1, 0x08, 0x44, 0x20, 0xEC, 0x41, 0x08,
  0x4E, 0x00, 0x63, 0x26, 0x30,
};

const GFXglyph IBMPlexMono_Light15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 1, 10, 9, 4, -10 },
  { 3, 3, 4, 9, 3, -11 },
  { 5, 9, 10, 9, 0, -10 },
  { 17, 7, 14, 9, 1, -12 },
  { 30, 9, 10, 9, 0, -10 },
  { 42, 8, 10, 9, 0, -10 },
  { 52, 1, 4, 9, 4, -11 },
  { 53, 4, 13, 9, 3, -11 },
  { 60, 4, 13, 9, 2, -11 },
  { 67, 7, 7, 9, 1, -8 },
  { 74, 7, 7, 9, 1, -8 },
  { 81, 2, 4, 9, 3, -2 },
  { 82, 5, 1, 9, 2, -5 },
  { 83, 1, 2, 9, 4, -2 },
  { 84, 7, 13, 9, 1, -11 },
  { 96, 7, 10, 9, 1, -10 },
  { 105, 7, 10, 9, 1, -10 },
  { 114, 7, 10, 9, 1, -10 },
  { 123, 7, 10, 9, 1, -10 },
  { 132, 7, 10, 9, 1, -10 },
  { 141, 7, 10, 9, 1, -10 },
  { 150, 7, 10, 9, 1, -10 },
  { 159, 7, 10, 9, 1, -10 },
  { 168, 7, 10, 9, 1, -10 },
  { 177, 7, 10, 9, 1, -10 },
  { 186, 1, 8, 9, 4, -8 },
  { 187, 2, 10, 9, 3, -8 },
  { 190, 7, 8, 9, 1, -9 },
  { 197, 7, 4, 9, 1, -7 },
  { 201, 7, 8, 9, 1, -9 },
  { 208, 7, 10, 9, 1, -10 },
  { 217, 7, 12, 9, 1, -10 },
  { 228, 7, 10, 9, 1, -10 },
  { 237, 7, 10, 9, 1, -10 },
  { 246, 7, 10, 9, 1, -10 },
  { 255, 7, 10, 9, 1, -10 },
  { 264, 7, 10, 9, 1, -10 },
  { 273, 7, 10, 9, 1, -10 },
  { 282, 7, 10, 9, 1, -10 },
  { 291, 7, 10, 9, 1, -10 },
  { 300, 7, 10, 9, 1, -10 },
  { 309, 6, 10, 9, 1, -10 },
  { 317, 7, 10, 9, 1, -10 },
  { 326, 6, 10, 9, 2, -10 },
  { 334, 7, 10, 9, 1, -10 },
  { 343, 7, 10, 9, 1, -10 },
  { 352, 7, 10, 9, 1, -10 },
  { 361, 7, 10, 9, 1, -10 },
  { 370, 7, 12, 9, 1, -10 },
  { 381, 7, 10, 9, 1, -10 },
  { 390, 7, 10, 9, 1, -10 },
  { 399, 9, 10, 9, 0, -10 },
  { 411, 7, 10, 9, 1, -10 },
  { 420, 7, 10, 9, 1, -10 },
  { 429, 7, 10, 9, 1, -10 },
  { 438, 7, 10, 9, 1, -10 },
  { 447, 9, 10, 9, 0, -10 },
  { 459, 7, 10, 9, 1, -10 },
  { 468, 4, 13, 9, 4, -11 },
  { 475, 7, 13, 9, 1, -11 },
  { 487, 4, 13, 9, 1, -11 },
  { 494, 7, 6, 9, 1, -10 },
  { 500, 7, 1, 9, 1, 1 },
  { 501, 2, 3, 9, 3, -12 },
  { 502, 7, 8, 9, 1, -8 },
  { 509, 6, 11, 9, 2, -11 },
  { 518, 7, 8, 9, 1, -8 },
  { 525, 6, 11, 9, 1, -11 },
  { 534, 7, 8, 9, 1, -8 },
  { 541, 7, 11, 9, 1, -11 },
  { 551, 7, 12, 9, 1, -9 },
  { 562, 5, 11, 9, 2, -11 },
  { 569, 6, 11, 9, 2, -11 },
  { 578, 6, 14, 9, 1, -11 },
  { 589, 7, 11, 9, 2, -11 },
  { 599, 7, 11, 9, 1, -11 },
  { 609, 7, 8, 9, 1, -8 },
  { 616, 5, 8, 9, 2, -8 },
  { 621, 7, 8, 9, 1, -8 },
  { 628, 6, 11, 9, 2, -8 },
  { 637, 6, 11, 9, 1, -8 },
  { 646, 7, 8, 9, 1, -8 },
  { 653, 7, 8, 9, 1, -8 },
  { 660, 7, 10, 9, 1, -10 },
  { 669, 5, 8, 9, 2, -8 },
  { 674, 7, 8, 9, 1, -8 },
  { 681, 9, 8, 9, 0, -8 },
  { 690, 7, 8, 9, 1, -8 },
  { 697, 7, 11, 9, 1, -8 },
  { 707, 7, 8, 9, 1, -8 },
  { 714, 5, 13, 9, 2, -11 },
  { 723, 1, 13, 9, 4, -11 },
  { 725, 5, 13, 9, 2, -11 },
  { 734, 7, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_Light15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_LIGHT15PT7B_H_
