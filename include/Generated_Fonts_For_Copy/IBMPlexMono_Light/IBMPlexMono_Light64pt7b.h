#ifndef _IBMPLEXMONO_LIGHT64PT7B_H_
#define _IBMPLEXMONO_LIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light64pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8,
  0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x8E, 0x3F, 0x80, 0xFC, 0x1C,
  0x0F, 0xC1, 0xE0, 0x38, 0x0F, 0xC7, 0x80, 0x70, 0x0F, 0x8F, 0x00, 0xE0,
  0x0E, 0x3C, 0x01, 0xC0, 0x08, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x3F, 0x0E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xDF, 0xF0, 0x00, 0x03, 0x87, 0xF0, 0x00,
  0x07, 0x03, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x01,
  0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x7A, 0x00, 0x1C, 0x00, 0xE6, 0x00, 0x38, 0x03, 0xDE, 0x00, 0x70,
  0x07, 0xBE, 0x00, 0xE0, 0x1E, 0x3F, 0x01, 0xC0, 0x7C, 0x3F, 0x03, 0x81,
  0xF0, 0x3F, 0xC7, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF0, 0x7F, 0xE0, 0x00, 0x0E, 0x1F, 0xFF, 0x00, 0x01, 0xE1, 0xE0, 0xF8,
  0x00, 0x1C, 0x3C, 0x03, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x38, 0x70,
  0x01, 0xE0, 0x07, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x0E,
  0x07, 0x00, 0x0E, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x0E,
  0x03, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x70, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x01, 0xC1, 0xE0,
  0x03, 0xC0, 0x3C, 0x1C, 0x00, 0x1E, 0x0F, 0x83, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x0F, 0xFF, 0x80, 0x03, 0x81,
  0xF0, 0x7C, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x38, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x70, 0x00,
  0xF0, 0x1C, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x70, 0x00, 0x70, 0x70, 0x07, 0x00, 0x0F, 0x0E,
  0x00, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x01,
  0xE3, 0xC0, 0x01, 0xC0, 0x1C, 0x38, 0x00, 0x1F, 0x07, 0xC7, 0x80, 0x00,
  0xFF, 0xF8, 0x70, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x3E, 0x78, 0x01, 0xFE, 0x0F, 0x0F, 0x00, 0x7F, 0x87, 0x81, 0xE0,
  0x1C, 0x03, 0xC0, 0x7C, 0x07, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x78, 0x01,
  0xE0, 0x70, 0x1C, 0x00, 0x3C, 0x1C, 0x0F, 0x00, 0x07, 0x87, 0x03, 0xC0,
  0x00, 0xF1, 0xC0, 0xF0, 0x00, 0x1E, 0x60, 0x3C, 0x00, 0x07, 0xB8, 0x0F,
  0x00, 0x00, 0xFE, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x19,
  0xE0, 0x3C, 0x00, 0x0E, 0x3C, 0x0F, 0x80, 0x07, 0x0F, 0x81, 0xFC, 0x0F,
  0x81, 0xF0, 0x3F, 0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0x3F,
  0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x70, 0x00, 0x5F, 0x00, 0x38, 0x01, 0xEF, 0xF0, 0x1C,
  0x07, 0xF7, 0xFF, 0x0E, 0x1F, 0xFC, 0x7F, 0xF7, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF1, 0xF0,
  0xF8, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x7F, 0x7F, 0xFF,
  0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x00,
  0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1E,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF8, 0x07, 0x80, 0x07,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x08,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0x80, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F,
  0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x08, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x1F, 0xE0, 0x03, 0x87, 0xFF, 0xC0, 0x39,
  0xFF, 0xFE, 0x03, 0xBC, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x7C, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF2, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x07, 0xF8, 0x00, 0xF0, 0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0xF0, 0x39, 0xE0,
  0x1F, 0xC3, 0xDC, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x78, 0xFC, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x03,
  0xE0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0D, 0xC3, 0xE0,
  0x01, 0xDE, 0x0F, 0xE0, 0x3E, 0xF0, 0x3F, 0xFF, 0xC7, 0x00, 0xFF, 0xFC,
  0x38, 0x00, 0xFF, 0x83, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F,
  0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F,
  0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x1F, 0x1F, 0xCF, 0xEF, 0xF3, 0xF9, 0xFC,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xC1,
  0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x3E, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x1F,
  0x8F, 0x70, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xEF, 0xF0, 0x1F, 0x07, 0xFE,
  0x03, 0xE0, 0x1F, 0xE0, 0x3C, 0x00, 0xFE, 0x03, 0x80, 0x0F, 0xE0, 0x78,
  0x00, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0xFE, 0x07, 0x00, 0x0F,
  0xE0, 0x70, 0x00, 0xFE, 0x07, 0x00, 0x0F, 0xE0, 0x70, 0x00, 0xFE, 0x07,
  0x00, 0x0F, 0xE0, 0x70, 0x00, 0xFE, 0x07, 0x00, 0x0F, 0xE0, 0x78, 0x00,
  0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x38, 0x00, 0xFE, 0x03, 0x80, 0x0F, 0xE0,
  0x3C, 0x00, 0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x1F, 0x8F, 0xFF, 0x00, 0xFF,
  0xEF, 0x70, 0x07, 0xFC, 0xF7, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01,
  0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x10, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x83, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x3F, 0x0F, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x10, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x37, 0x0F, 0x00, 0x03, 0xB8, 0x3E, 0x00, 0x39, 0xC1,
  0xFC, 0x07, 0x8E, 0x03, 0xFF, 0xF8, 0x70, 0x0F, 0xFF, 0x83, 0x80, 0x0F,
  0xF0, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF3, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0xFE, 0x00,
  0x03, 0xC7, 0xF8, 0x00, 0x0F, 0x3E, 0xF0, 0x00, 0x3D, 0xF3, 0xE0, 0x00,
  0xFF, 0x87, 0x80, 0x03, 0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xBC, 0x00, 0x1D, 0xFD,
  0xE0, 0x00, 0xEF, 0xE7, 0x00, 0x0F, 0x7F, 0x3C, 0x00, 0x73, 0xF8, 0xE0,
  0x07, 0x9F, 0xC7, 0x80, 0x38, 0xFE, 0x1C, 0x01, 0xC7, 0xF0, 0xE0, 0x1C,
  0x3F, 0x87, 0x80, 0xE1, 0xFC, 0x1C, 0x0F, 0x0F, 0xE0, 0xF0, 0x70, 0x7F,
  0x03, 0x87, 0x83, 0xF8, 0x1E, 0x38, 0x1F, 0xC0, 0x71, 0xC0, 0xFE, 0x03,
  0x9C, 0x07, 0xF0, 0x1E, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x78, 0x03, 0xF8, 0x03, 0xC0, 0x1F,
  0xC0, 0x0C, 0x00, 0xFE, 0x00, 0x60, 0x07, 0xF0, 0x01, 0x00, 0x3F, 0x80,
  0x10, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xDC,
  0x00, 0x03, 0xFB, 0xC0, 0x00, 0x7F, 0x78, 0x00, 0x0F, 0xE7, 0x80, 0x01,
  0xFC, 0xF0, 0x00, 0x3F, 0x8F, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0xFE, 0x1E,
  0x00, 0x1F, 0xC3, 0xC0, 0x03, 0xF8, 0x3C, 0x00, 0x7F, 0x07, 0x80, 0x0F,
  0xE0, 0x70, 0x01, 0xFC, 0x0F, 0x00, 0x3F, 0x81, 0xE0, 0x07, 0xF0, 0x1E,
  0x00, 0xFE, 0x03, 0xC0, 0x1F, 0xC0, 0x3C, 0x03, 0xF8, 0x07, 0x80, 0x7F,
  0x00, 0x78, 0x0F, 0xE0, 0x0F, 0x01, 0xFC, 0x00, 0xE0, 0x3F, 0x80, 0x1E,
  0x07, 0xF0, 0x01, 0xC0, 0xFE, 0x00, 0x3C, 0x1F, 0xC0, 0x07, 0x83, 0xF8,
  0x00, 0x78, 0x7F, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF1, 0xFC, 0x00, 0x1E,
  0x3F, 0x80, 0x01, 0xE7, 0xF0, 0x00, 0x3C, 0xFE, 0x00, 0x03, 0x9F, 0xC0,
  0x00, 0x7B, 0xF8, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF8,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00,
  0x10, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF2, 0x00, 0x00,
  0x01, 0xE6, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x7E, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0x7E,
  0x01, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x3E, 0x00,
  0xF3, 0x80, 0x1F, 0x00, 0x71, 0xC0, 0x1F, 0x80, 0x38, 0xF0, 0x0F, 0xC0,
  0x1C, 0x78, 0x07, 0xF0, 0x0E, 0x3C, 0x03, 0xB8, 0x07, 0x1E, 0x03, 0xDC,
  0x03, 0x8F, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0xE7, 0x80, 0xE1, 0xC0, 0x71,
  0xC0, 0xF0, 0xE0, 0x38, 0xE0, 0x78, 0x70, 0x38, 0x70, 0x3C, 0x38, 0x1C,
  0x38, 0x1E, 0x1C, 0x0E, 0x1E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x87,
  0x03, 0x83, 0x83, 0xC3, 0x81, 0xC1, 0xC1, 0xE1, 0xC0, 0xF0, 0xE0, 0xF0,
  0xE0, 0x38, 0x70, 0x78, 0xF0, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x1C, 0x0E,
  0x38, 0x07, 0x9E, 0x07, 0x1C, 0x01, 0xCF, 0x03, 0x9E, 0x00, 0xE7, 0x81,
  0xCE, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x3D, 0xC0, 0x73, 0x80, 0x0E, 0xE0,
  0x3B, 0xC0, 0x07, 0x70, 0x1F, 0xC0, 0x03, 0xB8, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0x1C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x04,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x7E, 0x07, 0x80, 0x03, 0x78, 0x1F, 0xC0, 0x7C, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFC, 0x3F, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x3C,
  0x3F, 0xFC, 0x07, 0x9F, 0xFF, 0xE0, 0xF7, 0x80, 0xFE, 0x1E, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3, 0xF0, 0x00,
  0x3C, 0x7B, 0x00, 0x1F, 0x8F, 0x78, 0x0F, 0xE1, 0xE7, 0xFF, 0xF8, 0x3C,
  0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x02, 0x1E, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0x01, 0xFF, 0xF0, 0xF0, 0x3F, 0xFF,
  0x8F, 0x07, 0xE0, 0x3C, 0xF0, 0xF8, 0x00, 0xEF, 0x1F, 0x00, 0x03, 0xF1,
  0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0xEF, 0x07, 0xE0, 0x3C, 0xF0, 0x3F, 0xFF, 0x8F, 0x01, 0xFF,
  0xF0, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x0F,
  0x00, 0x03, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x38, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0xFC, 0x07,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x30,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x1F, 0x87, 0x00, 0x00, 0x0F,
  0x9C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xFC, 0x03, 0xC3,
  0xFF, 0xC1, 0xE7, 0xFF, 0xF0, 0xF7, 0x80, 0xFC, 0x7B, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0x9F, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3B,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x71, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x1F, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x0F, 0x80,
  0xE0, 0x01, 0xF0, 0x0E, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0xF0, 0x00, 0xE0, 0x3E, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0xE0, 0xF8, 0x00,
  0x0E, 0x1F, 0x80, 0x00, 0xE3, 0xFC, 0x00, 0x0E, 0x7B, 0xE0, 0x00, 0xEF,
  0x1E, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x7C,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xC1,
  0xC7, 0xF8, 0x3F, 0xE3, 0x9F, 0xF8, 0xFF, 0xE7, 0x70, 0xF9, 0x83, 0xCE,
  0x80, 0xF6, 0x03, 0xDE, 0x00, 0xE8, 0x07, 0xBC, 0x01, 0xE0, 0x07, 0x78,
  0x03, 0xC0, 0x0E, 0xE0, 0x07, 0x80, 0x1D, 0xC0, 0x07, 0x00, 0x3B, 0x80,
  0x0E, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x38, 0x01, 0xFC, 0x00,
  0x70, 0x03, 0xF8, 0x00, 0xE0, 0x07, 0xF0, 0x01, 0xC0, 0x0F, 0xE0, 0x03,
  0x80, 0x1F, 0xC0, 0x07, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x7F, 0x00, 0x1C,
  0x00, 0xFE, 0x00, 0x38, 0x01, 0xFC, 0x00, 0x70, 0x03, 0xF8, 0x00, 0xE0,
  0x07, 0xF0, 0x01, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x1F, 0xC0, 0x07, 0x00,
  0x3F, 0x80, 0x0E, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x38, 0x01,
  0xFC, 0x00, 0x70, 0x03, 0xF8, 0x00, 0xE0, 0x07, 0xF0, 0x01, 0xC0, 0x0F,
  0xE0, 0x03, 0x80, 0x1F, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x78,
  0x7F, 0xF8, 0x3C, 0xFF, 0xFE, 0x1E, 0xF0, 0x1F, 0x8F, 0x60, 0x03, 0xE7,
  0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x70, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x1E, 0x1F, 0xFE, 0x03, 0xCF, 0xFF, 0xF0,
  0x7B, 0xC0, 0x7F, 0x0F, 0x60, 0x03, 0xF1, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x79, 0xF8, 0x00, 0x1E, 0x3D, 0x80, 0x0F, 0xC7, 0xBC,
  0x07, 0xF0, 0xF3, 0xFF, 0xFC, 0x1E, 0x1F, 0xFE, 0x03, 0xC0, 0xFF, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x0F,
  0x03, 0xFF, 0xF8, 0xF0, 0x7E, 0x03, 0xCF, 0x0F, 0x80, 0x0E, 0xF1, 0xF0,
  0x00, 0x3F, 0x1E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x3F, 0x0F, 0x80, 0x0E, 0xF0, 0x7E, 0x03, 0xCF, 0x03, 0xFF, 0xF8,
  0xF0, 0x1F, 0xFF, 0x0F, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF8, 0x01, 0xE3, 0x80, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x07, 0xB0,
  0x00, 0x00, 0x0F, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF8,
  0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x08, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x20, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0x3F, 0x00, 0x03, 0xE1, 0xFE,
  0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x17, 0x3C, 0x00, 0x37, 0x3F, 0x81, 0xE7, 0x1F, 0xFF,
  0xC7, 0x07, 0xFF, 0x87, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x1E,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x70, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x77, 0x00, 0x1F, 0x00, 0x1D, 0xC0, 0x0F, 0xC0, 0x07,
  0x70, 0x03, 0xB0, 0x03, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0x33, 0x80,
  0x39, 0xE0, 0x1C, 0xE0, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x8E, 0x01, 0xC6,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x18, 0x70, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x0E, 0x03, 0x83, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x30, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x07, 0x03, 0x83, 0x81,
  0xC1, 0xC0, 0x60, 0xE0, 0x70, 0x70, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x0E,
  0x03, 0x8E, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x30, 0xE0, 0x38, 0xE0, 0x0E,
  0x70, 0x0E, 0x30, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x77, 0x00,
  0x39, 0xC0, 0x1D, 0xC0, 0x06, 0x70, 0x07, 0x70, 0x01, 0xDC, 0x01, 0xD8,
  0x00, 0x76, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x70, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x06, 0x07, 0xF8, 0x00, 0x07, 0x0F, 0xFE, 0x00, 0x07, 0x1F,
  0x1F, 0x00, 0x0E, 0x1C, 0x0F, 0x80, 0x0E, 0x3C, 0x07, 0x80, 0x0E, 0x38,
  0x03, 0xC0, 0x1C, 0x38, 0x01, 0xE0, 0x1C, 0x70, 0x00, 0xF0, 0x38, 0x70,
  0x00, 0x78, 0x78, 0x70, 0x00, 0x3F, 0xF0, 0x70, 0x00, 0x1F, 0xE0, 0xE0,
  0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Light64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 8, 45, 38, 15, -45 },
  { 46, 14, 17, 38, 12, -47 },
  { 76, 36, 45, 38, 1, -45 },
  { 279, 31, 60, 38, 4, -52 },
  { 512, 36, 46, 38, 1, -45 },
  { 719, 34, 46, 38, 2, -45 },
  { 915, 4, 17, 38, 17, -47 },
  { 924, 17, 58, 38, 14, -49 },
  { 1048, 17, 58, 38, 7, -49 },
  { 1172, 33, 32, 38, 3, -35 },
  { 1304, 30, 31, 38, 4, -35 },
  { 1421, 9, 17, 38, 14, -7 },
  { 1441, 18, 3, 38, 10, -21 },
  { 1448, 8, 7, 38, 15, -7 },
  { 1455, 26, 58, 38, 6, -49 },
  { 1644, 30, 46, 38, 4, -45 },
  { 1817, 31, 45, 38, 4, -45 },
  { 1992, 29, 45, 38, 5, -45 },
  { 2156, 28, 46, 38, 4, -45 },
  { 2317, 34, 45, 38, 2, -45 },
  { 2509, 28, 46, 38, 5, -45 },
  { 2670, 29, 46, 38, 5, -45 },
  { 2837, 30, 45, 38, 4, -45 },
  { 3006, 30, 46, 38, 4, -45 },
  { 3179, 29, 45, 38, 5, -45 },
  { 3343, 8, 34, 38, 15, -34 },
  { 3377, 9, 44, 38, 14, -34 },
  { 3427, 28, 36, 38, 5, -38 },
  { 3553, 30, 15, 38, 4, -27 },
  { 3610, 28, 36, 38, 5, -38 },
  { 3736, 27, 45, 38, 5, -45 },
  { 3888, 28, 52, 38, 5, -45 },
  { 4070, 34, 45, 38, 2, -45 },
  { 4262, 28, 45, 38, 6, -45 },
  { 4420, 29, 46, 38, 5, -45 },
  { 4587, 28, 45, 38, 6, -45 },
  { 4745, 27, 45, 38, 6, -45 },
  { 4897, 28, 45, 38, 6, -45 },
  { 5055, 29, 46, 38, 4, -45 },
  { 5222, 27, 45, 38, 6, -45 },
  { 5374, 27, 45, 38, 6, -45 },
  { 5526, 25, 46, 38, 5, -45 },
  { 5670, 30, 45, 38, 6, -45 },
  { 5839, 26, 45, 38, 8, -45 },
  { 5986, 29, 45, 38, 5, -45 },
  { 6150, 27, 45, 38, 6, -45 },
  { 6302, 30, 46, 38, 4, -45 },
  { 6475, 28, 45, 38, 6, -45 },
  { 6633, 30, 55, 38, 4, -45 },
  { 6840, 28, 45, 38, 6, -45 },
  { 6998, 31, 46, 38, 3, -45 },
  { 7177, 34, 45, 38, 2, -45 },
  { 7369, 27, 46, 38, 6, -45 },
  { 7525, 33, 45, 38, 3, -45 },
  { 7711, 33, 45, 38, 3, -45 },
  { 7897, 34, 45, 38, 2, -45 },
  { 8089, 36, 45, 38, 1, -45 },
  { 8292, 32, 45, 38, 3, -45 },
  { 8472, 17, 58, 38, 15, -49 },
  { 8596, 26, 58, 38, 6, -49 },
  { 8785, 17, 58, 38, 6, -49 },
  { 8909, 32, 25, 38, 3, -45 },
  { 9009, 31, 3, 38, 4, 7 },
  { 9021, 10, 12, 38, 12, -50 },
  { 9036, 30, 35, 38, 5, -34 },
  { 9168, 27, 48, 38, 7, -47 },
  { 9330, 27, 35, 38, 6, -34 },
  { 9449, 28, 48, 38, 4, -47 },
  { 9617, 29, 35, 38, 5, -34 },
  { 9744, 30, 47, 38, 5, -47 },
  { 9921, 31, 51, 38, 5, -37 },
  { 10119, 25, 47, 38, 7, -47 },
  { 10266, 28, 48, 38, 7, -48 },
  { 10434, 23, 61, 38, 6, -48 },
  { 10610, 28, 47, 38, 8, -47 },
  { 10775, 28, 47, 38, 5, -47 },
  { 10940, 31, 34, 38, 4, -34 },
  { 11072, 25, 34, 38, 7, -34 },
  { 11179, 29, 35, 38, 5, -34 },
  { 11306, 27, 47, 38, 7, -34 },
  { 11465, 28, 47, 38, 4, -34 },
  { 11630, 31, 33, 38, 5, -33 },
  { 11758, 28, 35, 38, 5, -34 },
  { 11881, 32, 45, 38, 2, -45 },
  { 12061, 24, 34, 38, 7, -33 },
  { 12163, 29, 33, 38, 5, -33 },
  { 12283, 34, 33, 38, 2, -33 },
  { 12424, 29, 33, 38, 5, -33 },
  { 12544, 30, 46, 38, 4, -33 },
  { 12717, 27, 33, 38, 6, -33 },
  { 12829, 24, 58, 38, 7, -49 },
  { 13003, 3, 58, 38, 18, -49 },
  { 13025, 24, 58, 38, 7, -49 },
  { 13199, 32, 13, 38, 3, -26 },
};

const GFXfont IBMPlexMono_Light64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_LIGHT64PT7B_H_
