#ifndef _IBMPLEXMONO_LIGHT31PT7B_H_
#define _IBMPLEXMONO_LIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light31pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x62, 0x22, 0x22, 0x20, 0x00, 0x07, 0xF7,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x03, 0x0C, 0x01, 0x86, 0x00,
  0xC2, 0x00, 0x61, 0x00, 0x21, 0x80, 0x10, 0xC0, 0x18, 0x60, 0xFC, 0x3F,
  0x7E, 0x1F, 0x83, 0x08, 0x01, 0x0C, 0x00, 0x86, 0x00, 0xC3, 0x07, 0xE1,
  0xFB, 0xF0, 0xFC, 0x18, 0xC0, 0x08, 0x60, 0x04, 0x30, 0x06, 0x18, 0x03,
  0x08, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x7F, 0x03, 0xFF, 0x0E, 0x27, 0x98, 0x43, 0x60, 0x83, 0xC1, 0x01, 0x82,
  0x01, 0x84, 0x03, 0x88, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x9E,
  0x01, 0x0C, 0x02, 0x0C, 0x04, 0x18, 0x08, 0x3C, 0x10, 0x7C, 0x21, 0x9C,
  0x47, 0x1F, 0xFC, 0x0F, 0xE0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x3C,
  0x01, 0xBF, 0x81, 0xB8, 0xC0, 0xD8, 0x30, 0xC8, 0x18, 0x44, 0x0C, 0x62,
  0x06, 0x21, 0x83, 0x30, 0xE3, 0x10, 0x3F, 0x90, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x07, 0xF0, 0x67, 0x18, 0x23, 0x06, 0x31, 0x03, 0x10, 0x81, 0x98,
  0x40, 0xC8, 0x30, 0x6C, 0x1C, 0x64, 0x07, 0xF6, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0xE0, 0x18, 0x70, 0x30, 0x30, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1E, 0x0F, 0x37, 0x0F, 0x63, 0x8C,
  0xC1, 0xCC, 0xC0, 0xC8, 0xC0, 0x68, 0xC0, 0x38, 0xC0, 0x38, 0xE0, 0x3C,
  0x70, 0x6C, 0x3F, 0xC6, 0x1F, 0x83, 0xFF, 0xFF, 0x07, 0x0C, 0x08, 0x18,
  0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x07,
  0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x08,
  0x18, 0x30, 0x60, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x61, 0x83, 0xFD, 0x9F, 0x0F, 0xF8, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x77, 0x66, 0xEC, 0xCC, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0x70, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x00, 0xC8, 0x01, 0xB0,
  0x03, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x00, 0xF0, 0x01, 0x60, 0x06, 0x40, 0x0C, 0xC0, 0x19, 0xC0, 0x61,
  0xC1, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0xEC, 0x03, 0x98, 0x0E, 0x30, 0x38, 0x60, 0x20, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x07, 0xFF, 0xEF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x18, 0x06, 0x60, 0x1B, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0x07, 0x98, 0x06, 0x40, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x70, 0x3F, 0x00, 0xFE, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0D, 0x00, 0x6C, 0x01,
  0x9C, 0x1C, 0x3F, 0xE0, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x58,
  0x00, 0xD8, 0x01, 0x98, 0x01, 0x18, 0x03, 0x18, 0x06, 0x18, 0x04, 0x18,
  0x0C, 0x18, 0x18, 0x18, 0x10, 0x18, 0x30, 0x18, 0x60, 0x18, 0x40, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x3F, 0xF8, 0xFF, 0xE2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x67, 0xC1, 0xBF, 0xC7, 0x83, 0x98, 0x07, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0D, 0x00, 0x3E, 0x01, 0x8E,
  0x0E, 0x1F, 0xF0, 0x3F, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x67, 0xC1, 0xBF, 0xC7, 0x83,
  0xB8, 0x07, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80,
  0x36, 0x01, 0x8E, 0x0E, 0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x02, 0xC0, 0x1B, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x0F,
  0xC0, 0x7F, 0xE1, 0xE0, 0xE3, 0x00, 0xE6, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x18, 0x70, 0x70, 0x7F, 0x80, 0xFF, 0x03, 0x03, 0x8C,
  0x01, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x33, 0x81,
  0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x98, 0x06,
  0x60, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x36, 0x01,
  0xCE, 0x0B, 0x3F, 0xEC, 0x3E, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0x7F, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF7, 0x7F, 0x70, 0x00, 0x00, 0x00, 0x00, 0x77, 0x66,
  0xEC, 0xCC, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x00, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x18,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x00, 0x80,
  0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1D, 0xC0, 0x6C, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x01, 0xF0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x8C, 0x06, 0x60, 0x09, 0x80, 0x34,
  0x1E, 0xD0, 0xFF, 0xC7, 0x1F, 0x18, 0x3C, 0x60, 0xF1, 0x03, 0xC4, 0x0F,
  0x10, 0x3C, 0x40, 0xF1, 0x83, 0xC6, 0x0D, 0x0F, 0xF4, 0x1E, 0xD8, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x60, 0x06, 0x30, 0x06,
  0x30, 0x0C, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x1F, 0xFC, 0x3F, 0xFC, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60,
  0x03, 0x60, 0x03, 0xC0, 0x03, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x6C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x02, 0xC0, 0x36, 0x03, 0x3F, 0xF1, 0xFF,
  0xCC, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x7F, 0xFF, 0x7F, 0xE0, 0x07, 0xC0, 0x7F, 0xC3, 0xC3, 0x8C, 0x03,
  0x60, 0x0D, 0x80, 0x26, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x09, 0x80,
  0x33, 0x00, 0xCF, 0x0E, 0x1F, 0xF0, 0x1F, 0x00, 0xFF, 0x83, 0xFF, 0x8C,
  0x0F, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x02, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xB0, 0x06,
  0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x3C, 0xFF, 0xE3, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFD, 0xFF, 0xEC, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x07,
  0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x0D, 0x80, 0x2C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x7F, 0xC1, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x60, 0x0D, 0x80, 0x37, 0x01, 0xCE, 0x0F, 0x1F, 0xEC,
  0x3F, 0x30, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0C, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x3C, 0x06, 0xC0, 0x66, 0x0E, 0x7F, 0xC1, 0xF0, 0xC0,
  0x0D, 0x80, 0x33, 0x00, 0xC6, 0x03, 0x0C, 0x0E, 0x18, 0x38, 0x30, 0x60,
  0x61, 0x80, 0xC6, 0x01, 0x9C, 0x03, 0x78, 0x07, 0xD8, 0x0F, 0x38, 0x1C,
  0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x61, 0x80, 0x63, 0x00, 0xC6, 0x00,
  0xCC, 0x01, 0xD8, 0x01, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xF4, 0x0D, 0xD8, 0x37, 0x60,
  0x9C, 0x86, 0x73, 0x11, 0xC4, 0xC7, 0x1B, 0x1C, 0x68, 0x70, 0xE1, 0xC3,
  0x07, 0x04, 0x1C, 0x20, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x10, 0xE0, 0x1F, 0x00, 0xE8, 0x07, 0x60, 0x3B,
  0x01, 0xCC, 0x0E, 0x60, 0x71, 0x83, 0x8C, 0x1C, 0x30, 0xE1, 0x87, 0x04,
  0x38, 0x31, 0xC1, 0x8E, 0x06, 0x70, 0x33, 0x80, 0xDC, 0x06, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x0F, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80,
  0xC6, 0x00, 0xC8, 0x01, 0xB0, 0x03, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x60, 0x06, 0x40,
  0x0C, 0xC0, 0x19, 0xC0, 0x61, 0xC1, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0xFF,
  0xC3, 0xFF, 0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0xBF, 0xFC, 0xFF, 0xC3, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x00, 0xC8,
  0x01, 0xB0, 0x03, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x60, 0x06, 0x40, 0x0C, 0xC0, 0x19,
  0xC0, 0x61, 0xC1, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0xFF, 0xC3, 0xFF, 0xCC, 0x03, 0xB0, 0x06,
  0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1B, 0x00, 0x6C, 0x03,
  0xBF, 0xFC, 0xFF, 0xC3, 0x0C, 0x0C, 0x18, 0x30, 0x70, 0xC0, 0xC3, 0x01,
  0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x70, 0x0F, 0xE0, 0x7F, 0xE1,
  0xC0, 0xF3, 0x00, 0x6C, 0x00, 0x98, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x07, 0x80, 0x1B, 0x80, 0x33, 0x81, 0xE3, 0xFF, 0x81,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x0C, 0xE0, 0xE7, 0xFE, 0x0F,
  0xE0, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x08, 0x08, 0x18, 0x0C,
  0x18, 0x0C, 0x10, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x02,
  0x60, 0x03, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x61, 0xC3, 0x61,
  0xC3, 0x61, 0xC3, 0x63, 0x42, 0x63, 0x42, 0x62, 0x62, 0x62, 0x62, 0x66,
  0x22, 0x26, 0x26, 0x26, 0x36, 0x24, 0x36, 0x2C, 0x16, 0x3C, 0x16, 0x3C,
  0x1E, 0x38, 0x1E, 0x38, 0x1C, 0xE0, 0x03, 0x38, 0x03, 0x0C, 0x01, 0x83,
  0x01, 0x81, 0x81, 0x80, 0x60, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x03, 0x60,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x18,
  0xC0, 0x18, 0x60, 0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC6,
  0x00, 0x76, 0x00, 0x1C, 0xC0, 0x01, 0xB0, 0x01, 0x98, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x60, 0x18, 0x60, 0x06, 0x30, 0x03,
  0x30, 0x00, 0xD8, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xF0, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0x0F,
  0x00, 0x1B, 0x00, 0x66, 0x00, 0xC6, 0x03, 0x04, 0x04, 0x0C, 0x18, 0x0C,
  0x60, 0x18, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFC,
  0x46, 0x18, 0x43, 0x0C, 0x0F, 0x80, 0x7F, 0xC1, 0xC1, 0xC2, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x0F, 0xF8, 0x7F, 0xF0, 0xC0, 0x23, 0x00,
  0x46, 0x00, 0x8C, 0x07, 0x0C, 0x0A, 0x1F, 0xE7, 0x8F, 0x87, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xF8, 0xDF,
  0xE6, 0x83, 0xB8, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x7D, 0x07, 0x6F, 0xF3, 0x1F, 0x00,
  0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C, 0x01, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x26, 0x01, 0xB8, 0x38, 0xFF,
  0x81, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x21, 0xF1, 0x3F, 0xCB, 0xC3, 0x58, 0x06, 0xC0, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x58, 0x06, 0xC0, 0x37, 0x82,
  0x9F, 0xE4, 0x3E, 0x20, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x98, 0x02, 0x60,
  0x0D, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x02, 0x70, 0x1C, 0xE0, 0xE1, 0xFF, 0x01, 0xF0, 0x01, 0xFE, 0x07, 0xFC,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x0F,
  0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0x40, 0xFF, 0x83,
  0x83, 0x86, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x30, 0x18, 0x70, 0x70, 0x7F,
  0xC0, 0x7E, 0x01, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x40, 0x1D, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x6E, 0x01, 0xDF, 0xFF, 0x0F,
  0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x7C, 0xCF, 0xED, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x7F, 0xEF, 0xFC, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x0E, 0x80,
  0x62, 0x03, 0x08, 0x18, 0x20, 0xC0, 0x8E, 0x02, 0x70, 0x0B, 0x60, 0x38,
  0xC0, 0xC3, 0x82, 0x06, 0x08, 0x0C, 0x20, 0x18, 0x80, 0x72, 0x00, 0xC8,
  0x01, 0xC0, 0xFE, 0x07, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x7F, 0xFF, 0xFF, 0xE0, 0xDE, 0x39, 0xFC, 0xFB, 0x8E, 0x36, 0x18, 0x3C,
  0x30, 0x78, 0x60, 0xF0, 0xC1, 0xE1, 0x83, 0xC3, 0x07, 0x86, 0x0F, 0x0C,
  0x1E, 0x18, 0x3C, 0x30, 0x78, 0x60, 0xF0, 0xC1, 0xE1, 0x83, 0xC7, 0xCC,
  0xFE, 0xD0, 0x7E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x0F, 0xC0,
  0x7F, 0xC3, 0x83, 0x98, 0x06, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x34, 0x00, 0xD8, 0x03, 0x60, 0x18, 0xE0, 0xE1, 0xFF,
  0x03, 0xF0, 0xC7, 0xC6, 0xFF, 0x34, 0x1D, 0xC0, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3E, 0x03, 0xE8,
  0x3B, 0x7F, 0x98, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x0F, 0x89, 0xFE, 0x5E, 0x1A, 0xC0, 0x36, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0xC0, 0x36, 0x01, 0xBC,
  0x14, 0xFF, 0x21, 0xF1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0xFE, 0x3F, 0xFC, 0xFC, 0x1B, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x3F, 0xFF, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xC3,
  0x03, 0xD8, 0x02, 0x60, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x40, 0x0F, 0xC0, 0x73, 0xFF, 0x83, 0xF8,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x37, 0x07, 0x3F, 0xB1, 0xF3, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0x88,
  0x06, 0x30, 0x18, 0xC0, 0x41, 0x03, 0x06, 0x0C, 0x18, 0x60, 0x21, 0x80,
  0xC4, 0x01, 0x30, 0x06, 0xC0, 0x1A, 0x00, 0x38, 0x00, 0xE0, 0xC1, 0x81,
  0xE0, 0xE0, 0xB0, 0x50, 0x48, 0x68, 0x64, 0x34, 0x32, 0x13, 0x19, 0x89,
  0x8C, 0xC4, 0x44, 0x66, 0x22, 0x13, 0x1B, 0x09, 0x0D, 0x84, 0x82, 0xC3,
  0xC1, 0x61, 0xE0, 0xA0, 0xE0, 0x70, 0x30, 0x38, 0xE0, 0x0D, 0xC0, 0x63,
  0x03, 0x06, 0x0C, 0x0C, 0x60, 0x3B, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x1F, 0x00, 0xCC, 0x03, 0x18, 0x18, 0x30, 0xC0, 0xE6, 0x01, 0xB8, 0x03,
  0xC0, 0x06, 0x80, 0x19, 0x80, 0x33, 0x00, 0xC3, 0x01, 0x86, 0x02, 0x06,
  0x0C, 0x0C, 0x10, 0x08, 0x60, 0x18, 0xC0, 0x31, 0x00, 0x36, 0x00, 0x68,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x03, 0x0F, 0xE0, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x0E, 0x00, 0x7F, 0x03, 0xF0, 0xE0, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0x0F, 0xE0,
  0x3C, 0x06, 0xFC, 0x0D, 0x9C, 0x16, 0x18, 0x6C, 0x18, 0xD0, 0x1F, 0x20,
  0x1C, 0x00,
};

const GFXglyph IBMPlexMono_Light31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 4, 22, 19, 7, -22 },
  { 12, 7, 8, 19, 6, -23 },
  { 19, 17, 22, 19, 1, -22 },
  { 66, 15, 28, 19, 2, -25 },
  { 119, 17, 22, 19, 1, -22 },
  { 166, 16, 22, 19, 1, -22 },
  { 210, 2, 8, 19, 8, -23 },
  { 212, 8, 28, 19, 7, -24 },
  { 240, 8, 28, 19, 4, -24 },
  { 268, 16, 15, 19, 1, -17 },
  { 298, 15, 16, 19, 2, -17 },
  { 328, 4, 9, 19, 7, -4 },
  { 333, 9, 2, 19, 5, -10 },
  { 336, 4, 3, 19, 7, -3 },
  { 338, 13, 28, 19, 3, -24 },
  { 384, 15, 22, 19, 2, -22 },
  { 426, 15, 22, 19, 2, -22 },
  { 468, 14, 22, 19, 2, -22 },
  { 507, 14, 22, 19, 2, -22 },
  { 546, 16, 22, 19, 1, -22 },
  { 590, 14, 22, 19, 2, -22 },
  { 629, 14, 22, 19, 2, -22 },
  { 668, 14, 22, 19, 2, -22 },
  { 707, 15, 22, 19, 2, -22 },
  { 749, 14, 22, 19, 2, -22 },
  { 788, 4, 16, 19, 7, -16 },
  { 796, 4, 21, 19, 7, -16 },
  { 807, 13, 17, 19, 3, -18 },
  { 835, 15, 7, 19, 2, -13 },
  { 849, 13, 17, 19, 3, -18 },
  { 877, 13, 22, 19, 3, -22 },
  { 913, 14, 25, 19, 2, -22 },
  { 957, 16, 22, 19, 1, -22 },
  { 1001, 13, 22, 19, 3, -22 },
  { 1037, 14, 22, 19, 2, -22 },
  { 1076, 14, 22, 19, 3, -22 },
  { 1115, 13, 22, 19, 3, -22 },
  { 1151, 13, 22, 19, 3, -22 },
  { 1187, 14, 22, 19, 2, -22 },
  { 1226, 13, 22, 19, 3, -22 },
  { 1262, 13, 22, 19, 3, -22 },
  { 1298, 12, 22, 19, 3, -22 },
  { 1331, 15, 22, 19, 3, -22 },
  { 1373, 12, 22, 19, 4, -22 },
  { 1406, 14, 22, 19, 2, -22 },
  { 1445, 13, 22, 19, 3, -22 },
  { 1481, 15, 22, 19, 2, -22 },
  { 1523, 14, 22, 19, 3, -22 },
  { 1562, 15, 27, 19, 2, -22 },
  { 1613, 14, 22, 19, 3, -22 },
  { 1652, 15, 22, 19, 2, -22 },
  { 1694, 17, 22, 19, 1, -22 },
  { 1741, 13, 22, 19, 3, -22 },
  { 1777, 16, 22, 19, 1, -22 },
  { 1821, 16, 22, 19, 1, -22 },
  { 1865, 17, 22, 19, 1, -22 },
  { 1912, 17, 22, 19, 1, -22 },
  { 1959, 16, 22, 19, 1, -22 },
  { 2003, 9, 28, 19, 7, -24 },
  { 2035, 13, 28, 19, 3, -24 },
  { 2081, 8, 28, 19, 3, -24 },
  { 2109, 15, 12, 19, 2, -22 },
  { 2132, 15, 2, 19, 2, 3 },
  { 2136, 5, 6, 19, 6, -24 },
  { 2140, 15, 16, 19, 2, -16 },
  { 2170, 13, 23, 19, 3, -23 },
  { 2208, 13, 16, 19, 3, -16 },
  { 2234, 13, 23, 19, 2, -23 },
  { 2272, 14, 16, 19, 2, -16 },
  { 2300, 15, 23, 19, 2, -23 },
  { 2344, 15, 24, 19, 2, -18 },
  { 2389, 12, 23, 19, 3, -23 },
  { 2424, 14, 23, 19, 3, -23 },
  { 2465, 11, 29, 19, 3, -23 },
  { 2505, 14, 23, 19, 4, -23 },
  { 2546, 13, 23, 19, 3, -23 },
  { 2584, 15, 16, 19, 2, -16 },
  { 2614, 12, 16, 19, 3, -16 },
  { 2638, 14, 16, 19, 2, -16 },
  { 2666, 13, 22, 19, 3, -16 },
  { 2702, 13, 22, 19, 2, -16 },
  { 2738, 15, 16, 19, 2, -16 },
  { 2768, 14, 16, 19, 2, -16 },
  { 2796, 15, 22, 19, 1, -22 },
  { 2838, 12, 16, 19, 3, -16 },
  { 2862, 14, 16, 19, 2, -16 },
  { 2890, 17, 16, 19, 1, -16 },
  { 2924, 14, 16, 19, 2, -16 },
  { 2952, 15, 22, 19, 2, -16 },
  { 2994, 13, 16, 19, 3, -16 },
  { 3020, 12, 28, 19, 3, -24 },
  { 3062, 1, 28, 19, 9, -24 },
  { 3066, 12, 28, 19, 3, -24 },
  { 3108, 15, 7, 19, 2, -13 },
};

const GFXfont IBMPlexMono_Light31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_LIGHT31PT7B_H_
