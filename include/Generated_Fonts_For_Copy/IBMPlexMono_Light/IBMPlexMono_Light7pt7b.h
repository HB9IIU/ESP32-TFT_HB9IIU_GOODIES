#ifndef _IBMPLEXMONO_LIGHT7PT7B_H_
#define _IBMPLEXMONO_LIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x66, 0xFB, 0xA0, 0x4F, 0xC6, 0x5D, 0x60, 0xDE, 0x0F,
  0xF0, 0xE8, 0x5A, 0xF0, 0xC0, 0xFC, 0xA5, 0xA0, 0x4D, 0x2E, 0x44, 0xF4,
  0xE0, 0xC0, 0x80, 0x6A, 0x49, 0x00, 0x69, 0xD9, 0xE0, 0x6A, 0x22, 0x70,
  0xCD, 0x4E, 0xE2, 0x61, 0xE0, 0x26, 0xAA, 0x70, 0xD3, 0x1C, 0xD3, 0x5C,
  0xF2, 0x24, 0x40, 0x69, 0x69, 0xF0, 0xD6, 0xAC, 0x90, 0x93, 0x80, 0x72,
  0x30, 0xFF, 0x89, 0xC0, 0xC5, 0x48, 0xDE, 0xDD, 0x80, 0x46, 0xA6, 0x90,
  0xD7, 0x5C, 0xD6, 0x4E, 0xD6, 0xDC, 0xF3, 0xCE, 0xF3, 0x48, 0x69, 0x8B,
  0xF0, 0xB7, 0xDA, 0xF2, 0x4E, 0xD5, 0xC0, 0xBA, 0x6A, 0x92, 0x4E, 0xB7,
  0xDA, 0xB6, 0xFA, 0x69, 0x99, 0xE0, 0xD7, 0x48, 0x69, 0x99, 0xA6, 0xD7,
  0x6E, 0xE9, 0x61, 0xF0, 0xF4, 0x44, 0x40, 0xB6, 0xDC, 0x9A, 0xA6, 0x20,
  0x9D, 0xB7, 0x90, 0x96, 0x46, 0x90, 0x9A, 0x64, 0x40, 0xF2, 0x44, 0xF0,
  0xEA, 0xB0, 0x92, 0x24, 0xC0, 0xD5, 0x70, 0x2E, 0x90, 0xF0, 0x80, 0x62,
  0xEF, 0x9A, 0xDC, 0xD6, 0x70, 0x2E, 0xDE, 0xD7, 0x70, 0xFE, 0x4E, 0xFB,
  0x4E, 0xBF, 0xC0, 0x59, 0x2E, 0x75, 0x70, 0x97, 0x6A, 0x92, 0x4E, 0xFD,
  0xDD, 0xFF, 0xD6, 0xE0, 0xD6, 0xE8, 0x76, 0xD6, 0xBA, 0x70, 0xD5, 0xF0,
  0x4F, 0x44, 0x70, 0xFF, 0xBB, 0x20, 0xDB, 0x7A, 0x96, 0x2F, 0x9A, 0x64,
  0x40, 0xCA, 0x70, 0xE7, 0xB0, 0xFC, 0xAB, 0xA0, 0x5A,
};

const GFXglyph IBMPlexMono_Light7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 1, 6, 4, 2, -5 },
  { 18, 2, 6, 4, 1, -5 },
  { 20, 4, 4, 4, 0, -4 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 2, 2, 4, 1, -1 },
  { 25, 2, 1, 4, 1, -3 },
  { 26, 1, 1, 4, 2, -1 },
  { 27, 3, 6, 4, 1, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 1, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 3, 5, 4, 1, -5 },
  { 46, 3, 5, 4, 1, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 3, 5, 4, 1, -5 },
  { 56, 1, 4, 4, 2, -4 },
  { 57, 2, 5, 4, 1, -4 },
  { 59, 3, 4, 4, 1, -4 },
  { 61, 4, 2, 4, 0, -3 },
  { 62, 3, 4, 4, 1, -4 },
  { 64, 3, 5, 4, 1, -5 },
  { 66, 3, 6, 4, 1, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 3, 5, 4, 1, -5 },
  { 80, 3, 5, 4, 1, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 1, -5 },
  { 89, 2, 5, 4, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 3, 5, 4, 1, -5 },
  { 95, 3, 5, 4, 1, -5 },
  { 97, 3, 5, 4, 1, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 3, 5, 4, 1, -5 },
  { 104, 4, 6, 4, 0, -5 },
  { 107, 3, 5, 4, 1, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 3, 5, 4, 1, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 2, 6, 4, 2, -5 },
  { 134, 3, 6, 4, 1, -5 },
  { 137, 2, 6, 4, 1, -5 },
  { 139, 4, 3, 4, 0, -5 },
  { 141, 4, 1, 4, 0, 0 },
  { 142, 1, 1, 4, 1, -5 },
  { 143, 4, 4, 4, 0, -4 },
  { 145, 3, 5, 4, 1, -5 },
  { 147, 3, 4, 4, 1, -4 },
  { 149, 3, 5, 4, 0, -5 },
  { 151, 3, 4, 4, 1, -4 },
  { 153, 3, 5, 4, 1, -5 },
  { 155, 3, 5, 4, 1, -4 },
  { 157, 2, 5, 4, 1, -5 },
  { 159, 3, 5, 4, 1, -5 },
  { 161, 2, 6, 4, 1, -5 },
  { 163, 3, 5, 4, 1, -5 },
  { 165, 3, 5, 4, 1, -5 },
  { 167, 4, 4, 4, 0, -4 },
  { 169, 2, 4, 4, 1, -4 },
  { 170, 3, 4, 4, 1, -4 },
  { 172, 3, 5, 4, 1, -4 },
  { 174, 3, 5, 4, 0, -4 },
  { 176, 3, 4, 4, 1, -4 },
  { 178, 3, 4, 4, 1, -4 },
  { 180, 4, 5, 4, 0, -5 },
  { 183, 2, 4, 4, 1, -4 },
  { 184, 3, 4, 4, 1, -4 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 5, 4, 0, -4 },
  { 193, 3, 4, 4, 1, -4 },
  { 195, 2, 6, 4, 1, -5 },
  { 197, 1, 6, 4, 2, -5 },
  { 198, 2, 6, 4, 1, -5 },
  { 200, 4, 2, 4, 0, -3 },
};

const GFXfont IBMPlexMono_Light7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_LIGHT7PT7B_H_
