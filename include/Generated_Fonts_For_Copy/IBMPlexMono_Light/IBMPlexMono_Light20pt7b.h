#ifndef _IBMPLEXMONO_LIGHT20PT7B_H_
#define _IBMPLEXMONO_LIGHT20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFA, 0xA0, 0xF0, 0x99, 0x99, 0x90, 0x04, 0xC0, 0x48, 0x0C,
  0x80, 0x88, 0x78, 0xF0, 0x88, 0x09, 0x00, 0x90, 0x11, 0x0F, 0x1E, 0x11,
  0x01, 0x30, 0x12, 0x03, 0x20, 0x04, 0x01, 0x03, 0xF1, 0x96, 0x44, 0xD1,
  0x04, 0x41, 0x90, 0x3C, 0x01, 0xE0, 0x4C, 0x11, 0x04, 0x61, 0x36, 0x58,
  0xFC, 0x04, 0x01, 0x00, 0x38, 0x34, 0x42, 0x44, 0x44, 0x44, 0x44, 0x84,
  0x50, 0x38, 0x00, 0x1C, 0x0A, 0x21, 0x22, 0x22, 0x22, 0x22, 0x42, 0x2C,
  0x1C, 0x3C, 0x18, 0x84, 0x31, 0x00, 0x40, 0x08, 0x03, 0x0D, 0x64, 0x8D,
  0x21, 0x48, 0x32, 0x04, 0xC2, 0x9F, 0x30, 0xFF, 0xC0, 0x0C, 0x42, 0x08,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x30, 0xC0,
  0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x42, 0x08, 0x21, 0x04, 0x23,
  0x00, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0x7F, 0x83, 0x01, 0xE0, 0x48, 0x21,
  0x18, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC3, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x6D, 0x28, 0xFC, 0xF0, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80,
  0x1E, 0x08, 0x44, 0x09, 0x02, 0xC0, 0xF0, 0x3C, 0xCF, 0x33, 0xC0, 0xF0,
  0x34, 0x09, 0x02, 0x21, 0x07, 0x80, 0x0C, 0x05, 0x02, 0x41, 0x10, 0x84,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x1F, 0xF0,
  0x1E, 0x18, 0x44, 0x1B, 0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x1F, 0xF0, 0x3E, 0x30, 0x90, 0x60, 0x10, 0x18,
  0x08, 0x78, 0x06, 0x00, 0x80, 0x40, 0x30, 0x14, 0x11, 0xF0, 0x03, 0x01,
  0x40, 0x50, 0x24, 0x11, 0x04, 0x42, 0x11, 0x84, 0x41, 0x20, 0x4F, 0xFC,
  0x04, 0x01, 0x00, 0x40, 0x7F, 0xC0, 0x80, 0x80, 0x80, 0xBC, 0xC3, 0x01,
  0x01, 0x01, 0x01, 0x81, 0xC2, 0x7C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x17, 0x86, 0x19, 0x02, 0xC0, 0xB0, 0x34, 0x09, 0x02, 0x21, 0x07, 0x80,
  0xFF, 0xC0, 0x60, 0x30, 0x20, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x3F, 0x18, 0x64, 0x09, 0x02, 0x40, 0x88, 0x41,
  0xE1, 0x86, 0x40, 0xA0, 0x18, 0x07, 0x03, 0x61, 0x8F, 0xC0, 0x1E, 0x08,
  0x64, 0x09, 0x02, 0x40, 0xF0, 0x34, 0x09, 0x86, 0x1E, 0x80, 0x60, 0x10,
  0x08, 0x04, 0x06, 0x00, 0xF0, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x6D, 0x28,
  0x01, 0x03, 0x0C, 0x30, 0xC0, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0x03, 0x0C, 0x30, 0xC0, 0x80, 0x3C, 0x42, 0x81, 0x81, 0x01, 0x03, 0x06,
  0x18, 0x10, 0x10, 0x00, 0x00, 0x18, 0x38, 0x1E, 0x10, 0x90, 0x28, 0x14,
  0x7A, 0x45, 0x63, 0xA1, 0xD0, 0xAC, 0x52, 0x29, 0xF4, 0x02, 0x00, 0x80,
  0x3E, 0x0C, 0x03, 0x01, 0xE0, 0x48, 0x12, 0x0C, 0xC2, 0x10, 0x84, 0x21,
  0x1F, 0xE4, 0x09, 0x02, 0xC0, 0xE0, 0x10, 0xFE, 0x41, 0xA0, 0x50, 0x28,
  0x14, 0x13, 0xF1, 0x06, 0x81, 0x40, 0xE0, 0x70, 0x28, 0x37, 0xF0, 0x1F,
  0x0C, 0x66, 0x09, 0x01, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x83, 0x31, 0x87, 0xC0, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x50, 0x28, 0x27, 0xE0, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFD, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x1E, 0x10, 0xD0, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x8F,
  0xC0, 0xE0, 0x50, 0x28, 0x12, 0x18, 0xF4, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x7E,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x1C, 0x6F, 0x80,
  0x81, 0xC1, 0xA0, 0x90, 0x88, 0x84, 0x82, 0xE1, 0xD0, 0xCC, 0x42, 0x20,
  0x90, 0x68, 0x14, 0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0xF8, 0x7E, 0x1F, 0xC7, 0xD2,
  0xF4, 0xBC, 0xCF, 0x33, 0xC8, 0xF2, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30,
  0xC1, 0xC1, 0xE1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x87,
  0x83, 0x83, 0x1E, 0x08, 0x44, 0x09, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x34, 0x09, 0x02, 0x21, 0x07, 0x80, 0xFE, 0x40, 0xA0, 0x70,
  0x38, 0x1C, 0x0E, 0x05, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x1E, 0x08, 0x44, 0x09, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x34, 0x09, 0x02, 0x21, 0x07, 0x80, 0xC0, 0x30, 0x07, 0x80, 0xFE, 0x40,
  0xA0, 0x70, 0x38, 0x1C, 0x0E, 0x05, 0xFC, 0x88, 0x42, 0x21, 0x90, 0x48,
  0x34, 0x0C, 0x3F, 0x18, 0x64, 0x0F, 0x00, 0x40, 0x18, 0x03, 0xC0, 0x0E,
  0x00, 0x80, 0x30, 0x06, 0x03, 0x61, 0x8F, 0xC0, 0xFF, 0xC3, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC3, 0x3C, 0x80, 0x70, 0x34, 0x09, 0x02, 0x40, 0x88, 0x42,
  0x10, 0x84, 0x33, 0x04, 0x81, 0x20, 0x78, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x8C, 0x63, 0x18, 0xC5, 0x4A, 0x52, 0x94, 0xA5, 0x29,
  0x86, 0x61, 0x98, 0x60, 0xC0, 0x50, 0x22, 0x18, 0xC4, 0x12, 0x07, 0x80,
  0xC0, 0x30, 0x1A, 0x04, 0x82, 0x11, 0x86, 0x40, 0xA0, 0x10, 0xC0, 0x36,
  0x06, 0x20, 0x41, 0x08, 0x10, 0x80, 0x90, 0x0F, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xC0, 0x20, 0x18, 0x04,
  0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x3F,
  0xF0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87,
  0xC0, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0xC0, 0x0C, 0x03, 0x01, 0x20, 0xCC,
  0x21, 0x10, 0x24, 0x0A, 0x01, 0xFF, 0xC0, 0x99, 0x10, 0x3E, 0x10, 0xC0,
  0x10, 0x04, 0x3F, 0x10, 0x4C, 0x13, 0x04, 0x43, 0x0F, 0x30, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0xF3, 0x8D, 0x02, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x16, 0x1A, 0xF8, 0x3E, 0x43, 0xC1, 0x80, 0x80, 0x80, 0x80, 0xC1, 0x43,
  0x3E, 0x00, 0x80, 0x40, 0x20, 0x10, 0x09, 0xE5, 0x8A, 0x83, 0xC0, 0xE0,
  0x70, 0x38, 0x14, 0x0B, 0x1C, 0xF2, 0x3C, 0x43, 0x81, 0x81, 0xFF, 0x80,
  0x80, 0x81, 0x43, 0x3C, 0x0F, 0x8C, 0x06, 0x03, 0x01, 0x87, 0xFC, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC3, 0xFC, 0x03, 0x9F, 0x10,
  0x98, 0x28, 0x16, 0x19, 0x08, 0x78, 0xC0, 0x40, 0x1F, 0xD0, 0x18, 0x0C,
  0x0D, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xE2, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x0C, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x06, 0x0C, 0x00,
  0x0F, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x0F, 0x09, 0x88, 0xD8, 0x7C,
  0x33, 0x18, 0xCC, 0x26, 0x0B, 0x02, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xBB, 0xB3, 0x38,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x10, 0x9C, 0xE2,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x08, 0x44, 0x09,
  0x02, 0x40, 0xB0, 0x34, 0x09, 0x02, 0x21, 0x07, 0x80, 0x9E, 0x71, 0xA0,
  0x50, 0x38, 0x1C, 0x0E, 0x07, 0x02, 0xC3, 0x5F, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x3C, 0xB1, 0x50, 0x78, 0x1C, 0x0E, 0x07, 0x02, 0x81, 0x63, 0x9E,
  0x40, 0x20, 0x10, 0x08, 0x04, 0xF3, 0x8E, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x7F, 0x80, 0x3E, 0xC3, 0x80, 0x80, 0x78, 0x07, 0x01,
  0x81, 0xC1, 0x3E, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF8, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x7C, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x47, 0x39, 0xC0, 0xD0, 0x26, 0x18, 0x84, 0x21, 0x04,
  0x81, 0x20, 0x48, 0x0C, 0x03, 0x00, 0x8C, 0x63, 0x18, 0xC6, 0x51, 0x92,
  0x54, 0xA5, 0x29, 0x8A, 0x61, 0x98, 0x60, 0x40, 0x88, 0x43, 0x30, 0x68,
  0x0C, 0x03, 0x01, 0x20, 0xCC, 0x21, 0x30, 0x30, 0xC0, 0xD0, 0x26, 0x08,
  0x84, 0x21, 0x04, 0x81, 0x20, 0x78, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x10,
  0x1C, 0x00, 0xFF, 0x03, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0xFF,
  0x1F, 0x10, 0x10, 0x10, 0x18, 0x08, 0x04, 0x08, 0xF0, 0x18, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x20, 0x10, 0x0F, 0x18, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x08, 0xF8, 0x30, 0x52, 0x18, 0x4A, 0x0C,
};

const GFXglyph IBMPlexMono_Light20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 14, 12, 5, -14 },
  { 5, 4, 5, 12, 4, -15 },
  { 8, 12, 14, 12, 0, -14 },
  { 29, 10, 18, 12, 1, -16 },
  { 52, 12, 14, 12, 0, -14 },
  { 73, 10, 14, 12, 1, -14 },
  { 91, 2, 5, 12, 5, -15 },
  { 93, 6, 18, 12, 4, -15 },
  { 107, 6, 18, 12, 2, -15 },
  { 121, 10, 10, 12, 1, -11 },
  { 134, 10, 9, 12, 1, -11 },
  { 146, 3, 5, 12, 4, -2 },
  { 148, 6, 1, 12, 3, -7 },
  { 149, 2, 2, 12, 5, -2 },
  { 150, 8, 18, 12, 2, -15 },
  { 168, 10, 14, 12, 1, -14 },
  { 186, 10, 14, 12, 1, -14 },
  { 204, 10, 14, 12, 1, -14 },
  { 222, 9, 14, 12, 1, -14 },
  { 238, 10, 14, 12, 1, -14 },
  { 256, 8, 14, 12, 2, -14 },
  { 270, 10, 14, 12, 1, -14 },
  { 288, 9, 14, 12, 1, -14 },
  { 304, 10, 14, 12, 1, -14 },
  { 322, 10, 14, 12, 1, -14 },
  { 340, 2, 10, 12, 5, -10 },
  { 343, 3, 13, 12, 4, -10 },
  { 348, 8, 11, 12, 2, -12 },
  { 359, 10, 5, 12, 1, -9 },
  { 366, 8, 11, 12, 2, -12 },
  { 377, 8, 14, 12, 2, -14 },
  { 391, 9, 16, 12, 1, -14 },
  { 409, 10, 14, 12, 1, -14 },
  { 427, 9, 14, 12, 2, -14 },
  { 443, 10, 14, 12, 1, -14 },
  { 461, 9, 14, 12, 2, -14 },
  { 477, 8, 14, 12, 2, -14 },
  { 491, 9, 14, 12, 2, -14 },
  { 507, 9, 14, 12, 1, -14 },
  { 523, 8, 14, 12, 2, -14 },
  { 537, 8, 14, 12, 2, -14 },
  { 551, 7, 14, 12, 2, -14 },
  { 564, 9, 14, 12, 2, -14 },
  { 580, 8, 14, 12, 3, -14 },
  { 594, 10, 14, 12, 1, -14 },
  { 612, 8, 14, 12, 2, -14 },
  { 626, 10, 14, 12, 1, -14 },
  { 644, 9, 14, 12, 2, -14 },
  { 660, 10, 17, 12, 1, -14 },
  { 682, 9, 14, 12, 2, -14 },
  { 698, 10, 14, 12, 1, -14 },
  { 716, 10, 14, 12, 1, -14 },
  { 734, 8, 14, 12, 2, -14 },
  { 748, 10, 14, 12, 1, -14 },
  { 766, 10, 14, 12, 1, -14 },
  { 784, 10, 14, 12, 1, -14 },
  { 802, 12, 14, 12, 0, -14 },
  { 823, 10, 14, 12, 1, -14 },
  { 841, 5, 18, 12, 5, -15 },
  { 853, 8, 18, 12, 2, -15 },
  { 871, 5, 18, 12, 2, -15 },
  { 883, 10, 8, 12, 1, -14 },
  { 893, 10, 1, 12, 1, 2 },
  { 895, 3, 4, 12, 4, -16 },
  { 897, 10, 10, 12, 1, -10 },
  { 910, 9, 15, 12, 2, -15 },
  { 927, 8, 10, 12, 2, -10 },
  { 937, 9, 15, 12, 1, -15 },
  { 954, 8, 10, 12, 2, -10 },
  { 964, 9, 15, 12, 2, -15 },
  { 981, 9, 15, 12, 2, -11 },
  { 998, 8, 15, 12, 2, -15 },
  { 1013, 9, 14, 12, 2, -14 },
  { 1029, 7, 18, 12, 2, -14 },
  { 1045, 9, 15, 12, 2, -15 },
  { 1062, 8, 15, 12, 2, -15 },
  { 1077, 10, 10, 12, 1, -10 },
  { 1090, 8, 10, 12, 2, -10 },
  { 1100, 10, 10, 12, 1, -10 },
  { 1113, 9, 14, 12, 2, -10 },
  { 1129, 9, 14, 12, 1, -10 },
  { 1145, 9, 10, 12, 2, -10 },
  { 1157, 8, 10, 12, 2, -10 },
  { 1167, 9, 14, 12, 1, -14 },
  { 1183, 8, 10, 12, 2, -10 },
  { 1193, 10, 10, 12, 1, -10 },
  { 1206, 10, 10, 12, 1, -10 },
  { 1219, 10, 10, 12, 1, -10 },
  { 1232, 10, 14, 12, 1, -10 },
  { 1250, 8, 10, 12, 2, -10 },
  { 1260, 8, 18, 12, 2, -15 },
  { 1278, 2, 18, 12, 5, -15 },
  { 1283, 8, 18, 12, 2, -15 },
  { 1301, 10, 4, 12, 1, -8 },
};

const GFXfont IBMPlexMono_Light20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_LIGHT20PT7B_H_
