#ifndef _IBMPLEXMONO_LIGHT41PT7B_H_
#define _IBMPLEXMONO_LIGHT41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light41pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x31, 0x8C, 0x21,
  0x08, 0x40, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0x00, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0xFF,
  0x83, 0xFD, 0xFE, 0x07, 0xF8, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0E,
  0x03, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xC0, 0x70, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8,
  0x1E, 0x33, 0xC3, 0x83, 0x0E, 0x30, 0x30, 0x77, 0x03, 0x04, 0x70, 0x30,
  0x07, 0x03, 0x00, 0x70, 0x30, 0x07, 0x03, 0x00, 0x30, 0x30, 0x03, 0xC3,
  0x00, 0x1F, 0x30, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x31, 0xE0, 0x03, 0x06, 0x00, 0x30, 0x70, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x36, 0x03, 0x07, 0xF0, 0x30, 0x77, 0x83, 0x0E,
  0x3E, 0x33, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x0E, 0x7F, 0x80, 0x19,
  0xC3, 0x80, 0x63, 0x03, 0x00, 0xCC, 0x03, 0x03, 0x18, 0x06, 0x0E, 0x30,
  0x0C, 0x18, 0x60, 0x18, 0x70, 0xC0, 0x30, 0xC1, 0x80, 0x63, 0x01, 0x81,
  0x86, 0x03, 0x87, 0x18, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0x1C, 0x30, 0x0C, 0x60,
  0x30, 0x30, 0xC0, 0x60, 0x61, 0x80, 0xC1, 0x83, 0x01, 0xC3, 0x06, 0x03,
  0x8C, 0x0C, 0x06, 0x38, 0x18, 0x0C, 0x60, 0x30, 0x19, 0x80, 0x38, 0x63,
  0x00, 0x3F, 0xCC, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0xF0, 0xF0, 0x03, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x07, 0xCE,
  0x38, 0x3F, 0x30, 0x60, 0xE1, 0xC1, 0xC3, 0x06, 0x03, 0x8C, 0x38, 0x07,
  0x30, 0xE0, 0x0E, 0xC3, 0x80, 0x1F, 0x0E, 0x00, 0x38, 0x18, 0x00, 0xE0,
  0x60, 0x02, 0xC1, 0xC0, 0x1B, 0x83, 0xC1, 0xC7, 0x07, 0xFE, 0x0E, 0x07,
  0xE0, 0x1C, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0xE0, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x1C, 0x0C, 0x0E, 0xFC, 0x63, 0xF8, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00,
  0x0E, 0x30, 0x00, 0x61, 0xC0, 0x06, 0x07, 0x00, 0x70, 0x18, 0x07, 0x00,
  0x60, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0xE7, 0x9E, 0x71, 0xC6, 0x38, 0xE3, 0x0C,
  0x00, 0xFF, 0xFF, 0xFC, 0xF7, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x3C, 0x1C, 0x01, 0xC7,
  0x00, 0x38, 0xC0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0E, 0x0F, 0x83, 0xC1, 0xF0,
  0x78, 0x3E, 0x07, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x70,
  0x01, 0x87, 0x00, 0x70, 0x78, 0x3C, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x03,
  0x87, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xC0, 0x70, 0x08, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0x80, 0xF0, 0x3C, 0x38, 0x03, 0x87, 0x00, 0x39,
  0xC0, 0x03, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x78, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x1C, 0x40, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3A, 0x00, 0x06, 0xE0, 0x01, 0xCE, 0x00, 0x70, 0xF0,
  0x1E, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x39, 0x80, 0x01, 0x8C,
  0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x06,
  0x06, 0x00, 0x60, 0x30, 0x07, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x38, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00,
  0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC7, 0xE0, 0x67, 0xFE, 0x1B, 0x03, 0xC7, 0x80, 0x38, 0x80, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0D, 0x00, 0x07, 0xE0, 0x01, 0x9C, 0x00, 0xE3, 0xC0, 0xF0,
  0x7F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0xFC, 0x06, 0x7F, 0xE0,
  0xD8, 0x1E, 0x3E, 0x00, 0xE7, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1B,
  0x80, 0x03, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xB8, 0x00, 0x33,
  0x00, 0x0E, 0x70, 0x01, 0x87, 0x00, 0x70, 0x70, 0x3C, 0x07, 0xFF, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0xC0, 0xF0, 0x3C, 0x3C, 0x01, 0xC7, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00,
  0x37, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0xC0, 0x06, 0x1C, 0x01,
  0xC1, 0xC0, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xE0, 0x38, 0x70, 0x01,
  0x9C, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xCE, 0x00, 0x38, 0xF0, 0x1E,
  0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x3C,
  0x1C, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x06,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x76, 0x00, 0x0E,
  0xE0, 0x03, 0x9E, 0x00, 0xF1, 0xE0, 0x76, 0x1F, 0xFD, 0xC0, 0x7E, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0xF7, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xBF, 0xFF, 0x00, 0x79, 0xF7, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0xE7, 0x9E, 0x71, 0xC6, 0x38, 0xE3, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0x07, 0x8E, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xE0, 0xF0, 0x60, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x66, 0x00,
  0x1D, 0x80, 0x03, 0x60, 0x7C, 0xD8, 0x3F, 0xBC, 0x1C, 0x3F, 0x06, 0x07,
  0xC3, 0x80, 0xF0, 0xC0, 0x3C, 0x30, 0x0F, 0x0C, 0x03, 0xC3, 0x00, 0xF0,
  0xC0, 0x3C, 0x30, 0x0F, 0x0C, 0x03, 0xC3, 0x00, 0xF0, 0x60, 0x3C, 0x1C,
  0x1F, 0x03, 0xFB, 0x60, 0x7C, 0xD8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xB0,
  0x00, 0x1D, 0x80, 0x00, 0xCE, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03,
  0x0E, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0E, 0x00, 0x60, 0x70,
  0x07, 0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0xE0,
  0x0C, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x70,
  0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x00, 0x03, 0xB8, 0x00,
  0x0D, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C,
  0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x3B, 0x00,
  0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x0E,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0x00, 0x3C, 0xC0, 0x03, 0xB0, 0x00, 0x6C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x1E, 0x0E, 0x01, 0xC3, 0x80,
  0x1C, 0x60, 0x01, 0xDC, 0x00, 0x33, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x21, 0x80, 0x07, 0x38, 0x01,
  0xC3, 0x80, 0x70, 0x38, 0x1E, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0E, 0x01, 0xE3, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0, 0x0E, 0x30, 0x01, 0x9C,
  0x00, 0x76, 0x00, 0x0B, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x36, 0x00, 0x0D, 0xC0, 0x07, 0x70, 0x01, 0xCE, 0x00, 0xB1, 0xE0,
  0xEC, 0x3F, 0xF3, 0x03, 0xF0, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0x1F, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xE0, 0x03, 0x70, 0x07,
  0x70, 0x0E, 0x3C, 0x1E, 0x1F, 0xF8, 0x07, 0xE0, 0xC0, 0x00, 0xF8, 0x00,
  0x3B, 0x00, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x06,
  0x06, 0x01, 0xC0, 0xC0, 0x70, 0x18, 0x1C, 0x03, 0x07, 0x00, 0x61, 0xC0,
  0x0C, 0x78, 0x01, 0x8F, 0x00, 0x33, 0xF0, 0x06, 0xE7, 0x00, 0xF8, 0xE0,
  0x1E, 0x0E, 0x03, 0x80, 0xE0, 0x60, 0x1C, 0x0C, 0x01, 0xC1, 0x80, 0x18,
  0x30, 0x03, 0x86, 0x00, 0x38, 0xC0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x07,
  0x60, 0x00, 0xEC, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFD, 0x80, 0x3F, 0xB8, 0x0D, 0xF3, 0x01, 0xBE,
  0x60, 0x77, 0xC6, 0x0C, 0xF8, 0xC3, 0x9F, 0x1C, 0x63, 0xE1, 0x8C, 0x7C,
  0x33, 0x0F, 0x83, 0x61, 0xF0, 0x7C, 0x3E, 0x07, 0x07, 0xC0, 0xE0, 0xF8,
  0x18, 0x1F, 0x01, 0x03, 0xE0, 0x40, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3D, 0x80, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0x98, 0x03, 0xCE, 0x01, 0xE3,
  0x00, 0xF1, 0xC0, 0x78, 0x60, 0x3C, 0x38, 0x1E, 0x0C, 0x0F, 0x07, 0x07,
  0x81, 0x83, 0xC0, 0xC1, 0xE0, 0x70, 0xF0, 0x18, 0x78, 0x0E, 0x3C, 0x03,
  0x1E, 0x01, 0xCF, 0x00, 0x67, 0x80, 0x3B, 0xC0, 0x0D, 0xE0, 0x06, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x78, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78,
  0x3C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0x98, 0x00, 0x37, 0x00,
  0x06, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x0E, 0x70, 0x01, 0x87, 0x00, 0x70, 0x78, 0x3C, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8C, 0x00, 0x73, 0x00, 0x0E,
  0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x01, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x78, 0x3C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0x98,
  0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x70, 0x01, 0x87, 0x00, 0x70, 0x78,
  0x3C, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8C, 0x00, 0x73, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06,
  0xC0, 0x03, 0xB0, 0x01, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xC0, 0xE0, 0x30,
  0x18, 0x0C, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30, 0x07, 0x0C, 0x00,
  0xC3, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xCC, 0x00, 0x3B, 0x00, 0x0E,
  0xC0, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1E, 0x03, 0xC3, 0x80,
  0x0E, 0x30, 0x00, 0x77, 0x00, 0x04, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x76, 0x00, 0x07, 0xF0, 0x00, 0x67, 0x80, 0x0E, 0x3E, 0x03, 0xC0, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x06, 0xE0, 0x03, 0x38, 0x03, 0x9E, 0x07, 0x87, 0xFF, 0x80,
  0xFF, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0xE7, 0x00, 0x06, 0x38, 0x00, 0x30, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0xC0, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0xC0, 0x38, 0x0C, 0x01, 0xC0, 0x60, 0x06, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x33, 0x80, 0x01, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x80,
  0x00, 0xDC, 0x00, 0x06, 0x60, 0x70, 0x33, 0x03, 0x81, 0x98, 0x3C, 0x0C,
  0xC1, 0xB0, 0x66, 0x0D, 0x83, 0x30, 0x6C, 0x19, 0x86, 0x61, 0xCC, 0x33,
  0x8C, 0x61, 0x8C, 0x63, 0x0C, 0x63, 0x1C, 0xC3, 0x18, 0xE6, 0x1C, 0xC3,
  0x30, 0x66, 0x19, 0x83, 0x30, 0xD8, 0x19, 0x86, 0xC0, 0xEC, 0x36, 0x03,
  0x61, 0xB0, 0x1B, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x1C, 0x00,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0xE0, 0x38, 0x03, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0xE0, 0x03, 0x83,
  0x00, 0x07, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x3B, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x03,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x06,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x60, 0x60, 0x01, 0xC3,
  0x80, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x03, 0x80,
  0x0E, 0x03, 0x00, 0x38, 0x07, 0x00, 0x60, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x19, 0xC0,
  0x00, 0x3B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x7F, 0xFF, 0xFE, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x19, 0xC0,
  0x03, 0x8C, 0x00, 0x30, 0xE0, 0x07, 0x06, 0x00, 0x60, 0x70, 0x0E, 0x03,
  0x00, 0xC0, 0x18, 0x18, 0x01, 0xC3, 0x80, 0x0C, 0x30, 0x00, 0xE7, 0x00,
  0x06, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0x87, 0x0C, 0x18, 0x70, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0x81, 0xE0, 0x78,
  0x30, 0x03, 0x04, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3C, 0x01, 0x8E, 0x00, 0x31,
  0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xE0, 0x07, 0x1C, 0x01, 0x61,
  0xC0, 0xEC, 0x1F, 0xF9, 0xF0, 0xFC, 0x1E, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0xFC, 0x0E, 0x7F, 0xC3, 0xB0, 0x78, 0xF0, 0x07,
  0x38, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x06, 0xE0, 0x01, 0xB8, 0x00, 0xEF, 0x00, 0x73, 0xB0, 0x38, 0xE7, 0xFC,
  0x38, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00, 0xE7,
  0x00, 0x3B, 0x00, 0x13, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x02, 0x70, 0x03, 0x9C, 0x03, 0x8F, 0x03, 0x81, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x83, 0xF0, 0xC7, 0xFE, 0x67,
  0x81, 0xB7, 0x00, 0x7B, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xB8, 0x01, 0xDC, 0x01, 0xE7, 0x81, 0xB1,
  0xFF, 0x98, 0x3F, 0x0C, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0,
  0x0E, 0x70, 0x01, 0x98, 0x00, 0x76, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x02, 0x70, 0x01, 0xCE, 0x00, 0xE1, 0xE0, 0x70, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x07, 0xFF,
  0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF2, 0x00,
  0xFF, 0xE0, 0x1E, 0x0F, 0x03, 0x80, 0x30, 0x30, 0x03, 0x83, 0x00, 0x18,
  0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x38, 0x03,
  0x01, 0xE0, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x30,
  0x00, 0xE6, 0x00, 0x06, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0x78, 0x01, 0xE3, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xF0, 0xE7, 0xFC, 0xEC, 0x1E, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xC0, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xEC, 0x00, 0x73, 0x00, 0x38,
  0xC0, 0x38, 0x30, 0x1C, 0x0C, 0x0E, 0x03, 0x07, 0x00, 0xC3, 0x80, 0x31,
  0xC0, 0x0C, 0xF8, 0x03, 0x67, 0x00, 0xF0, 0xE0, 0x38, 0x1C, 0x0C, 0x07,
  0x03, 0x00, 0xE0, 0xC0, 0x1C, 0x30, 0x03, 0x8C, 0x00, 0x73, 0x00, 0x1C,
  0xC0, 0x03, 0xB0, 0x00, 0x70, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xCF, 0x07, 0x9B, 0xF3, 0xFB, 0x87, 0x43, 0xE0, 0x70, 0x7C, 0x0E,
  0x07, 0x81, 0x80, 0xF0, 0x30, 0x1E, 0x06, 0x03, 0xC0, 0xC0, 0x78, 0x18,
  0x0F, 0x03, 0x01, 0xE0, 0x60, 0x3C, 0x0C, 0x07, 0x81, 0x80, 0xF0, 0x30,
  0x1E, 0x06, 0x03, 0xC0, 0xC0, 0x78, 0x18, 0x0F, 0x03, 0x01, 0xE0, 0x60,
  0x3C, 0x0C, 0x06, 0xE3, 0xF0, 0xE7, 0xFC, 0xEC, 0x1E, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x70, 0x3C, 0x1C, 0x01, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x98,
  0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x70,
  0x01, 0x87, 0x00, 0x70, 0x70, 0x3C, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xE3,
  0xF0, 0x39, 0xFF, 0x0E, 0xC1, 0xE3, 0xC0, 0x1C, 0xE0, 0x03, 0xB8, 0x00,
  0x6E, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x06, 0xE0,
  0x03, 0xBC, 0x01, 0xCE, 0xC0, 0xE3, 0x9F, 0xF0, 0xE3, 0xF0, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE1, 0x8F, 0xFC, 0xCF, 0x03, 0x6E,
  0x00, 0xF7, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0x70, 0x03, 0xB8, 0x03, 0xCF, 0x03, 0x63, 0xFF, 0x30,
  0x7E, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0xFF, 0x87, 0xFF, 0xF8, 0xFF,
  0x01, 0x98, 0x00, 0x1A, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0x78, 0xC0, 0x07, 0x70, 0x01, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x60, 0x00, 0xFC, 0x00, 0x73, 0xC0, 0x78, 0x7F, 0xFC, 0x03, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x0B, 0x38, 0x1B, 0x1F,
  0xF3, 0x0F, 0xC3, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x00, 0xC0, 0xC0, 0x38, 0x1C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x38, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x38,
  0x01, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x38, 0x0D, 0x80, 0xE0, 0x36, 0x07,
  0x80, 0xD8, 0x1A, 0x03, 0x60, 0x6C, 0x1D, 0x81, 0xB0, 0x66, 0x04, 0xC1,
  0x8C, 0x31, 0x06, 0x30, 0xC6, 0x18, 0xC3, 0x18, 0x63, 0x08, 0x61, 0x8C,
  0x61, 0x8C, 0x31, 0x82, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0xC0,
  0xCC, 0x1B, 0x01, 0x20, 0x6C, 0x07, 0x81, 0xB0, 0x1E, 0x03, 0x80, 0x78,
  0x0E, 0x01, 0xE0, 0xE0, 0x01, 0xCE, 0x00, 0x30, 0xE0, 0x0E, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x1C, 0x18, 0x01, 0xC7, 0x00, 0x1D, 0xC0, 0x03, 0xB0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x06, 0x70,
  0x01, 0x87, 0x00, 0x70, 0x70, 0x1C, 0x06, 0x03, 0x00, 0xE0, 0xC0, 0x0E,
  0x38, 0x00, 0xEE, 0x00, 0x1E, 0xC0, 0x00, 0xFC, 0x00, 0x19, 0x80, 0x03,
  0x38, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x00, 0xC0, 0xC0, 0x18,
  0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x38, 0x07, 0x06, 0x00, 0x61, 0xC0,
  0x0E, 0x30, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x01, 0xE0, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0x00, 0x31, 0xF8, 0x03, 0x31, 0xC0, 0x37, 0x0E, 0x03, 0x60,
  0x70, 0x66, 0x03, 0x8E, 0xC0, 0x1F, 0xCC, 0x00, 0x78,
};

const GFXglyph IBMPlexMono_Light41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 5, 29, 25, 10, -29 },
  { 20, 9, 11, 25, 8, -30 },
  { 33, 23, 29, 25, 1, -29 },
  { 117, 20, 37, 25, 2, -33 },
  { 210, 23, 29, 25, 1, -29 },
  { 294, 22, 29, 25, 1, -29 },
  { 374, 2, 11, 25, 11, -30 },
  { 377, 11, 37, 25, 9, -31 },
  { 428, 11, 37, 25, 5, -31 },
  { 479, 21, 20, 25, 2, -22 },
  { 532, 19, 20, 25, 3, -23 },
  { 580, 6, 11, 25, 9, -5 },
  { 589, 11, 2, 25, 7, -13 },
  { 592, 5, 4, 25, 10, -4 },
  { 595, 17, 37, 25, 4, -31 },
  { 674, 19, 29, 25, 3, -29 },
  { 743, 20, 29, 25, 3, -29 },
  { 816, 19, 29, 25, 3, -29 },
  { 885, 19, 29, 25, 2, -29 },
  { 954, 21, 29, 25, 2, -29 },
  { 1031, 18, 29, 25, 3, -29 },
  { 1097, 19, 29, 25, 3, -29 },
  { 1166, 18, 29, 25, 3, -29 },
  { 1232, 19, 29, 25, 3, -29 },
  { 1301, 19, 29, 25, 3, -29 },
  { 1370, 5, 21, 25, 10, -21 },
  { 1384, 6, 27, 25, 9, -21 },
  { 1405, 18, 23, 25, 3, -24 },
  { 1457, 19, 9, 25, 3, -17 },
  { 1479, 18, 23, 25, 3, -24 },
  { 1531, 17, 29, 25, 4, -29 },
  { 1593, 18, 34, 25, 3, -29 },
  { 1670, 21, 29, 25, 2, -29 },
  { 1747, 18, 29, 25, 4, -29 },
  { 1813, 19, 29, 25, 3, -29 },
  { 1882, 18, 29, 25, 4, -29 },
  { 1948, 17, 29, 25, 4, -29 },
  { 2010, 18, 29, 25, 4, -29 },
  { 2076, 18, 29, 25, 3, -29 },
  { 2142, 17, 29, 25, 4, -29 },
  { 2204, 17, 29, 25, 4, -29 },
  { 2266, 16, 29, 25, 3, -29 },
  { 2324, 19, 29, 25, 4, -29 },
  { 2393, 17, 29, 25, 5, -29 },
  { 2455, 19, 29, 25, 3, -29 },
  { 2524, 17, 29, 25, 4, -29 },
  { 2586, 19, 29, 25, 3, -29 },
  { 2655, 18, 29, 25, 4, -29 },
  { 2721, 19, 35, 25, 3, -29 },
  { 2805, 18, 29, 25, 4, -29 },
  { 2871, 20, 29, 25, 2, -29 },
  { 2944, 22, 29, 25, 1, -29 },
  { 3024, 17, 29, 25, 4, -29 },
  { 3086, 21, 29, 25, 2, -29 },
  { 3163, 21, 29, 25, 2, -29 },
  { 3240, 22, 29, 25, 1, -29 },
  { 3320, 23, 29, 25, 1, -29 },
  { 3404, 21, 29, 25, 2, -29 },
  { 3481, 11, 37, 25, 10, -31 },
  { 3532, 17, 37, 25, 4, -31 },
  { 3611, 11, 37, 25, 4, -31 },
  { 3662, 20, 16, 25, 2, -29 },
  { 3702, 20, 2, 25, 2, 4 },
  { 3707, 6, 7, 25, 8, -31 },
  { 3713, 19, 21, 25, 3, -21 },
  { 3763, 18, 30, 25, 4, -30 },
  { 3831, 17, 21, 25, 4, -21 },
  { 3876, 17, 30, 25, 3, -30 },
  { 3940, 18, 21, 25, 3, -21 },
  { 3988, 19, 30, 25, 3, -30 },
  { 4060, 20, 31, 25, 3, -23 },
  { 4138, 16, 30, 25, 4, -30 },
  { 4198, 17, 30, 25, 5, -30 },
  { 4262, 14, 38, 25, 4, -30 },
  { 4329, 18, 30, 25, 5, -30 },
  { 4397, 18, 30, 25, 3, -30 },
  { 4465, 19, 21, 25, 3, -21 },
  { 4515, 16, 21, 25, 4, -21 },
  { 4557, 19, 21, 25, 3, -21 },
  { 4607, 18, 29, 25, 4, -21 },
  { 4673, 17, 29, 25, 3, -21 },
  { 4735, 20, 21, 25, 3, -21 },
  { 4788, 18, 21, 25, 3, -21 },
  { 4836, 19, 29, 25, 2, -29 },
  { 4905, 16, 21, 25, 4, -21 },
  { 4947, 19, 21, 25, 3, -21 },
  { 4997, 22, 21, 25, 1, -21 },
  { 5055, 19, 21, 25, 3, -21 },
  { 5105, 19, 29, 25, 3, -21 },
  { 5174, 17, 21, 25, 4, -21 },
  { 5219, 16, 37, 25, 4, -31 },
  { 5293, 2, 37, 25, 11, -31 },
  { 5303, 16, 37, 25, 4, -31 },
  { 5377, 20, 8, 25, 2, -17 },
};

const GFXfont IBMPlexMono_Light41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_LIGHT41PT7B_H_
