#ifndef _IBMPLEXMONO_LIGHT18PT7B_H_
#define _IBMPLEXMONO_LIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light18pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x43, 0xC0, 0x99, 0x99, 0x90, 0x08, 0x82, 0x40, 0x90,
  0x24, 0x79, 0xC4, 0x41, 0x20, 0x48, 0xF3, 0xC4, 0x81, 0x20, 0x88, 0x24,
  0x00, 0x08, 0x04, 0x0F, 0x89, 0x2C, 0x9C, 0x41, 0x20, 0xD0, 0x1E, 0x04,
  0x82, 0x21, 0x18, 0x8A, 0x48, 0xF8, 0x10, 0x08, 0x00, 0x78, 0x52, 0x18,
  0x4A, 0x14, 0x49, 0x1E, 0x80, 0x00, 0x0E, 0x14, 0x49, 0x12, 0x45, 0x11,
  0xC3, 0x80, 0x38, 0x22, 0x10, 0x88, 0x04, 0x01, 0x01, 0xC7, 0x32, 0x8A,
  0x43, 0x20, 0x98, 0xA7, 0x98, 0xF8, 0x19, 0x10, 0x88, 0x42, 0x10, 0x84,
  0x21, 0x04, 0x20, 0x83, 0xC1, 0x08, 0x21, 0x04, 0x21, 0x08, 0x42, 0x21,
  0x10, 0x98, 0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0xE0, 0x50, 0x44, 0x43,
  0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00,
  0x6B, 0x48, 0xF8, 0xF0, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x3C, 0x31, 0x90, 0x58, 0x28, 0x1C,
  0x46, 0x23, 0x01, 0x81, 0xC0, 0x90, 0x4C, 0x63, 0xC0, 0x18, 0x1C, 0x1A,
  0x19, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x07, 0xF8,
  0x3C, 0x21, 0x30, 0x40, 0x20, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x0F, 0xF8, 0x3C, 0x42, 0x81, 0x01, 0x01, 0x02, 0x3C, 0x06, 0x01,
  0x01, 0x81, 0x43, 0x3C, 0x06, 0x03, 0x02, 0x82, 0x41, 0x21, 0x11, 0x08,
  0x84, 0x82, 0x7F, 0xC0, 0x80, 0x40, 0x20, 0x7F, 0x40, 0x40, 0x40, 0x40,
  0x5E, 0x63, 0x01, 0x01, 0x01, 0x81, 0x43, 0x3C, 0x0C, 0x18, 0x30, 0x20,
  0x40, 0x5E, 0xE3, 0xC1, 0x81, 0x81, 0x41, 0x63, 0x3E, 0xFF, 0x81, 0x81,
  0x82, 0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x30, 0x3E, 0x31,
  0x90, 0x48, 0x24, 0x13, 0x18, 0x70, 0xC6, 0x81, 0xC0, 0x60, 0x68, 0x23,
  0xE0, 0x3E, 0x31, 0x90, 0x50, 0x28, 0x12, 0x0D, 0x8C, 0x7A, 0x01, 0x01,
  0x01, 0x81, 0x83, 0x80, 0xF0, 0x00, 0xF0, 0xD8, 0x00, 0x00, 0x6B, 0x48,
  0x02, 0x08, 0x63, 0x08, 0x10, 0x18, 0x0C, 0x06, 0x04, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x81, 0x80, 0xC0, 0x60, 0x60, 0xC3, 0x18, 0xC1, 0x00,
  0x7D, 0x8E, 0x08, 0x10, 0x20, 0x8E, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00,
  0x3C, 0x63, 0x41, 0x41, 0x8F, 0x91, 0x91, 0x91, 0x91, 0x91, 0x8F, 0x40,
  0x40, 0x20, 0x1E, 0x08, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x10, 0x88, 0x84,
  0x7F, 0x20, 0xB0, 0x50, 0x18, 0x08, 0xFC, 0x86, 0x82, 0x82, 0x82, 0x84,
  0xFC, 0x82, 0x82, 0x83, 0x82, 0x82, 0xFC, 0x1E, 0x11, 0x90, 0x48, 0x1C,
  0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x64, 0x61, 0xE0, 0xF8, 0x84,
  0x82, 0x82, 0x83, 0x81, 0x81, 0x81, 0x83, 0x82, 0x82, 0x84, 0xF8, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x00, 0x3C,
  0x63, 0x41, 0xC0, 0x80, 0x80, 0x80, 0x8F, 0x81, 0xC1, 0x41, 0x63, 0x3D,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0,
  0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC2, 0x42,
  0x3C, 0x83, 0x82, 0x84, 0x88, 0x90, 0xB0, 0xF0, 0xC8, 0x88, 0x84, 0x86,
  0x82, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0xC1, 0xC3, 0xA3, 0xA3, 0x95, 0x95, 0x99, 0x89, 0x89,
  0x81, 0x81, 0x81, 0x81, 0x83, 0x87, 0x0D, 0x1A, 0x34, 0x64, 0xC9, 0x8B,
  0x16, 0x1C, 0x38, 0x60, 0x3C, 0x31, 0x90, 0x58, 0x28, 0x1C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0x90, 0x4C, 0x63, 0xC0, 0xFC, 0x82, 0x83, 0x81, 0x83,
  0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3C, 0x31, 0x90, 0x58,
  0x28, 0x1C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x90, 0x4C, 0x63, 0xC0, 0x40,
  0x20, 0x1E, 0xFC, 0x82, 0x83, 0x81, 0x83, 0x82, 0xFC, 0x98, 0x88, 0x84,
  0x84, 0x82, 0x83, 0x3E, 0x20, 0xB0, 0x70, 0x0C, 0x03, 0x00, 0x78, 0x02,
  0x01, 0x80, 0x60, 0x68, 0x23, 0xE0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0x80, 0xC0, 0xD0,
  0x48, 0x24, 0x13, 0x10, 0x88, 0x44, 0x24, 0x0A, 0x05, 0x02, 0x80, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x8C, 0xC6, 0x55, 0x2A, 0x95, 0x32, 0x98,
  0xCC, 0x66, 0x30, 0x80, 0xA0, 0x98, 0x84, 0x41, 0x40, 0xE0, 0x20, 0x28,
  0x34, 0x11, 0x10, 0xC8, 0x28, 0x08, 0xC0, 0x50, 0x32, 0x08, 0x84, 0x11,
  0x06, 0x80, 0xA0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0xFF,
  0x80, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10,
  0x0F, 0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F,
  0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x81, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x0A,
  0x09, 0x04, 0x44, 0x32, 0x0A, 0x02, 0xFF, 0x80, 0xC8, 0x80, 0x3C, 0x21,
  0x00, 0x80, 0x47, 0xE6, 0x12, 0x09, 0x84, 0x7D, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xC6, 0x82, 0x83, 0x83, 0x83, 0x82, 0xC6, 0xBC, 0x3D, 0x8E,
  0x14, 0x08, 0x10, 0x20, 0xE3, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43,
  0xC1, 0x81, 0x81, 0x81, 0xC1, 0x43, 0x3D, 0x3C, 0x63, 0x41, 0x81, 0xFF,
  0x80, 0x40, 0x61, 0x3E, 0x0F, 0x84, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x07, 0xF0, 0x03, 0x9F, 0x18, 0x88, 0x24,
  0x13, 0x10, 0xF0, 0x80, 0x40, 0x1F, 0x90, 0x30, 0x14, 0x1B, 0xF8, 0x81,
  0x02, 0x04, 0x0B, 0xD8, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x18,
  0x18, 0x00, 0x00, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0x0C, 0x30, 0x00, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0xF8, 0x80, 0x80, 0x80, 0x80, 0x83, 0x84, 0x88, 0xB0, 0xF8, 0x88, 0x84,
  0x82, 0x81, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x8F, 0xE0, 0xB3, 0x66, 0xE2, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88,
  0x80, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x3E, 0x63, 0x41,
  0x81, 0x81, 0x81, 0x41, 0x63, 0x3E, 0xBC, 0xC6, 0x82, 0x83, 0x83, 0x83,
  0x82, 0xC6, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x43, 0xC1, 0x81, 0x81,
  0x81, 0xC1, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xF3, 0x8E, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x00, 0x3E, 0x41, 0x40, 0x60, 0x3E,
  0x01, 0x01, 0xC1, 0x3E, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x1F, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3,
  0x7A, 0xC1, 0x41, 0x41, 0x22, 0x22, 0x24, 0x14, 0x14, 0x08, 0x88, 0xCC,
  0x65, 0x32, 0x99, 0x55, 0x29, 0x8C, 0xC6, 0x63, 0x00, 0xC1, 0x11, 0x0D,
  0x02, 0x80, 0x80, 0xA0, 0x98, 0xC4, 0xC1, 0x80, 0x81, 0xA0, 0x90, 0x44,
  0x42, 0x21, 0x20, 0x50, 0x28, 0x08, 0x04, 0x04, 0x02, 0x06, 0x00, 0xFE,
  0x0C, 0x30, 0x41, 0x04, 0x10, 0x40, 0xFE, 0x1E, 0x40, 0x80, 0x81, 0x01,
  0x02, 0x78, 0x18, 0x10, 0x20, 0x82, 0x04, 0x08, 0x0F, 0xFF, 0xFF, 0xF0,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x0F, 0x30, 0x40, 0x80, 0x81, 0x02, 0x04,
  0x78, 0x70, 0xAC, 0x62, 0x50, 0xE0,
};

const GFXglyph IBMPlexMono_Light18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 13, 11, 4, -13 },
  { 5, 4, 5, 11, 3, -13 },
  { 8, 10, 13, 11, 0, -13 },
  { 25, 9, 17, 11, 1, -15 },
  { 45, 10, 13, 11, 0, -13 },
  { 62, 9, 13, 11, 1, -13 },
  { 77, 1, 5, 11, 5, -13 },
  { 78, 5, 16, 11, 4, -14 },
  { 88, 5, 16, 11, 2, -14 },
  { 98, 9, 9, 11, 1, -10 },
  { 109, 9, 9, 11, 1, -10 },
  { 120, 3, 5, 11, 4, -2 },
  { 122, 5, 1, 11, 3, -6 },
  { 123, 2, 2, 11, 4, -2 },
  { 124, 7, 16, 11, 2, -14 },
  { 138, 9, 13, 11, 1, -13 },
  { 153, 9, 13, 11, 1, -13 },
  { 168, 9, 13, 11, 1, -13 },
  { 183, 8, 13, 11, 1, -13 },
  { 196, 9, 13, 11, 1, -13 },
  { 211, 8, 13, 11, 1, -13 },
  { 224, 8, 13, 11, 1, -13 },
  { 237, 8, 13, 11, 1, -13 },
  { 250, 9, 13, 11, 1, -13 },
  { 265, 9, 13, 11, 1, -13 },
  { 280, 2, 10, 11, 4, -10 },
  { 283, 3, 13, 11, 4, -10 },
  { 288, 7, 10, 11, 2, -10 },
  { 297, 9, 5, 11, 1, -8 },
  { 303, 7, 10, 11, 2, -10 },
  { 312, 7, 13, 11, 2, -13 },
  { 324, 8, 15, 11, 1, -13 },
  { 339, 9, 13, 11, 1, -13 },
  { 354, 8, 13, 11, 2, -13 },
  { 367, 9, 13, 11, 1, -13 },
  { 382, 8, 13, 11, 2, -13 },
  { 395, 7, 13, 11, 2, -13 },
  { 407, 7, 13, 11, 2, -13 },
  { 419, 8, 13, 11, 1, -13 },
  { 432, 7, 13, 11, 2, -13 },
  { 444, 7, 13, 11, 2, -13 },
  { 456, 8, 13, 11, 1, -13 },
  { 469, 8, 13, 11, 2, -13 },
  { 482, 8, 13, 11, 2, -13 },
  { 495, 8, 13, 11, 1, -13 },
  { 508, 7, 13, 11, 2, -13 },
  { 520, 9, 13, 11, 1, -13 },
  { 535, 8, 13, 11, 2, -13 },
  { 548, 9, 16, 11, 1, -13 },
  { 566, 8, 13, 11, 2, -13 },
  { 579, 9, 13, 11, 1, -13 },
  { 594, 9, 13, 11, 1, -13 },
  { 609, 7, 13, 11, 2, -13 },
  { 621, 9, 13, 11, 1, -13 },
  { 636, 9, 13, 11, 1, -13 },
  { 651, 9, 13, 11, 1, -13 },
  { 666, 10, 13, 11, 0, -13 },
  { 683, 9, 13, 11, 1, -13 },
  { 698, 5, 16, 11, 4, -14 },
  { 708, 7, 16, 11, 2, -14 },
  { 722, 4, 16, 11, 2, -14 },
  { 730, 9, 7, 11, 1, -13 },
  { 738, 9, 1, 11, 1, 2 },
  { 740, 3, 3, 11, 3, -14 },
  { 742, 9, 9, 11, 1, -9 },
  { 753, 8, 13, 11, 2, -13 },
  { 766, 7, 9, 11, 2, -9 },
  { 774, 8, 13, 11, 1, -13 },
  { 787, 8, 9, 11, 1, -9 },
  { 796, 9, 13, 11, 1, -13 },
  { 811, 9, 14, 11, 1, -10 },
  { 827, 7, 13, 11, 2, -13 },
  { 839, 8, 13, 11, 2, -13 },
  { 852, 6, 17, 11, 2, -13 },
  { 865, 8, 13, 11, 2, -13 },
  { 878, 7, 13, 11, 2, -13 },
  { 890, 9, 9, 11, 1, -9 },
  { 901, 7, 9, 11, 2, -9 },
  { 909, 8, 9, 11, 1, -9 },
  { 918, 8, 13, 11, 2, -9 },
  { 931, 8, 13, 11, 1, -9 },
  { 944, 9, 9, 11, 1, -9 },
  { 955, 8, 9, 11, 1, -9 },
  { 964, 8, 13, 11, 1, -13 },
  { 977, 7, 9, 11, 2, -9 },
  { 985, 8, 9, 11, 1, -9 },
  { 994, 9, 9, 11, 1, -9 },
  { 1005, 9, 9, 11, 1, -9 },
  { 1016, 9, 13, 11, 1, -9 },
  { 1031, 7, 9, 11, 2, -9 },
  { 1039, 7, 16, 11, 2, -14 },
  { 1053, 1, 16, 11, 5, -14 },
  { 1055, 7, 16, 11, 2, -14 },
  { 1069, 9, 4, 11, 1, -7 },
};

const GFXfont IBMPlexMono_Light18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_LIGHT18PT7B_H_
