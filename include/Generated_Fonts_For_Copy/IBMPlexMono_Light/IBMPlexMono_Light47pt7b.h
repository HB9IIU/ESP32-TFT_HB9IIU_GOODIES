#ifndef _IBMPLEXMONO_LIGHT47PT7B_H_
#define _IBMPLEXMONO_LIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light47pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0x78, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00,
  0x0C, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x18, 0x1C, 0x00, 0x06, 0x07, 0x00, 0xFF, 0x81, 0xFF, 0x3F, 0xE0,
  0x7F, 0xC0, 0x38, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00,
  0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x7F, 0xE0, 0x38, 0x18, 0x00, 0x0E, 0x06,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C,
  0x0E, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x18, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xFE, 0x07, 0xCE, 0x7C, 0x3C, 0x38, 0x78, 0xE0, 0xE0, 0x77, 0x03,
  0x80, 0x9C, 0x0E, 0x00, 0x60, 0x38, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07,
  0x8E, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0E,
  0x7C, 0x00, 0x38, 0x78, 0x00, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x07,
  0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x40,
  0x38, 0x1F, 0x80, 0xE0, 0x7F, 0x03, 0x83, 0x9E, 0x0E, 0x1E, 0x3F, 0x39,
  0xF0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC7,
  0xF8, 0x00, 0x63, 0x87, 0x00, 0x39, 0xC0, 0xE0, 0x0C, 0x60, 0x18, 0x07,
  0x38, 0x07, 0x01, 0x8E, 0x01, 0xC0, 0xE3, 0x80, 0x70, 0x30, 0xE0, 0x1C,
  0x18, 0x38, 0x07, 0x0E, 0x0E, 0x01, 0xC3, 0x01, 0x80, 0x61, 0xC0, 0x70,
  0x38, 0x60, 0x0E, 0x1C, 0x38, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0x0E,
  0x1C, 0x01, 0x87, 0x03, 0x80, 0xE1, 0x80, 0x60, 0x30, 0x60, 0x1C, 0x1C,
  0x38, 0x07, 0x06, 0x0E, 0x00, 0xC3, 0x83, 0x80, 0x30, 0xC0, 0xE0, 0x0C,
  0x70, 0x18, 0x03, 0x18, 0x06, 0x01, 0xCC, 0x01, 0x80, 0x67, 0x00, 0x70,
  0x39, 0x80, 0x0E, 0x1C, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x3C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x04, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xE0, 0x1F, 0x87, 0x38, 0x0F, 0xC7, 0x0C, 0x06, 0x07, 0x07,
  0x03, 0x07, 0x01, 0xC1, 0x83, 0x80, 0x70, 0xC1, 0xC0, 0x1C, 0x60, 0xC0,
  0x06, 0x30, 0xE0, 0x01, 0xB0, 0x70, 0x00, 0xF8, 0x18, 0x00, 0x3C, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x0F, 0x83, 0xC0, 0x04, 0xE0, 0xE0, 0x06, 0x38,
  0x3C, 0x0E, 0x0E, 0x0F, 0xFE, 0x03, 0x81, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x70, 0x18, 0x0F, 0xFE,
  0x18, 0x7F, 0x3F, 0xDB, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x01,
  0xC3, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x78, 0xF1, 0xE3, 0x8F, 0x1C,
  0x38, 0x70, 0xC3, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0,
  0x3C, 0x07, 0x80, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x19, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x1E,
  0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60,
  0x00, 0x1D, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0x60, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x07, 0x00, 0x3C,
  0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xF0, 0x3C, 0x0F, 0x00,
  0x78, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x28, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0x81, 0xF0, 0x70, 0x03, 0xC7, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x80, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x71, 0xE0, 0x07, 0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0xFE, 0x01, 0x9F, 0xFC, 0x0D, 0xC0, 0xF8,
  0x78, 0x01, 0xE3, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x80, 0x00, 0xEE, 0x00, 0x06, 0x70, 0x00,
  0x71, 0xE0, 0x07, 0x07, 0xC0, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE1, 0xF8, 0x07, 0x1F, 0xF8, 0x1D, 0xC0, 0xF8, 0x74, 0x00, 0xF1, 0xA0,
  0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x1B, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77,
  0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0xC0,
  0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xF0,
  0x3E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x8C,
  0x00, 0x0E, 0x38, 0x00, 0x70, 0x70, 0x03, 0x80, 0xF0, 0x3C, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x7C, 0x07, 0x83, 0x80, 0x07, 0x1C, 0x00, 0x0E,
  0x70, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE3, 0xC0, 0x07, 0x07, 0xC0, 0x78, 0x0F, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x70,
  0x03, 0x87, 0x00, 0x0E, 0x30, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xEE, 0x00, 0x1F, 0x78, 0x01, 0xB1,
  0xF0, 0x39, 0x83, 0xFF, 0x9C, 0x07, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF,
  0x78, 0x3C, 0xFD, 0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0x8F, 0x1E, 0x38, 0xF1,
  0xC3, 0x87, 0x0C, 0x38, 0x70, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xC0, 0xF0, 0x1C, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x00, 0xC6, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xD8,
  0x07, 0xC6, 0xC0, 0x7F, 0x36, 0x07, 0x05, 0xB0, 0x70, 0x1D, 0x83, 0x00,
  0xEC, 0x18, 0x03, 0x61, 0xC0, 0x1F, 0x0E, 0x00, 0xF8, 0x70, 0x07, 0xC3,
  0x80, 0x3E, 0x1C, 0x01, 0xB0, 0xE0, 0x0D, 0x87, 0x00, 0x6C, 0x18, 0x03,
  0x60, 0xC0, 0x1B, 0x07, 0x01, 0xD8, 0x38, 0x16, 0xC0, 0xFB, 0xB7, 0x03,
  0xF9, 0xB8, 0x02, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x81,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0x18, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x00, 0xF1,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x70,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00, 0x73, 0x80,
  0x07, 0x9F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0x00, 0x78, 0x1E, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3,
  0x80, 0x01, 0xCE, 0x00, 0x04, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x01, 0x0E, 0x00, 0x07,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x07, 0x01, 0xE0, 0x78, 0x03,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xE0, 0x0F,
  0x0E, 0x00, 0x78, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x78, 0xE0, 0x0F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xE0, 0xF8, 0x3C, 0x01, 0xE1, 0xC0, 0x07, 0x1C,
  0x00, 0x1C, 0xC0, 0x00, 0xEE, 0x00, 0x04, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0x60, 0x00, 0x73,
  0x80, 0x03, 0x9E, 0x00, 0x2C, 0x78, 0x03, 0x61, 0xE0, 0x73, 0x07, 0xFF,
  0x18, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xE7, 0x80, 0x70,
  0xF0, 0x3C, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x78,
  0x38, 0x01, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x78, 0x00, 0x71, 0xF0, 0x00, 0xE7, 0x70, 0x01, 0xDC, 0x70, 0x03, 0xF0,
  0xE0, 0x07, 0xE0, 0xE0, 0x0F, 0x81, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x70, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFD,
  0x80, 0x1F, 0xEE, 0x00, 0xDF, 0x70, 0x0E, 0xF9, 0x80, 0x67, 0xCE, 0x07,
  0x3E, 0x30, 0x31, 0xF1, 0xC1, 0x8F, 0x86, 0x1C, 0x7C, 0x38, 0xC3, 0xE1,
  0xCE, 0x1F, 0x06, 0x60, 0xF8, 0x3F, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x1C, 0x0F, 0x80, 0xC0, 0x7C, 0x06, 0x03, 0xE0, 0x20, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3E, 0xE0, 0x03, 0xEE, 0x00, 0x3E, 0x60, 0x03,
  0xE7, 0x00, 0x3E, 0x30, 0x03, 0xE3, 0x80, 0x3E, 0x38, 0x03, 0xE1, 0xC0,
  0x3E, 0x1C, 0x03, 0xE0, 0xE0, 0x3E, 0x0E, 0x03, 0xE0, 0x70, 0x3E, 0x07,
  0x03, 0xE0, 0x30, 0x3E, 0x03, 0x83, 0xE0, 0x38, 0x3E, 0x01, 0xC3, 0xE0,
  0x1C, 0x3E, 0x00, 0xE3, 0xE0, 0x0E, 0x3E, 0x00, 0x73, 0xE0, 0x07, 0x3E,
  0x00, 0x33, 0xE0, 0x03, 0xBE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3C, 0x07,
  0x80, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x19, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D,
  0xC0, 0x00, 0x67, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x38, 0x00, 0x70, 0x60,
  0x01, 0xC1, 0xC0, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xC0, 0x03, 0xCC, 0x00, 0x0E, 0xC0,
  0x00, 0xEC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0E,
  0xC0, 0x00, 0xEC, 0x00, 0x3C, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x38, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00,
  0x19, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x19, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x03, 0x80, 0xF0,
  0x3C, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xC0, 0x03, 0xCC, 0x00, 0x0E, 0xC0, 0x00,
  0xEC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xC0,
  0x00, 0xEC, 0x00, 0x3C, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0xC0, 0x70, 0x0C,
  0x07, 0x00, 0xC0, 0x38, 0x0C, 0x03, 0xC0, 0xC0, 0x1C, 0x0C, 0x00, 0xE0,
  0xC0, 0x0E, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xC0, 0x01,
  0xCC, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3C, 0x03, 0xE0, 0xF0, 0x01, 0xE3, 0xC0,
  0x01, 0xE7, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x39, 0x00, 0x00, 0x77, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0x8F, 0x00, 0x0E, 0x0F, 0x80, 0x78, 0x0F, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x06, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xE0, 0x7C, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C,
  0x00, 0x38, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x76, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x3C, 0x06, 0x60,
  0x3C, 0x06, 0x70, 0x3C, 0x06, 0x70, 0x3E, 0x06, 0x70, 0x7E, 0x06, 0x70,
  0x66, 0x0E, 0x70, 0x66, 0x0E, 0x70, 0x67, 0x0E, 0x30, 0xE7, 0x0E, 0x30,
  0xE3, 0x0E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x8C, 0x31, 0xC3, 0x8C, 0x31,
  0xC1, 0x8C, 0x39, 0x81, 0x8C, 0x39, 0x81, 0xCC, 0x3B, 0x81, 0xCC, 0x3B,
  0x80, 0xDC, 0x3B, 0x00, 0xDC, 0x1B, 0x00, 0xFC, 0x1B, 0x00, 0xFC, 0x1F,
  0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x81, 0xC0, 0x06, 0x01,
  0x80, 0x1C, 0x03, 0x80, 0x30, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0x1D, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x21, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x07, 0x04, 0x01, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x1E, 0x03, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x08, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1C,
  0x00, 0xB8, 0x1E, 0x07, 0x3F, 0x1F, 0xFC, 0x3E, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE1, 0xFC, 0x0E, 0x7F, 0xF0, 0xEE, 0x0F, 0x8F, 0x80, 0x3C, 0xF0, 0x01,
  0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E,
  0x00, 0x0E, 0xE0, 0x00, 0xEF, 0x00, 0x1C, 0xF8, 0x03, 0xCE, 0xE0, 0xF8,
  0xE7, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0x03,
  0xC1, 0xC0, 0x0E, 0x38, 0x00, 0x63, 0x80, 0x07, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x33, 0x80, 0x07,
  0x1C, 0x00, 0xE0, 0xF0, 0x3C, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x01,
  0xF8, 0x70, 0x7F, 0xE7, 0x1F, 0x03, 0x71, 0xC0, 0x1F, 0x38, 0x00, 0xF7,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x73, 0x80, 0x0F, 0x1C, 0x01, 0xF1, 0xF0, 0x37, 0x07,
  0xFE, 0x70, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xC1, 0xE0,
  0x78, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x47, 0x00, 0x07, 0x18,
  0x00, 0x70, 0xF0, 0x07, 0x83, 0xC0, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0x98, 0x01, 0xFF, 0xE0, 0x1E, 0x07, 0x80, 0x70,
  0x07, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xC0, 0x03, 0x83,
  0x80, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0x80, 0x07, 0x98,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xE7, 0x80, 0x0F, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x1F, 0x83, 0x9F, 0xF8, 0xEE, 0x0F, 0x3E, 0x00, 0xEF, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xDF, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x01, 0xEC, 0x00, 0x3C, 0x60, 0x03, 0xC3, 0x00, 0x3C, 0x18, 0x03,
  0xC0, 0xC0, 0x38, 0x06, 0x03, 0x80, 0x30, 0x38, 0x01, 0x83, 0x80, 0x0C,
  0x78, 0x00, 0x67, 0xE0, 0x03, 0x77, 0x80, 0x1F, 0x1E, 0x00, 0xF0, 0x70,
  0x07, 0x01, 0xC0, 0x30, 0x07, 0x01, 0x80, 0x3C, 0x0C, 0x00, 0xF0, 0x60,
  0x03, 0x83, 0x00, 0x0E, 0x18, 0x00, 0x38, 0xC0, 0x01, 0xE6, 0x00, 0x07,
  0xB0, 0x00, 0x1E, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC1, 0xF3, 0x3F, 0x8F,
  0xED, 0x0F, 0x43, 0xF8, 0x1E, 0x07, 0xE0, 0x38, 0x0F, 0x00, 0xC0, 0x3C,
  0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0,
  0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x30, 0x0C, 0x01, 0xF8, 0x39, 0xFF, 0x8E, 0xE0, 0xF3, 0xE0,
  0x0E, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x70, 0x03, 0x83,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x37, 0x00, 0x01,
  0xB8, 0x00, 0x1C, 0xC0, 0x00, 0xE7, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xE0,
  0x07, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x0E, 0x7F, 0xF0, 0xEE, 0x0F, 0x8F, 0x80, 0x3C, 0xF0, 0x01, 0xCE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E,
  0xE0, 0x00, 0xEF, 0x00, 0x1C, 0xF8, 0x03, 0xCE, 0xE0, 0xF8, 0xE7, 0xFF,
  0x0E, 0x1F, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE7, 0x1F, 0x03, 0x71, 0xC0, 0x1F, 0x38, 0x00, 0xF7,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x73, 0x80, 0x0F, 0x1C, 0x01, 0xF1, 0xF0, 0x37, 0x07,
  0xFE, 0x70, 0x1F, 0x87, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xF0, 0x1C, 0xC0, 0x00, 0x76, 0x00, 0x01,
  0xD0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1E,
  0x07, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x04, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0x78, 0x00, 0xE3, 0xE0, 0x3C, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x03, 0xDC, 0x00, 0xF3,
  0xC0, 0xDC, 0x7F, 0xE7, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xC7, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xE0,
  0x03, 0x07, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xE0, 0x0C, 0x07, 0x00, 0xE0,
  0x18, 0x06, 0x00, 0xE0, 0x30, 0x03, 0x03, 0x80, 0x18, 0x18, 0x00, 0xE1,
  0xC0, 0x03, 0x0E, 0x00, 0x1C, 0x60, 0x00, 0xE7, 0x00, 0x03, 0x30, 0x00,
  0x1D, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x01, 0xB0, 0x0F, 0x00, 0xD8, 0x07, 0x80, 0x6E, 0x03,
  0x60, 0x37, 0x03, 0x30, 0x39, 0x81, 0x98, 0x1C, 0xC0, 0xCC, 0x0C, 0x60,
  0x63, 0x06, 0x30, 0x61, 0x83, 0x1C, 0x30, 0xC1, 0x8E, 0x18, 0x60, 0xC3,
  0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x60, 0xC6, 0x06, 0x30, 0x63, 0x03, 0x18,
  0x39, 0x81, 0x8C, 0x0C, 0xC0, 0x66, 0x06, 0xC0, 0x37, 0x03, 0x60, 0x1B,
  0x01, 0xB0, 0x0D, 0x80, 0xD8, 0x06, 0xC0, 0x7C, 0x01, 0xE0, 0x1C, 0x00,
  0xF0, 0x70, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x07, 0x00, 0x38,
  0x0E, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE1, 0xC0, 0x01,
  0xCE, 0x00, 0x03, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x87, 0x00,
  0x1C, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0,
  0x01, 0xC7, 0x80, 0x03, 0xBC, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0x80, 0x00,
  0x77, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC1,
  0xC0, 0x06, 0x07, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0x61, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x0C, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F,
  0x00, 0x0E, 0x3F, 0x80, 0x18, 0xE3, 0x80, 0x33, 0x83, 0x80, 0x66, 0x03,
  0x81, 0xDC, 0x03, 0x03, 0x30, 0x07, 0x8C, 0x60, 0x07, 0xF8, 0xC0, 0x03,
  0xC0,
};

const GFXglyph IBMPlexMono_Light47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 33, 28, 11, -33 },
  { 26, 10, 13, 28, 9, -35 },
  { 43, 26, 33, 28, 1, -33 },
  { 151, 22, 44, 28, 3, -38 },
  { 272, 26, 34, 28, 1, -33 },
  { 383, 25, 34, 28, 1, -33 },
  { 490, 2, 13, 28, 13, -35 },
  { 494, 13, 42, 28, 10, -36 },
  { 563, 13, 42, 28, 5, -36 },
  { 632, 24, 23, 28, 2, -26 },
  { 701, 22, 22, 28, 3, -25 },
  { 762, 7, 12, 28, 10, -5 },
  { 773, 13, 2, 28, 8, -15 },
  { 777, 6, 5, 28, 11, -5 },
  { 781, 19, 42, 28, 5, -36 },
  { 881, 22, 34, 28, 3, -33 },
  { 975, 23, 33, 28, 3, -33 },
  { 1070, 22, 33, 28, 3, -33 },
  { 1161, 21, 34, 28, 3, -33 },
  { 1251, 24, 33, 28, 2, -33 },
  { 1350, 21, 34, 28, 4, -33 },
  { 1440, 22, 34, 28, 3, -33 },
  { 1534, 22, 33, 28, 3, -33 },
  { 1625, 22, 34, 28, 3, -33 },
  { 1719, 21, 33, 28, 4, -33 },
  { 1806, 6, 25, 28, 11, -25 },
  { 1825, 7, 32, 28, 10, -25 },
  { 1853, 20, 26, 28, 4, -27 },
  { 1918, 22, 11, 28, 3, -20 },
  { 1949, 20, 26, 28, 4, -27 },
  { 2014, 20, 33, 28, 4, -33 },
  { 2097, 21, 38, 28, 3, -33 },
  { 2197, 24, 33, 28, 2, -33 },
  { 2296, 21, 33, 28, 4, -33 },
  { 2383, 22, 34, 28, 3, -33 },
  { 2477, 20, 33, 28, 5, -33 },
  { 2560, 19, 33, 28, 5, -33 },
  { 2639, 20, 33, 28, 5, -33 },
  { 2722, 21, 34, 28, 3, -33 },
  { 2812, 20, 33, 28, 4, -33 },
  { 2895, 20, 33, 28, 4, -33 },
  { 2978, 18, 34, 28, 4, -33 },
  { 3055, 23, 33, 28, 4, -33 },
  { 3150, 19, 33, 28, 6, -33 },
  { 3229, 21, 33, 28, 4, -33 },
  { 3316, 20, 33, 28, 4, -33 },
  { 3399, 22, 34, 28, 3, -33 },
  { 3493, 20, 33, 28, 5, -33 },
  { 3576, 22, 39, 28, 3, -33 },
  { 3684, 20, 33, 28, 5, -33 },
  { 3767, 23, 34, 28, 2, -33 },
  { 3865, 26, 33, 28, 1, -33 },
  { 3973, 20, 34, 28, 4, -33 },
  { 4058, 24, 33, 28, 2, -33 },
  { 4157, 24, 33, 28, 2, -33 },
  { 4256, 25, 33, 28, 2, -33 },
  { 4360, 26, 33, 28, 1, -33 },
  { 4468, 24, 33, 28, 2, -33 },
  { 4567, 13, 42, 28, 11, -36 },
  { 4636, 19, 42, 28, 5, -36 },
  { 4736, 12, 42, 28, 5, -36 },
  { 4799, 23, 19, 28, 3, -33 },
  { 4854, 22, 2, 28, 3, 5 },
  { 4860, 7, 9, 28, 9, -37 },
  { 4868, 23, 26, 28, 3, -25 },
  { 4943, 20, 36, 28, 5, -35 },
  { 5033, 20, 26, 28, 4, -25 },
  { 5098, 20, 36, 28, 3, -35 },
  { 5188, 21, 26, 28, 4, -25 },
  { 5257, 21, 35, 28, 4, -35 },
  { 5349, 22, 37, 28, 4, -27 },
  { 5451, 18, 35, 28, 5, -35 },
  { 5530, 20, 34, 28, 5, -34 },
  { 5615, 17, 43, 28, 4, -34 },
  { 5707, 21, 35, 28, 6, -35 },
  { 5799, 20, 35, 28, 4, -35 },
  { 5887, 22, 25, 28, 3, -25 },
  { 5956, 18, 25, 28, 5, -25 },
  { 6013, 21, 26, 28, 4, -25 },
  { 6082, 20, 34, 28, 5, -25 },
  { 6167, 20, 34, 28, 3, -25 },
  { 6252, 22, 24, 28, 4, -24 },
  { 6318, 20, 26, 28, 4, -25 },
  { 6383, 23, 33, 28, 2, -33 },
  { 6478, 18, 25, 28, 5, -24 },
  { 6535, 21, 24, 28, 4, -24 },
  { 6598, 25, 24, 28, 2, -24 },
  { 6673, 22, 24, 28, 3, -24 },
  { 6739, 22, 33, 28, 3, -24 },
  { 6830, 20, 24, 28, 4, -24 },
  { 6890, 18, 42, 28, 5, -36 },
  { 6985, 2, 42, 28, 13, -36 },
  { 6996, 18, 42, 28, 5, -36 },
  { 7091, 23, 9, 28, 3, -19 },
};

const GFXfont IBMPlexMono_Light47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_LIGHT47PT7B_H_
