#ifndef _IBMPLEXMONO_LIGHT56PT7B_H_
#define _IBMPLEXMONO_LIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light56pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC7,
  0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xF8,
  0x0F, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xE0,
  0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xF8, 0xE7, 0xF0, 0x7C, 0x1C, 0x1F, 0x1E, 0x03, 0x81, 0xF3, 0xC0,
  0x70, 0x1C, 0x70, 0x0E, 0x01, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00,
  0x78, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x07, 0xC1, 0xC0, 0x00,
  0x7E, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x73, 0xF8, 0x00, 0x0E, 0x0F, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0xC8, 0x01, 0xC0, 0x3B, 0x80, 0x38, 0x0F, 0xF8, 0x07, 0x01,
  0xEF, 0x80, 0xE0, 0x78, 0xF8, 0x1C, 0x1E, 0x0F, 0xE3, 0x9F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1C, 0x7F, 0xF0, 0x00, 0x39, 0xE0, 0xF0, 0x00, 0xE7, 0x80, 0xF0, 0x03,
  0x8E, 0x00, 0xE0, 0x07, 0x18, 0x00, 0xC0, 0x1C, 0x30, 0x01, 0xC0, 0x38,
  0xE0, 0x03, 0x80, 0xE1, 0xC0, 0x07, 0x01, 0xC3, 0x80, 0x0E, 0x07, 0x03,
  0x00, 0x1C, 0x0E, 0x06, 0x00, 0x30, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x1E,
  0x03, 0xC1, 0xC0, 0x1E, 0x0F, 0x07, 0x00, 0x1F, 0xFC, 0x0E, 0x00, 0x1F,
  0xF0, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3C,
  0x3F, 0xFC, 0x00, 0x70, 0x78, 0x7C, 0x01, 0xC1, 0xC0, 0x38, 0x03, 0x83,
  0x00, 0x30, 0x0E, 0x0E, 0x00, 0x70, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x38,
  0x01, 0xC0, 0xC0, 0x70, 0x03, 0x83, 0x80, 0xE0, 0x07, 0x0E, 0x01, 0xC0,
  0x0E, 0x1C, 0x03, 0x80, 0x1C, 0x70, 0x07, 0x00, 0x38, 0xE0, 0x06, 0x00,
  0x73, 0x80, 0x0E, 0x01, 0xC7, 0x00, 0x1F, 0x0F, 0x9C, 0x00, 0x1F, 0xFE,
  0x30, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78,
  0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x80, 0x3F,
  0x8F, 0x1E, 0x01, 0xFC, 0xF0, 0xF0, 0x0E, 0x07, 0x03, 0xC0, 0x70, 0x70,
  0x0F, 0x03, 0x03, 0x80, 0x3C, 0x18, 0x3C, 0x00, 0xF1, 0xC1, 0xC0, 0x03,
  0xCE, 0x0E, 0x00, 0x0E, 0x70, 0x70, 0x00, 0x7B, 0x83, 0x80, 0x01, 0xF8,
  0x1C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x3C,
  0x00, 0x0D, 0xE0, 0xF0, 0x00, 0x67, 0x87, 0xC0, 0x0E, 0x3C, 0x1F, 0x81,
  0xF0, 0xF0, 0x7F, 0xFF, 0x03, 0xC1, 0xFF, 0xE0, 0x0F, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x02,
  0xF8, 0x0E, 0x01, 0xFF, 0xF0, 0xE1, 0xFF, 0x3F, 0xEE, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0x1F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0x70, 0xF0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x1C, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x3C, 0x03, 0xF8, 0x0F, 0x80, 0x7F,
  0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x03, 0xC0, 0x3B, 0x80, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x78,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFB, 0x80,
  0x00, 0x3E, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0xF8,
  0x38, 0x00, 0x3E, 0x07, 0x00, 0x0F, 0x80, 0xE0, 0x03, 0xE0, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xE0,
  0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x03,
  0xE1, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x30, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x90, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xCF, 0x00,
  0x01, 0xE3, 0xE0, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x38, 0xFF, 0xF0, 0x1D, 0xFF, 0xFC,
  0x0E, 0xE0, 0x3F, 0x07, 0xC0, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0x40, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x7F, 0x00, 0x38,
  0xFF, 0xF0, 0x3C, 0xFF, 0xFC, 0x1C, 0xE0, 0x3F, 0x0E, 0xC0, 0x07, 0xCF,
  0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0,
  0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x0F, 0x00,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0x80, 0x7C, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x03, 0xF0,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0x71, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x1B, 0x87, 0xE0, 0x3D, 0xE0, 0xFF,
  0xFE, 0x70, 0x0F, 0xFF, 0x1C, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x1E, 0x3F, 0x3F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xF8, 0x0F, 0xC3, 0xC0, 0x07, 0xCF, 0x00, 0x07, 0x9C, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x1F,
  0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x1E, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x77, 0x00, 0x7C, 0x3B, 0x80, 0xFF, 0x9D, 0x80, 0xFF, 0xEF, 0xC0,
  0x78, 0x37, 0xE0, 0x78, 0x07, 0xF0, 0x38, 0x03, 0xF8, 0x1C, 0x00, 0xFC,
  0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x3F, 0x07, 0x00, 0x1F, 0x83, 0x80, 0x0F,
  0xC1, 0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xF0, 0x70, 0x01, 0xF8, 0x38, 0x00,
  0xFC, 0x1C, 0x00, 0x7E, 0x07, 0x00, 0x3F, 0x03, 0x80, 0x1F, 0x81, 0xC0,
  0x1E, 0xC0, 0xF0, 0x1F, 0x70, 0x3F, 0x7B, 0xB8, 0x0F, 0xF9, 0xDC, 0x03,
  0xF8, 0xEE, 0x00, 0x30, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0,
  0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38,
  0xF0, 0x00, 0x38, 0x78, 0x00, 0x78, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x87, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x87, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x38, 0x00, 0x03, 0x8F,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x1F,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0,
  0x03, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0,
  0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xB8, 0x00, 0x02,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0x71, 0xF0, 0x03,
  0xB8, 0x7E, 0x07, 0x9C, 0x1F, 0xFF, 0x8E, 0x07, 0xFF, 0x87, 0x00, 0x7F,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xDC, 0x00, 0x3C, 0xF0, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x3F, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x79, 0xDE, 0x00,
  0x0F, 0x79, 0xE0, 0x01, 0xFE, 0x1C, 0x00, 0x3F, 0x83, 0xC0, 0x07, 0xE0,
  0x3C, 0x00, 0xF8, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x70, 0x00, 0xFF, 0xB8, 0x00, 0xEF, 0xCE, 0x00, 0x77, 0xE7,
  0x00, 0x33, 0xF1, 0xC0, 0x39, 0xF8, 0xE0, 0x1C, 0xFC, 0x70, 0x1C, 0x7E,
  0x1C, 0x0E, 0x3F, 0x0E, 0x0E, 0x1F, 0x83, 0x87, 0x0F, 0xC1, 0xC3, 0x07,
  0xE0, 0x73, 0x83, 0xF0, 0x39, 0xC1, 0xF8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0x78, 0x0F, 0xC0, 0x18,
  0x07, 0xE0, 0x0C, 0x03, 0xF0, 0x04, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7, 0x00, 0x07,
  0xE7, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0xC0, 0x07,
  0xE1, 0xC0, 0x07, 0xE1, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xF0, 0x07,
  0xE0, 0x70, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x07,
  0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x0E, 0x07,
  0xE0, 0x0F, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x87, 0xE0, 0x03, 0x87,
  0xE0, 0x03, 0xC7, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xE7, 0xE0, 0x00, 0xE7,
  0xE0, 0x00, 0xE7, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xF8,
  0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x80, 0xF8,
  0x01, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x1E, 0x00, 0x0F, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x1C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x1E, 0x00, 0x0F, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x78,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x04, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x3B, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0x3F,
  0x80, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0x80, 0x07, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x0F, 0x00, 0xE3, 0x80, 0x78,
  0x07, 0x1C, 0x07, 0xC0, 0x38, 0xE0, 0x3F, 0x01, 0xC7, 0x01, 0xF8, 0x0E,
  0x38, 0x0D, 0xC0, 0x71, 0xC0, 0xE6, 0x03, 0x8E, 0x07, 0x38, 0x1C, 0x70,
  0x39, 0xC0, 0xC3, 0x81, 0x8E, 0x0E, 0x1C, 0x1C, 0x30, 0x70, 0xE0, 0xE1,
  0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x30, 0x70, 0xE0, 0xE3, 0x81, 0x87,
  0x07, 0x1C, 0x0E, 0x38, 0x38, 0xE0, 0x71, 0xC1, 0xC6, 0x03, 0x8E, 0x0E,
  0x70, 0x1C, 0x70, 0x73, 0x80, 0x73, 0x83, 0x9C, 0x03, 0x98, 0x1C, 0xC0,
  0x1D, 0xC0, 0xEE, 0x00, 0xEE, 0x07, 0x70, 0x03, 0xF0, 0x1B, 0x80, 0x1F,
  0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x07, 0x80,
  0x01, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60,
  0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x02, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xC0, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0x80, 0x07, 0x07, 0x80, 0x01, 0xC3, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x0D,
  0xC1, 0xF8, 0x0E, 0x7F, 0x3F, 0xFF, 0x8F, 0xC3, 0xFF, 0x81, 0xF0, 0x3F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x7F, 0x00, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0x01, 0xF0, 0xEC,
  0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1C, 0xF8, 0x00, 0x3C, 0xEC, 0x00, 0x78, 0xE7, 0x01, 0xF0, 0xE3,
  0xFF, 0xE0, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0x3C, 0x1C,
  0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x06, 0x3C, 0x00, 0x0F, 0x1C,
  0x00, 0x1E, 0x1F, 0x00, 0x3C, 0x0F, 0xC0, 0xF8, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0xFE, 0x0F, 0x03, 0xFF, 0x8F, 0x0F, 0xFF, 0xCF, 0x1F,
  0x80, 0xEF, 0x3E, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x8F, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x81,
  0xF0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x70,
  0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x07, 0x81,
  0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x7F,
  0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0,
  0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x1C, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x3F, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0xE0,
  0x00, 0x3E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x1E, 0x7E, 0x00, 0x1F, 0x87, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x1F, 0xC0, 0xE1, 0xFF, 0xC3, 0x8F, 0xFF, 0x8E, 0x70, 0x3F,
  0x3B, 0x00, 0x3C, 0xE8, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE7,
  0x00, 0x01, 0xE3, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xE0, 0x03, 0xE0,
  0x70, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0E, 0x03, 0xC0,
  0x07, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC3, 0xC0, 0x00, 0xE3, 0xF0,
  0x00, 0x77, 0xBC, 0x00, 0x3F, 0x8F, 0x00, 0x1F, 0x87, 0x80, 0x0F, 0x81,
  0xE0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xE0,
  0x03, 0xC0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x87, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x1E,
  0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x1C, 0x7F,
  0x0F, 0xF3, 0x9F, 0xF3, 0xFF, 0x76, 0x1E, 0x61, 0xEE, 0x81, 0xF8, 0x1F,
  0xE0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E,
  0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E,
  0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70,
  0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0,
  0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80,
  0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80,
  0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01,
  0xC0, 0x00, 0x7F, 0x03, 0x87, 0xFF, 0x0E, 0x3F, 0xFE, 0x39, 0xC0, 0xFC,
  0xEC, 0x00, 0xF3, 0xA0, 0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x1F,
  0x81, 0xF0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x0F,
  0x01, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0x01,
  0xF0, 0xEC, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1C, 0xF8, 0x00, 0x3C, 0xEC, 0x00, 0x78, 0xE7, 0x01,
  0xF0, 0xE3, 0xFF, 0xE0, 0xE1, 0xFF, 0xC0, 0xE0, 0x7F, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0x0F, 0xFF,
  0xCF, 0x1F, 0x80, 0xEF, 0x3E, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3E, 0x00,
  0x3F, 0x1F, 0x80, 0xEF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x8F, 0x00, 0xFE,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0x3C, 0xE0, 0x00, 0x07, 0xB0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xC1, 0xE0, 0x01,
  0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x08, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x40, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x8F, 0x80, 0x03, 0xC3, 0xF0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x7D, 0xE0, 0x03, 0xF3, 0xE0, 0x3B,
  0xC7, 0xFF, 0xCF, 0x0F, 0xFE, 0x3C, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xB8, 0x03, 0xE0, 0x0E, 0x60, 0x0D, 0xC0, 0x39, 0xC0,
  0x33, 0x00, 0xE7, 0x00, 0xCC, 0x03, 0x9C, 0x07, 0x30, 0x0E, 0x70, 0x1C,
  0xE0, 0x31, 0xC0, 0x63, 0x81, 0xC3, 0x01, 0x86, 0x07, 0x0E, 0x0E, 0x18,
  0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC1, 0xC1, 0xC3, 0x83, 0x07, 0x06,
  0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x70, 0x30, 0xE0, 0x61, 0xC0, 0xE3, 0x81,
  0xC6, 0x03, 0x8E, 0x07, 0x18, 0x06, 0x38, 0x1C, 0xE0, 0x18, 0xC0, 0x73,
  0x80, 0x73, 0x00, 0xCC, 0x01, 0xDC, 0x03, 0x30, 0x07, 0x70, 0x0E, 0xC0,
  0x0D, 0xC0, 0x3F, 0x00, 0x37, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x3E, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x60, 0xFF, 0x00, 0x07, 0x1F,
  0xF8, 0x00, 0xE3, 0xC7, 0xC0, 0x0E, 0x38, 0x1E, 0x00, 0xE7, 0x00, 0xF0,
  0x1C, 0x70, 0x07, 0x81, 0xC6, 0x00, 0x3C, 0x38, 0xE0, 0x01, 0xFF, 0x8E,
  0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Light56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 6, 39, 34, 14, -39 },
  { 31, 12, 15, 34, 11, -41 },
  { 54, 32, 39, 34, 1, -39 },
  { 210, 27, 53, 34, 3, -46 },
  { 389, 31, 41, 34, 1, -40 },
  { 548, 29, 41, 34, 2, -40 },
  { 697, 3, 15, 34, 15, -41 },
  { 703, 15, 51, 34, 12, -43 },
  { 799, 14, 51, 34, 7, -43 },
  { 889, 28, 28, 34, 3, -31 },
  { 987, 27, 27, 34, 3, -31 },
  { 1079, 8, 15, 34, 12, -6 },
  { 1094, 16, 3, 34, 9, -19 },
  { 1100, 6, 6, 34, 14, -6 },
  { 1105, 23, 51, 34, 5, -43 },
  { 1252, 27, 41, 34, 3, -40 },
  { 1391, 27, 39, 34, 4, -39 },
  { 1523, 26, 40, 34, 4, -40 },
  { 1653, 25, 41, 34, 3, -40 },
  { 1782, 29, 39, 34, 2, -39 },
  { 1924, 25, 40, 34, 4, -39 },
  { 2049, 25, 40, 34, 4, -39 },
  { 2174, 25, 39, 34, 4, -39 },
  { 2296, 27, 41, 34, 3, -40 },
  { 2435, 26, 40, 34, 4, -40 },
  { 2565, 6, 30, 34, 14, -30 },
  { 2588, 8, 39, 34, 12, -30 },
  { 2627, 24, 31, 34, 5, -33 },
  { 2720, 27, 14, 34, 3, -24 },
  { 2768, 24, 31, 34, 5, -33 },
  { 2861, 23, 40, 34, 5, -40 },
  { 2976, 25, 46, 34, 4, -40 },
  { 3120, 29, 39, 34, 2, -39 },
  { 3262, 25, 39, 34, 5, -39 },
  { 3384, 26, 41, 34, 4, -40 },
  { 3518, 24, 39, 34, 6, -39 },
  { 3635, 24, 39, 34, 5, -39 },
  { 3752, 24, 39, 34, 5, -39 },
  { 3869, 25, 41, 34, 4, -40 },
  { 3998, 24, 39, 34, 5, -39 },
  { 4115, 24, 39, 34, 5, -39 },
  { 4232, 21, 40, 34, 5, -39 },
  { 4337, 27, 39, 34, 5, -39 },
  { 4469, 23, 39, 34, 7, -39 },
  { 4582, 25, 39, 34, 4, -39 },
  { 4704, 24, 39, 34, 5, -39 },
  { 4821, 27, 41, 34, 3, -40 },
  { 4960, 25, 39, 34, 5, -39 },
  { 5082, 27, 49, 34, 3, -40 },
  { 5248, 25, 39, 34, 5, -39 },
  { 5370, 27, 41, 34, 3, -40 },
  { 5509, 30, 39, 34, 2, -39 },
  { 5656, 24, 40, 34, 5, -39 },
  { 5776, 29, 39, 34, 2, -39 },
  { 5918, 29, 39, 34, 2, -39 },
  { 6060, 30, 39, 34, 2, -39 },
  { 6207, 31, 39, 34, 1, -39 },
  { 6359, 28, 39, 34, 3, -39 },
  { 6496, 15, 51, 34, 13, -43 },
  { 6592, 23, 51, 34, 5, -43 },
  { 6739, 15, 51, 34, 5, -43 },
  { 6835, 28, 22, 34, 3, -39 },
  { 6912, 27, 3, 34, 3, 6 },
  { 6923, 8, 10, 34, 11, -43 },
  { 6933, 26, 31, 34, 4, -30 },
  { 7034, 24, 42, 34, 6, -41 },
  { 7160, 24, 31, 34, 5, -30 },
  { 7253, 24, 42, 34, 4, -41 },
  { 7379, 25, 31, 34, 4, -30 },
  { 7476, 26, 41, 34, 4, -41 },
  { 7610, 27, 44, 34, 4, -32 },
  { 7759, 22, 41, 34, 6, -41 },
  { 7872, 24, 42, 34, 6, -42 },
  { 7998, 20, 53, 34, 5, -42 },
  { 8131, 25, 41, 34, 7, -41 },
  { 8260, 24, 41, 34, 5, -41 },
  { 8383, 27, 30, 34, 3, -30 },
  { 8485, 22, 30, 34, 6, -30 },
  { 8568, 25, 31, 34, 4, -30 },
  { 8665, 24, 41, 34, 6, -30 },
  { 8788, 24, 41, 34, 4, -30 },
  { 8911, 27, 29, 34, 4, -29 },
  { 9009, 25, 31, 34, 4, -30 },
  { 9106, 27, 39, 34, 2, -39 },
  { 9238, 22, 30, 34, 6, -29 },
  { 9321, 25, 29, 34, 4, -29 },
  { 9412, 30, 29, 34, 2, -29 },
  { 9521, 26, 29, 34, 4, -29 },
  { 9616, 26, 40, 34, 4, -29 },
  { 9746, 23, 29, 34, 5, -29 },
  { 9830, 22, 51, 34, 6, -43 },
  { 9971, 3, 51, 34, 15, -43 },
  { 9991, 22, 51, 34, 6, -43 },
  { 10132, 28, 11, 34, 3, -23 },
};

const GFXfont IBMPlexMono_Light56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_LIGHT56PT7B_H_
