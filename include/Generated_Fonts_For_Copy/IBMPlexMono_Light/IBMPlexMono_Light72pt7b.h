#ifndef _IBMPLEXMONO_LIGHT72PT7B_H_
#define _IBMPLEXMONO_LIGHT72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Light.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Light72pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC7, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF, 0x8F, 0x80, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x78, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF1, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x39, 0xFF, 0x00, 0xFC, 0x07, 0x03,
  0xF0, 0x3F, 0x00, 0xE0, 0x3F, 0x07, 0xC0, 0x1C, 0x01, 0xF1, 0xF0, 0x03,
  0x80, 0x1F, 0x3C, 0x00, 0x70, 0x01, 0x07, 0x80, 0x0E, 0x00, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x3E, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x7C, 0x01,
  0xC0, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0xFE, 0x07, 0x00, 0x00, 0x0F,
  0xF8, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x38, 0xFF, 0x80, 0x00, 0x07, 0x03, 0xF8, 0x00, 0x00,
  0xE0, 0x3F, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x3E, 0x00,
  0x00, 0x70, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0F, 0x30, 0x00,
  0x70, 0x03, 0xEF, 0x00, 0x0E, 0x00, 0x7B, 0xF0, 0x01, 0xC0, 0x1F, 0x3F,
  0x00, 0x38, 0x07, 0xE3, 0xF0, 0x07, 0x01, 0xF8, 0x3F, 0x80, 0xE0, 0x7E,
  0x03, 0xFE, 0x1C, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x3F, 0x07, 0xC0, 0x00,
  0x3C, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0x70,
  0x00, 0xE0, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x01, 0xC0,
  0xE0, 0x00, 0x78, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x07, 0x80, 0xE0, 0x00,
  0x78, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x01, 0xE0,
  0x78, 0x00, 0x3F, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x03, 0xFF, 0xF0, 0x00,
  0x1E, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xE0,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x1C, 0x00,
  0x0E, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x1C, 0x00, 0x0E, 0x0F,
  0x00, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x00, 0x3C,
  0x38, 0x00, 0x0F, 0x80, 0x78, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x01, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x7E, 0xF8, 0x00, 0x7F, 0xC3, 0xF1, 0xF0,
  0x01, 0xFF, 0x1F, 0x03, 0xE0, 0x07, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x3F, 0x03, 0xC0, 0x7C, 0x00, 0x7C,
  0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0xF0, 0x3E,
  0x00, 0x03, 0xE3, 0x80, 0xF8, 0x00, 0x07, 0xCE, 0x03, 0xE0, 0x00, 0x0F,
  0xB8, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x00, 0xCF, 0x80, 0xF8,
  0x00, 0x07, 0x1F, 0x01, 0xF8, 0x00, 0x78, 0x7E, 0x07, 0xF8, 0x07, 0xC0,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xE0, 0x1F,
  0xFF, 0x80, 0x07, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x3F, 0x00, 0x3C, 0x01, 0xFB, 0xFF, 0x81, 0xE0, 0x7F, 0xE7, 0xFF, 0x8F,
  0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x01, 0xF7, 0x80, 0x1F,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x01, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC3,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x06, 0x00, 0x00, 0x1F, 0x02, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x08, 0x00, 0x00, 0x0F, 0x9C, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x03, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x0F, 0xF8, 0x00, 0x38, 0x3F, 0xFF, 0x00, 0x38, 0xFF, 0xFF, 0xC0,
  0x39, 0xFF, 0xFF, 0xE0, 0x3B, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x08, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x20, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x7F, 0x80, 0x03, 0xE1, 0xFF, 0xF8, 0x01, 0xE1,
  0xFF, 0xFF, 0x00, 0xF3, 0xFF, 0xFF, 0xC0, 0xFB, 0xF0, 0x0F, 0xF0, 0x79,
  0xC0, 0x01, 0xFC, 0x3D, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1F,
  0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x37, 0x87, 0xF0, 0x00, 0x7B, 0xC1, 0xFF, 0x00,
  0xF9, 0xE0, 0x7F, 0xFF, 0xF9, 0xF0, 0x0F, 0xFF, 0xF8, 0xF0, 0x03, 0xFF,
  0xF0, 0x78, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xF7, 0xF1, 0xF0, 0x0F, 0x83, 0xF8, 0x7F,
  0x9F, 0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x7F, 0x0F, 0x78, 0x01, 0xFF, 0x8F, 0x78, 0x03, 0xFF, 0xCF, 0x78, 0x07,
  0xFF, 0xEF, 0x78, 0x07, 0xE0, 0x6F, 0x70, 0x0F, 0x80, 0x3F, 0x70, 0x0F,
  0x00, 0x1F, 0x70, 0x1F, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1E,
  0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1E,
  0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1E,
  0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1E,
  0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0x70, 0x1E,
  0x00, 0x0F, 0x70, 0x0F, 0x00, 0x0F, 0x70, 0x0F, 0x00, 0x1F, 0x70, 0x0F,
  0x80, 0x3F, 0x78, 0x07, 0xF0, 0xEF, 0x78, 0x03, 0xFF, 0xEF, 0x78, 0x03,
  0xFF, 0xCF, 0x78, 0x00, 0xFF, 0x8F, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x0F, 0xCF, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x00, 0x41, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x08, 0x3E, 0x00, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x0F, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xE0, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0x10, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x6F, 0x0F, 0xE0, 0x01,
  0xEF, 0x07, 0xF8, 0x07, 0xCF, 0x03, 0xFF, 0xFF, 0x8F, 0x01, 0xFF, 0xFF,
  0x0F, 0x00, 0x7F, 0xFE, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x00,
  0x7E, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x7E, 0x00,
  0x00, 0xF0, 0x3F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xF0,
  0x00, 0x03, 0xC3, 0xFE, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x00, 0x3C, 0xF9,
  0xF0, 0x00, 0x0F, 0x7C, 0x3E, 0x00, 0x03, 0xDE, 0x0F, 0x80, 0x00, 0xFF,
  0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xDE, 0x00, 0x01, 0xDF, 0xEF, 0x00, 0x01, 0xEF, 0xF3, 0xC0, 0x00, 0xE7,
  0xF9, 0xE0, 0x00, 0xF3, 0xFC, 0x78, 0x00, 0x71, 0xFE, 0x3C, 0x00, 0x78,
  0xFF, 0x1E, 0x00, 0x3C, 0x7F, 0x87, 0x80, 0x1C, 0x3F, 0xC3, 0xC0, 0x1E,
  0x1F, 0xE0, 0xF0, 0x0E, 0x0F, 0xF0, 0x78, 0x0F, 0x07, 0xF8, 0x1E, 0x07,
  0x03, 0xFC, 0x0F, 0x07, 0x81, 0xFE, 0x07, 0x83, 0xC0, 0xFF, 0x01, 0xE1,
  0xC0, 0x7F, 0x80, 0xF1, 0xE0, 0x3F, 0xC0, 0x3C, 0xE0, 0x1F, 0xE0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0x80,
  0x0E, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x1F, 0xE0, 0x01, 0x00, 0x0F, 0xF0,
  0x00, 0x80, 0x07, 0xF8, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFD, 0xE0, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0x0F, 0xF3, 0xC0, 0x00,
  0x1F, 0xE7, 0xC0, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x7F, 0x8F, 0x80, 0x00,
  0xFF, 0x0F, 0x00, 0x01, 0xFE, 0x1F, 0x00, 0x03, 0xFC, 0x1E, 0x00, 0x07,
  0xF8, 0x3C, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x3F,
  0xC0, 0xF8, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xFE,
  0x01, 0xE0, 0x03, 0xFC, 0x03, 0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xF0,
  0x07, 0xC0, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x7F, 0x80,
  0x0F, 0x00, 0xFF, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x3E, 0x03, 0xFC, 0x00,
  0x3C, 0x07, 0xF8, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x78, 0x1F, 0xE0, 0x00,
  0xF8, 0x3F, 0xC0, 0x00, 0xF0, 0x7F, 0x80, 0x01, 0xF0, 0xFF, 0x00, 0x01,
  0xE1, 0xFE, 0x00, 0x03, 0xE3, 0xFC, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x07,
  0x8F, 0xF0, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x1F,
  0x7F, 0x80, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0xF8,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0xF8, 0xF0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x03, 0xE0, 0x03, 0xC7, 0x00, 0x1F, 0x80, 0x1E,
  0x38, 0x00, 0xFC, 0x00, 0xF1, 0xE0, 0x0F, 0xE0, 0x07, 0x8F, 0x00, 0x7F,
  0x00, 0x38, 0x78, 0x03, 0xBC, 0x01, 0xC3, 0xC0, 0x1D, 0xE0, 0x0E, 0x1E,
  0x01, 0xEF, 0x00, 0xF0, 0xF0, 0x0F, 0x38, 0x07, 0x87, 0x80, 0x71, 0xE0,
  0x3C, 0x3C, 0x03, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xC0, 0x78, 0x38, 0x0E, 0x0F, 0x03, 0xC1, 0xC0, 0x70, 0x78, 0x1E,
  0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xC0,
  0x78, 0x38, 0x1E, 0x0E, 0x03, 0xC1, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07,
  0x87, 0x80, 0x70, 0xF0, 0x3C, 0x38, 0x03, 0xC7, 0x81, 0xE1, 0xC0, 0x1E,
  0x3C, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x78, 0xF0, 0x07, 0x8F, 0x01, 0xC7,
  0x00, 0x1E, 0x78, 0x0E, 0x38, 0x00, 0xF3, 0xC0, 0x73, 0xC0, 0x07, 0x9C,
  0x03, 0xDE, 0x00, 0x3C, 0xE0, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0xF7, 0x00,
  0x07, 0xB8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0xE2, 0x00,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x3E, 0x0F,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07,
  0x01, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x05, 0xE0, 0x7C, 0x00, 0x03, 0x78, 0x1F, 0x80,
  0x03, 0x9E, 0x03, 0xF8, 0x07, 0xC7, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xFC, 0x00,
  0xF0, 0x7F, 0xFC, 0x03, 0xC3, 0xFF, 0xFC, 0x0F, 0x1F, 0xFF, 0xF8, 0x3C,
  0xF8, 0x0F, 0xF0, 0xF7, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0xF8,
  0xF7, 0x00, 0x0F, 0xE3, 0xCF, 0x80, 0xFF, 0x0F, 0x1F, 0xFF, 0xF8, 0x3C,
  0x3F, 0xFF, 0xC0, 0xF0, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x21,
  0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xF0, 0x1F, 0x00, 0xFF, 0xF8, 0x3E, 0x07, 0xFF, 0xF8, 0x7C,
  0x1F, 0xFF, 0xFC, 0xF8, 0x7F, 0x80, 0x7D, 0xF1, 0xFC, 0x00, 0x3B, 0xE3,
  0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xBE,
  0x1F, 0xE0, 0x1F, 0x7C, 0x1F, 0xFF, 0xFC, 0xF8, 0x1F, 0xFF, 0xE1, 0xF0,
  0x0F, 0xFF, 0x83, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x8E, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xE0,
  0x00, 0x03, 0xF8, 0xF8, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x01, 0xFE, 0x00, 0xF0, 0x7F, 0xFC, 0x0F, 0x1F, 0xFF, 0xE0,
  0xF3, 0xFF, 0xFF, 0x0F, 0x3C, 0x03, 0xF8, 0xF7, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7C, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0xF8, 0xFF, 0x80, 0x00, 0x7D, 0xF7,
  0xE0, 0x00, 0x3F, 0xF1, 0xF0, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x0F, 0xF0,
  0x1F, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0x1E, 0x3F, 0xE0, 0x7F, 0xE3, 0xCF, 0xFE, 0x1F, 0xFE,
  0x79, 0xFF, 0xE3, 0xFF, 0xCF, 0x70, 0x7C, 0xE0, 0xFD, 0xE8, 0x07, 0xD8,
  0x0F, 0xBE, 0x00, 0x7E, 0x00, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01,
  0xF0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x07, 0xF8,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x03,
  0xFC, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0x3C, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x03, 0xFC, 0x00,
  0x3C, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1F,
  0xE0, 0x0F, 0x07, 0xFF, 0xC0, 0xF1, 0xFF, 0xFE, 0x0F, 0x3F, 0xFF, 0xF0,
  0xF3, 0xC0, 0x3F, 0x8F, 0x70, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xC1, 0xFF, 0xF0, 0x0F,
  0x0F, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0xE0, 0xF3, 0xE0, 0x3F, 0xC3, 0xDC,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F,
  0x3F, 0x00, 0x00, 0x7C, 0xFE, 0x00, 0x03, 0xE3, 0xDC, 0x00, 0x3F, 0x8F,
  0x3E, 0x03, 0xFC, 0x3C, 0x7F, 0xFF, 0xE0, 0xF0, 0xFF, 0xFF, 0x03, 0xC1,
  0xFF, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x7C, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0xF9, 0xF0, 0xFF,
  0x00, 0xFB, 0xE3, 0xF8, 0x00, 0x77, 0xC7, 0xC0, 0x00, 0x3F, 0x9F, 0x00,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0x7C, 0x3F, 0xC0, 0x3E, 0xF8, 0x3F,
  0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0xC3, 0xE0, 0x1F, 0xFF, 0x07, 0xC0, 0x0F,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x00,
  0x7B, 0x00, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x00, 0xFC,
  0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x80, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3E, 0xFE, 0x00, 0x00, 0x3E, 0x1F,
  0xC0, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x0E, 0xF1, 0xFE,
  0x03, 0xEF, 0x0F, 0xFF, 0xFC, 0xF0, 0x7F, 0xFF, 0x8F, 0x03, 0xFF, 0xE0,
  0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0xE0, 0x00, 0xF8, 0x00, 0x3D, 0xC0,
  0x01, 0xF8, 0x00, 0x73, 0xC0, 0x07, 0xF0, 0x00, 0xE7, 0x80, 0x0E, 0xE0,
  0x03, 0xCF, 0x00, 0x1D, 0xC0, 0x07, 0x9E, 0x00, 0x3B, 0xC0, 0x0F, 0x1C,
  0x00, 0x73, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x00, 0x38, 0x78, 0x03, 0x8E,
  0x00, 0x70, 0xF0, 0x07, 0x1C, 0x00, 0xE1, 0xE0, 0x0E, 0x3C, 0x03, 0xC3,
  0xC0, 0x3C, 0x38, 0x07, 0x83, 0x80, 0x70, 0x70, 0x0F, 0x07, 0x00, 0xE0,
  0xE0, 0x1C, 0x0F, 0x01, 0xC1, 0xE0, 0x38, 0x1E, 0x03, 0x81, 0xC0, 0x70,
  0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0x70, 0x38,
  0x0E, 0x07, 0x80, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xC1, 0xE0, 0x1C, 0x1C,
  0x03, 0xC3, 0x80, 0x38, 0x38, 0x07, 0x87, 0x00, 0x70, 0x70, 0x0F, 0x0E,
  0x00, 0xF1, 0xE0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x79, 0xC0, 0x07, 0x9C, 0x00, 0xF3,
  0x80, 0x0F, 0x38, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x1D,
  0xE0, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0x00,
  0x1C, 0x3F, 0xFC, 0x00, 0x03, 0x87, 0xFF, 0xC0, 0x00, 0xF1, 0xF0, 0xFC,
  0x00, 0x1E, 0x7C, 0x0F, 0x80, 0x03, 0x8F, 0x00, 0xF8, 0x00, 0xF1, 0xC0,
  0x0F, 0x80, 0x1E, 0x78, 0x00, 0xF8, 0x07, 0x8E, 0x00, 0x0F, 0x81, 0xF1,
  0xC0, 0x00, 0xF8, 0x7C, 0x78, 0x00, 0x0F, 0xFF, 0x8F, 0x00, 0x00, 0xFF,
  0xE1, 0xC0, 0x00, 0x0F, 0xF8, 0x18, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Light72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 9, 51, 43, 17, -50 },
  { 59, 15, 19, 43, 14, -53 },
  { 95, 41, 50, 43, 1, -50 },
  { 352, 35, 66, 43, 4, -58 },
  { 641, 40, 52, 43, 2, -51 },
  { 901, 38, 52, 43, 2, -51 },
  { 1148, 4, 19, 43, 20, -53 },
  { 1158, 19, 65, 43, 16, -55 },
  { 1313, 20, 65, 43, 8, -55 },
  { 1476, 37, 36, 43, 3, -39 },
  { 1643, 35, 36, 43, 4, -40 },
  { 1801, 11, 19, 43, 15, -8 },
  { 1828, 20, 4, 43, 12, -24 },
  { 1838, 9, 8, 43, 17, -7 },
  { 1847, 29, 65, 43, 7, -55 },
  { 2083, 35, 52, 43, 4, -51 },
  { 2311, 35, 50, 43, 5, -50 },
  { 2530, 33, 51, 43, 5, -51 },
  { 2741, 33, 52, 43, 4, -51 },
  { 2956, 37, 50, 43, 3, -50 },
  { 3188, 32, 51, 43, 6, -50 },
  { 3392, 33, 51, 43, 5, -50 },
  { 3603, 33, 50, 43, 5, -50 },
  { 3810, 35, 52, 43, 4, -51 },
  { 4038, 33, 51, 43, 5, -51 },
  { 4249, 9, 38, 43, 17, -37 },
  { 4292, 11, 48, 43, 15, -37 },
  { 4358, 31, 40, 43, 6, -42 },
  { 4513, 35, 18, 43, 4, -31 },
  { 4592, 31, 40, 43, 6, -42 },
  { 4747, 30, 52, 43, 6, -51 },
  { 4942, 32, 59, 43, 5, -51 },
  { 5178, 37, 50, 43, 3, -50 },
  { 5410, 31, 50, 43, 7, -50 },
  { 5604, 33, 52, 43, 5, -51 },
  { 5819, 32, 50, 43, 7, -50 },
  { 6019, 30, 50, 43, 7, -50 },
  { 6207, 31, 50, 43, 7, -50 },
  { 6401, 32, 52, 43, 5, -51 },
  { 6609, 31, 50, 43, 6, -50 },
  { 6803, 31, 50, 43, 6, -50 },
  { 6997, 28, 51, 43, 6, -50 },
  { 7176, 34, 50, 43, 7, -50 },
  { 7389, 29, 50, 43, 9, -50 },
  { 7571, 33, 50, 43, 5, -50 },
  { 7778, 31, 50, 43, 6, -50 },
  { 7972, 35, 52, 43, 4, -51 },
  { 8200, 32, 50, 43, 7, -50 },
  { 8400, 35, 63, 43, 4, -51 },
  { 8676, 32, 50, 43, 7, -50 },
  { 8876, 35, 52, 43, 4, -51 },
  { 9104, 39, 50, 43, 2, -50 },
  { 9348, 31, 51, 43, 6, -50 },
  { 9546, 37, 50, 43, 3, -50 },
  { 9778, 37, 50, 43, 3, -50 },
  { 10010, 38, 50, 43, 3, -50 },
  { 10248, 40, 50, 43, 2, -50 },
  { 10498, 37, 50, 43, 3, -50 },
  { 10730, 19, 65, 43, 17, -55 },
  { 10885, 29, 65, 43, 7, -55 },
  { 11121, 19, 65, 43, 7, -55 },
  { 11276, 35, 29, 43, 4, -50 },
  { 11403, 35, 4, 43, 4, 7 },
  { 11421, 10, 13, 43, 14, -55 },
  { 11438, 34, 39, 43, 5, -38 },
  { 11604, 30, 54, 43, 8, -53 },
  { 11807, 30, 39, 43, 7, -38 },
  { 11954, 31, 54, 43, 5, -53 },
  { 12164, 32, 39, 43, 6, -38 },
  { 12320, 33, 53, 43, 6, -53 },
  { 12539, 35, 57, 43, 5, -42 },
  { 12789, 28, 53, 43, 8, -53 },
  { 12975, 31, 54, 43, 8, -54 },
  { 13185, 25, 68, 43, 7, -54 },
  { 13398, 33, 53, 43, 8, -53 },
  { 13617, 31, 53, 43, 6, -53 },
  { 13823, 35, 38, 43, 4, -38 },
  { 13990, 28, 38, 43, 8, -38 },
  { 14123, 33, 39, 43, 5, -38 },
  { 14284, 30, 52, 43, 8, -38 },
  { 14479, 31, 52, 43, 5, -38 },
  { 14681, 34, 37, 43, 6, -37 },
  { 14839, 33, 39, 43, 5, -38 },
  { 15000, 35, 50, 43, 3, -50 },
  { 15219, 28, 38, 43, 7, -37 },
  { 15352, 33, 37, 43, 5, -37 },
  { 15505, 39, 37, 43, 2, -37 },
  { 15686, 33, 37, 43, 5, -37 },
  { 15839, 34, 51, 43, 5, -37 },
  { 16056, 30, 37, 43, 7, -37 },
  { 16195, 27, 65, 43, 8, -55 },
  { 16415, 3, 65, 43, 20, -55 },
  { 16440, 27, 65, 43, 8, -55 },
  { 16660, 35, 15, 43, 4, -29 },
};

const GFXfont IBMPlexMono_Light72pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Light72pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Light72pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _IBMPLEXMONO_LIGHT72PT7B_H_
