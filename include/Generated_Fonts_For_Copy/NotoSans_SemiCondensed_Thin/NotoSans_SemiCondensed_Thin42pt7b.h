#ifndef _NOTOSANS_SEMICONDENSED_THIN42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin42pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x0F,
  0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00,
  0xC0, 0x40, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x80,
  0x80, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00, 0x40, 0x20, 0x01, 0x00, 0x81,
  0xFF, 0xFF, 0xF0, 0x10, 0x10, 0x00, 0x40, 0x40, 0x03, 0x01, 0x00, 0x08,
  0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x08, 0x08,
  0x00, 0x20, 0x20, 0x3F, 0xFF, 0xFC, 0x04, 0x02, 0x00, 0x10, 0x10, 0x00,
  0x40, 0x40, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80,
  0x40, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x80, 0x0F, 0x7C, 0x31, 0x06, 0x61, 0x00, 0x41, 0x00,
  0xC1, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0xC1, 0x00, 0x41, 0x00,
  0x61, 0x00, 0x31, 0x00, 0x0D, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0x38,
  0x01, 0x0C, 0x01, 0x06, 0x01, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x01, 0x06, 0xC1, 0x0C, 0x7F, 0xF0,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x1F, 0x00, 0x18, 0x08, 0x20, 0x04,
  0x06, 0x0C, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x40, 0x30, 0x10,
  0x10, 0x08, 0x04, 0x0C, 0x02, 0x01, 0x82, 0x00, 0x80, 0x61, 0x80, 0x20,
  0x18, 0x40, 0x08, 0x06, 0x10, 0x02, 0x01, 0x08, 0x00, 0xC0, 0x42, 0x3E,
  0x10, 0x11, 0x10, 0x44, 0x04, 0x4C, 0x19, 0x82, 0x22, 0x02, 0x20, 0x88,
  0x80, 0x87, 0xC4, 0x20, 0x20, 0x01, 0x18, 0x0C, 0x00, 0x86, 0x03, 0x00,
  0x21, 0x00, 0x40, 0x10, 0x40, 0x10, 0x04, 0x18, 0x0C, 0x03, 0x06, 0x03,
  0x00, 0x80, 0x80, 0x80, 0x60, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x03,
  0x06, 0x02, 0x00, 0x41, 0x01, 0x80, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x30,
  0x20, 0x00, 0x80, 0xC0, 0x04, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x10,
  0x01, 0x00, 0x40, 0x04, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x20, 0x00,
  0x41, 0x80, 0x01, 0x8C, 0x00, 0x02, 0x60, 0x00, 0x06, 0x00, 0x00, 0x68,
  0x00, 0x02, 0x30, 0x00, 0x10, 0x60, 0x00, 0x80, 0x80, 0x24, 0x01, 0x01,
  0x90, 0x02, 0x04, 0x80, 0x04, 0x12, 0x00, 0x18, 0x88, 0x00, 0x32, 0x20,
  0x00, 0x58, 0x80, 0x00, 0xC1, 0x00, 0x03, 0x04, 0x00, 0x12, 0x08, 0x00,
  0x8C, 0x10, 0x0C, 0x10, 0x3F, 0xC0, 0x30, 0xFF, 0xE0, 0x02, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x80, 0x81, 0x81, 0x01, 0x02, 0x06,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x60, 0x81, 0x06, 0x08, 0x30, 0x41,
  0x86, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x18, 0x20, 0x4E, 0x47, 0x03, 0x70, 0x01, 0x80, 0x05, 0x00, 0x09, 0x00,
  0x21, 0x00, 0x81, 0x02, 0x03, 0x04, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x7F, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x24, 0xB4, 0x96, 0x90, 0xFF, 0xC0, 0xF0, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x07, 0xF0, 0x06, 0x06, 0x04, 0x01, 0x06,
  0x00, 0x42, 0x00, 0x21, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x34,
  0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0xC0, 0x02, 0x20, 0x03, 0x10, 0x01,
  0x04, 0x00, 0x83, 0x00, 0x80, 0xC0, 0x80, 0x3F, 0x80, 0x01, 0x07, 0x0D,
  0x19, 0x61, 0xC1, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x0F, 0xF0, 0x30, 0x18, 0x40, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0x1F, 0xF0, 0x70, 0x0C, 0xC0, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x70, 0x0F, 0xE0, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0xC0,
  0x0C, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x01,
  0xA0, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00,
  0x82, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x02, 0x03, 0x00, 0x20,
  0x20, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x3F, 0xFC, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x5F, 0xC0, 0xF0, 0x30, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0xC0, 0x30, 0x7F, 0xE0, 0x03, 0xFC, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x8F, 0xF0, 0x98, 0x08, 0xA0, 0x04,
  0xC0, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02,
  0x20, 0x04, 0x18, 0x08, 0x0F, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x07, 0xF8,
  0x0C, 0x06, 0x0C, 0x00, 0x84, 0x00, 0x46, 0x00, 0x12, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x60, 0x01, 0x10, 0x01, 0x0C, 0x01, 0x83, 0x01, 0x80,
  0x63, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1C, 0x70, 0x18, 0x0C, 0x18, 0x03,
  0x18, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x44, 0x00, 0x41, 0x80, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x0C, 0x0C, 0x08, 0x01, 0x0C, 0x00, 0xC4, 0x00,
  0x22, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x0E, 0x40, 0x0A,
  0x10, 0x09, 0x07, 0xF8, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x07, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x67, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x64, 0x44,
  0xC8, 0x80, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xC6, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x07, 0x80, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x22, 0x00, 0xFF, 0x01, 0x40, 0x10, 0x10, 0x14, 0x02, 0x01,
  0x01, 0x40, 0x40, 0x10, 0x14, 0x04, 0x01, 0x01, 0xC0, 0x80, 0x10, 0x18,
  0x08, 0x01, 0x01, 0x80, 0x80, 0x10, 0x18, 0x08, 0x03, 0x01, 0x80, 0x80,
  0x30, 0x18, 0x08, 0x03, 0x01, 0x80, 0x80, 0x30, 0x1C, 0x0C, 0x03, 0x03,
  0x40, 0x40, 0x50, 0x24, 0x06, 0x09, 0x06, 0x40, 0x3F, 0x0F, 0xC6, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xB0, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x02, 0x30,
  0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x40, 0x80, 0x04,
  0x04, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x7F, 0xFC, 0x02, 0x00, 0x20, 0x10, 0x00, 0x81, 0x00,
  0x04, 0x08, 0x00, 0x20, 0x40, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21,
  0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0xFF, 0xE0, 0x40, 0x0E, 0x20, 0x01, 0x90, 0x00, 0x48, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x90, 0x00, 0x48, 0x00, 0xC4, 0x03, 0xC3, 0xFF, 0xC1, 0x00, 0x18, 0x80,
  0x02, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0xD0, 0x00,
  0xC8, 0x01, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xE0, 0x0C, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x04, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x10, 0x07, 0x02, 0x00, 0x18,
  0x40, 0x01, 0x88, 0x00, 0x19, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x06, 0x80, 0x00, 0x90, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x06, 0x08,
  0x03, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xA0, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x3F, 0xFE, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x18, 0x01, 0xC3, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x03, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x20, 0x00, 0x09, 0x80, 0x00, 0x46,
  0x00, 0x02, 0x18, 0x00, 0x10, 0x70, 0x01, 0x80, 0xFF, 0xF0, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC0, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x06, 0xFC, 0x80, 0x03,
  0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x84, 0x01, 0x82, 0x01,
  0x81, 0x01, 0x80, 0x80, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x08,
  0xC0, 0x04, 0xE0, 0x02, 0x58, 0x01, 0x44, 0x00, 0xC1, 0x00, 0x40, 0xC0,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x06, 0x04, 0x01, 0x02, 0x00, 0x41, 0x00,
  0x30, 0x80, 0x08, 0x40, 0x06, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x34,
  0x00, 0x0C, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xA0, 0x00, 0x07, 0xA0, 0x00, 0x05, 0xB0, 0x00,
  0x05, 0x90, 0x00, 0x09, 0x90, 0x00, 0x09, 0x88, 0x00, 0x09, 0x88, 0x00,
  0x11, 0x8C, 0x00, 0x11, 0x84, 0x00, 0x31, 0x84, 0x00, 0x21, 0x86, 0x00,
  0x21, 0x82, 0x00, 0x41, 0x82, 0x00, 0x41, 0x81, 0x00, 0x41, 0x81, 0x00,
  0x81, 0x81, 0x00, 0x81, 0x80, 0x81, 0x81, 0x80, 0x81, 0x01, 0x80, 0xC1,
  0x01, 0x80, 0x43, 0x01, 0x80, 0x42, 0x01, 0x80, 0x22, 0x01, 0x80, 0x24,
  0x01, 0x80, 0x24, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00,
  0x64, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x84, 0x00, 0x61, 0x80, 0x18,
  0x20, 0x06, 0x0C, 0x01, 0x81, 0x00, 0x60, 0x20, 0x18, 0x0C, 0x06, 0x01,
  0x01, 0x80, 0x60, 0x60, 0x08, 0x18, 0x01, 0x06, 0x00, 0x41, 0x80, 0x08,
  0x60, 0x03, 0x18, 0x00, 0x46, 0x00, 0x09, 0x80, 0x02, 0x60, 0x00, 0x58,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x10, 0x03, 0xFF, 0x00,
  0x18, 0x06, 0x00, 0x80, 0x06, 0x04, 0x00, 0x08, 0x20, 0x00, 0x11, 0x80,
  0x00, 0x64, 0x00, 0x00, 0x90, 0x00, 0x02, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x90, 0x00, 0x02, 0x60, 0x00, 0x10, 0x80, 0x00, 0x41, 0x00, 0x02, 0x02,
  0x00, 0x10, 0x06, 0x01, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0x00, 0xE2,
  0x00, 0x34, 0x00, 0x28, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x02,
  0x40, 0x18, 0xFF, 0xC1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x18, 0x06, 0x00, 0x80,
  0x06, 0x04, 0x00, 0x08, 0x20, 0x00, 0x11, 0x80, 0x00, 0x64, 0x00, 0x00,
  0x90, 0x00, 0x02, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90, 0x00, 0x02, 0x60,
  0x00, 0x18, 0x80, 0x00, 0x41, 0x00, 0x02, 0x06, 0x00, 0x18, 0x06, 0x01,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0xFF,
  0xC0, 0x40, 0x3C, 0x20, 0x03, 0x10, 0x00, 0x88, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x44, 0x00, 0x62, 0x00, 0x61, 0xFF, 0xC0, 0xFF, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x10, 0x04, 0x08, 0x02, 0x04, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x10, 0x80, 0x0C, 0x40, 0x02, 0x20, 0x01, 0x90, 0x00, 0x48, 0x00,
  0x34, 0x00, 0x0C, 0x07, 0xFC, 0x18, 0x03, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0xC0,
  0x0C, 0x7F, 0xF0, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00,
  0x09, 0x80, 0x02, 0x10, 0x00, 0xC1, 0x80, 0x70, 0x1F, 0xF8, 0x00, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x66, 0x00, 0x02,
  0x10, 0x00, 0x10, 0x80, 0x01, 0x86, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80,
  0x06, 0x06, 0x00, 0x20, 0x10, 0x01, 0x00, 0x80, 0x18, 0x06, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x60, 0x04, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81,
  0x80, 0x04, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00,
  0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x05, 0x00, 0x0A, 0x00, 0x1A, 0x00, 0x14, 0x00, 0x24, 0x00, 0x28,
  0x00, 0x48, 0x00, 0x50, 0x00, 0x88, 0x01, 0x30, 0x03, 0x10, 0x02, 0x20,
  0x04, 0x20, 0x04, 0x40, 0x08, 0x40, 0x08, 0x80, 0x10, 0x40, 0x21, 0x80,
  0x60, 0x80, 0x41, 0x00, 0x81, 0x00, 0x82, 0x01, 0x02, 0x01, 0x04, 0x02,
  0x02, 0x06, 0x0C, 0x0C, 0x04, 0x08, 0x08, 0x10, 0x08, 0x10, 0x10, 0x20,
  0x10, 0x20, 0x20, 0x40, 0x10, 0xC0, 0x61, 0x00, 0x21, 0x00, 0x42, 0x00,
  0x42, 0x00, 0x84, 0x00, 0x84, 0x01, 0x08, 0x00, 0x98, 0x03, 0x20, 0x01,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x80, 0x04, 0x80, 0x09, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x44, 0x00, 0x10, 0xC0, 0x06, 0x08, 0x00,
  0x81, 0x80, 0x30, 0x10, 0x04, 0x01, 0x01, 0x80, 0x20, 0x20, 0x02, 0x08,
  0x00, 0x41, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x0A, 0x00, 0x01, 0xC0,
  0x00, 0x10, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x08, 0x03, 0x01, 0x80, 0x40, 0x10,
  0x10, 0x03, 0x02, 0x00, 0x20, 0x80, 0x06, 0x30, 0x00, 0x44, 0x00, 0x0D,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0x50, 0x00, 0x34, 0x00, 0x08, 0x80, 0x06,
  0x20, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x60, 0x08, 0x08, 0x04, 0x03,
  0x01, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x13,
  0x00, 0x04, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x01, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x02, 0x30, 0x01, 0x84, 0x00, 0x41, 0x80, 0x30, 0x20,
  0x08, 0x0C, 0x06, 0x01, 0x01, 0x00, 0x60, 0xC0, 0x08, 0x20, 0x03, 0x18,
  0x00, 0x44, 0x00, 0x1A, 0x00, 0x02, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0x80,
  0x81, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x01, 0x00, 0x7F, 0xC2, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x01, 0xC1, 0xF9, 0x38, 0x05, 0x80, 0x14, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x15, 0x80, 0x93, 0xFC, 0x40, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0xE0, 0x31, 0xDE, 0x1B, 0x01,
  0x8D, 0x00, 0x27, 0x00, 0x13, 0x80, 0x05, 0x80, 0x02, 0xC0, 0x01, 0x60,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x6E, 0x00,
  0x25, 0x80, 0x32, 0x60, 0x31, 0x0F, 0xE0, 0x00, 0xE0, 0x1F, 0xF0, 0xC0,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x10, 0x7F, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x60, 0x41, 0xDE, 0x23,
  0x01, 0x93, 0x00, 0x69, 0x00, 0x15, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01,
  0xA0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x52,
  0x00, 0x29, 0x80, 0x24, 0x60, 0x32, 0x1F, 0xE1, 0x01, 0x80, 0x07, 0x70,
  0x18, 0x0C, 0x10, 0x04, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x01,
  0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x02, 0x07, 0xFC, 0x01, 0xF8, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x3F, 0xF0,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0xC0,
  0x03, 0xFC, 0x46, 0x01, 0x26, 0x00, 0x72, 0x00, 0x3B, 0x00, 0x0D, 0x00,
  0x06, 0x80, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x00,
  0xD0, 0x00, 0xE4, 0x00, 0x73, 0x00, 0x58, 0xC0, 0x6C, 0x1F, 0xC6, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x11, 0x00, 0x18, 0xE0, 0x18, 0x1F, 0xF0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x81, 0x83, 0x1D, 0xE6, 0xC0, 0x6D, 0x00, 0x5C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x55,
  0x55, 0x55, 0x55, 0x55, 0x50, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x0C, 0x21, 0xBC, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0xB0, 0x04, 0xC0, 0x23, 0x01, 0x0C,
  0x0C, 0x30, 0x60, 0xC1, 0x03, 0x08, 0x0C, 0x40, 0x33, 0x00, 0xCA, 0x03,
  0x4C, 0x0E, 0x10, 0x30, 0x20, 0xC0, 0xC3, 0x01, 0x0C, 0x06, 0x30, 0x08,
  0xC0, 0x13, 0x00, 0x6C, 0x00, 0xB0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x00, 0x10, 0x23, 0xB8, 0x3F, 0x89, 0x01, 0x10, 0x12, 0x80, 0x28, 0x02,
  0xA0, 0x0A, 0x00, 0xB0, 0x03, 0x00, 0x3C, 0x00, 0x40, 0x07, 0x00, 0x10,
  0x01, 0xC0, 0x04, 0x00, 0x70, 0x01, 0x00, 0x1C, 0x00, 0x40, 0x07, 0x00,
  0x10, 0x01, 0xC0, 0x04, 0x00, 0x70, 0x01, 0x00, 0x1C, 0x00, 0x40, 0x07,
  0x00, 0x10, 0x01, 0xC0, 0x04, 0x00, 0x70, 0x01, 0x00, 0x1C, 0x00, 0x40,
  0x07, 0x00, 0x10, 0x01, 0xC0, 0x04, 0x00, 0x70, 0x01, 0x00, 0x1C, 0x00,
  0x40, 0x04, 0x01, 0x81, 0x0E, 0xF2, 0x60, 0x34, 0x80, 0x2A, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0x00, 0xC0,
  0x03, 0xBC, 0x06, 0x01, 0x06, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09, 0x00,
  0x06, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x98, 0x00, 0x44, 0x00, 0x61, 0x00, 0x20, 0xC0, 0x60, 0x1F, 0xE0, 0x01,
  0x80, 0x8E, 0xF0, 0x90, 0x18, 0xA0, 0x04, 0xC0, 0x04, 0xC0, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0xC0,
  0x06, 0xC0, 0x04, 0xA0, 0x0C, 0xB0, 0x18, 0x8F, 0xE0, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0x80, 0x0F, 0xF9, 0x18, 0x0D, 0x30,
  0x07, 0x20, 0x03, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x20, 0x03, 0x30, 0x05, 0x18,
  0x09, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x02,
  0x4F, 0xEC, 0x1C, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x03, 0x01, 0xFF, 0xD8, 0x02, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0xC0,
  0x19, 0xFF, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x0F, 0xFC,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x80, 0x3F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x0D,
  0x00, 0x2B, 0x00, 0x53, 0x03, 0x23, 0xFC, 0x40, 0x80, 0x01, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x80, 0x08, 0x01, 0xC0, 0x0C, 0x00, 0xA0, 0x05,
  0x00, 0x48, 0x02, 0x80, 0x24, 0x03, 0x40, 0x22, 0x01, 0x20, 0x11, 0x00,
  0x88, 0x08, 0x40, 0x44, 0x04, 0x20, 0x42, 0x04, 0x10, 0x21, 0x82, 0x0C,
  0x10, 0x41, 0x02, 0x18, 0x20, 0x81, 0x08, 0x10, 0x80, 0x84, 0x04, 0x40,
  0x62, 0x02, 0x20, 0x12, 0x01, 0x10, 0x09, 0x00, 0xD0, 0x04, 0x80, 0x28,
  0x01, 0xC0, 0x14, 0x00, 0xC0, 0x0A, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0xC0, 0x06, 0x60, 0x04, 0x20, 0x08, 0x10, 0x08, 0x18, 0x10, 0x08,
  0x30, 0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x03, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x02, 0xC0, 0x04, 0x40, 0x04, 0x20, 0x08, 0x20, 0x18, 0x10, 0x10,
  0x18, 0x20, 0x08, 0x60, 0x04, 0x40, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0x40,
  0x03, 0x40, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x10, 0x04, 0x10,
  0x0C, 0x10, 0x08, 0x08, 0x08, 0x08, 0x18, 0x08, 0x10, 0x04, 0x10, 0x04,
  0x30, 0x04, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x7F,
  0xFC, 0x01, 0xE0, 0xE0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x0E, 0x03, 0x00, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x10, 0x01, 0xE0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x30, 0x03, 0x81, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x78, 0x0C, 0x00, 0x18, 0x00, 0x33, 0xC0, 0x60, 0x38,
  0x70, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Thin42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 30, 9, 3, -30 },
  { 13, 7, 11, 13, 3, -30 },
  { 23, 22, 30, 24, 1, -30 },
  { 106, 16, 34, 21, 2, -32 },
  { 174, 26, 30, 30, 2, -30 },
  { 272, 22, 30, 25, 2, -30 },
  { 355, 1, 11, 7, 3, -30 },
  { 357, 7, 37, 11, 2, -30 },
  { 390, 7, 37, 11, 2, -30 },
  { 423, 15, 15, 20, 2, -32 },
  { 452, 17, 19, 21, 2, -24 },
  { 493, 3, 10, 8, 2, -5 },
  { 497, 10, 1, 13, 1, -12 },
  { 499, 2, 2, 9, 3, -2 },
  { 500, 12, 30, 14, 1, -30 },
  { 545, 17, 30, 21, 2, -30 },
  { 609, 8, 30, 21, 4, -30 },
  { 639, 16, 30, 21, 2, -30 },
  { 699, 16, 30, 21, 2, -30 },
  { 759, 20, 30, 21, 1, -30 },
  { 834, 16, 30, 21, 3, -30 },
  { 894, 16, 30, 21, 3, -30 },
  { 954, 17, 30, 21, 2, -30 },
  { 1018, 17, 30, 21, 2, -30 },
  { 1082, 17, 30, 21, 2, -30 },
  { 1146, 2, 22, 9, 3, -22 },
  { 1152, 4, 27, 9, 2, -22 },
  { 1166, 17, 18, 21, 2, -24 },
  { 1205, 17, 10, 21, 2, -20 },
  { 1227, 17, 18, 21, 2, -24 },
  { 1266, 13, 30, 15, 1, -30 },
  { 1315, 28, 34, 33, 2, -30 },
  { 1434, 21, 30, 21, 0, -30 },
  { 1513, 17, 30, 23, 4, -30 },
  { 1577, 19, 30, 23, 3, -30 },
  { 1649, 19, 30, 26, 4, -30 },
  { 1721, 14, 30, 21, 4, -30 },
  { 1774, 14, 30, 19, 4, -30 },
  { 1827, 21, 30, 27, 3, -30 },
  { 1906, 18, 30, 26, 4, -30 },
  { 1974, 7, 30, 11, 2, -30 },
  { 2001, 8, 37, 9, -3, -30 },
  { 2038, 17, 30, 21, 4, -30 },
  { 2102, 14, 30, 19, 4, -30 },
  { 2155, 24, 30, 32, 4, -30 },
  { 2245, 18, 30, 26, 4, -30 },
  { 2313, 22, 30, 28, 3, -30 },
  { 2396, 15, 30, 21, 4, -30 },
  { 2453, 22, 37, 28, 3, -30 },
  { 2555, 17, 30, 22, 4, -30 },
  { 2619, 16, 30, 20, 2, -30 },
  { 2679, 18, 30, 19, 0, -30 },
  { 2747, 19, 30, 26, 4, -30 },
  { 2819, 21, 30, 21, 0, -30 },
  { 2898, 31, 30, 33, 1, -30 },
  { 3015, 19, 30, 19, 0, -30 },
  { 3087, 18, 30, 18, 0, -30 },
  { 3155, 18, 30, 20, 1, -30 },
  { 3223, 8, 37, 13, 4, -30 },
  { 3260, 12, 30, 14, 1, -30 },
  { 3305, 8, 37, 13, 1, -30 },
  { 3342, 18, 17, 21, 2, -30 },
  { 3381, 17, 1, 16, 0, 4 },
  { 3384, 6, 7, 10, 2, -32 },
  { 3390, 14, 23, 19, 2, -23 },
  { 3431, 17, 32, 22, 3, -32 },
  { 3499, 14, 23, 17, 2, -23 },
  { 3540, 17, 32, 22, 2, -32 },
  { 3608, 16, 23, 20, 2, -23 },
  { 3654, 13, 32, 11, 0, -32 },
  { 3706, 17, 33, 22, 2, -23 },
  { 3777, 15, 32, 22, 3, -32 },
  { 3837, 2, 30, 8, 3, -30 },
  { 3845, 6, 40, 8, -1, -30 },
  { 3875, 14, 32, 17, 3, -32 },
  { 3931, 1, 32, 8, 4, -32 },
  { 3935, 26, 23, 32, 3, -23 },
  { 4010, 15, 23, 22, 3, -23 },
  { 4054, 17, 23, 22, 2, -23 },
  { 4103, 16, 33, 22, 4, -23 },
  { 4169, 16, 33, 22, 2, -23 },
  { 4235, 9, 23, 14, 4, -23 },
  { 4261, 13, 23, 17, 2, -23 },
  { 4299, 10, 28, 12, 1, -28 },
  { 4334, 15, 22, 22, 3, -22 },
  { 4376, 16, 22, 16, 0, -22 },
  { 4420, 25, 22, 26, 1, -22 },
  { 4489, 16, 22, 18, 1, -22 },
  { 4533, 16, 32, 16, 0, -22 },
  { 4597, 13, 22, 16, 2, -22 },
  { 4633, 11, 37, 14, 2, -30 },
  { 4684, 2, 42, 20, 9, -32 },
  { 4695, 11, 37, 14, 2, -30 },
  { 4746, 17, 4, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Thin42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_THIN42PT7B_H_
