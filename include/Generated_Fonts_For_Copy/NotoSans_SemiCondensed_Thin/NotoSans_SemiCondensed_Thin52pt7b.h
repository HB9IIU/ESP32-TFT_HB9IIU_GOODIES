#ifndef _NOTOSANS_SEMICONDENSED_THIN52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin52pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20,
  0x00, 0x03, 0xFE, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x18,
  0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x0C,
  0x01, 0x00, 0x01, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x00, 0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80,
  0x30, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00,
  0x18, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00, 0x08, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x20, 0x04, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x30,
  0x00, 0x10, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x18,
  0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x81, 0x84, 0x1C, 0x60, 0x80, 0x18,
  0x10, 0x06, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x80, 0x80, 0x30, 0x10, 0x03, 0x02, 0x00, 0x30,
  0x40, 0x03, 0x08, 0x00, 0x39, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xB8, 0x00, 0x11, 0xC0, 0x02, 0x0C, 0x00, 0x40, 0xC0, 0x08, 0x08, 0x01,
  0x01, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x60, 0x08, 0x08, 0x01, 0x03, 0x40, 0x20, 0xCF, 0x04,
  0xF0, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x00, 0xC1, 0x00, 0x04,
  0x03, 0x01, 0x00, 0x18, 0x04, 0x02, 0x00, 0x20, 0x08, 0x06, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0x40, 0x08, 0x06, 0x00, 0x80, 0x10, 0x08, 0x01,
  0x00, 0x20, 0x30, 0x02, 0x00, 0x60, 0x40, 0x04, 0x00, 0xC0, 0x80, 0x08,
  0x01, 0x83, 0x00, 0x10, 0x03, 0x04, 0x00, 0x20, 0x04, 0x18, 0x00, 0x40,
  0x08, 0x20, 0xF0, 0x80, 0x10, 0xC7, 0x71, 0x80, 0x21, 0x08, 0x11, 0x00,
  0xC6, 0x30, 0x32, 0x01, 0x08, 0x40, 0x26, 0x06, 0x31, 0x80, 0x66, 0x08,
  0x42, 0x00, 0xC7, 0xE1, 0x84, 0x00, 0x83, 0x02, 0x08, 0x01, 0x00, 0x0C,
  0x10, 0x02, 0x00, 0x10, 0x20, 0x04, 0x00, 0x60, 0x40, 0x08, 0x00, 0x80,
  0x80, 0x10, 0x01, 0x01, 0x00, 0x20, 0x06, 0x02, 0x00, 0x40, 0x08, 0x04,
  0x00, 0x80, 0x30, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x30,
  0x08, 0x02, 0x00, 0x20, 0x10, 0x0C, 0x00, 0x60, 0x60, 0x10, 0x00, 0x61,
  0x80, 0x60, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x60, 0x20, 0x00, 0x30, 0x04, 0x00, 0x08, 0x01,
  0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x60, 0x02, 0x00, 0x18,
  0x00, 0x80, 0x06, 0x00, 0x20, 0x00, 0x80, 0x18, 0x00, 0x20, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x22, 0x00, 0xC0, 0x09,
  0x80, 0x10, 0x02, 0xC0, 0x02, 0x01, 0xB0, 0x00, 0xC0, 0x48, 0x00, 0x18,
  0x12, 0x00, 0x03, 0x0C, 0x80, 0x00, 0x62, 0x20, 0x00, 0x09, 0x88, 0x00,
  0x01, 0x42, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x10, 0x00, 0x0D, 0x86,
  0x00, 0x06, 0x20, 0xC0, 0x03, 0x04, 0x1C, 0x03, 0x01, 0x81, 0xFF, 0x80,
  0x30, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x0E, 0x04, 0x0C, 0xF1, 0x1C, 0x07, 0x78, 0x00, 0x30, 0x00, 0x0A,
  0x00, 0x04, 0xC0, 0x03, 0x10, 0x01, 0x82, 0x00, 0x40, 0xC0, 0x20, 0x18,
  0x18, 0x03, 0x04, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x11,
  0x33, 0x32, 0x26, 0x64, 0x4C, 0x80, 0xFF, 0xFF, 0xFF, 0xDF, 0x80, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x0E, 0x03, 0x00, 0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x04,
  0x20, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x34, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x60, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x00,
  0x80, 0xC0, 0x18, 0x06, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x70, 0x34,
  0x31, 0x18, 0x4C, 0x1E, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xFF, 0xC0,
  0x38, 0x06, 0x06, 0x00, 0x10, 0x40, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x07,
  0x00, 0x61, 0xC0, 0x01, 0x84, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x19, 0x00, 0x01, 0x8F, 0x00, 0x38, 0x0F, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x04, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x20, 0x00, 0x30, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xC1,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0xFF,
  0xC0, 0x7C, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x80, 0x01,
  0x8F, 0x00, 0x70, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xFE, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x1F, 0x00, 0xC3, 0xFF, 0x06, 0x60, 0x0C, 0x36, 0x00, 0x11, 0xE0, 0x00,
  0xCE, 0x00, 0x02, 0x70, 0x00, 0x1B, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0,
  0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01,
  0x20, 0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x20, 0x00, 0x31, 0x80,
  0x01, 0x06, 0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x38, 0x01, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0C, 0x03, 0x81, 0x80, 0x0C, 0x30, 0x00,
  0x46, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x02, 0x60, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x18,
  0x01, 0x80, 0xC0, 0x30, 0x07, 0x0E, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x39, 0xC0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x06,
  0x40, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00,
  0x02, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x1C, 0x03, 0x80, 0x7F, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x1C, 0x07, 0x03, 0x00, 0x18,
  0x20, 0x00, 0x86, 0x00, 0x0C, 0x40, 0x00, 0x4C, 0x00, 0x06, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x40,
  0x00, 0x56, 0x00, 0x0D, 0x30, 0x01, 0xB1, 0x80, 0x33, 0x0F, 0xFC, 0x30,
  0x1F, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x40, 0x38, 0x07, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0x5F, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1B, 0xF0, 0x11, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x31, 0x8C, 0x42, 0x31, 0x88, 0x46,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xC3, 0x00, 0xE0,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x02, 0x30, 0x00, 0xFF, 0x80, 0x66, 0x00,
  0x70, 0x10, 0x04, 0x80, 0x18, 0x02, 0x00, 0x90, 0x06, 0x00, 0x40, 0x16,
  0x00, 0x80, 0x08, 0x03, 0xC0, 0x30, 0x01, 0x00, 0x70, 0x04, 0x00, 0x20,
  0x0E, 0x00, 0x80, 0x04, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x38, 0x06, 0x00,
  0x30, 0x07, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x1C, 0x03,
  0x00, 0x18, 0x02, 0x80, 0x60, 0x03, 0x00, 0x50, 0x04, 0x00, 0x60, 0x1A,
  0x00, 0x80, 0x14, 0x03, 0x60, 0x18, 0x02, 0x80, 0x4C, 0x01, 0x00, 0x98,
  0x18, 0x80, 0x38, 0x71, 0x86, 0x10, 0x01, 0xF8, 0x1F, 0x83, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x03,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06,
  0x00, 0x80, 0x01, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0xFF,
  0xFC, 0x04, 0x00, 0x78, 0x20, 0x00, 0x71, 0x00, 0x00, 0xC8, 0x00, 0x06,
  0x40, 0x00, 0x12, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00,
  0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x32,
  0x00, 0x03, 0x10, 0x00, 0x30, 0x80, 0x0F, 0x07, 0xFF, 0xC0, 0x20, 0x01,
  0xE1, 0x00, 0x01, 0x88, 0x00, 0x06, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x06, 0x80,
  0x00, 0x24, 0x00, 0x03, 0x20, 0x00, 0x71, 0x00, 0x1E, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xE0, 0x06, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0x00, 0xFF, 0xF8,
  0x00, 0x80, 0x1F, 0x00, 0x80, 0x01, 0xC0, 0x80, 0x00, 0xE0, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x60, 0x80, 0x00, 0xC0, 0x80, 0x03, 0x80, 0x80, 0x3E, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x81, 0xC0, 0x00, 0x10, 0x0E, 0x00, 0x1E, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFF, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x06, 0xC7, 0x3F,
  0x80, 0x80, 0x00, 0x34, 0x00, 0x03, 0x20, 0x00, 0x31, 0x00, 0x03, 0x08,
  0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x18, 0x10, 0x01, 0x80, 0x80, 0x18,
  0x04, 0x01, 0x80, 0x20, 0x18, 0x01, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x40,
  0xC0, 0x02, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0x8E, 0x00, 0x04, 0xD8, 0x00,
  0x24, 0x60, 0x01, 0x41, 0x00, 0x0E, 0x0C, 0x00, 0x60, 0x30, 0x02, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x18, 0x04, 0x00, 0x40, 0x20, 0x03, 0x01,
  0x00, 0x0C, 0x08, 0x00, 0x60, 0x40, 0x01, 0x82, 0x00, 0x04, 0x10, 0x00,
  0x30, 0x80, 0x00, 0xC4, 0x00, 0x02, 0x20, 0x00, 0x19, 0x00, 0x00, 0x68,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xF8, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00,
  0x05, 0xB0, 0x00, 0x00, 0x36, 0x40, 0x00, 0x00, 0x99, 0x00, 0x00, 0x02,
  0x66, 0x00, 0x00, 0x19, 0x88, 0x00, 0x00, 0x46, 0x30, 0x00, 0x03, 0x18,
  0xC0, 0x00, 0x0C, 0x61, 0x00, 0x00, 0x21, 0x86, 0x00, 0x01, 0x86, 0x08,
  0x00, 0x04, 0x18, 0x20, 0x00, 0x10, 0x60, 0xC0, 0x00, 0xC1, 0x81, 0x00,
  0x02, 0x06, 0x06, 0x00, 0x18, 0x18, 0x18, 0x00, 0x60, 0x60, 0x20, 0x01,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x01, 0x00, 0x20, 0x18, 0x04, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x10, 0x06, 0x00, 0x80, 0x40, 0x18,
  0x03, 0x03, 0x00, 0x60, 0x04, 0x08, 0x01, 0x80, 0x18, 0x60, 0x06, 0x00,
  0x61, 0x80, 0x18, 0x00, 0x84, 0x00, 0x60, 0x03, 0x30, 0x01, 0x80, 0x04,
  0x80, 0x06, 0x00, 0x12, 0x00, 0x18, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1D, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x72, 0x00, 0x00, 0xE6, 0x00,
  0x01, 0xC6, 0x00, 0x03, 0x84, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x08, 0x00,
  0x1C, 0x18, 0x00, 0x38, 0x18, 0x00, 0x70, 0x10, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x20, 0x03, 0x80, 0x60, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x40, 0x1C,
  0x00, 0xC0, 0x38, 0x00, 0x80, 0x70, 0x01, 0x80, 0xE0, 0x01, 0x81, 0xC0,
  0x01, 0x03, 0x80, 0x03, 0x07, 0x00, 0x02, 0x0E, 0x00, 0x06, 0x1C, 0x00,
  0x04, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x09, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x17, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x1C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x10,
  0x03, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0xC8, 0x00, 0x0D, 0x00, 0x00, 0xA0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x14, 0x00, 0x06, 0x80,
  0x00, 0x90, 0x00, 0x32, 0x00, 0x1C, 0x40, 0x1E, 0x0F, 0xFF, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xF8,
  0x08, 0x01, 0xE0, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00,
  0x04, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80,
  0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0x48,
  0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x0E, 0x0F, 0xFF, 0x80,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x80, 0x18, 0x08, 0x01, 0x80, 0x80, 0x0C,
  0x08, 0x00, 0x40, 0x80, 0x06, 0x08, 0x00, 0x20, 0x80, 0x03, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80,
  0x00, 0x68, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x70, 0x00, 0x7F, 0xF8,
  0x1C, 0x00, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0xE0, 0x07, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0x20, 0x00, 0x06, 0x60, 0x00, 0x08, 0x60, 0x00, 0x30, 0x60, 0x00,
  0xC0, 0x70, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x20,
  0x00, 0x01, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x08,
  0x10, 0x00, 0x06, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x40, 0x20, 0x00,
  0x30, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0x40, 0x01, 0x80, 0x10,
  0x00, 0x40, 0x06, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x02, 0x00,
  0x0C, 0x00, 0x80, 0x01, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x18, 0x04,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x04,
  0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x02, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x12, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x80, 0x00, 0x60, 0x00, 0x09, 0x00, 0x00, 0xE0,
  0x00, 0x13, 0x00, 0x01, 0x40, 0x00, 0x66, 0x00, 0x02, 0x80, 0x00, 0xC4,
  0x00, 0x0D, 0x00, 0x01, 0x08, 0x00, 0x13, 0x00, 0x02, 0x18, 0x00, 0x22,
  0x00, 0x0C, 0x30, 0x00, 0x44, 0x00, 0x18, 0x20, 0x01, 0x88, 0x00, 0x20,
  0x40, 0x03, 0x18, 0x00, 0x40, 0xC0, 0x04, 0x10, 0x01, 0x81, 0x80, 0x08,
  0x20, 0x03, 0x01, 0x00, 0x30, 0x40, 0x04, 0x02, 0x00, 0x60, 0xC0, 0x08,
  0x06, 0x00, 0x80, 0x80, 0x30, 0x0C, 0x01, 0x01, 0x00, 0x60, 0x08, 0x06,
  0x02, 0x00, 0x80, 0x10, 0x0C, 0x06, 0x01, 0x00, 0x30, 0x10, 0x04, 0x06,
  0x00, 0x60, 0x20, 0x08, 0x0C, 0x00, 0x40, 0xC0, 0x10, 0x10, 0x00, 0x81,
  0x80, 0x30, 0x20, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x03, 0x04, 0x00, 0x41,
  0x80, 0x02, 0x18, 0x00, 0x82, 0x00, 0x04, 0x30, 0x01, 0x84, 0x00, 0x0C,
  0x40, 0x01, 0x18, 0x00, 0x18, 0x80, 0x02, 0x30, 0x00, 0x13, 0x00, 0x04,
  0x40, 0x00, 0x26, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x1B, 0x00, 0x00,
  0xD0, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x18, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x80,
  0x80, 0x03, 0x01, 0x80, 0x04, 0x01, 0x00, 0x18, 0x03, 0x00, 0x20, 0x03,
  0x00, 0xC0, 0x02, 0x01, 0x00, 0x06, 0x06, 0x00, 0x04, 0x08, 0x00, 0x0C,
  0x30, 0x00, 0x08, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x16, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x08, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x41, 0x80, 0x01, 0x81, 0x00,
  0x02, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x00, 0x40, 0x04, 0x01,
  0x80, 0x0C, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x18, 0x60,
  0x00, 0x11, 0x80, 0x00, 0x33, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x80, 0x00, 0x19, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC3, 0x00,
  0x01, 0x02, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x0C, 0x00,
  0x60, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x30, 0x04, 0x00, 0x20, 0x18,
  0x00, 0x60, 0x20, 0x00, 0x40, 0xC0, 0x00, 0xC1, 0x00, 0x00, 0x86, 0x00,
  0x01, 0x88, 0x00, 0x01, 0x10, 0x00, 0x03, 0x60, 0x00, 0x02, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xC0, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0xFF,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0xA0, 0x00, 0x06, 0xC0, 0x00, 0x11, 0x00, 0x00, 0xC6, 0x00, 0x02, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x40, 0xC0, 0x03, 0x01, 0x00, 0x08, 0x06, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x20, 0x01, 0x81, 0x80,
  0x02, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x80, 0x00, 0x66, 0x00, 0x00,
  0x90, 0x00, 0x03, 0xC0, 0x00, 0x04, 0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x20,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF8, 0x03, 0xE7, 0x81, 0x80, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x7F,
  0xF0, 0xF0, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1D, 0x00, 0x07, 0x40,
  0x03, 0x58, 0x01, 0x93, 0x00, 0xC4, 0x7F, 0xC1, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC1, 0xFC, 0x0C, 0x78, 0xF0, 0xCC, 0x01,
  0x8D, 0x80, 0x0C, 0xF0, 0x00, 0x6E, 0x00, 0x02, 0xE0, 0x00, 0x2C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x02,
  0xE0, 0x00, 0x2E, 0x00, 0x06, 0xD0, 0x00, 0xCD, 0x80, 0x18, 0x8E, 0x03,
  0x08, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x01, 0xE3, 0xC3, 0x80,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x20, 0x7F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x01, 0xF8, 0x10, 0x78, 0xE1, 0x0C, 0x01, 0x91, 0x80, 0x09,
  0x30, 0x00, 0x52, 0x00, 0x05, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x76,
  0x00, 0x05, 0x30, 0x00, 0xD1, 0x80, 0x19, 0x0C, 0x03, 0x10, 0x7F, 0xC1,
  0x00, 0x20, 0x00, 0x01, 0xF8, 0x00, 0xE3, 0xC0, 0x30, 0x0C, 0x0C, 0x00,
  0xC3, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x12, 0x00, 0x03, 0x40, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x04, 0x38, 0x03, 0x01, 0xFF, 0xC0, 0x02, 0x00,
  0x00, 0x78, 0x03, 0xFC, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x1F, 0xFC, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x01, 0xFC, 0x00, 0x78, 0xF1, 0x0C, 0x01, 0x91, 0x80,
  0x0D, 0x30, 0x00, 0x52, 0x00, 0x07, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00,
  0x56, 0x00, 0x05, 0x30, 0x00, 0xD1, 0x80, 0x19, 0x0C, 0x07, 0x10, 0x7F,
  0xC1, 0x00, 0x60, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x44,
  0x00, 0x0C, 0x70, 0x03, 0x01, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x1F, 0xC1, 0x8F, 0x1E, 0x33, 0x00, 0xE6, 0xC0, 0x04,
  0xF0, 0x00, 0xDC, 0x00, 0x0B, 0x80, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x5B, 0xA0, 0x00,
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80,
  0x01, 0x01, 0x80, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x7E, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x08,
  0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x86,
  0x00, 0xC7, 0x00, 0x66, 0x80, 0x36, 0x60, 0x1A, 0x10, 0x0E, 0x04, 0x07,
  0x03, 0x03, 0x00, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x60, 0x04, 0x30, 0x03,
  0x18, 0x00, 0x8C, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x07,
  0xE0, 0x87, 0x1C, 0x1E, 0x78, 0x98, 0x06, 0x30, 0x0C, 0x90, 0x02, 0x60,
  0x06, 0xE0, 0x03, 0x40, 0x06, 0xE0, 0x01, 0xC0, 0x02, 0xC0, 0x01, 0x80,
  0x02, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0x01, 0xFC, 0x10, 0xF1, 0xE2, 0x30, 0x0E, 0x4C, 0x00, 0x4F, 0x00,
  0x0D, 0xC0, 0x00, 0xB8, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x01, 0xFC, 0x00, 0x3C,
  0x78, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11,
  0x80, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00,
  0x24, 0x00, 0x01, 0x20, 0x00, 0x19, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x30,
  0x00, 0x40, 0xC0, 0x06, 0x03, 0x80, 0xE0, 0x07, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFC, 0x04, 0x3C, 0x78, 0x23, 0x00, 0x61, 0x30, 0x01, 0x89,
  0x00, 0x06, 0x78, 0x00, 0x13, 0x80, 0x00, 0x9C, 0x00, 0x06, 0xC0, 0x00,
  0x16, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x00,
  0xB0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x70, 0x00, 0x13, 0x80,
  0x00, 0x9E, 0x00, 0x0C, 0xD0, 0x00, 0xC6, 0xC0, 0x0C, 0x33, 0x80, 0xC1,
  0x87, 0xFC, 0x0C, 0x02, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x78, 0xE1, 0x0C, 0x03, 0x11, 0x80, 0x09, 0x30, 0x00, 0x56, 0x00,
  0x05, 0x40, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x56, 0x00, 0x05, 0x30, 0x00,
  0x91, 0x80, 0x19, 0x0C, 0x07, 0x10, 0x7F, 0xC1, 0x00, 0x40, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x01, 0xFE, 0x3F, 0xB3, 0x01, 0xA0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x03, 0xF8, 0x0F, 0x8F, 0x8C, 0x00, 0x4C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x40, 0x01, 0xB8, 0x03, 0x87, 0xFF, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x0F, 0xFF, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x7F, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x15, 0x80,
  0x0D, 0x20, 0x06, 0x4E, 0x03, 0x10, 0xFF, 0x84, 0x02, 0x00, 0xC0, 0x00,
  0x34, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00,
  0x0C, 0x30, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x81, 0x80, 0x10, 0x08,
  0x01, 0x00, 0x80, 0x30, 0x0C, 0x02, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00,
  0x60, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x03, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x18, 0x00, 0x19, 0x00, 0x00, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x0B, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x14, 0x00, 0x64, 0x00, 0x6C,
  0x00, 0x8C, 0x00, 0xD8, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10, 0x02, 0x20,
  0x0C, 0x20, 0x0C, 0x60, 0x10, 0x60, 0x10, 0x40, 0x20, 0x40, 0x20, 0x80,
  0x40, 0x80, 0xC1, 0x01, 0x81, 0x81, 0x83, 0x02, 0x03, 0x02, 0x02, 0x04,
  0x02, 0x04, 0x04, 0x08, 0x04, 0x18, 0x0C, 0x30, 0x0C, 0x20, 0x08, 0x40,
  0x18, 0x40, 0x10, 0x80, 0x11, 0x80, 0x21, 0x00, 0x22, 0x00, 0x66, 0x00,
  0x64, 0x00, 0x48, 0x00, 0x58, 0x00, 0x90, 0x00, 0xB0, 0x01, 0xA0, 0x01,
  0x40, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x64, 0x00, 0x18, 0xC0, 0x02, 0x0C, 0x00,
  0xC0, 0x80, 0x30, 0x18, 0x04, 0x01, 0x81, 0x80, 0x10, 0x60, 0x03, 0x08,
  0x00, 0x23, 0x00, 0x06, 0x40, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x2C, 0x00, 0x0C, 0x80, 0x01, 0x18, 0x00, 0x61, 0x80, 0x18, 0x10,
  0x02, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x06, 0x06, 0x00, 0x61, 0x80, 0x04,
  0x20, 0x00, 0xCC, 0x00, 0x0F, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x34, 0x00,
  0x02, 0x60, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x04, 0x10,
  0x00, 0xC1, 0x00, 0x08, 0x18, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00,
  0xC0, 0x10, 0x04, 0x03, 0x00, 0x40, 0x20, 0x06, 0x02, 0x00, 0x20, 0x60,
  0x02, 0x04, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x88,
  0x00, 0x09, 0x80, 0x00, 0x90, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0x80, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x16, 0x03, 0x80, 0xE0,
  0x03, 0xDE, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 37, 11, 4, -37 },
  { 15, 8, 13, 16, 4, -37 },
  { 28, 27, 37, 29, 1, -37 },
  { 153, 19, 42, 26, 3, -39 },
  { 253, 31, 39, 37, 3, -38 },
  { 405, 26, 39, 30, 3, -38 },
  { 532, 1, 13, 9, 4, -37 },
  { 534, 9, 45, 13, 2, -37 },
  { 585, 9, 45, 13, 2, -37 },
  { 636, 18, 18, 25, 3, -39 },
  { 677, 22, 24, 26, 2, -30 },
  { 743, 4, 13, 9, 2, -6 },
  { 750, 12, 2, 16, 2, -15 },
  { 753, 3, 3, 11, 4, -3 },
  { 755, 15, 37, 17, 1, -37 },
  { 825, 20, 38, 26, 3, -38 },
  { 920, 10, 37, 26, 5, -37 },
  { 967, 20, 38, 26, 3, -38 },
  { 1062, 21, 39, 26, 2, -38 },
  { 1165, 25, 37, 26, 1, -37 },
  { 1281, 20, 38, 26, 3, -37 },
  { 1376, 21, 39, 26, 3, -38 },
  { 1479, 20, 37, 26, 3, -37 },
  { 1572, 20, 39, 26, 3, -38 },
  { 1670, 20, 39, 26, 3, -38 },
  { 1768, 3, 28, 11, 4, -28 },
  { 1779, 5, 35, 11, 2, -28 },
  { 1801, 22, 23, 26, 2, -30 },
  { 1865, 22, 12, 26, 2, -24 },
  { 1898, 22, 23, 26, 2, -30 },
  { 1962, 15, 38, 19, 2, -38 },
  { 2034, 35, 42, 40, 3, -37 },
  { 2218, 26, 37, 26, 0, -37 },
  { 2339, 21, 37, 28, 5, -37 },
  { 2437, 24, 39, 28, 3, -38 },
  { 2554, 24, 37, 32, 5, -37 },
  { 2665, 17, 37, 25, 5, -37 },
  { 2744, 17, 37, 23, 5, -37 },
  { 2823, 27, 39, 34, 3, -38 },
  { 2955, 23, 37, 33, 5, -37 },
  { 3062, 8, 37, 14, 3, -37 },
  { 3099, 10, 46, 11, -4, -37 },
  { 3157, 21, 37, 26, 5, -37 },
  { 3255, 17, 37, 23, 5, -37 },
  { 3334, 30, 37, 40, 5, -37 },
  { 3473, 23, 37, 33, 5, -37 },
  { 3580, 28, 39, 35, 3, -38 },
  { 3717, 19, 37, 26, 5, -37 },
  { 3805, 28, 47, 35, 3, -38 },
  { 3970, 20, 37, 27, 5, -37 },
  { 4063, 20, 39, 25, 3, -38 },
  { 4161, 23, 37, 23, 0, -37 },
  { 4268, 23, 38, 33, 5, -37 },
  { 4378, 26, 37, 26, 0, -37 },
  { 4499, 39, 37, 41, 1, -37 },
  { 4680, 23, 37, 23, 0, -37 },
  { 4787, 23, 37, 23, 0, -37 },
  { 4894, 22, 37, 25, 2, -37 },
  { 4996, 10, 45, 16, 5, -37 },
  { 5053, 15, 37, 17, 1, -37 },
  { 5123, 10, 45, 16, 2, -37 },
  { 5180, 22, 21, 26, 2, -37 },
  { 5238, 20, 1, 20, 0, 5 },
  { 5241, 8, 8, 12, 2, -40 },
  { 5249, 18, 29, 24, 2, -28 },
  { 5315, 20, 41, 27, 4, -40 },
  { 5418, 17, 29, 22, 3, -28 },
  { 5480, 20, 41, 27, 3, -40 },
  { 5583, 19, 29, 25, 3, -28 },
  { 5652, 15, 40, 13, 1, -40 },
  { 5727, 20, 41, 27, 3, -28 },
  { 5830, 19, 40, 27, 4, -40 },
  { 5925, 3, 38, 10, 4, -38 },
  { 5940, 9, 51, 10, -2, -38 },
  { 5998, 17, 40, 21, 4, -40 },
  { 6083, 2, 40, 10, 4, -40 },
  { 6093, 32, 28, 40, 4, -28 },
  { 6205, 19, 28, 27, 4, -28 },
  { 6272, 21, 29, 27, 3, -28 },
  { 6349, 21, 40, 27, 4, -28 },
  { 6454, 20, 40, 27, 3, -28 },
  { 6554, 13, 28, 17, 4, -28 },
  { 6600, 17, 29, 21, 2, -28 },
  { 6662, 12, 35, 15, 1, -34 },
  { 6715, 18, 28, 27, 4, -27 },
  { 6778, 20, 27, 20, 0, -27 },
  { 6846, 31, 27, 32, 1, -27 },
  { 6951, 19, 27, 22, 1, -27 },
  { 7016, 20, 40, 20, 0, -27 },
  { 7116, 16, 27, 20, 2, -27 },
  { 7170, 14, 45, 18, 2, -37 },
  { 7249, 1, 53, 25, 12, -40 },
  { 7256, 14, 45, 18, 2, -37 },
  { 7335, 22, 5, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Thin52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_THIN52PT7B_H_
