#ifndef _NOTOSANS_SEMICONDENSED_THIN14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x40, 0xFF, 0x12, 0x14, 0x24, 0x7F, 0x24, 0x24, 0xFE, 0x28,
  0x48, 0x48, 0x22, 0xE9, 0x4A, 0x20, 0xC5, 0x29, 0x7C, 0x40, 0xE2, 0xA4,
  0xA4, 0xA8, 0xAF, 0xF5, 0x19, 0x29, 0x25, 0x47, 0x71, 0x12, 0x22, 0x86,
  0x14, 0x24, 0xC6, 0x85, 0xF4, 0xF0, 0x6A, 0xAA, 0xA9, 0xA5, 0x55, 0x5A,
  0x21, 0x2E, 0xC5, 0x00, 0x21, 0x09, 0xF2, 0x10, 0xF0, 0xF0, 0x80, 0x11,
  0x12, 0x22, 0x44, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0x80, 0x3C,
  0x92, 0x49, 0x24, 0xF0, 0x42, 0x10, 0x88, 0x88, 0x87, 0xC0, 0xF0, 0x42,
  0x17, 0x04, 0x21, 0x0F, 0x80, 0x08, 0x10, 0x51, 0x22, 0x48, 0xA1, 0x3F,
  0x04, 0x08, 0xFC, 0x21, 0x0F, 0x04, 0x21, 0x0F, 0x80, 0x7C, 0x21, 0x0F,
  0xC6, 0x31, 0x8B, 0xC0, 0xF8, 0x42, 0x21, 0x08, 0x84, 0x42, 0x00, 0x7C,
  0x63, 0x17, 0x6E, 0x31, 0x8F, 0xC0, 0xF4, 0x63, 0x18, 0xFC, 0x21, 0x0F,
  0x80, 0x82, 0x87, 0x80, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0x83,
  0x06, 0x36, 0x40, 0xF0, 0x42, 0x11, 0x11, 0x08, 0x02, 0x00, 0x3E, 0x20,
  0xA0, 0x33, 0xDA, 0x2D, 0x16, 0x93, 0x49, 0x9B, 0x40, 0x1F, 0x80, 0x10,
  0x20, 0xA1, 0x42, 0x4F, 0x91, 0x21, 0x83, 0x04, 0xFA, 0x18, 0x61, 0xFA,
  0x18, 0x61, 0x87, 0xE0, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0xF0,
  0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0xF0, 0xFC, 0x21, 0x0F,
  0xC2, 0x10, 0x87, 0xC0, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x00, 0x3E,
  0x82, 0x04, 0x08, 0x11, 0xE0, 0xC1, 0x82, 0xFC, 0x86, 0x18, 0x61, 0xFE,
  0x18, 0x61, 0x86, 0x10, 0xEA, 0xAA, 0xB0, 0x24, 0x92, 0x49, 0x24, 0xF0,
  0x86, 0x29, 0x28, 0xC2, 0x89, 0x22, 0x8A, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x87, 0xC0, 0x81, 0x81, 0xC1, 0xC3, 0xA3, 0xA3, 0x95, 0x95, 0x99,
  0x89, 0x87, 0x1C, 0x69, 0x96, 0x58, 0xE3, 0x86, 0x10, 0x7D, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0xF8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x84,
  0x00, 0x7D, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xE8, 0x20, 0x20,
  0xFA, 0x18, 0x61, 0x8B, 0xC9, 0x22, 0x8A, 0x10, 0xFC, 0x21, 0x06, 0x08,
  0x21, 0x0F, 0x80, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xF8, 0x83, 0x06, 0x12, 0x24,
  0x49, 0x0A, 0x14, 0x30, 0x20, 0x84, 0x30, 0x85, 0x29, 0x25, 0x24, 0xA4,
  0x94, 0x8C, 0x61, 0x8C, 0x31, 0x82, 0x20, 0x85, 0x24, 0x8C, 0x10, 0x42,
  0x92, 0x46, 0x10, 0x86, 0x14, 0x92, 0x30, 0x41, 0x04, 0x10, 0x40, 0x7C,
  0x10, 0x82, 0x10, 0x42, 0x10, 0x43, 0xF0, 0xF2, 0x49, 0x24, 0x92, 0x70,
  0x88, 0x44, 0x22, 0x21, 0x11, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x10, 0x50,
  0xA2, 0x24, 0x50, 0x40, 0xFC, 0xA4, 0x69, 0x11, 0xF9, 0x9F, 0x82, 0x08,
  0x2C, 0xCA, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x3C, 0x88, 0x88, 0x87, 0x08,
  0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x7E, 0x74, 0x63, 0x1F, 0x42, 0x0F, 0x34,
  0x4E, 0x44, 0x44, 0x44, 0x40, 0x74, 0x63, 0x18, 0xC6, 0x2F, 0x08, 0x7E,
  0x84, 0x21, 0x6C, 0xC6, 0x31, 0x8C, 0x62, 0x9F, 0xC0, 0x41, 0x55, 0x55,
  0xC0, 0x84, 0x21, 0x09, 0x53, 0x14, 0xA4, 0xA2, 0xFF, 0xE0, 0x77, 0x44,
  0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x36, 0x63, 0x18, 0xC6, 0x31,
  0x74, 0x63, 0x18, 0xC6, 0x2F, 0x33, 0x28, 0x61, 0x86, 0x18, 0x7E, 0x82,
  0x08, 0x00, 0x74, 0x63, 0x18, 0xC6, 0x3F, 0x08, 0x42, 0x3A, 0x49, 0x24,
  0x78, 0x88, 0x61, 0x1F, 0x4F, 0x44, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18,
  0xC7, 0xE0, 0x8C, 0x52, 0xA5, 0x10, 0x80, 0x88, 0xCC, 0x95, 0x4A, 0xA5,
  0x53, 0x10, 0x88, 0xC9, 0x43, 0x08, 0x31, 0x28, 0xC0, 0x8C, 0x52, 0xA5,
  0x10, 0x84, 0x26, 0x00, 0xF2, 0x24, 0x88, 0xF0, 0x32, 0x22, 0x24, 0xC2,
  0x22, 0x23, 0xFF, 0xFC, 0x89, 0x24, 0x9A, 0x49, 0x60, 0x45, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Thin14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 2, 4, 4, 1, -10 },
  { 4, 8, 10, 8, 0, -10 },
  { 14, 5, 12, 7, 1, -11 },
  { 22, 8, 10, 10, 1, -10 },
  { 32, 7, 10, 8, 1, -10 },
  { 41, 1, 4, 2, 1, -10 },
  { 42, 2, 12, 4, 1, -10 },
  { 45, 2, 12, 4, 1, -10 },
  { 48, 5, 5, 7, 1, -11 },
  { 52, 5, 6, 7, 1, -8 },
  { 56, 1, 4, 3, 1, -2 },
  { 57, 4, 1, 4, 0, -4 },
  { 58, 1, 1, 3, 1, -1 },
  { 59, 4, 10, 5, 0, -10 },
  { 64, 5, 10, 7, 1, -10 },
  { 71, 3, 10, 7, 1, -10 },
  { 75, 5, 10, 7, 1, -10 },
  { 82, 5, 10, 7, 1, -10 },
  { 89, 7, 10, 7, 0, -10 },
  { 98, 5, 10, 7, 1, -10 },
  { 105, 5, 10, 7, 1, -10 },
  { 112, 5, 10, 7, 1, -10 },
  { 119, 5, 10, 7, 1, -10 },
  { 126, 5, 10, 7, 1, -10 },
  { 133, 1, 7, 3, 1, -7 },
  { 134, 1, 9, 3, 1, -7 },
  { 136, 5, 6, 7, 1, -8 },
  { 140, 5, 4, 7, 1, -7 },
  { 143, 5, 6, 7, 1, -8 },
  { 147, 5, 10, 5, 0, -10 },
  { 154, 9, 11, 11, 1, -10 },
  { 167, 7, 10, 7, 0, -10 },
  { 176, 6, 10, 8, 1, -10 },
  { 184, 6, 10, 8, 1, -10 },
  { 192, 7, 10, 9, 1, -10 },
  { 201, 5, 10, 7, 1, -10 },
  { 208, 5, 10, 6, 1, -10 },
  { 215, 7, 10, 9, 1, -10 },
  { 224, 6, 10, 9, 1, -10 },
  { 232, 2, 10, 4, 1, -10 },
  { 235, 3, 12, 3, -1, -10 },
  { 240, 6, 10, 7, 1, -10 },
  { 248, 5, 10, 6, 1, -10 },
  { 255, 8, 10, 11, 1, -10 },
  { 265, 6, 10, 9, 1, -10 },
  { 273, 7, 10, 9, 1, -10 },
  { 282, 5, 10, 7, 1, -10 },
  { 289, 7, 12, 9, 1, -10 },
  { 300, 6, 10, 7, 1, -10 },
  { 308, 5, 10, 7, 1, -10 },
  { 315, 6, 10, 6, 0, -10 },
  { 323, 7, 10, 9, 1, -10 },
  { 332, 7, 10, 7, 0, -10 },
  { 341, 11, 10, 11, 0, -10 },
  { 355, 6, 10, 6, 0, -10 },
  { 363, 6, 10, 6, 0, -10 },
  { 371, 6, 10, 7, 0, -10 },
  { 379, 3, 12, 4, 1, -10 },
  { 384, 4, 10, 5, 0, -10 },
  { 389, 3, 12, 4, 0, -10 },
  { 394, 7, 6, 7, 0, -10 },
  { 400, 6, 1, 5, 0, 1 },
  { 401, 2, 3, 3, 1, -11 },
  { 402, 4, 8, 6, 1, -8 },
  { 406, 6, 11, 7, 1, -11 },
  { 415, 4, 8, 6, 1, -8 },
  { 419, 5, 11, 7, 1, -11 },
  { 426, 5, 8, 7, 1, -8 },
  { 431, 4, 11, 4, 0, -11 },
  { 437, 5, 11, 7, 1, -8 },
  { 444, 5, 11, 7, 1, -11 },
  { 451, 1, 10, 3, 1, -10 },
  { 453, 2, 13, 3, 0, -10 },
  { 457, 5, 11, 6, 1, -11 },
  { 464, 1, 11, 3, 1, -11 },
  { 466, 9, 8, 11, 1, -8 },
  { 475, 5, 8, 7, 1, -8 },
  { 480, 5, 8, 7, 1, -8 },
  { 485, 6, 11, 7, 1, -8 },
  { 494, 5, 11, 7, 1, -8 },
  { 501, 3, 8, 5, 1, -8 },
  { 504, 4, 8, 6, 1, -8 },
  { 508, 4, 9, 4, 0, -9 },
  { 513, 5, 7, 7, 1, -7 },
  { 518, 5, 7, 5, 0, -7 },
  { 523, 9, 7, 9, 0, -7 },
  { 531, 6, 7, 6, 0, -7 },
  { 537, 5, 10, 5, 0, -7 },
  { 544, 4, 7, 5, 1, -7 },
  { 548, 4, 12, 5, 0, -10 },
  { 554, 1, 14, 7, 3, -11 },
  { 556, 3, 12, 5, 1, -10 },
  { 561, 5, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Thin14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_THIN14PT7B_H_
