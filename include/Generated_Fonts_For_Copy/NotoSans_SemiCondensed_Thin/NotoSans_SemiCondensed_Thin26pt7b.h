#ifndef _NOTOSANS_SEMICONDENSED_THIN26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x60, 0x99, 0x99, 0x99, 0x90, 0x04, 0x20, 0x21, 0x02,
  0x08, 0x10, 0x80, 0x84, 0x04, 0x23, 0xFF, 0xE1, 0x08, 0x10, 0x40, 0x84,
  0x04, 0x20, 0x21, 0x0F, 0xFF, 0x08, 0x40, 0x82, 0x04, 0x20, 0x21, 0x01,
  0x08, 0x08, 0x40, 0x04, 0x01, 0x03, 0xF9, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x44, 0x0D, 0x00, 0xC0, 0x1C, 0x04, 0x81, 0x10, 0x44, 0x11, 0x04,
  0x41, 0x1C, 0x58, 0xB0, 0x04, 0x01, 0x00, 0x38, 0x08, 0x44, 0x08, 0x44,
  0x10, 0x82, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x4C, 0x82,
  0x92, 0x44, 0xA1, 0x45, 0x21, 0x39, 0x21, 0x02, 0x21, 0x02, 0x21, 0x02,
  0x21, 0x04, 0x21, 0x04, 0x21, 0x08, 0x21, 0x08, 0x1E, 0x0E, 0x00, 0x44,
  0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x01, 0x10, 0x04, 0xC0, 0x0C,
  0x00, 0x70, 0x02, 0x20, 0x10, 0x42, 0x81, 0x0A, 0x02, 0x28, 0x05, 0x20,
  0x08, 0x40, 0x31, 0x01, 0x23, 0xF8, 0xC0, 0xFE, 0x08, 0x88, 0x44, 0x21,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x42, 0x08, 0x60, 0x82,
  0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x42,
  0x22, 0x00, 0x04, 0x01, 0x00, 0x43, 0x11, 0x3F, 0x81, 0x00, 0xA0, 0x48,
  0x21, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x55, 0xA0, 0xFC, 0xC0, 0x01,
  0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x0F, 0x06, 0x10, 0x81, 0x20, 0x24,
  0x04, 0x80, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x80, 0x50, 0x12, 0x02, 0x40, 0x44, 0x10, 0x7C, 0x00, 0x04, 0x72, 0x71,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40,
  0x1E, 0x18, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC,
  0x1E, 0x18, 0x68, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x07,
  0xC0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x2F, 0xF0,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x81, 0x08,
  0x10, 0x82, 0x08, 0x40, 0x84, 0x08, 0x80, 0x8F, 0xFF, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x90, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x4F, 0xE0, 0x0F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x30, 0xB3, 0x30, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x90, 0x23, 0xF0, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x00, 0x1F, 0x04, 0x11, 0x01,
  0x20, 0x24, 0x04, 0x80, 0x90, 0x11, 0x04, 0x1B, 0x01, 0xC0, 0xC6, 0x20,
  0x24, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x48, 0x08, 0xFE, 0x00, 0x1E,
  0x08, 0x64, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x12,
  0x1C, 0x79, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x47, 0xE0, 0xC0,
  0x0C, 0x50, 0x00, 0x01, 0x56, 0x80, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x79,
  0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x10, 0x41, 0x02, 0x04, 0x08,
  0x00, 0x00, 0x40, 0x80, 0x07, 0xFC, 0x02, 0x00, 0x81, 0x00, 0x10, 0x80,
  0x02, 0x40, 0x00, 0x90, 0x7E, 0x14, 0x20, 0x86, 0x08, 0x21, 0x84, 0x08,
  0x61, 0x02, 0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10, 0x60, 0x8A, 0x24,
  0x3C, 0x71, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x38,
  0x60, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x10, 0x01, 0x40, 0x0A, 0x00, 0x48,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x40, 0x82, 0x04, 0x10, 0x3F, 0xC2,
  0x02, 0x10, 0x11, 0x00, 0x48, 0x02, 0x40, 0x14, 0x00, 0x60, 0x02, 0xFE,
  0x10, 0x32, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x14, 0x02, 0x81, 0x9F,
  0xF2, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x1B,
  0xFC, 0x00, 0x07, 0xC3, 0x04, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x7F, 0x80, 0xFE, 0x08, 0x18, 0x80, 0x48, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x48, 0x08, 0xFF, 0x00, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xE0, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xF0, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x07, 0xE0, 0xC0, 0xC8, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x01, 0x40, 0x09, 0x80, 0x43,
  0xFC, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x5C, 0x80, 0x30, 0x0A, 0x02, 0x40,
  0x88, 0x21, 0x08, 0x22, 0x04, 0x40, 0x90, 0x15, 0x03, 0x20, 0x42, 0x08,
  0x21, 0x04, 0x20, 0x44, 0x04, 0x80, 0x90, 0x0A, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0xA0, 0x09, 0x90, 0x09, 0x90, 0x09,
  0x88, 0x11, 0x88, 0x11, 0x88, 0x11, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21,
  0x82, 0x41, 0x82, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x1C,
  0x01, 0xC0, 0x1A, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x81, 0x84, 0x18,
  0x21, 0x82, 0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x98, 0x05, 0x80, 0x38,
  0x03, 0x80, 0x10, 0x0F, 0x80, 0x41, 0x86, 0x01, 0x10, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x10, 0x80, 0x81, 0xFC,
  0x00, 0xFC, 0x20, 0xC8, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xA0, 0x6F, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x0F, 0x80, 0x41, 0x82, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x10, 0x80, 0x81, 0xFC, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0xF4, 0x10, 0x62, 0x02, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x23, 0xF8, 0x41, 0x08, 0x21,
  0x02, 0x20, 0x44, 0x04, 0x80, 0x90, 0x0A, 0x00, 0x80, 0x1F, 0x88, 0x14,
  0x01, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x2F, 0xF0, 0xFF, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x22, 0x02, 0x1F, 0xC0, 0x80, 0x0C, 0x00, 0x50, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x10, 0x80, 0x84, 0x04, 0x20, 0x40, 0x82, 0x04, 0x10, 0x21,
  0x00, 0x88, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x05, 0x00, 0x30, 0x00, 0x80,
  0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x28, 0x0A, 0x04,
  0x82, 0x40, 0x90, 0x48, 0x12, 0x09, 0x04, 0x41, 0x10, 0x84, 0x42, 0x10,
  0x88, 0x44, 0x11, 0x08, 0x82, 0x20, 0x90, 0x28, 0x12, 0x05, 0x02, 0x80,
  0xA0, 0x50, 0x14, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x00, 0x40, 0x28,
  0x04, 0x81, 0x10, 0x21, 0x08, 0x21, 0x02, 0x40, 0x50, 0x06, 0x00, 0x80,
  0x18, 0x04, 0x80, 0x90, 0x21, 0x08, 0x21, 0x02, 0x40, 0x48, 0x06, 0x00,
  0x80, 0x80, 0x30, 0x05, 0x01, 0x20, 0x22, 0x04, 0x41, 0x04, 0x20, 0x88,
  0x09, 0x01, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0xFF, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x03, 0xFF, 0x80, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x01, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04, 0x00, 0xC0, 0x28,
  0x04, 0x81, 0x10, 0x21, 0x08, 0x21, 0x02, 0x40, 0x48, 0x06, 0x00, 0x80,
  0xFF, 0xC0, 0x84, 0x21, 0x3E, 0x20, 0x80, 0x20, 0x10, 0x08, 0x04, 0x3E,
  0x61, 0x40, 0xC0, 0x60, 0x30, 0x18, 0x1B, 0xF4, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x09, 0xF2, 0x82, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x0A, 0xFC, 0x0F, 0x98, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00,
  0xFC, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x47, 0xC9, 0x05,
  0x40, 0x68, 0x0D, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40,
  0x68, 0x0C, 0x82, 0x8F, 0x90, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x40, 0x60,
  0x1F, 0xFE, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x07, 0xF0, 0x0F,
  0x10, 0x10, 0x20, 0x20, 0x20, 0xFC, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x1F, 0x48, 0x34, 0x05, 0x01,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x01, 0x20, 0xC7,
  0xD0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x09, 0xFC, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x79, 0x42, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0xC7, 0xFF, 0xE0, 0x11, 0x00,
  0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x05, 0x04, 0x84, 0x42, 0x22, 0x12,
  0x0B, 0x06, 0x42, 0x21, 0x08, 0x82, 0x41, 0x20, 0x50, 0x30, 0xFF, 0xFF,
  0xF0, 0xBE, 0x3C, 0xC1, 0x42, 0xC1, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x9E, 0x50, 0xB0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x1F, 0x04, 0x11,
  0x01, 0x20, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x00,
  0xA0, 0x22, 0x04, 0x3F, 0x00, 0x9F, 0x28, 0x2C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0xAF, 0xC8, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1F, 0x48, 0x34, 0x05, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x01, 0x20, 0xC7, 0xD0,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x9E, 0x8C, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x40,
  0x30, 0x0E, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFE, 0x20, 0x40, 0x87, 0xF2,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x1E, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x14, 0x1B, 0xF4, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40, 0x88, 0x42, 0x10,
  0x84, 0x12, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x81, 0x40,
  0x81, 0x41, 0x82, 0x41, 0x42, 0x41, 0x42, 0x22, 0x42, 0x22, 0x44, 0x22,
  0x24, 0x24, 0x24, 0x14, 0x24, 0x14, 0x18, 0x14, 0x18, 0x08, 0x18, 0x08,
  0x08, 0x80, 0xC0, 0x90, 0x44, 0x42, 0x40, 0xA0, 0x20, 0x10, 0x14, 0x11,
  0x08, 0x88, 0x28, 0x14, 0x04, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40, 0x88,
  0x42, 0x10, 0x84, 0x12, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x03, 0x80, 0x7F, 0x01, 0x02, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFF, 0x06, 0x30, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x86, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x40, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x30, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x38, 0x00, 0x7C, 0x30, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_Thin26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 19, 6, 2, -19 },
  { 4, 4, 7, 8, 2, -19 },
  { 8, 13, 19, 15, 1, -19 },
  { 39, 10, 22, 13, 1, -20 },
  { 67, 16, 19, 19, 1, -19 },
  { 105, 14, 19, 15, 1, -19 },
  { 139, 1, 7, 4, 2, -19 },
  { 140, 5, 23, 7, 1, -19 },
  { 155, 5, 23, 7, 1, -19 },
  { 170, 10, 9, 12, 1, -20 },
  { 182, 11, 12, 13, 1, -15 },
  { 199, 2, 6, 5, 1, -3 },
  { 201, 6, 1, 8, 1, -8 },
  { 202, 1, 2, 5, 2, -2 },
  { 203, 8, 19, 8, 0, -19 },
  { 222, 11, 19, 13, 1, -19 },
  { 249, 6, 19, 13, 2, -19 },
  { 264, 10, 19, 13, 1, -19 },
  { 288, 10, 19, 13, 1, -19 },
  { 312, 12, 19, 13, 1, -19 },
  { 341, 10, 19, 13, 2, -19 },
  { 365, 10, 19, 13, 2, -19 },
  { 389, 11, 19, 13, 1, -19 },
  { 416, 11, 19, 13, 1, -19 },
  { 443, 10, 19, 13, 1, -19 },
  { 467, 1, 14, 5, 2, -14 },
  { 469, 2, 17, 5, 1, -14 },
  { 474, 11, 11, 13, 1, -15 },
  { 490, 11, 6, 13, 1, -12 },
  { 499, 11, 11, 13, 1, -15 },
  { 515, 7, 19, 9, 1, -19 },
  { 532, 18, 21, 20, 1, -18 },
  { 580, 13, 19, 13, 0, -19 },
  { 611, 11, 19, 14, 2, -19 },
  { 638, 11, 19, 14, 2, -19 },
  { 665, 12, 19, 16, 2, -19 },
  { 694, 9, 19, 13, 2, -19 },
  { 716, 9, 19, 11, 2, -19 },
  { 738, 13, 19, 17, 2, -19 },
  { 769, 12, 19, 16, 2, -19 },
  { 798, 4, 19, 7, 1, -19 },
  { 808, 5, 24, 6, -2, -19 },
  { 823, 11, 19, 13, 2, -19 },
  { 850, 9, 19, 12, 2, -19 },
  { 872, 16, 19, 20, 2, -19 },
  { 910, 12, 19, 16, 2, -19 },
  { 939, 14, 19, 17, 2, -19 },
  { 973, 10, 19, 13, 2, -19 },
  { 997, 14, 23, 17, 2, -19 },
  { 1038, 11, 19, 13, 2, -19 },
  { 1065, 10, 19, 13, 1, -19 },
  { 1089, 11, 19, 12, 0, -19 },
  { 1116, 12, 19, 16, 2, -19 },
  { 1145, 13, 19, 13, 0, -19 },
  { 1176, 19, 19, 20, 1, -19 },
  { 1222, 11, 19, 12, 0, -19 },
  { 1249, 11, 19, 11, 0, -19 },
  { 1276, 11, 19, 13, 1, -19 },
  { 1303, 5, 23, 8, 2, -19 },
  { 1318, 8, 19, 8, 0, -19 },
  { 1337, 5, 23, 8, 1, -19 },
  { 1352, 11, 11, 13, 1, -19 },
  { 1368, 10, 1, 10, 0, 2 },
  { 1370, 4, 4, 6, 1, -20 },
  { 1372, 9, 14, 12, 1, -14 },
  { 1388, 10, 20, 14, 2, -20 },
  { 1413, 9, 14, 11, 1, -14 },
  { 1429, 11, 20, 14, 1, -20 },
  { 1457, 10, 14, 13, 1, -14 },
  { 1475, 8, 20, 7, 0, -20 },
  { 1495, 10, 20, 14, 1, -14 },
  { 1520, 9, 20, 13, 2, -20 },
  { 1543, 1, 19, 5, 2, -19 },
  { 1546, 4, 25, 5, -1, -19 },
  { 1559, 9, 20, 11, 2, -20 },
  { 1582, 1, 20, 5, 2, -20 },
  { 1585, 16, 14, 20, 2, -14 },
  { 1613, 9, 14, 13, 2, -14 },
  { 1629, 11, 14, 13, 1, -14 },
  { 1649, 10, 20, 14, 2, -14 },
  { 1674, 10, 20, 14, 1, -14 },
  { 1699, 6, 14, 9, 2, -14 },
  { 1710, 8, 14, 11, 1, -14 },
  { 1724, 7, 17, 7, 0, -17 },
  { 1739, 9, 14, 13, 2, -14 },
  { 1755, 10, 14, 10, 0, -14 },
  { 1773, 16, 14, 16, 0, -14 },
  { 1801, 9, 14, 11, 1, -14 },
  { 1817, 10, 20, 10, 0, -14 },
  { 1842, 8, 14, 10, 1, -14 },
  { 1856, 7, 23, 9, 1, -19 },
  { 1877, 1, 26, 12, 6, -20 },
  { 1881, 7, 23, 9, 1, -19 },
  { 1902, 11, 2, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Thin26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_THIN26PT7B_H_
