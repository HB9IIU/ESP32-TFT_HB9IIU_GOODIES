#ifndef _NOTOSANS_SEMICONDENSED_THIN10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xC0, 0x29, 0x54, 0xAF, 0xA9, 0x40, 0x56, 0x44, 0xDD, 0x40,
  0xD3, 0x4E, 0xBD, 0x25, 0x55, 0xC0, 0xE5, 0x29, 0x8A, 0xCB, 0xA0, 0xC0,
  0x5A, 0xA9, 0x40, 0x95, 0x55, 0x80, 0x4F, 0x50, 0x21, 0x3E, 0x42, 0x00,
  0xC0, 0xE0, 0x80, 0x25, 0x25, 0x20, 0xF6, 0xDB, 0x78, 0xD5, 0x54, 0xE4,
  0x95, 0x38, 0xF1, 0x17, 0x11, 0xF0, 0x11, 0x94, 0xA9, 0x3C, 0x40, 0xF3,
  0x12, 0x78, 0xE8, 0xE9, 0x99, 0xE0, 0xE4, 0x94, 0xA0, 0xF6, 0xFB, 0x78,
  0x79, 0x95, 0x31, 0x70, 0x08, 0x0C, 0x19, 0x30, 0x60, 0x80, 0xF8, 0x3E,
  0xC1, 0x06, 0xC8, 0x00, 0xE4, 0xA4, 0x10, 0x7A, 0x1B, 0xF3, 0xD7, 0xF8,
  0x1E, 0x22, 0x94, 0xAA, 0xC6, 0x20, 0xF9, 0x9E, 0x99, 0xF0, 0xF8, 0x88,
  0x88, 0xF0, 0xF4, 0x63, 0x18, 0xCB, 0x80, 0xF2, 0x79, 0x38, 0xF2, 0x79,
  0x20, 0xFC, 0x21, 0x78, 0xC5, 0xE0, 0x99, 0x9F, 0x99, 0x90, 0xFE, 0x55,
  0x55, 0xC0, 0x9A, 0xCC, 0xAA, 0x90, 0x92, 0x49, 0x38, 0x86, 0x18, 0xF3,
  0xD6, 0xDA, 0x40, 0x99, 0xDB, 0xB9, 0x90, 0xF4, 0x63, 0x18, 0xC7, 0xC0,
  0xF9, 0x9E, 0x88, 0x80, 0xF4, 0x63, 0x18, 0xC7, 0xC2, 0x10, 0xF9, 0x9E,
  0xAA, 0x90, 0xF2, 0x22, 0x78, 0xF2, 0x22, 0x22, 0x20, 0x99, 0x99, 0x99,
  0xF0, 0x8C, 0x64, 0xA5, 0x30, 0x80, 0x91, 0x91, 0x5A, 0x5A, 0x64, 0x24,
  0x24, 0x95, 0x62, 0x69, 0x90, 0x99, 0x62, 0x22, 0x20, 0x78, 0x88, 0x44,
  0x23, 0xE0, 0xEA, 0xAA, 0xC0, 0x91, 0x22, 0x48, 0xD5, 0x55, 0xC0, 0x22,
  0x95, 0x10, 0xF0, 0x90, 0x71, 0x79, 0xF0, 0x88, 0xE9, 0x99, 0x9E, 0xF2,
  0x4E, 0x25, 0xDB, 0x6F, 0xF7, 0x4E, 0x2B, 0x24, 0x92, 0xF6, 0xDE, 0x78,
  0x93, 0x5B, 0x6D, 0x3E, 0x3F, 0x80, 0x92, 0x5D, 0xB5, 0xFF, 0xFE, 0x9A,
  0x69, 0xA4, 0xF6, 0xDA, 0xF9, 0x99, 0xE0, 0xF9, 0x99, 0xE8, 0x80, 0xF6,
  0xDE, 0x48, 0xEA, 0x80, 0xF8, 0x61, 0xF0, 0x9E, 0x49, 0x18, 0xB6, 0xDE,
  0x99, 0x66, 0x40, 0x96, 0xDB, 0x52, 0x48, 0x96, 0x46, 0x90, 0x99, 0x66,
  0x44, 0xC0, 0x65, 0x2E, 0x69, 0x2C, 0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22,
  0x92, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Thin10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 1, 2, 3, 1, -7 },
  { 3, 5, 7, 6, 0, -7 },
  { 8, 3, 9, 5, 1, -8 },
  { 12, 6, 7, 7, 1, -7 },
  { 18, 5, 7, 6, 1, -7 },
  { 23, 1, 2, 2, 0, -7 },
  { 24, 2, 9, 3, 0, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 3, 4, 5, 1, -8 },
  { 32, 5, 5, 5, 0, -6 },
  { 36, 1, 2, 2, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 1, -1 },
  { 39, 3, 7, 3, 0, -7 },
  { 42, 3, 7, 5, 1, -7 },
  { 45, 2, 7, 5, 1, -7 },
  { 47, 3, 7, 5, 1, -7 },
  { 50, 4, 7, 5, 0, -7 },
  { 54, 5, 7, 5, 0, -7 },
  { 59, 3, 7, 5, 1, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 3, 7, 5, 1, -7 },
  { 69, 3, 7, 5, 1, -7 },
  { 72, 4, 7, 5, 0, -7 },
  { 76, 1, 5, 2, 1, -5 },
  { 77, 1, 6, 2, 0, -5 },
  { 78, 5, 5, 5, 0, -6 },
  { 82, 5, 3, 5, 0, -5 },
  { 84, 5, 5, 5, 0, -6 },
  { 88, 3, 7, 4, 0, -7 },
  { 91, 6, 8, 8, 1, -7 },
  { 97, 5, 7, 5, 0, -7 },
  { 102, 4, 7, 5, 1, -7 },
  { 106, 4, 7, 5, 1, -7 },
  { 110, 5, 7, 6, 1, -7 },
  { 115, 3, 7, 5, 1, -7 },
  { 118, 3, 7, 4, 1, -7 },
  { 121, 5, 7, 6, 1, -7 },
  { 126, 4, 7, 6, 1, -7 },
  { 130, 1, 7, 3, 1, -7 },
  { 131, 2, 9, 2, -1, -7 },
  { 134, 4, 7, 5, 1, -7 },
  { 138, 3, 7, 4, 1, -7 },
  { 141, 6, 7, 8, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 5, 7, 7, 1, -7 },
  { 156, 4, 7, 5, 1, -7 },
  { 160, 5, 9, 7, 1, -7 },
  { 166, 4, 7, 5, 1, -7 },
  { 170, 3, 7, 5, 1, -7 },
  { 173, 4, 7, 4, 0, -7 },
  { 177, 4, 7, 6, 1, -7 },
  { 181, 5, 7, 5, 0, -7 },
  { 186, 8, 7, 8, 0, -7 },
  { 193, 4, 7, 4, 0, -7 },
  { 197, 4, 7, 4, 0, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 2, 9, 3, 1, -7 },
  { 209, 3, 7, 3, 0, -7 },
  { 212, 2, 9, 3, 0, -7 },
  { 215, 5, 4, 5, 0, -7 },
  { 218, 4, 1, 4, 0, 1 },
  { 219, 2, 2, 2, 0, -8 },
  { 220, 4, 5, 5, 0, -5 },
  { 223, 4, 8, 5, 1, -8 },
  { 227, 3, 5, 4, 1, -5 },
  { 229, 3, 8, 5, 1, -8 },
  { 232, 3, 5, 5, 1, -5 },
  { 234, 3, 8, 3, 0, -8 },
  { 237, 3, 7, 5, 1, -5 },
  { 240, 3, 8, 5, 1, -8 },
  { 243, 1, 7, 2, 0, -7 },
  { 244, 1, 9, 2, 0, -7 },
  { 246, 3, 8, 4, 1, -8 },
  { 249, 1, 8, 2, 0, -8 },
  { 250, 6, 5, 8, 1, -5 },
  { 254, 3, 5, 5, 1, -5 },
  { 256, 4, 5, 5, 1, -5 },
  { 259, 4, 7, 5, 1, -5 },
  { 263, 3, 7, 5, 1, -5 },
  { 266, 2, 5, 3, 1, -5 },
  { 268, 4, 5, 4, 0, -5 },
  { 271, 3, 7, 3, 0, -7 },
  { 274, 3, 5, 5, 1, -5 },
  { 276, 4, 5, 4, 0, -5 },
  { 279, 6, 5, 6, 0, -5 },
  { 283, 4, 5, 4, 0, -5 },
  { 286, 4, 7, 4, 0, -5 },
  { 290, 3, 5, 4, 0, -5 },
  { 292, 3, 9, 3, 0, -7 },
  { 296, 1, 10, 5, 2, -8 },
  { 298, 3, 9, 3, 0, -7 },
  { 302, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Thin10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_THIN10PT7B_H_
