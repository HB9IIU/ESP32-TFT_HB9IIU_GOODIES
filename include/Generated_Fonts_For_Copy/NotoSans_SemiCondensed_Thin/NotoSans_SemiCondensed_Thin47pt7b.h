#ifndef _NOTOSANS_SEMICONDENSED_THIN47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0xF0, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0x00,
  0x20, 0x10, 0x00, 0x20, 0x10, 0x00, 0x60, 0x10, 0x00, 0x40, 0x10, 0x00,
  0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00,
  0xC0, 0x20, 0x00, 0x80, 0x20, 0x00, 0x80, 0x60, 0x3F, 0xFF, 0xFF, 0x00,
  0x80, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x00, 0x40, 0x01,
  0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x03,
  0x00, 0x80, 0x02, 0x00, 0x80, 0xFF, 0xFF, 0xFE, 0x02, 0x01, 0x00, 0x02,
  0x01, 0x00, 0x02, 0x01, 0x00, 0x06, 0x01, 0x00, 0x04, 0x01, 0x00, 0x04,
  0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C,
  0x02, 0x00, 0x08, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x0F, 0xF0, 0x0C, 0x47, 0x8C, 0x10, 0x22, 0x04, 0x01, 0x01, 0x00, 0x40,
  0x40, 0x30, 0x10, 0x0C, 0x04, 0x03, 0x01, 0x00, 0x40, 0x40, 0x10, 0x10,
  0x06, 0x04, 0x00, 0xC1, 0x00, 0x18, 0x40, 0x01, 0x90, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x5C, 0x00, 0x11, 0x80, 0x04, 0x10, 0x01, 0x02, 0x00,
  0x40, 0xC0, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10,
  0x10, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x41, 0x1C, 0x11, 0x83, 0xFF, 0xC0,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x04,
  0x03, 0x18, 0x00, 0xC0, 0x60, 0xC0, 0x08, 0x04, 0x04, 0x00, 0x80, 0x80,
  0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x20, 0x08, 0x02, 0x02,
  0x00, 0x80, 0x20, 0x60, 0x08, 0x02, 0x04, 0x00, 0x80, 0x20, 0xC0, 0x08,
  0x02, 0x08, 0x00, 0x80, 0x21, 0x80, 0x08, 0x02, 0x10, 0x60, 0x80, 0x63,
  0x1F, 0x88, 0x06, 0x23, 0x04, 0xC0, 0x46, 0x20, 0x64, 0x04, 0x46, 0x02,
  0x60, 0x8C, 0x40, 0x23, 0x18, 0x84, 0x03, 0x1F, 0x08, 0x40, 0x30, 0x01,
  0x04, 0x01, 0x00, 0x10, 0xC0, 0x10, 0x02, 0x0C, 0x01, 0x00, 0x20, 0xC0,
  0x10, 0x06, 0x0C, 0x01, 0x00, 0x40, 0x40, 0x10, 0x0C, 0x04, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x60, 0x20, 0x30, 0x02,
  0x06, 0x02, 0x00, 0x30, 0xC0, 0x60, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00, 0x80, 0x10, 0x00,
  0x40, 0x08, 0x00, 0x20, 0x04, 0x00, 0x10, 0x02, 0x00, 0x08, 0x01, 0x00,
  0x04, 0x00, 0x80, 0x03, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x62, 0x00,
  0x80, 0x23, 0x00, 0x20, 0x11, 0x00, 0x08, 0x08, 0x80, 0x06, 0x08, 0xC0,
  0x01, 0x84, 0x60, 0x00, 0x66, 0x30, 0x00, 0x12, 0x08, 0x00, 0x06, 0x04,
  0x00, 0x03, 0x02, 0x00, 0x03, 0xC0, 0x80, 0x03, 0x30, 0x60, 0x03, 0x08,
  0x18, 0x07, 0x02, 0x03, 0xFE, 0x00, 0xC0, 0xFF, 0xFF, 0xFD, 0x40, 0x01,
  0x03, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0,
  0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x04, 0x06, 0x03, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x20, 0x60, 0xC0, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x83, 0x78,
  0x9E, 0x06, 0xE0, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x04, 0x20, 0x08,
  0x10, 0x18, 0x18, 0x30, 0x0C, 0x10, 0x08, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x33, 0x22, 0x26, 0x44, 0x48, 0x80, 0xFF, 0xE0, 0xBC, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0x87, 0x01, 0x80, 0x60, 0xC0, 0x08, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00,
  0x19, 0x00, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02,
  0x60, 0x01, 0x08, 0x00, 0x43, 0x00, 0x30, 0x60, 0x18, 0x0C, 0x0C, 0x01,
  0xFE, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x1B, 0x18, 0xCC, 0x3E, 0x0D, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x03, 0xF0, 0x03,
  0xC3, 0x81, 0xC0, 0x08, 0x10, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x03, 0x81, 0xC1, 0xC0,
  0x0C, 0x60, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x24, 0x00, 0x08, 0xE0, 0x06,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x28, 0x00,
  0x01, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x04,
  0x20, 0x00, 0x30, 0x80, 0x01, 0x82, 0x00, 0x04, 0x08, 0x00, 0x30, 0x20,
  0x00, 0x80, 0x80, 0x04, 0x02, 0x00, 0x30, 0x08, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x02, 0x00, 0x80, 0x08, 0x04, 0x00, 0x20, 0x30, 0x00,
  0x80, 0x80, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0xFF, 0xFF, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0xFF, 0x01, 0xE0,
  0x70, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x32, 0x00,
  0x18, 0xE0, 0x0C, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xF0, 0x40, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x10, 0x08, 0x7F, 0xC2, 0x70, 0x08, 0xB0, 0x01, 0x28, 0x00, 0x2C, 0x00,
  0x0B, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x60, 0x00, 0xC8,
  0x00, 0x23, 0x00, 0x18, 0x40, 0x0C, 0x0C, 0x06, 0x01, 0xFF, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0,
  0x03, 0x07, 0x03, 0x00, 0x20, 0x80, 0x04, 0x40, 0x01, 0x90, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x18, 0x80,
  0x04, 0x30, 0x02, 0x06, 0x03, 0x00, 0x61, 0x80, 0x0F, 0x80, 0x01, 0xE0,
  0x01, 0x8E, 0x01, 0x80, 0xC0, 0xC0, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x28,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x18, 0x80, 0x0C, 0x18, 0x06,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xC1, 0x80, 0x60, 0x08, 0x18, 0x00,
  0x82, 0x00, 0x18, 0xC0, 0x01, 0x10, 0x00, 0x32, 0x00, 0x02, 0xC0, 0x00,
  0x58, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00,
  0xD0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0xA4, 0x00, 0x3C, 0x40, 0x0D,
  0x86, 0x06, 0x30, 0x7F, 0x84, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x07, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0B, 0xC0, 0x33, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x22, 0x66, 0x44,
  0x48, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC3,
  0xC1, 0xC4, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x06, 0x30, 0x01,
  0xF8, 0x02, 0x20, 0x07, 0x0E, 0x02, 0x20, 0x0C, 0x06, 0x03, 0x60, 0x18,
  0x06, 0x03, 0x40, 0x30, 0x04, 0x01, 0x40, 0x20, 0x04, 0x01, 0x40, 0x20,
  0x04, 0x01, 0x40, 0x60, 0x04, 0x01, 0x40, 0x40, 0x04, 0x01, 0xC0, 0x40,
  0x04, 0x01, 0xC0, 0x40, 0x04, 0x01, 0xC0, 0x40, 0x04, 0x01, 0x40, 0x40,
  0x04, 0x03, 0x40, 0x60, 0x0C, 0x02, 0x40, 0x20, 0x0C, 0x02, 0x40, 0x20,
  0x1E, 0x06, 0x40, 0x30, 0x32, 0x0C, 0x60, 0x1C, 0x63, 0x98, 0x20, 0x07,
  0x80, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x01, 0x01, 0x80, 0x01, 0x00, 0x80,
  0x01, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x04, 0x00, 0x20, 0x07, 0xFF, 0xE0, 0x0C, 0x00, 0x30,
  0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x10, 0x00, 0x18, 0x10, 0x00, 0x08,
  0x10, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x40, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x0D,
  0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0B,
  0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0xC6,
  0x00, 0xF0, 0xFF, 0xF8, 0x18, 0x00, 0xE3, 0x00, 0x06, 0x60, 0x00, 0x6C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xB0,
  0x00, 0x36, 0x00, 0x0C, 0xC0, 0x0E, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0x03, 0xC0, 0xC0, 0x02, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x18,
  0x07, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0C, 0x00, 0x70, 0x30,
  0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00,
  0x04, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00,
  0x01, 0x0C, 0x00, 0x08, 0x30, 0x00, 0xC0, 0xC0, 0x1E, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xE0, 0x1E, 0x03,
  0x80, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x10, 0x00, 0x01, 0x18, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x06, 0x00, 0x01, 0x01, 0xC0, 0x07, 0x00, 0x7F, 0xF8, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0x1C, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x83, 0x3F, 0x80, 0xC0, 0x00, 0x78, 0x00,
  0x1B, 0x00, 0x06, 0x60, 0x00, 0x8C, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x03,
  0x06, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x40,
  0x0C, 0x18, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0xDB, 0x00,
  0x1A, 0x30, 0x03, 0x82, 0x00, 0x60, 0x60, 0x0C, 0x04, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x18, 0x01, 0x83, 0x00, 0x10,
  0x60, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x02, 0x30, 0x00, 0x66, 0x00, 0x06,
  0xC0, 0x00, 0x58, 0x00, 0x0C, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x5E,
  0x00, 0x00, 0x05, 0xF0, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x0B, 0xD8, 0x00,
  0x00, 0xBC, 0x80, 0x00, 0x1B, 0xC8, 0x00, 0x01, 0x3C, 0xC0, 0x00, 0x33,
  0xC4, 0x00, 0x02, 0x3C, 0x40, 0x00, 0x23, 0xC6, 0x00, 0x06, 0x3C, 0x20,
  0x00, 0x43, 0xC2, 0x00, 0x04, 0x3C, 0x10, 0x00, 0xC3, 0xC1, 0x00, 0x08,
  0x3C, 0x18, 0x00, 0x83, 0xC0, 0x80, 0x10, 0x3C, 0x08, 0x01, 0x03, 0xC0,
  0xC0, 0x30, 0x3C, 0x04, 0x02, 0x03, 0xC0, 0x40, 0x20, 0x3C, 0x02, 0x06,
  0x03, 0xC0, 0x20, 0x40, 0x3C, 0x03, 0x04, 0x03, 0xC0, 0x10, 0xC0, 0x3C,
  0x01, 0x08, 0x03, 0xC0, 0x19, 0x80, 0x3C, 0x00, 0x90, 0x03, 0xC0, 0x09,
  0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1D, 0x00,
  0x00, 0xEC, 0x00, 0x07, 0x20, 0x00, 0x39, 0x80, 0x01, 0xC4, 0x00, 0x0E,
  0x30, 0x00, 0x70, 0xC0, 0x03, 0x82, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x40,
  0x07, 0x03, 0x00, 0x38, 0x08, 0x01, 0xC0, 0x20, 0x0E, 0x01, 0x80, 0x70,
  0x04, 0x03, 0x80, 0x30, 0x1C, 0x00, 0x80, 0xE0, 0x02, 0x07, 0x00, 0x18,
  0x38, 0x00, 0x41, 0xC0, 0x03, 0x0E, 0x00, 0x08, 0x70, 0x00, 0x23, 0x80,
  0x01, 0x9C, 0x00, 0x04, 0xE0, 0x00, 0x37, 0x00, 0x00, 0xB8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x70,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x01, 0x80, 0x00, 0x40, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x44, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x0C, 0x00, 0xE3,
  0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00,
  0x2C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x03, 0x8F, 0xFF, 0x83,
  0xFE, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xE0, 0x70, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x01, 0x80,
  0x00, 0x40, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x40,
  0x00, 0x01, 0x20, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x20, 0x80, 0x00, 0x20, 0x20, 0x00, 0x30, 0x08,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0x03, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01,
  0x30, 0x00, 0x26, 0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x4C, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x46, 0x00, 0x18,
  0xC0, 0x06, 0x18, 0x07, 0x03, 0xFF, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01,
  0x80, 0x20, 0x30, 0x06, 0x06, 0x00, 0x40, 0xC0, 0x0C, 0x18, 0x00, 0x83,
  0x00, 0x18, 0x60, 0x01, 0x0C, 0x00, 0x11, 0x80, 0x03, 0x30, 0x00, 0x26,
  0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0C, 0x01, 0xFE, 0x01, 0xE0, 0x78,
  0x60, 0x01, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0xE0,
  0x06, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x90, 0x00, 0x02, 0x40, 0x00, 0x19, 0x80, 0x00, 0x43, 0x00, 0x02, 0x06,
  0x00, 0x18, 0x0C, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x12, 0x00, 0x00, 0x26, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x18, 0x00, 0x04, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x20, 0x60, 0x00, 0x40, 0x40, 0x01, 0x80, 0x80, 0x02, 0x01, 0x00, 0x04,
  0x01, 0x00, 0x18, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x01, 0x80,
  0x08, 0x02, 0x00, 0x10, 0x04, 0x00, 0x30, 0x18, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x40, 0x00, 0xC1, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x03,
  0x18, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x0A,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x38, 0x00, 0x08, 0x00, 0x0D, 0x00, 0x03, 0x80, 0x01, 0xA0,
  0x00, 0x50, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x04, 0xC0, 0x01, 0x40, 0x01,
  0x88, 0x00, 0x6C, 0x00, 0x31, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x10,
  0x00, 0x86, 0x00, 0x22, 0x00, 0x30, 0x40, 0x0C, 0x60, 0x04, 0x08, 0x01,
  0x04, 0x00, 0x81, 0x00, 0x20, 0x80, 0x10, 0x30, 0x04, 0x10, 0x06, 0x02,
  0x01, 0x83, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x01, 0x80, 0x80, 0x80, 0xC0, 0x10, 0x30, 0x18, 0x10, 0x02, 0x04, 0x03,
  0x02, 0x00, 0x40, 0x80, 0x20, 0x40, 0x0C, 0x10, 0x04, 0x18, 0x00, 0x86,
  0x00, 0xC2, 0x00, 0x10, 0x80, 0x18, 0x40, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x62, 0x00, 0x23, 0x00, 0x04, 0xC0, 0x04, 0x40, 0x00, 0x90, 0x00, 0xC8,
  0x00, 0x12, 0x00, 0x09, 0x00, 0x03, 0x40, 0x01, 0x60, 0x00, 0x38, 0x00,
  0x28, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x11, 0x00, 0x01, 0x8C, 0x00, 0x08, 0x20,
  0x00, 0xC1, 0x80, 0x04, 0x04, 0x00, 0x40, 0x30, 0x02, 0x00, 0x80, 0x20,
  0x02, 0x03, 0x00, 0x10, 0x10, 0x00, 0x41, 0x80, 0x03, 0x08, 0x00, 0x08,
  0xC0, 0x00, 0x64, 0x00, 0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00, 0x82,
  0x00, 0x04, 0x18, 0x00, 0x40, 0x40, 0x06, 0x03, 0x00, 0x20, 0x08, 0x03,
  0x00, 0x60, 0x10, 0x01, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x20, 0x80, 0x01,
  0x8C, 0x00, 0x04, 0x40, 0x00, 0x16, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0x40, 0x00, 0x26, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x04,
  0x10, 0x00, 0xC1, 0x80, 0x08, 0x08, 0x01, 0x80, 0xC0, 0x10, 0x04, 0x03,
  0x00, 0x40, 0x20, 0x02, 0x02, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x80, 0x00, 0x88, 0x00, 0x09, 0x80, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x01, 0x88, 0x00, 0x10,
  0x80, 0x03, 0x0C, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0x40, 0x20, 0x0C,
  0x03, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81, 0x00, 0x08, 0x30, 0x00, 0xC2,
  0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x30, 0xFF, 0xFF,
  0xC0, 0xC0, 0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x07, 0xF0, 0x38, 0x0C,
  0x20, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x0F, 0x81, 0x18, 0x01,
  0x20, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x07, 0xC0, 0x05, 0x40, 0x09, 0x30, 0x19, 0x1F, 0xE1, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x1F,
  0xE0, 0x8C, 0x0E, 0x24, 0x00, 0xCA, 0x00, 0x12, 0x80, 0x06, 0xC0, 0x00,
  0xB0, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06, 0xA0, 0x01,
  0x2C, 0x00, 0x89, 0x80, 0xC2, 0x1F, 0xE0, 0x03, 0xFE, 0x1C, 0x04, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0E, 0x01, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x1F, 0xE1, 0x0C, 0x0C, 0x44,
  0x00, 0x92, 0x00, 0x35, 0x80, 0x05, 0x40, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0D, 0x00, 0x05, 0x60, 0x01, 0x4C, 0x00, 0x91, 0x80,
  0xC4, 0x3F, 0xE1, 0x07, 0xF0, 0x06, 0x06, 0x04, 0x01, 0x84, 0x00, 0x46,
  0x00, 0x12, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x18,
  0x41, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x01, 0xFF, 0x80, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x47, 0x03,
  0x13, 0x00, 0x24, 0x80, 0x05, 0x60, 0x01, 0xD0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x01, 0x58, 0x00, 0xD3, 0x00, 0x2C,
  0x60, 0x33, 0x0F, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x20, 0x00,
  0xC7, 0x00, 0xE0, 0x7F, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x87, 0xF8, 0x8C, 0x0C, 0x90, 0x06, 0xA0, 0x03, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x7D, 0x80, 0x00, 0x09, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x03, 0x07, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x04, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x28, 0x00, 0x90, 0x02, 0x20, 0x0C, 0x40, 0x30, 0x80, 0x41, 0x01,
  0x02, 0x04, 0x04, 0x18, 0x08, 0x60, 0x10, 0x80, 0x23, 0x80, 0x49, 0x00,
  0xB1, 0x01, 0xC3, 0x03, 0x02, 0x04, 0x06, 0x08, 0x06, 0x10, 0x04, 0x20,
  0x0C, 0x40, 0x08, 0x80, 0x09, 0x00, 0x1A, 0x00, 0x14, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x87, 0xE0, 0x3F, 0x89, 0x81, 0x86, 0x0C, 0xB0,
  0x08, 0x80, 0x6A, 0x00, 0x50, 0x02, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x87, 0xF8, 0x8C, 0x0C,
  0x90, 0x06, 0xA0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x07, 0xF8,
  0x03, 0x03, 0x81, 0x00, 0x30, 0x80, 0x04, 0x60, 0x00, 0x90, 0x00, 0x2C,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x43,
  0x00, 0x30, 0x60, 0x18, 0x07, 0xF8, 0x00, 0x83, 0xF8, 0x23, 0x03, 0x89,
  0x80, 0x32, 0xC0, 0x04, 0xA0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0B, 0x00, 0x02, 0xE0, 0x01, 0xA8, 0x00, 0x49, 0x00, 0x22, 0x70,
  0x38, 0x87, 0xF8, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xFC, 0x21, 0xC0, 0xC4, 0x60, 0x04, 0x88,
  0x00, 0xD3, 0x00, 0x0A, 0x40, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x03, 0x40,
  0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00,
  0x01, 0xB0, 0x00, 0x52, 0x00, 0x0E, 0x60, 0x03, 0xC6, 0x00, 0xD8, 0x60,
  0x33, 0x07, 0xFC, 0x60, 0x08, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x87, 0xF3, 0x82, 0x40, 0x50, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x00, 0x0F, 0xF8, 0x70, 0x1D, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x60, 0x0C, 0x7F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x3F, 0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x01, 0xF8, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x05, 0x60, 0x09, 0x30, 0x19, 0x1F,
  0xE1, 0x80, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x09, 0x00, 0x06, 0x20, 0x01,
  0x08, 0x00, 0x42, 0x00, 0x30, 0x40, 0x08, 0x10, 0x02, 0x04, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x03, 0x02, 0x00, 0x40, 0x80, 0x10,
  0x60, 0x06, 0x10, 0x00, 0x84, 0x00, 0x23, 0x00, 0x0C, 0x80, 0x01, 0x20,
  0x00, 0x58, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x38, 0x00, 0x60, 0x02, 0xC0, 0x06, 0x00, 0x24, 0x00, 0xE0, 0x02,
  0x40, 0x09, 0x00, 0x64, 0x00, 0x90, 0x04, 0x60, 0x09, 0x00, 0x42, 0x01,
  0x18, 0x04, 0x20, 0x10, 0x80, 0xC2, 0x01, 0x08, 0x08, 0x30, 0x30, 0x80,
  0x81, 0x02, 0x0C, 0x08, 0x10, 0x20, 0x41, 0x81, 0x06, 0x04, 0x10, 0x18,
  0x40, 0x61, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x23, 0x00, 0x8C, 0x02,
  0x20, 0x04, 0x80, 0x32, 0x00, 0x48, 0x01, 0x20, 0x05, 0x80, 0x16, 0x00,
  0x50, 0x01, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0x88, 0x00, 0xC2, 0x00, 0x41, 0x80,
  0x40, 0x40, 0x60, 0x30, 0x20, 0x08, 0x30, 0x02, 0x30, 0x01, 0x90, 0x00,
  0x58, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x04, 0x80, 0x04, 0x60,
  0x06, 0x10, 0x02, 0x0C, 0x03, 0x02, 0x03, 0x00, 0x81, 0x00, 0x61, 0x80,
  0x10, 0x80, 0x0C, 0x80, 0x03, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x50, 0x00,
  0x34, 0x00, 0x09, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x43, 0x00, 0x10,
  0x40, 0x0C, 0x10, 0x02, 0x06, 0x00, 0x80, 0x80, 0x60, 0x20, 0x10, 0x0C,
  0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x08, 0x20, 0x02, 0x18, 0x00, 0x84,
  0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x28, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00, 0xFF,
  0xFC, 0x00, 0x10, 0x1F, 0x03, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0xF0, 0x0F, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xF0, 0x0F, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0xFC, 0x01, 0xC0, 0x70, 0x28, 0x01, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Thin47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 34, 10, 4, -34 },
  { 10, 8, 13, 15, 3, -34 },
  { 23, 24, 34, 27, 1, -34 },
  { 125, 18, 39, 24, 2, -36 },
  { 213, 28, 34, 33, 3, -34 },
  { 332, 25, 34, 28, 2, -34 },
  { 439, 2, 13, 8, 3, -34 },
  { 443, 8, 41, 12, 2, -34 },
  { 484, 8, 41, 12, 2, -34 },
  { 525, 16, 17, 22, 3, -36 },
  { 559, 20, 21, 24, 2, -27 },
  { 612, 4, 11, 8, 2, -5 },
  { 618, 11, 1, 14, 2, -13 },
  { 620, 2, 3, 10, 4, -3 },
  { 621, 14, 34, 15, 1, -34 },
  { 681, 18, 34, 24, 3, -34 },
  { 758, 10, 34, 24, 4, -34 },
  { 801, 19, 34, 24, 2, -34 },
  { 882, 19, 34, 24, 2, -34 },
  { 963, 22, 34, 24, 1, -34 },
  { 1057, 18, 34, 24, 3, -34 },
  { 1134, 18, 35, 24, 3, -34 },
  { 1213, 19, 34, 24, 2, -34 },
  { 1294, 18, 34, 24, 3, -34 },
  { 1371, 19, 35, 24, 2, -34 },
  { 1455, 2, 25, 10, 4, -25 },
  { 1462, 4, 31, 10, 2, -25 },
  { 1478, 20, 20, 24, 2, -27 },
  { 1528, 20, 11, 24, 2, -22 },
  { 1556, 20, 20, 24, 2, -27 },
  { 1606, 14, 34, 17, 1, -34 },
  { 1666, 32, 38, 37, 2, -33 },
  { 1818, 24, 34, 24, 0, -34 },
  { 1920, 19, 34, 26, 4, -34 },
  { 2001, 21, 34, 25, 3, -34 },
  { 2091, 22, 34, 29, 4, -34 },
  { 2185, 16, 34, 23, 4, -34 },
  { 2253, 16, 34, 21, 4, -34 },
  { 2321, 24, 34, 30, 3, -34 },
  { 2423, 21, 34, 29, 4, -34 },
  { 2513, 8, 34, 12, 2, -34 },
  { 2547, 10, 42, 10, -4, -34 },
  { 2600, 19, 34, 23, 4, -34 },
  { 2681, 16, 34, 21, 4, -34 },
  { 2749, 28, 34, 36, 4, -34 },
  { 2868, 21, 34, 29, 4, -34 },
  { 2958, 25, 34, 31, 3, -34 },
  { 3065, 18, 34, 24, 4, -34 },
  { 3142, 25, 42, 31, 3, -34 },
  { 3274, 19, 34, 24, 4, -34 },
  { 3355, 19, 34, 23, 2, -34 },
  { 3436, 21, 34, 21, 0, -34 },
  { 3526, 22, 34, 30, 4, -34 },
  { 3620, 23, 34, 23, 0, -34 },
  { 3718, 35, 34, 37, 1, -34 },
  { 3867, 21, 34, 21, 0, -34 },
  { 3957, 20, 34, 20, 0, -34 },
  { 4042, 19, 34, 23, 2, -34 },
  { 4123, 9, 41, 15, 4, -34 },
  { 4170, 14, 34, 15, 1, -34 },
  { 4230, 10, 41, 15, 1, -34 },
  { 4282, 20, 19, 24, 2, -34 },
  { 4330, 18, 1, 18, 0, 4 },
  { 4333, 7, 8, 11, 2, -36 },
  { 4340, 16, 25, 22, 2, -25 },
  { 4390, 18, 36, 25, 4, -36 },
  { 4471, 15, 25, 19, 3, -25 },
  { 4518, 18, 36, 25, 3, -36 },
  { 4599, 17, 25, 23, 3, -25 },
  { 4653, 13, 36, 12, 1, -36 },
  { 4712, 18, 36, 25, 3, -25 },
  { 4793, 16, 36, 24, 4, -36 },
  { 4865, 3, 34, 9, 3, -34 },
  { 4878, 8, 45, 9, -2, -34 },
  { 4923, 15, 36, 19, 4, -36 },
  { 4991, 1, 36, 9, 4, -36 },
  { 4996, 28, 25, 36, 4, -25 },
  { 5084, 16, 25, 24, 4, -25 },
  { 5134, 18, 25, 24, 3, -25 },
  { 5191, 18, 36, 25, 4, -25 },
  { 5272, 19, 36, 25, 2, -25 },
  { 5358, 11, 25, 16, 4, -25 },
  { 5393, 15, 25, 19, 2, -25 },
  { 5440, 11, 31, 13, 1, -31 },
  { 5483, 16, 25, 24, 4, -25 },
  { 5533, 18, 25, 18, 0, -25 },
  { 5590, 28, 25, 29, 1, -25 },
  { 5678, 17, 25, 20, 1, -25 },
  { 5732, 18, 36, 18, 0, -25 },
  { 5813, 14, 25, 18, 2, -25 },
  { 5857, 12, 41, 16, 2, -34 },
  { 5919, 1, 48, 22, 11, -36 },
  { 5925, 12, 41, 16, 2, -34 },
  { 5987, 20, 4, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Thin47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_THIN47PT7B_H_
