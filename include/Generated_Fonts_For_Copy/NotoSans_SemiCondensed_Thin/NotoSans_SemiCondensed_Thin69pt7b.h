#ifndef _NOTOSANS_SEMICONDENSED_THIN69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin69pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD9, 0x24,
  0x92, 0x49, 0x24, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0,
  0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0x00,
  0x02, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x20, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x10,
  0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x60, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x01, 0xE2, 0x1F, 0xC1, 0xC0, 0x80, 0xE0, 0xE0, 0x20, 0x08,
  0x70, 0x08, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x20,
  0x00, 0xC0, 0x08, 0x00, 0x30, 0x02, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00,
  0x20, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x03,
  0x80, 0x20, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x38, 0x20, 0x00, 0x07, 0x88, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0B, 0xC0, 0x00, 0x02, 0x3C, 0x00,
  0x00, 0x83, 0x80, 0x00, 0x20, 0x70, 0x00, 0x08, 0x06, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x80, 0x18, 0x00, 0x20, 0x06, 0x00, 0x08, 0x00, 0x80, 0x02,
  0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x08, 0x00, 0xC0,
  0x02, 0x00, 0x20, 0x00, 0x80, 0x18, 0x00, 0x20, 0x06, 0x00, 0x08, 0x01,
  0x80, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x62, 0x00, 0x20, 0x70, 0xF8, 0x08,
  0x78, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x07, 0x07,
  0x00, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x20, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x30, 0x3F, 0x06,
  0x00, 0x18, 0x30, 0x79, 0xE3, 0x00, 0x0C, 0x18, 0x30, 0x38, 0x80, 0x06,
  0x08, 0x30, 0x0C, 0x60, 0x02, 0x0C, 0x30, 0x03, 0x30, 0x03, 0x04, 0x18,
  0x01, 0x8C, 0x01, 0x86, 0x08, 0x00, 0x46, 0x01, 0x83, 0x0C, 0x00, 0x31,
  0xC1, 0x83, 0x06, 0x00, 0x18, 0x7F, 0x81, 0x83, 0x00, 0x0C, 0x1F, 0x81,
  0x81, 0x80, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x80, 0x00, 0x60, 0x20, 0x00, 0x40, 0x00, 0x60, 0x10, 0x00, 0x20,
  0x00, 0x30, 0x08, 0x00, 0x10, 0x00, 0x30, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x00, 0x0E, 0x1C, 0x00,
  0x60, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x01, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x0C, 0x60, 0x01, 0x80, 0x01, 0x1C, 0x00, 0x18,
  0x00, 0x63, 0x00, 0x03, 0x80, 0x0C, 0xC0, 0x00, 0x38, 0x01, 0x98, 0x00,
  0x03, 0x00, 0x63, 0x00, 0x00, 0x30, 0x0C, 0x60, 0x00, 0x03, 0x01, 0x88,
  0x00, 0x00, 0x30, 0x61, 0x00, 0x00, 0x03, 0x0C, 0x20, 0x00, 0x00, 0x73,
  0x04, 0x00, 0x00, 0x06, 0x60, 0xC0, 0x00, 0x00, 0x78, 0x18, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x00, 0x7E, 0x06, 0x00,
  0x00, 0x1C, 0xC0, 0x60, 0x00, 0x07, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0xC0,
  0xE0, 0x00, 0xE0, 0x0C, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x7F, 0xFC, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0xE0, 0x08, 0x03, 0x7C, 0x04, 0x0F, 0xC3, 0xC2, 0x3E, 0x00, 0x3D, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x60, 0x08,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x18, 0xC6,
  0x31, 0x8C, 0xC6, 0x31, 0x98, 0xC6, 0x23, 0x18, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x6F, 0xF7, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x32, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x3B, 0x03, 0x8C, 0x1C, 0x30, 0xE0, 0xCE,
  0x03, 0x70, 0x0F, 0x80, 0x34, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x70, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x20, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0xF0, 0x7E, 0x00, 0x78, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x7F, 0xFE, 0x00, 0x7F, 0xC3, 0xF0, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xF0, 0x02, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x03, 0xFE, 0x00, 0x83, 0xFF, 0xF0, 0x30, 0xE0, 0x03, 0x86, 0x30,
  0x00, 0x38, 0xCC, 0x00, 0x03, 0x1B, 0x00, 0x00, 0x33, 0x40, 0x00, 0x03,
  0x78, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x01,
  0xE0, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1C, 0x3C, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x0A, 0x30, 0x00, 0x01, 0xA1, 0x80, 0x00, 0x32, 0x1C, 0x00, 0x07, 0x20,
  0xE0, 0x00, 0xE6, 0x07, 0x80, 0x38, 0x60, 0x1F, 0xFF, 0x06, 0x00, 0x7F,
  0x80, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x18, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x67, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x70, 0x18, 0x71, 0xC7, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3,
  0x18, 0x61, 0x84, 0x30, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0xF0,
  0x07, 0x84, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0x8C, 0x00, 0x07, 0xFF, 0xC0, 0x06, 0x70, 0x00, 0x78, 0x03, 0x00,
  0x19, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x66, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xD8, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xF0,
  0x01, 0x80, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xF0, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xF0, 0x03, 0x00,
  0x01, 0x80, 0x03, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x1B, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x6C, 0x00, 0x60, 0x00, 0xF0, 0x01, 0xB0, 0x01, 0x80, 0x02,
  0xC0, 0x0C, 0xC0, 0x03, 0x00, 0x1B, 0x00, 0x33, 0x00, 0x0C, 0x00, 0x44,
  0x01, 0x86, 0x00, 0x18, 0x07, 0x18, 0x0E, 0x18, 0x00, 0x38, 0x78, 0x38,
  0xF0, 0x60, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xE0, 0x0C,
  0x00, 0x7F, 0xC0, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x03,
  0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x3E, 0x0C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x1F,
  0xF8, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x06, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xFC, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC8,
  0x0E, 0x3F, 0xF0, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC3, 0x60,
  0x00, 0x0C, 0x67, 0x00, 0x00, 0xCC, 0x30, 0x00, 0x0D, 0x81, 0x80, 0x00,
  0xF8, 0x1C, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFB, 0x00, 0x00,
  0x00, 0x01, 0xBD, 0x80, 0x00, 0x00, 0x00, 0xDE, 0xC0, 0x00, 0x00, 0x00,
  0x6F, 0x30, 0x00, 0x00, 0x00, 0x67, 0x98, 0x00, 0x00, 0x00, 0x33, 0xC6,
  0x00, 0x00, 0x00, 0x19, 0xE3, 0x00, 0x00, 0x00, 0x18, 0xF1, 0x80, 0x00,
  0x00, 0x0C, 0x78, 0x60, 0x00, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0x00, 0x06,
  0x1E, 0x18, 0x00, 0x00, 0x03, 0x0F, 0x06, 0x00, 0x00, 0x03, 0x07, 0x83,
  0x00, 0x00, 0x01, 0x83, 0xC0, 0x80, 0x00, 0x00, 0xC1, 0xE0, 0x60, 0x00,
  0x00, 0xC0, 0xF0, 0x30, 0x00, 0x00, 0x60, 0x78, 0x0C, 0x00, 0x00, 0x60,
  0x3C, 0x06, 0x00, 0x00, 0x30, 0x1E, 0x03, 0x00, 0x00, 0x18, 0x0F, 0x00,
  0xC0, 0x00, 0x18, 0x07, 0x80, 0x60, 0x00, 0x0C, 0x03, 0xC0, 0x30, 0x00,
  0x06, 0x01, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xF0, 0x06, 0x00, 0x03, 0x00,
  0x78, 0x01, 0x80, 0x01, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0x80, 0x1E, 0x00,
  0x60, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xE0, 0x01, 0x80, 0x30, 0x00,
  0xF0, 0x00, 0xC0, 0x18, 0x00, 0x78, 0x00, 0x30, 0x08, 0x00, 0x3C, 0x00,
  0x18, 0x0C, 0x00, 0x1E, 0x00, 0x0C, 0x06, 0x00, 0x0F, 0x00, 0x03, 0x06,
  0x00, 0x07, 0x80, 0x01, 0x83, 0x00, 0x03, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0xE0, 0x00, 0x31, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xC0, 0x00, 0x78, 0x00,
  0x04, 0x60, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x01, 0xB0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3D, 0x80, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x01, 0xE3, 0x00, 0x00,
  0x03, 0xC6, 0x00, 0x00, 0x07, 0x86, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x1E, 0x0C, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x78, 0x18, 0x00, 0x00,
  0xF0, 0x18, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xE0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x03, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x78, 0x00,
  0x06, 0x00, 0xF0, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0x0C, 0x03, 0xC0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x18, 0x1E, 0x00, 0x00,
  0x30, 0x3C, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x00,
  0x61, 0xE0, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x00,
  0xCF, 0x00, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x07,
  0xFC, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x3C, 0x30, 0x00, 0x3C, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x80, 0x0C, 0x03, 0xFF,
  0x00, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x78, 0x00, 0xF8, 0x38, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xF0, 0xFC, 0x01,
  0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x61, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x62, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x20, 0x18, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x00,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x30, 0x18,
  0x00, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x7C, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC,
  0x07, 0xF0, 0x18, 0x3C, 0x00, 0x31, 0xC0, 0x00, 0x67, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x02, 0xF0, 0x00, 0x0D, 0x60, 0x00, 0x32, 0xE0, 0x00, 0xC4, 0xE0, 0x03,
  0x88, 0xF0, 0x1C, 0x10, 0x7F, 0xF0, 0x20, 0x3E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x03, 0xFE, 0x00, 0x81, 0xFF, 0xF0, 0x10, 0xF0, 0x07, 0x02, 0x38,
  0x00, 0x30, 0x4E, 0x00, 0x03, 0x09, 0x80, 0x00, 0x31, 0x60, 0x00, 0x06,
  0x2C, 0x00, 0x00, 0x65, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x19, 0x40, 0x00, 0x06, 0x2C, 0x00, 0x00,
  0xC4, 0xC0, 0x00, 0x30, 0x9C, 0x00, 0x0C, 0x11, 0xC0, 0x07, 0x02, 0x1E,
  0x03, 0xC0, 0x40, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xFC, 0x07, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x08, 0x1F, 0x00, 0xF0, 0x0F, 0xFF, 0xC0, 0x01, 0xE8, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x03, 0xFE, 0x03, 0x01, 0xFF, 0xF0, 0x60, 0x70, 0x07, 0x0C,
  0x18, 0x00, 0x31, 0x86, 0x00, 0x03, 0x31, 0x80, 0x00, 0x36, 0x60, 0x00,
  0x06, 0xCC, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x02, 0xCC, 0x00,
  0x00, 0xD8, 0xC0, 0x00, 0x33, 0x1C, 0x00, 0x06, 0x61, 0xC0, 0x03, 0x8C,
  0x0F, 0x01, 0xE1, 0x80, 0xFF, 0xF0, 0x30, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x08, 0x60, 0x00, 0x06, 0x20,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x41, 0xC0, 0x00, 0xC0,
  0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0x00, 0xE0, 0x10, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFC, 0x10, 0x38, 0x01, 0xC4, 0x38, 0x00, 0x31, 0x0C,
  0x00, 0x06, 0x46, 0x00, 0x00, 0xD3, 0x00, 0x00, 0x14, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x14, 0xC0, 0x00, 0x0D, 0x18, 0x00, 0x06, 0x43, 0x00, 0x03,
  0x10, 0xE0, 0x01, 0xC4, 0x0F, 0x01, 0xC1, 0x01, 0xFF, 0xE0, 0x40, 0x0F,
  0xC0, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC0, 0xFC, 0x03, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x7F, 0x80, 0xC1, 0xFF, 0xE0, 0xC7, 0x80, 0x78,
  0xCE, 0x00, 0x1C, 0xD8, 0x00, 0x0C, 0x98, 0x00, 0x06, 0xB0, 0x00, 0x06,
  0xA0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x6F, 0xFE, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0xC0, 0x3C, 0x07, 0x80,
  0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x1C, 0x87,
  0x1F, 0xC0, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x02,
  0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0,
  0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x80, 0xC0, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC6, 0xC0, 0x03, 0x31,
  0x80, 0x0C, 0xC6, 0x00, 0x26, 0x0C, 0x00, 0xB0, 0x38, 0x03, 0x80, 0x60,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x41, 0xFF, 0xC0,
  0x3F, 0xFC, 0x21, 0xC0, 0x30, 0x38, 0x07, 0x11, 0x80, 0x0C, 0x38, 0x00,
  0xC9, 0x80, 0x03, 0x38, 0x00, 0x35, 0x80, 0x01, 0x98, 0x00, 0x1A, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x78, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x20, 0x00, 0x07, 0x80, 0x00, 0x10,
  0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x20,
  0x00, 0x07, 0x80, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x78, 0x00,
  0x01, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x40,
  0x00, 0x0F, 0x00, 0x00, 0x20, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00, 0x03,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x7F, 0x80, 0x81, 0xFF, 0xE0, 0x87, 0x80, 0x78, 0x8E,
  0x00, 0x1C, 0x98, 0x00, 0x0C, 0x90, 0x00, 0x06, 0xB0, 0x00, 0x06, 0xA0,
  0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x38, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x10, 0x3F, 0xFE,
  0x02, 0x0E, 0x00, 0xE0, 0x43, 0x00, 0x06, 0x08, 0xC0, 0x00, 0x61, 0x30,
  0x00, 0x06, 0x24, 0x00, 0x00, 0xC5, 0x80, 0x00, 0x0C, 0xA0, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x13, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x19, 0x40, 0x00, 0x03, 0x2C,
  0x00, 0x00, 0xC6, 0x80, 0x00, 0x18, 0xD8, 0x00, 0x06, 0x19, 0x80, 0x01,
  0x83, 0x1C, 0x00, 0x60, 0x61, 0xE0, 0x78, 0x0C, 0x1F, 0xFE, 0x01, 0x80,
  0x3C, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x10,
  0x38, 0x03, 0x84, 0x38, 0x00, 0x31, 0x0C, 0x00, 0x06, 0x46, 0x00, 0x00,
  0xD3, 0x00, 0x00, 0x34, 0xC0, 0x00, 0x05, 0x60, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x53, 0x00, 0x00, 0x34, 0xC0, 0x00,
  0x0D, 0x18, 0x00, 0x06, 0x47, 0x00, 0x03, 0x10, 0xE0, 0x01, 0x84, 0x1E,
  0x03, 0xC1, 0x01, 0xFF, 0xE0, 0x40, 0x0F, 0x80, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFE,
  0x83, 0xFF, 0x87, 0x00, 0x8C, 0x00, 0x98, 0x00, 0x90, 0x00, 0xB0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xE1, 0xE0, 0x03, 0x8E, 0x00, 0x02, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1A, 0x00, 0x00, 0xCC, 0x00, 0x07,
  0x3F, 0x00, 0xF8, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x0F, 0xF8, 0x01, 0xE0, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE8,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x2D, 0x80, 0x00, 0x36,
  0x60, 0x00, 0x33, 0x38, 0x00, 0x39, 0x8E, 0x00, 0x38, 0xC3, 0xC0, 0x70,
  0x60, 0xFF, 0xF0, 0x30, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x08, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x02, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x98, 0x00, 0x07, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xC0, 0x00,
  0x66, 0x00, 0x01, 0x60, 0x00, 0x31, 0x00, 0x01, 0x90, 0x00, 0x10, 0xC0,
  0x00, 0xCC, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x08, 0x00, 0x30, 0xC0, 0x02, 0x06, 0x00, 0x18, 0x60, 0x03,
  0x03, 0x00, 0x08, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0x40,
  0x06, 0x06, 0x00, 0x40, 0x30, 0x03, 0x03, 0x00, 0x60, 0x18, 0x03, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x08,
  0x01, 0x80, 0x40, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x04, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x02, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00,
  0x64, 0x00, 0x03, 0x60, 0x00, 0x12, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00,
  0x00, 0x50, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x98, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x18, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x20, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x22, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x09, 0xE1, 0xE0, 0x00, 0x58, 0x01, 0xC0, 0x0F, 0x80, 0x07,
  0xC1, 0xE8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 49, 15, 6, -49 },
  { 20, 12, 18, 21, 5, -49 },
  { 47, 35, 49, 39, 2, -49 },
  { 262, 26, 56, 35, 4, -52 },
  { 444, 41, 51, 49, 4, -50 },
  { 706, 35, 51, 40, 4, -50 },
  { 930, 2, 18, 12, 5, -49 },
  { 935, 12, 60, 18, 3, -49 },
  { 1025, 12, 60, 18, 3, -49 },
  { 1115, 25, 24, 33, 4, -52 },
  { 1190, 29, 32, 35, 3, -40 },
  { 1306, 5, 17, 12, 3, -8 },
  { 1317, 16, 2, 21, 2, -20 },
  { 1321, 4, 4, 14, 5, -4 },
  { 1323, 20, 49, 22, 1, -49 },
  { 1446, 27, 51, 35, 4, -50 },
  { 1619, 14, 49, 35, 6, -49 },
  { 1705, 26, 50, 35, 4, -50 },
  { 1868, 27, 51, 35, 3, -50 },
  { 2041, 33, 50, 35, 1, -50 },
  { 2248, 27, 50, 35, 4, -49 },
  { 2417, 27, 51, 35, 4, -50 },
  { 2590, 27, 49, 35, 4, -49 },
  { 2756, 27, 51, 35, 4, -50 },
  { 2929, 28, 51, 35, 3, -50 },
  { 3108, 4, 37, 14, 5, -37 },
  { 3127, 6, 46, 14, 3, -37 },
  { 3162, 29, 30, 35, 3, -40 },
  { 3271, 29, 16, 35, 3, -32 },
  { 3329, 29, 30, 35, 3, -40 },
  { 3438, 20, 50, 25, 2, -50 },
  { 3563, 46, 56, 54, 4, -49 },
  { 3885, 35, 49, 35, 0, -49 },
  { 4100, 28, 49, 38, 6, -49 },
  { 4272, 31, 51, 37, 4, -50 },
  { 4470, 32, 49, 42, 6, -49 },
  { 4666, 24, 49, 34, 6, -49 },
  { 4813, 24, 49, 30, 6, -49 },
  { 4960, 36, 51, 45, 4, -50 },
  { 5190, 31, 49, 43, 6, -49 },
  { 5380, 10, 49, 18, 4, -49 },
  { 5442, 14, 61, 15, -5, -49 },
  { 5549, 28, 49, 34, 6, -49 },
  { 5721, 23, 49, 31, 6, -49 },
  { 5862, 41, 49, 53, 6, -49 },
  { 6114, 31, 49, 43, 6, -49 },
  { 6304, 38, 51, 46, 4, -50 },
  { 6547, 26, 49, 35, 6, -49 },
  { 6707, 38, 62, 46, 4, -50 },
  { 7002, 28, 49, 35, 6, -49 },
  { 7174, 26, 51, 34, 4, -50 },
  { 7340, 30, 49, 31, 0, -49 },
  { 7524, 31, 50, 43, 6, -49 },
  { 7718, 34, 49, 34, 0, -49 },
  { 7927, 51, 49, 54, 2, -49 },
  { 8240, 31, 49, 31, 0, -49 },
  { 8430, 30, 49, 30, 0, -49 },
  { 8614, 29, 49, 33, 2, -49 },
  { 8792, 13, 60, 21, 6, -49 },
  { 8890, 20, 49, 22, 1, -49 },
  { 9013, 13, 60, 21, 2, -49 },
  { 9111, 30, 27, 35, 2, -49 },
  { 9213, 27, 2, 27, 0, 6 },
  { 9220, 11, 11, 17, 3, -53 },
  { 9236, 23, 38, 32, 3, -37 },
  { 9346, 27, 53, 36, 6, -52 },
  { 9525, 23, 38, 29, 4, -37 },
  { 9635, 27, 53, 36, 4, -52 },
  { 9814, 25, 38, 33, 4, -37 },
  { 9933, 20, 53, 17, 1, -53 },
  { 10066, 26, 54, 36, 4, -37 },
  { 10242, 24, 52, 35, 6, -52 },
  { 10398, 4, 50, 14, 5, -50 },
  { 10423, 11, 67, 14, -2, -50 },
  { 10516, 22, 52, 28, 6, -52 },
  { 10659, 2, 52, 13, 6, -52 },
  { 10672, 41, 37, 53, 6, -37 },
  { 10862, 24, 37, 35, 6, -37 },
  { 10973, 28, 38, 35, 4, -37 },
  { 11106, 27, 53, 36, 6, -37 },
  { 11285, 26, 53, 36, 4, -37 },
  { 11458, 16, 37, 23, 6, -37 },
  { 11532, 22, 38, 28, 3, -37 },
  { 11637, 17, 46, 19, 1, -45 },
  { 11735, 25, 37, 35, 5, -36 },
  { 11851, 26, 36, 26, 0, -36 },
  { 11968, 41, 36, 43, 1, -36 },
  { 12153, 25, 36, 29, 2, -36 },
  { 12266, 27, 53, 27, 0, -36 },
  { 12445, 21, 36, 26, 3, -36 },
  { 12540, 19, 60, 23, 2, -49 },
  { 12683, 1, 70, 33, 16, -53 },
  { 12692, 18, 60, 23, 3, -49 },
  { 12827, 29, 6, 35, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_Thin69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_THIN69PT7B_H_
