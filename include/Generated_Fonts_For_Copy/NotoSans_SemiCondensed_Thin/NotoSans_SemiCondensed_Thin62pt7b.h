#ifndef _NOTOSANS_SEMICONDENSED_THIN62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin62pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD2, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x40, 0x00, 0x00, 0x5F, 0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01, 0xA0, 0x34, 0x06,
  0x80, 0xD0, 0x1A, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0x10, 0x7C, 0x1C, 0x10, 0x08, 0x30, 0x10, 0x00,
  0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x10, 0x00,
  0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00,
  0x40, 0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0x30, 0x10, 0x00,
  0x18, 0x10, 0x00, 0x0E, 0x10, 0x00, 0x03, 0x90, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x13, 0xC0, 0x00, 0x10, 0xE0,
  0x00, 0x10, 0x38, 0x00, 0x10, 0x1C, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x06,
  0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03,
  0x00, 0x10, 0x03, 0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x10, 0x06,
  0x00, 0x10, 0x06, 0x00, 0x10, 0x0C, 0x80, 0x10, 0x18, 0xF0, 0x10, 0x70,
  0x7F, 0xD7, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x01, 0x00, 0x08, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x80,
  0x00, 0xC0, 0x02, 0x06, 0x00, 0x03, 0x00, 0x08, 0x10, 0x00, 0x04, 0x00,
  0x20, 0xC1, 0xF8, 0x10, 0x01, 0x83, 0x0E, 0x38, 0x60, 0x06, 0x18, 0x60,
  0x61, 0x80, 0x18, 0x61, 0x00, 0xC6, 0x00, 0x43, 0x0C, 0x01, 0x0C, 0x03,
  0x0C, 0x20, 0x06, 0x30, 0x08, 0x61, 0x80, 0x18, 0x60, 0x61, 0x86, 0x00,
  0x20, 0xFF, 0x04, 0x18, 0x00, 0x80, 0xF0, 0x30, 0x40, 0x03, 0x00, 0x00,
  0x81, 0x00, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x30, 0x00, 0x10, 0x10, 0x00,
  0xC0, 0x00, 0xC0, 0x40, 0x03, 0x00, 0x02, 0x01, 0x00, 0x0C, 0x00, 0x18,
  0x04, 0x00, 0x30, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x03, 0x00, 0x10, 0x00,
  0x0C, 0x38, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x38, 0x01, 0x80, 0x06,
  0x30, 0x00, 0xC0, 0x04, 0x60, 0x00, 0xC0, 0x04, 0x60, 0x00, 0x60, 0x0C,
  0x40, 0x00, 0x30, 0x08, 0xC0, 0x00, 0x18, 0x18, 0xC0, 0x00, 0x0C, 0x18,
  0xC0, 0x00, 0x06, 0x10, 0xC0, 0x00, 0x06, 0x30, 0xC0, 0x00, 0x03, 0x60,
  0xC0, 0x00, 0x01, 0xE0, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xE0,
  0x60, 0x00, 0x03, 0x20, 0x30, 0x00, 0x06, 0x30, 0x38, 0x00, 0x0C, 0x18,
  0x1C, 0x00, 0x38, 0x0C, 0x07, 0x00, 0xF0, 0x06, 0x03, 0xFF, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0x55, 0x55, 0x00, 0xE0, 0x30, 0x06,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xE0,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x20, 0x08,
  0x02, 0xF8, 0x10, 0x1E, 0x3C, 0x21, 0xE0, 0x0F, 0x5E, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x05, 0x80, 0x00, 0x11, 0x80, 0x00, 0x41, 0x00,
  0x01, 0x83, 0x00, 0x06, 0x03, 0x00, 0x08, 0x03, 0x00, 0x30, 0x02, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x5F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x0C, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x33, 0x0E, 0x31,
  0xC3, 0x38, 0x36, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x1E, 0x00, 0xE0, 0x78, 0x00, 0x30, 0x20, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1C, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xFC, 0x01,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0,
  0x04, 0x00, 0x06, 0x00, 0x10, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x40,
  0x06, 0x00, 0x01, 0x00, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xF8, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x6F, 0xFF, 0x80, 0x7E, 0x03, 0xE0, 0x20, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0xE0, 0xF8, 0x03, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xE0, 0x04, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0xC3, 0xF3, 0xE0, 0xC6,
  0x00, 0x30, 0xCC, 0x00, 0x18, 0x98, 0x00, 0x0C, 0xB0, 0x00, 0x04, 0xA0,
  0x00, 0x06, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04,
  0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x38,
  0x38, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x03,
  0x83, 0x80, 0x07, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x05, 0x30, 0x00, 0x0D, 0x30, 0x00, 0x19, 0x18,
  0x00, 0x31, 0x0E, 0x00, 0xE1, 0x07, 0xFF, 0xC3, 0x00, 0xFE, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x20, 0x0F, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xBF, 0xE0, 0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC7, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x21, 0x86, 0x10,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0x0E,
  0x00, 0xE2, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x80, 0x01, 0x0C, 0x00, 0x0F,
  0xFE, 0x00, 0x63, 0x00, 0x07, 0x01, 0x80, 0x18, 0xC0, 0x07, 0x00, 0x20,
  0x02, 0x60, 0x01, 0x80, 0x08, 0x00, 0x98, 0x00, 0xC0, 0x02, 0x00, 0x36,
  0x00, 0x60, 0x00, 0x80, 0x0D, 0x80, 0x18, 0x00, 0x20, 0x03, 0x40, 0x0C,
  0x00, 0x18, 0x00, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xC0, 0x01,
  0x80, 0x0F, 0x00, 0x20, 0x00, 0x60, 0x03, 0xC0, 0x08, 0x00, 0x18, 0x00,
  0xF0, 0x02, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x80, 0x01, 0x80, 0x0F, 0x00,
  0x20, 0x00, 0x60, 0x03, 0xC0, 0x08, 0x00, 0x18, 0x00, 0xB0, 0x02, 0x00,
  0x06, 0x00, 0x2C, 0x00, 0xC0, 0x03, 0x80, 0x19, 0x00, 0x30, 0x00, 0xA0,
  0x06, 0x40, 0x04, 0x00, 0x68, 0x03, 0x18, 0x01, 0x80, 0x13, 0x00, 0xC6,
  0x00, 0x30, 0x1C, 0xC0, 0x61, 0x80, 0x07, 0x1E, 0x1E, 0xF0, 0x20, 0x00,
  0xFE, 0x03, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x01,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0x80, 0x40, 0x01, 0xF0, 0x20, 0x00, 0x0E,
  0x10, 0x00, 0x03, 0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x34, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x20,
  0x00, 0x0C, 0x10, 0x00, 0x3C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x02,
  0x00, 0x01, 0xE1, 0x00, 0x00, 0x38, 0x80, 0x00, 0x06, 0x40, 0x00, 0x01,
  0x20, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x19, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x40,
  0x00, 0x38, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x20, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x80, 0x00, 0x70,
  0x08, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x70, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x38, 0x08, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC8, 0x0E, 0x7F, 0xC0,
  0xF8, 0x00, 0x80, 0x00, 0x07, 0x40, 0x00, 0x07, 0x20, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x08, 0x00, 0x03, 0x04, 0x00, 0x03, 0x02, 0x00, 0x03, 0x01,
  0x00, 0x03, 0x00, 0x80, 0x03, 0x80, 0x40, 0x03, 0x80, 0x20, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x08, 0x01, 0x80, 0x04, 0x01, 0x80, 0x02, 0x01, 0xC0,
  0x01, 0x01, 0xC0, 0x00, 0x81, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x20, 0xC0,
  0x00, 0x10, 0xF0, 0x00, 0x08, 0xD8, 0x00, 0x04, 0xC6, 0x00, 0x02, 0x61,
  0x80, 0x01, 0x60, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x20,
  0x06, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x60, 0x04, 0x00, 0x30, 0x02,
  0x00, 0x0C, 0x01, 0x00, 0x07, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60,
  0x20, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x03, 0x20, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x70, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0x00, 0xFB,
  0x00, 0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00, 0x00, 0xB9, 0x00, 0x00, 0x00,
  0x1B, 0x98, 0x00, 0x00, 0x01, 0xB9, 0x80, 0x00, 0x00, 0x33, 0x8C, 0x00,
  0x00, 0x03, 0x38, 0xC0, 0x00, 0x00, 0x23, 0x84, 0x00, 0x00, 0x06, 0x38,
  0x60, 0x00, 0x00, 0x63, 0x86, 0x00, 0x00, 0x04, 0x38, 0x20, 0x00, 0x00,
  0xC3, 0x83, 0x00, 0x00, 0x0C, 0x38, 0x30, 0x00, 0x00, 0x83, 0x81, 0x80,
  0x00, 0x18, 0x38, 0x18, 0x00, 0x01, 0x83, 0x80, 0x80, 0x00, 0x30, 0x38,
  0x0C, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x20, 0x38, 0x04, 0x00, 0x06,
  0x03, 0x80, 0x60, 0x00, 0x60, 0x38, 0x06, 0x00, 0x04, 0x03, 0x80, 0x20,
  0x00, 0xC0, 0x38, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x30, 0x01, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x18, 0x01, 0x00, 0x38, 0x00, 0x80, 0x30,
  0x03, 0x80, 0x0C, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x20, 0x03, 0x80, 0x04,
  0x06, 0x00, 0x38, 0x00, 0x60, 0x60, 0x03, 0x80, 0x06, 0x0C, 0x00, 0x38,
  0x00, 0x30, 0xC0, 0x03, 0x80, 0x03, 0x08, 0x00, 0x38, 0x00, 0x11, 0x80,
  0x03, 0x80, 0x01, 0x98, 0x00, 0x38, 0x00, 0x19, 0x00, 0x03, 0x80, 0x00,
  0xB0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x84, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x18, 0x00, 0x07,
  0x01, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x40, 0x01, 0xC0, 0x0C, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x30,
  0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C,
  0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x02, 0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0x00, 0x1F, 0x02, 0x00, 0x03, 0x84, 0x00, 0x03,
  0x88, 0x00, 0x01, 0x90, 0x00, 0x03, 0x20, 0x00, 0x03, 0x40, 0x00, 0x06,
  0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x06, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC8, 0x00,
  0x03, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x70, 0x40, 0x3F, 0x80, 0xFF, 0xF8,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x00, 0x80, 0x0F, 0xC0,
  0x80, 0x00, 0xE0, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x01, 0xC0,
  0x80, 0x3F, 0x80, 0xFF, 0xFC, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x0C, 0x00,
  0x80, 0x06, 0x00, 0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00,
  0x80, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8,
  0x07, 0x00, 0x1E, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x30, 0xF8, 0x01, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x38, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x20, 0x06, 0x00, 0x01, 0x80, 0x08, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x86, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x02, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x0C,
  0x40, 0x00, 0x10, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x31,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x80, 0x80, 0x01, 0x82,
  0x00, 0x02, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x08, 0x18, 0x00, 0x30, 0x04, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x06, 0x00, 0x80,
  0x18, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x04, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0x08, 0x18, 0x00, 0x20, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0x80, 0x01, 0x82, 0x00, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x68, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x34, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x10, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x08, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x80,
  0x03, 0x00, 0x30, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFC, 0x1C, 0x06, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0x18,
  0x70, 0x00, 0xCE, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x05, 0xB0, 0x00, 0x4D, 0xC0, 0x06,
  0x67, 0x00, 0xE3, 0x0F, 0xFC, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0xC3, 0xC1, 0xE0, 0xC6, 0x00, 0x70,
  0xCC, 0x00, 0x18, 0xD8, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x04,
  0xF0, 0x00, 0x0C, 0xD0, 0x00, 0x18, 0xD8, 0x00, 0x18, 0xCC, 0x00, 0x70,
  0xC7, 0x01, 0xE0, 0x81, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF0,
  0x0F, 0x81, 0xC0, 0xE0, 0x02, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x00, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0xFF, 0x81,
  0x03, 0xC1, 0xE1, 0x07, 0x00, 0x31, 0x0C, 0x00, 0x19, 0x18, 0x00, 0x0D,
  0x18, 0x00, 0x05, 0x30, 0x00, 0x07, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x07, 0x30, 0x00, 0x05, 0x18, 0x00, 0x0D,
  0x1C, 0x00, 0x19, 0x0E, 0x00, 0x31, 0x07, 0x80, 0xE1, 0x01, 0xFF, 0xC1,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0x83, 0xC0, 0x1C, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x02, 0x20, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x01, 0x01, 0xE0, 0x1E, 0x00,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x38, 0x20, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xC1, 0x03, 0xE1, 0xE1, 0x07, 0x00, 0x31,
  0x0C, 0x00, 0x19, 0x18, 0x00, 0x0D, 0x18, 0x00, 0x05, 0x30, 0x00, 0x07,
  0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x07,
  0x30, 0x00, 0x05, 0x18, 0x00, 0x0D, 0x0C, 0x00, 0x19, 0x0E, 0x00, 0x31,
  0x07, 0x80, 0xE1, 0x01, 0xFF, 0xC1, 0x00, 0x1C, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x3C, 0x00, 0x70, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x0F, 0xF8, 0x30, 0xF0, 0x70, 0xC6,
  0x00, 0x63, 0x30, 0x00, 0xCD, 0x80, 0x01, 0xBC, 0x00, 0x06, 0xE0, 0x00,
  0x0B, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xC0, 0xDF, 0xE0, 0x00, 0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xCF, 0xE3, 0xE0, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x6C, 0x00,
  0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0,
  0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C,
  0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x68, 0x00,
  0xCC, 0xC0, 0x0D, 0x86, 0x00, 0xD0, 0x60, 0x0F, 0x03, 0x00, 0xE0, 0x18,
  0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x06, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00, 0x0C, 0xC0,
  0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x81, 0xFE, 0x00, 0xFF, 0x84,
  0x3C, 0x38, 0x0E, 0x0E, 0x23, 0x00, 0x60, 0xC0, 0x19, 0xB0, 0x01, 0x8C,
  0x00, 0x6D, 0x00, 0x04, 0xC0, 0x01, 0x70, 0x00, 0x34, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x80, 0xFF, 0x82, 0x0F, 0x07, 0x0C, 0x60, 0x07,
  0x33, 0x00, 0x0C, 0xD8, 0x00, 0x1B, 0xC0, 0x00, 0x6E, 0x00, 0x00, 0xB8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00,
  0xFF, 0xC0, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x07, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xFF,
  0x80, 0xC3, 0xC1, 0xE0, 0xC6, 0x00, 0x30, 0xCC, 0x00, 0x18, 0xD8, 0x00,
  0x0C, 0xD0, 0x00, 0x0C, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x02, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x02, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xF0, 0x00, 0x0C, 0xD8, 0x00,
  0x08, 0xCC, 0x00, 0x18, 0xCE, 0x00, 0x70, 0xC7, 0x80, 0xE0, 0xC1, 0xFF,
  0x80, 0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x81, 0x03, 0xC1,
  0xE1, 0x07, 0x00, 0x31, 0x0C, 0x00, 0x19, 0x18, 0x00, 0x0D, 0x18, 0x00,
  0x05, 0x30, 0x00, 0x07, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x05, 0x30, 0x00, 0x0D, 0x18, 0x00, 0x09, 0x18, 0x00,
  0x19, 0x0E, 0x00, 0x31, 0x07, 0x80, 0xE1, 0x01, 0xFF, 0x81, 0x00, 0x3C,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xC1, 0xFF, 0x8F, 0x9F, 0x38, 0x06, 0x40, 0x0D,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0xF8, 0x3F, 0x1C,
  0x00, 0x23, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0xC0, 0x00, 0xEF,
  0x80, 0x3C, 0x1F, 0xFF, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x81, 0x01, 0xFE,
  0x00, 0x70, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0B, 0x60, 0x00, 0x6D, 0x80, 0x03,
  0x33, 0x00, 0x18, 0xC7, 0x01, 0xC3, 0x0F, 0xFE, 0x0C, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x22,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x02, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x04, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x18,
  0x00, 0x30, 0x20, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC2, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x03, 0x20, 0x00, 0x06, 0xC0, 0x00,
  0x05, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0xB0, 0x00, 0x1C, 0x00,
  0x04, 0x80, 0x00, 0xE0, 0x00, 0x66, 0x00, 0x05, 0x80, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x10, 0x80, 0x03, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x0C,
  0x30, 0x00, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x02, 0x04, 0x00, 0x61,
  0x00, 0x10, 0x20, 0x02, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x0C,
  0x01, 0x81, 0x00, 0x40, 0x20, 0x08, 0x08, 0x02, 0x01, 0x80, 0x40, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x08, 0x01, 0x01,
  0x00, 0x60, 0x40, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x30,
  0x03, 0x04, 0x00, 0x41, 0x00, 0x08, 0x60, 0x03, 0x08, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x46, 0x00, 0x08, 0x80, 0x03, 0x20, 0x00,
  0x4C, 0x00, 0x19, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x02,
  0xC0, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x18, 0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00,
  0x01, 0x90, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x60, 0x00,
  0x60, 0x60, 0x01, 0x80, 0x40, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x30, 0x00, 0x02, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x08, 0x00,
  0x18, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30, 0x06, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40, 0x03, 0x00,
  0xC0, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81,
  0x80, 0x00, 0xC1, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x43, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x26, 0x00, 0x00, 0x34, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x17, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x0E, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 44, 13, 5, -44 },
  { 18, 11, 16, 19, 4, -44 },
  { 40, 32, 44, 35, 1, -44 },
  { 216, 24, 51, 31, 3, -47 },
  { 369, 38, 46, 44, 3, -45 },
  { 588, 32, 46, 36, 3, -45 },
  { 772, 2, 16, 10, 4, -44 },
  { 776, 11, 54, 16, 3, -44 },
  { 851, 11, 54, 16, 2, -44 },
  { 926, 23, 22, 29, 3, -47 },
  { 990, 26, 28, 31, 3, -36 },
  { 1081, 6, 15, 11, 2, -7 },
  { 1093, 14, 2, 19, 2, -18 },
  { 1097, 3, 4, 13, 5, -4 },
  { 1099, 18, 44, 20, 1, -44 },
  { 1198, 24, 46, 31, 4, -45 },
  { 1336, 12, 44, 31, 6, -44 },
  { 1402, 24, 45, 31, 3, -45 },
  { 1537, 24, 46, 31, 3, -45 },
  { 1675, 30, 45, 31, 1, -45 },
  { 1844, 24, 45, 31, 4, -44 },
  { 1979, 24, 46, 31, 4, -45 },
  { 2117, 25, 44, 31, 3, -44 },
  { 2255, 25, 46, 31, 3, -45 },
  { 2399, 24, 46, 31, 3, -45 },
  { 2537, 3, 33, 13, 5, -33 },
  { 2550, 6, 41, 13, 2, -33 },
  { 2581, 26, 27, 31, 3, -36 },
  { 2669, 26, 14, 31, 3, -29 },
  { 2715, 26, 27, 31, 3, -36 },
  { 2803, 18, 45, 22, 2, -45 },
  { 2905, 42, 50, 48, 3, -44 },
  { 3168, 31, 44, 31, 0, -44 },
  { 3339, 25, 44, 34, 6, -44 },
  { 3477, 28, 46, 34, 4, -45 },
  { 3638, 28, 44, 38, 6, -44 },
  { 3792, 21, 44, 30, 6, -44 },
  { 3908, 21, 44, 27, 6, -44 },
  { 4024, 32, 46, 40, 4, -45 },
  { 4208, 27, 44, 39, 6, -44 },
  { 4357, 10, 44, 16, 3, -44 },
  { 4412, 13, 55, 13, -5, -44 },
  { 4502, 25, 44, 31, 6, -44 },
  { 4640, 20, 44, 28, 6, -44 },
  { 4750, 36, 44, 48, 6, -44 },
  { 4948, 27, 44, 39, 6, -44 },
  { 5097, 34, 46, 41, 4, -45 },
  { 5293, 23, 44, 32, 6, -44 },
  { 5420, 34, 56, 41, 4, -45 },
  { 5658, 24, 44, 32, 6, -44 },
  { 5790, 24, 46, 30, 3, -45 },
  { 5928, 27, 44, 27, 0, -44 },
  { 6077, 29, 45, 39, 5, -44 },
  { 6241, 30, 44, 30, 0, -44 },
  { 6406, 47, 44, 49, 1, -44 },
  { 6665, 27, 44, 28, 0, -44 },
  { 6814, 27, 44, 27, 0, -44 },
  { 6963, 26, 44, 30, 2, -44 },
  { 7106, 12, 54, 19, 5, -44 },
  { 7187, 18, 44, 20, 1, -44 },
  { 7286, 12, 54, 19, 2, -44 },
  { 7367, 27, 25, 31, 2, -44 },
  { 7452, 24, 1, 24, 0, 6 },
  { 7455, 10, 9, 15, 2, -47 },
  { 7467, 21, 34, 28, 3, -33 },
  { 7557, 24, 48, 33, 5, -47 },
  { 7701, 21, 34, 26, 3, -33 },
  { 7791, 24, 48, 33, 3, -47 },
  { 7935, 23, 34, 30, 3, -33 },
  { 8033, 18, 47, 16, 1, -47 },
  { 8139, 24, 48, 32, 3, -33 },
  { 8283, 22, 47, 32, 5, -47 },
  { 8413, 3, 45, 12, 5, -45 },
  { 8430, 10, 60, 12, -2, -45 },
  { 8505, 20, 47, 25, 5, -47 },
  { 8623, 2, 47, 12, 5, -47 },
  { 8635, 37, 33, 47, 5, -33 },
  { 8788, 22, 33, 32, 5, -33 },
  { 8879, 25, 34, 32, 3, -33 },
  { 8986, 24, 47, 32, 5, -33 },
  { 9127, 24, 47, 32, 3, -33 },
  { 9268, 15, 33, 21, 5, -33 },
  { 9330, 20, 34, 25, 2, -33 },
  { 9415, 15, 42, 17, 1, -41 },
  { 9494, 22, 34, 32, 5, -33 },
  { 9588, 23, 33, 24, 0, -33 },
  { 9683, 37, 33, 39, 1, -33 },
  { 9836, 23, 33, 26, 1, -33 },
  { 9931, 24, 48, 24, 0, -33 },
  { 10075, 20, 33, 24, 2, -33 },
  { 10158, 16, 54, 21, 2, -44 },
  { 10266, 2, 62, 30, 14, -47 },
  { 10282, 16, 54, 21, 3, -44 },
  { 10390, 26, 6, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_Thin62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_THIN62PT7B_H_
