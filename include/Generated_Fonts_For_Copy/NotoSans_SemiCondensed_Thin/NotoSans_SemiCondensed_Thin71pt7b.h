#ifndef _NOTOSANS_SEMICONDENSED_THIN71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin71pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x69, 0x24, 0x90, 0x00, 0x00, 0x07, 0xFF, 0xA0, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x03, 0xC3, 0x07, 0xC0, 0xE0, 0x60, 0x18, 0x38, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x07, 0xB0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x3C,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x30, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x0C,
  0x07, 0x18, 0x01, 0x81, 0xC3, 0xF0, 0x31, 0xF0, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xC0, 0x01, 0xC7, 0x80, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x18, 0x1F,
  0x81, 0x80, 0x03, 0x06, 0x07, 0xFC, 0x30, 0x00, 0x60, 0xC1, 0x81, 0xC3,
  0x00, 0x18, 0x30, 0x60, 0x18, 0x60, 0x03, 0x06, 0x18, 0x01, 0x8C, 0x00,
  0x61, 0x83, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x40, 0x03, 0x18, 0x03, 0x0C,
  0x18, 0x00, 0x61, 0x80, 0xC1, 0x83, 0x00, 0x0C, 0x1E, 0xF0, 0x20, 0x60,
  0x01, 0x81, 0xFC, 0x0C, 0x0C, 0x00, 0x10, 0x00, 0x01, 0x81, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xE1,
  0xC0, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x61, 0x80,
  0x0C, 0x00, 0x04, 0x30, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x03, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0x00, 0xCC, 0x00, 0x01, 0xC0, 0x0C, 0xC0, 0x00, 0x0E,
  0x01, 0x8C, 0x00, 0x00, 0x60, 0x18, 0xC0, 0x00, 0x03, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x0C, 0x00, 0x00, 0x0E, 0x60,
  0xC0, 0x00, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x66, 0x06, 0x00,
  0x00, 0x0E, 0x70, 0x30, 0x00, 0x01, 0xC3, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x78, 0x07, 0xC0, 0x06, 0x01, 0xFF, 0xF0,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x1C, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0xF8, 0x04, 0x01, 0xDF, 0x02, 0x07, 0xC1,
  0xF1, 0x1F, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x20,
  0x00, 0x30, 0x18, 0x00, 0x10, 0x06, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x04, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x71, 0x86, 0x18,
  0x63, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x30, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF4, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0E,
  0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xF0,
  0x07, 0xC0, 0x3B, 0x01, 0xCC, 0x1C, 0x30, 0xE0, 0xC7, 0x03, 0x70, 0x0F,
  0x80, 0x3C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x78, 0x00, 0xE0,
  0x3C, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x0F, 0x80, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x84, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x0E, 0x07, 0xF0,
  0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xCF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1F, 0x80, 0x3E, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFC,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x1F, 0xE0, 0x06, 0x0F, 0xFF, 0xC0, 0x43,
  0xC0, 0x0E, 0x04, 0x70, 0x00, 0x30, 0xCE, 0x00, 0x01, 0x8C, 0xC0, 0x00,
  0x0C, 0xD8, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x30, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x0C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x00, 0x7C,
  0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x01, 0xE6, 0x00, 0x00,
  0x6C, 0xE0, 0x00, 0x1D, 0x8E, 0x00, 0x07, 0x30, 0xE0, 0x03, 0xC6, 0x0F,
  0x87, 0xE0, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xDF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xD0, 0x1C, 0x71, 0xC7, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x18, 0x61, 0x86, 0x38,
  0xC3, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x03, 0xF8, 0xFC, 0x38, 0x00, 0xF1, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x03, 0xFE, 0x00,
  0x0C, 0x30, 0x00, 0x1F, 0xFF, 0x80, 0x0C, 0x30, 0x00, 0x38, 0x01, 0x80,
  0x06, 0x60, 0x00, 0x70, 0x01, 0x80, 0x06, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x60, 0x01, 0x80, 0x01, 0x80,
  0x06, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0x02, 0xC0, 0x02, 0x00, 0x01, 0x80, 0x02, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x02, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x06, 0xC0, 0x06, 0x00, 0x01, 0x00, 0x06, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x06, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x06, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x0C, 0xC0, 0x06, 0x00, 0x07, 0x80, 0x0C, 0xC0, 0x03, 0x00, 0x05, 0x80,
  0x0C, 0xC0, 0x03, 0x00, 0x0D, 0x80, 0x18, 0x60, 0x01, 0x80, 0x18, 0xC0,
  0x38, 0x60, 0x01, 0xC0, 0x30, 0xE0, 0x70, 0x60, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x60, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0xFC, 0x0C, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x0F, 0xC0, 0xC0, 0x00,
  0x0F, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFC, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x0F, 0xF3, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x1F, 0x7E, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x00, 0xC0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0xC0,
  0x00, 0x0C, 0x7C, 0x00, 0x00, 0xCE, 0x60, 0x00, 0x0D, 0xC7, 0x00, 0x00,
  0xD8, 0x30, 0x00, 0x0F, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF6, 0x00,
  0x00, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x00, 0x00, 0x7D, 0x80, 0x00, 0x00,
  0x00, 0x6E, 0x60, 0x00, 0x00, 0x00, 0x37, 0xB0, 0x00, 0x00, 0x00, 0x33,
  0xCC, 0x00, 0x00, 0x00, 0x19, 0xE6, 0x00, 0x00, 0x00, 0x0C, 0xF3, 0x00,
  0x00, 0x00, 0x0C, 0x78, 0xC0, 0x00, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x00,
  0x03, 0x1E, 0x30, 0x00, 0x00, 0x03, 0x0F, 0x0C, 0x00, 0x00, 0x01, 0x87,
  0x86, 0x00, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x00, 0x00, 0xC1, 0xE0, 0xC0,
  0x00, 0x00, 0x60, 0xF0, 0x60, 0x00, 0x00, 0x60, 0x78, 0x18, 0x00, 0x00,
  0x30, 0x3C, 0x0C, 0x00, 0x00, 0x18, 0x1E, 0x06, 0x00, 0x00, 0x18, 0x0F,
  0x01, 0x80, 0x00, 0x0C, 0x07, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0xC0, 0x60,
  0x00, 0x06, 0x01, 0xE0, 0x18, 0x00, 0x03, 0x00, 0xF0, 0x0C, 0x00, 0x03,
  0x00, 0x78, 0x03, 0x00, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x00, 0xC0, 0x1E,
  0x00, 0xC0, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x00, 0x60, 0x07, 0x80, 0x18,
  0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xF0, 0x01, 0x80, 0x18, 0x00, 0x78, 0x00, 0x60, 0x0C, 0x00, 0x3C,
  0x00, 0x30, 0x06, 0x00, 0x1E, 0x00, 0x18, 0x06, 0x00, 0x0F, 0x00, 0x06,
  0x03, 0x00, 0x07, 0x80, 0x03, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x81, 0x80,
  0x01, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0xC0, 0x00, 0x78,
  0x00, 0x0C, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x30, 0x00, 0x1E, 0x00, 0x03,
  0x30, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03,
  0xCC, 0x00, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x1E,
  0x18, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x30, 0x00, 0x00, 0xF0,
  0x30, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x3C, 0x01,
  0x80, 0x00, 0x78, 0x01, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x03,
  0x00, 0x03, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0F, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x30,
  0x07, 0x80, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x60,
  0x3C, 0x00, 0x00, 0x60, 0x78, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x00, 0xC1,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0x87, 0x80, 0x00, 0x01, 0x8F,
  0x00, 0x00, 0x03, 0x1E, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x07, 0x78,
  0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x3F, 0x03, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x07, 0x0C, 0x00, 0x0F, 0x03, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xC0, 0x03, 0xF0, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x1F,
  0xF0, 0x1C, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x1C, 0x1F, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7A, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0x00, 0x38,
  0x08, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF3,
  0x03, 0xE0, 0x03, 0x0F, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x38, 0x00, 0x03,
  0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x60, 0x00, 0x0B, 0x60, 0x00, 0x1B, 0x30, 0x00, 0x33,
  0x38, 0x00, 0x63, 0x1E, 0x03, 0xC3, 0x07, 0xFF, 0x03, 0x00, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0xE0, 0x18, 0x3F, 0xFF,
  0x03, 0x0E, 0x00, 0x70, 0x63, 0x00, 0x07, 0x0C, 0xC0, 0x00, 0x71, 0xB0,
  0x00, 0x07, 0x34, 0x00, 0x00, 0x67, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x67, 0x80, 0x00, 0x0C, 0xD0, 0x00, 0x03, 0x1B, 0x00, 0x00,
  0xE3, 0x30, 0x00, 0x38, 0x43, 0x00, 0x0E, 0x08, 0x3C, 0x0F, 0x81, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC,
  0x07, 0x80, 0x08, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x10, 0x1F, 0x01, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xE0, 0x20, 0x3F, 0xFF, 0x04,
  0x0E, 0x00, 0x70, 0x83, 0x80, 0x07, 0x10, 0xC0, 0x00, 0x32, 0x38, 0x00,
  0x06, 0x46, 0x00, 0x00, 0x69, 0x80, 0x00, 0x05, 0x30, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x29, 0x80, 0x00, 0x0D, 0x38, 0x00, 0x01, 0xA3, 0x00, 0x00, 0x64,
  0x30, 0x00, 0x18, 0x83, 0x80, 0x06, 0x10, 0x3C, 0x07, 0x82, 0x01, 0xFF,
  0xE0, 0x40, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x1E,
  0x00, 0x06, 0x01, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x07, 0xEF, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x04, 0x0E, 0x00,
  0x70, 0x83, 0x00, 0x03, 0x10, 0xC0, 0x00, 0x32, 0x30, 0x00, 0x03, 0x46,
  0x00, 0x00, 0x79, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x29,
  0x80, 0x00, 0x0D, 0x38, 0x00, 0x01, 0x23, 0x00, 0x00, 0x6C, 0x30, 0x00,
  0x19, 0x83, 0x80, 0x0E, 0x30, 0x3C, 0x07, 0x86, 0x01, 0xFF, 0xC0, 0xC0,
  0x07, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0xC0,
  0x01, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x7F, 0xC0, 0x60, 0xFF, 0xF8, 0x30, 0xE0, 0x0E, 0x19, 0xC0, 0x01, 0x8C,
  0xC0, 0x00, 0x66, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x0D, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x7F, 0xF7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x63, 0xFC, 0x7E, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x80,
  0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x1C,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x38, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x87, 0x80, 0x03,
  0x19, 0x80, 0x06, 0x63, 0x80, 0x0D, 0xC3, 0x00, 0x1B, 0x03, 0x00, 0x3C,
  0x06, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x71, 0x80, 0x00, 0x63, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x10, 0x7F, 0xF8, 0x07, 0xFF, 0x82, 0x1C,
  0x03, 0x81, 0xC0, 0x3C, 0x46, 0x00, 0x18, 0x70, 0x01, 0xC9, 0x80, 0x03,
  0x18, 0x00, 0x19, 0xA0, 0x00, 0x33, 0x00, 0x03, 0xBC, 0x00, 0x06, 0xC0,
  0x00, 0x37, 0x00, 0x00, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x7F, 0xC0, 0x40, 0xFF, 0xF8, 0x20, 0xE0, 0x0F, 0x10, 0xC0,
  0x01, 0x88, 0xC0, 0x00, 0x66, 0xC0, 0x00, 0x3B, 0x40, 0x00, 0x0D, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x01, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x00, 0x70, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x08, 0x1F, 0xFF, 0x80,
  0x83, 0x80, 0x1C, 0x08, 0x70, 0x00, 0xE0, 0x8C, 0x00, 0x03, 0x0D, 0x80,
  0x00, 0x38, 0xD8, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x0C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x18, 0xD8, 0x00, 0x03,
  0x8D, 0xC0, 0x00, 0x30, 0xCE, 0x00, 0x06, 0x0C, 0x70, 0x01, 0xC0, 0xC3,
  0xC0, 0x78, 0x0C, 0x0F, 0xFE, 0x00, 0xC0, 0x1F, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x04, 0x0E, 0x00, 0x70,
  0x83, 0x80, 0x07, 0x10, 0xC0, 0x00, 0x72, 0x30, 0x00, 0x06, 0x4E, 0x00,
  0x00, 0x69, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x79, 0x80,
  0x00, 0x0F, 0x38, 0x00, 0x03, 0x63, 0x00, 0x00, 0x6C, 0x30, 0x00, 0x19,
  0x83, 0x80, 0x0E, 0x30, 0x3C, 0x07, 0x86, 0x03, 0xFF, 0xC0, 0xC0, 0x0F,
  0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x60, 0xFF, 0xF1, 0xC0, 0x19,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x78, 0x00, 0x71, 0xC0,
  0x00, 0x23, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x66, 0x00, 0x03, 0x8F, 0xC0, 0x1E,
  0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0E, 0x04, 0x03, 0xFE, 0x00,
  0x3C, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x15, 0x80,
  0x00, 0x1A, 0x60, 0x00, 0x0D, 0x30, 0x00, 0x0C, 0x8C, 0x00, 0x0C, 0x47,
  0x00, 0x0C, 0x21, 0xE0, 0x3C, 0x10, 0x3F, 0xF8, 0x08, 0x01, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0x80, 0x00, 0x36, 0x00, 0x00, 0xE0, 0x00, 0x09, 0x80, 0x00, 0x2C,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x01, 0x88, 0x00, 0x06, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x10, 0x00, 0x10, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30,
  0x00, 0x31, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x80, 0x02,
  0x0C, 0x00, 0x20, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0,
  0x06, 0x03, 0x00, 0x10, 0x10, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40,
  0x30, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x18, 0x06, 0x00,
  0xC0, 0x60, 0x02, 0x01, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x01,
  0x06, 0x00, 0x08, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x64, 0x00,
  0x03, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x0C,
  0x03, 0x00, 0x07, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x02, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0xF0, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x17, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x0E, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 52, 15, 6, -51 },
  { 21, 12, 19, 22, 5, -51 },
  { 50, 36, 51, 40, 2, -51 },
  { 280, 27, 58, 36, 4, -54 },
  { 476, 43, 52, 51, 4, -51 },
  { 756, 36, 52, 42, 4, -51 },
  { 990, 2, 19, 12, 5, -51 },
  { 995, 13, 62, 18, 3, -51 },
  { 1096, 12, 62, 18, 3, -51 },
  { 1189, 25, 25, 34, 4, -54 },
  { 1268, 30, 32, 36, 3, -41 },
  { 1388, 6, 17, 13, 3, -8 },
  { 1401, 17, 2, 21, 2, -20 },
  { 1406, 3, 5, 15, 6, -4 },
  { 1408, 21, 51, 23, 1, -51 },
  { 1542, 28, 52, 36, 4, -51 },
  { 1724, 14, 51, 36, 7, -51 },
  { 1814, 27, 51, 36, 4, -51 },
  { 1987, 28, 52, 36, 3, -51 },
  { 2169, 34, 51, 36, 1, -51 },
  { 2386, 27, 52, 36, 5, -51 },
  { 2562, 28, 52, 36, 4, -51 },
  { 2744, 28, 51, 36, 4, -51 },
  { 2923, 28, 52, 36, 4, -51 },
  { 3105, 27, 52, 36, 4, -51 },
  { 3281, 3, 39, 15, 6, -38 },
  { 3296, 6, 47, 14, 3, -38 },
  { 3332, 30, 31, 36, 3, -41 },
  { 3449, 30, 16, 36, 3, -33 },
  { 3509, 30, 31, 36, 3, -41 },
  { 3626, 21, 52, 25, 2, -51 },
  { 3763, 48, 57, 55, 4, -50 },
  { 4105, 36, 51, 36, 0, -51 },
  { 4335, 28, 51, 39, 7, -51 },
  { 4514, 32, 52, 38, 4, -51 },
  { 4722, 32, 51, 43, 7, -51 },
  { 4926, 24, 51, 35, 7, -51 },
  { 5079, 24, 51, 31, 7, -51 },
  { 5232, 37, 52, 46, 4, -51 },
  { 5473, 31, 51, 44, 7, -51 },
  { 5671, 11, 51, 18, 4, -51 },
  { 5742, 15, 63, 15, -6, -51 },
  { 5861, 28, 51, 35, 7, -51 },
  { 6040, 23, 51, 32, 7, -51 },
  { 6187, 41, 51, 55, 7, -51 },
  { 6449, 31, 51, 45, 7, -51 },
  { 6647, 39, 52, 47, 4, -51 },
  { 6901, 26, 51, 36, 7, -51 },
  { 7067, 39, 63, 47, 4, -51 },
  { 7375, 28, 51, 37, 7, -51 },
  { 7554, 27, 52, 35, 4, -51 },
  { 7730, 31, 51, 31, 0, -51 },
  { 7928, 33, 52, 45, 6, -51 },
  { 8143, 35, 51, 35, 0, -51 },
  { 8367, 52, 51, 56, 2, -51 },
  { 8699, 31, 51, 32, 0, -51 },
  { 8897, 31, 51, 31, 0, -51 },
  { 9095, 30, 51, 34, 2, -51 },
  { 9287, 14, 62, 22, 6, -51 },
  { 9396, 21, 51, 23, 1, -51 },
  { 9530, 14, 62, 22, 2, -51 },
  { 9639, 30, 29, 36, 3, -51 },
  { 9748, 28, 2, 28, 0, 6 },
  { 9755, 11, 11, 17, 3, -54 },
  { 9771, 24, 39, 33, 3, -38 },
  { 9888, 27, 55, 37, 6, -54 },
  { 10074, 23, 39, 29, 4, -38 },
  { 10187, 27, 55, 37, 4, -54 },
  { 10373, 26, 39, 34, 4, -38 },
  { 10500, 20, 54, 18, 1, -54 },
  { 10635, 27, 55, 37, 4, -38 },
  { 10821, 25, 54, 36, 6, -54 },
  { 10990, 4, 51, 14, 5, -51 },
  { 11016, 11, 68, 14, -2, -51 },
  { 11110, 23, 54, 29, 6, -54 },
  { 11266, 2, 54, 14, 6, -54 },
  { 11280, 43, 38, 54, 6, -38 },
  { 11485, 25, 38, 36, 6, -38 },
  { 11604, 28, 39, 36, 4, -38 },
  { 11741, 28, 54, 37, 6, -38 },
  { 11930, 27, 54, 37, 4, -38 },
  { 12113, 17, 38, 24, 6, -38 },
  { 12194, 23, 39, 29, 3, -38 },
  { 12307, 17, 48, 20, 1, -47 },
  { 12409, 25, 38, 36, 5, -37 },
  { 12528, 27, 37, 27, 0, -37 },
  { 12653, 42, 37, 44, 1, -37 },
  { 12848, 26, 37, 30, 2, -37 },
  { 12969, 27, 54, 27, 0, -37 },
  { 13152, 22, 37, 27, 3, -37 },
  { 13254, 18, 62, 24, 3, -51 },
  { 13394, 2, 72, 34, 16, -54 },
  { 13412, 19, 62, 24, 3, -51 },
  { 13560, 30, 6, 36, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Thin71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_THIN71PT7B_H_
