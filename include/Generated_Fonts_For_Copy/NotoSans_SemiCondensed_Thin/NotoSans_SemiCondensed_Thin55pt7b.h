#ifndef _NOTOSANS_SEMICONDENSED_THIN55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin55pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0x00, 0x00, 0x07, 0xD8, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x20, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x40, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x06, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x02, 0x00, 0x01,
  0x80, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x08, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0E, 0x30, 0x70, 0xC1, 0x80,
  0x8C, 0x0C, 0x00, 0x40, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x00,
  0xC0, 0x08, 0x06, 0x00, 0x40, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x38, 0xC0, 0x00, 0x76,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x63, 0x80,
  0x03, 0x0E, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30,
  0x08, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x04, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x32, 0x01, 0x87,
  0x1F, 0x8C, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x0F, 0xE0, 0x00,
  0x20, 0x0C, 0x18, 0x00, 0x30, 0x04, 0x06, 0x00, 0x10, 0x06, 0x01, 0x00,
  0x18, 0x02, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10,
  0x04, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x60, 0x04, 0x02, 0x00, 0x20, 0x02,
  0x03, 0x00, 0x10, 0x01, 0x01, 0x80, 0x08, 0x00, 0x80, 0x80, 0x04, 0x00,
  0x40, 0xC0, 0x02, 0x00, 0x20, 0x40, 0x01, 0x80, 0x10, 0x60, 0x00, 0xC0,
  0x08, 0x20, 0xF8, 0x60, 0x04, 0x30, 0xC6, 0x10, 0x06, 0x10, 0xC1, 0x88,
  0x03, 0x18, 0xC0, 0x66, 0x01, 0x08, 0x40, 0x11, 0x01, 0x8C, 0x60, 0x08,
  0xC1, 0x84, 0x30, 0x06, 0x3F, 0x86, 0x18, 0x03, 0x07, 0x02, 0x08, 0x00,
  0x80, 0x03, 0x04, 0x00, 0x40, 0x01, 0x02, 0x00, 0x20, 0x01, 0x81, 0x00,
  0x10, 0x00, 0xC0, 0x80, 0x08, 0x00, 0x40, 0x40, 0x04, 0x00, 0x60, 0x20,
  0x02, 0x00, 0x20, 0x10, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0x80, 0x20, 0x0C, 0x00,
  0x60, 0x30, 0x04, 0x00, 0x10, 0x10, 0x06, 0x00, 0x0C, 0x18, 0x02, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0x40, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x23, 0x00, 0x40, 0x06, 0x60, 0x06, 0x00, 0x64, 0x00,
  0x30, 0x04, 0xC0, 0x01, 0x80, 0x4C, 0x00, 0x0C, 0x0C, 0x80, 0x00, 0x60,
  0x88, 0x00, 0x02, 0x18, 0x80, 0x00, 0x11, 0x08, 0x00, 0x01, 0xB0, 0x80,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0F, 0x06, 0x00, 0x01,
  0x90, 0x20, 0x00, 0x31, 0x83, 0x00, 0x0E, 0x0C, 0x1C, 0x03, 0x80, 0x60,
  0x7F, 0xF0, 0x03, 0x00, 0x20, 0x00, 0x00, 0xEA, 0xAA, 0xAA, 0xA0, 0x00,
  0xC0, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x0E, 0x04, 0x07, 0x3C, 0x43, 0xC0, 0x74, 0xE0,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x90, 0x00, 0x11, 0x80, 0x03, 0x0C,
  0x00, 0x20, 0x40, 0x04, 0x02, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x18,
  0xC4, 0x23, 0x18, 0x84, 0x63, 0x10, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0x40, 0x00,
  0x83, 0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0x64,
  0x00, 0x01, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x90, 0x00,
  0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x04,
  0x20, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x02, 0x06, 0x00, 0x18, 0x08,
  0x00, 0x40, 0x30, 0x03, 0x00, 0x70, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x34, 0x0C, 0x83, 0x10, 0xC2, 0x70, 0x58, 0x0E, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xF8, 0x00, 0x7F, 0xF0,
  0x0E, 0x00, 0xE0, 0xC0, 0x01, 0x84, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xC0, 0x0C,
  0x1C, 0x00, 0x18, 0x40, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x33, 0x00, 0x01,
  0x8F, 0x80, 0x1C, 0x07, 0xFF, 0xC0, 0x00, 0x50, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x40, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x03,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xC1, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFE,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x88, 0x00, 0x18, 0x70, 0x07, 0x80, 0xFF, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0xFF, 0x01,
  0x0F, 0x0F, 0x04, 0xE0, 0x06, 0x36, 0x00, 0x0C, 0xD0, 0x00, 0x13, 0x80,
  0x00, 0x6E, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x23, 0x00,
  0x01, 0x84, 0x00, 0x04, 0x18, 0x00, 0x30, 0x30, 0x01, 0x80, 0x70, 0x1C,
  0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xE0, 0x1C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0x80, 0x00, 0xC6, 0x00,
  0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x18, 0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x80, 0x06, 0x03,
  0x00, 0x30, 0x06, 0x03, 0x80, 0x0E, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0x8E, 0x00, 0x18, 0x0E, 0x01, 0xC0, 0x0C, 0x0C, 0x00, 0x18,
  0x20, 0x00, 0x31, 0x80, 0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x24, 0x00, 0x01, 0x98, 0x00, 0x04, 0x30, 0x00, 0x30,
  0x60, 0x01, 0x80, 0xE0, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0x00, 0xE0, 0x20, 0x01, 0x83, 0x00, 0x04,
  0x30, 0x00, 0x31, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00,
  0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00,
  0x06, 0xC0, 0x00, 0x52, 0x00, 0x06, 0x98, 0x00, 0x64, 0x60, 0x06, 0x21,
  0xFF, 0xE1, 0x01, 0xF8, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x01, 0x00, 0x70, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x19, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x62, 0x11, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xC0, 0x7F, 0xF0, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x60, 0x00,
  0xFE, 0x00, 0x62, 0x00, 0x1E, 0x3C, 0x03, 0x30, 0x01, 0x80, 0x60, 0x09,
  0x80, 0x18, 0x03, 0x00, 0x48, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x18, 0x00,
  0xC0, 0x1E, 0x00, 0x80, 0x06, 0x00, 0xF0, 0x04, 0x00, 0x20, 0x07, 0x80,
  0x60, 0x01, 0x00, 0x3C, 0x03, 0x00, 0x08, 0x01, 0xC0, 0x10, 0x00, 0x40,
  0x0E, 0x00, 0x80, 0x02, 0x00, 0x70, 0x04, 0x00, 0x10, 0x03, 0x80, 0x20,
  0x00, 0x80, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0xB0, 0x0C, 0x00, 0x60, 0x05,
  0x80, 0x60, 0x03, 0x00, 0x6C, 0x01, 0x00, 0x3C, 0x02, 0x60, 0x0C, 0x01,
  0x60, 0x31, 0x00, 0x30, 0x11, 0x03, 0x08, 0x00, 0xE7, 0x07, 0x70, 0x60,
  0x03, 0xF0, 0x1F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x18, 0x01, 0x80, 0x01, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x04, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x08, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x18, 0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0x03, 0x00, 0x1F, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x13, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x4C, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00,
  0x3E, 0x0F, 0xFF, 0xE0, 0x30, 0x00, 0xF0, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0xC0, 0x00, 0xE3, 0x00, 0x3E, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x38, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x60, 0x07, 0xC0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x1C, 0x06, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFD, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x20, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0xA0, 0x67, 0xF8, 0x10, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xCC,
  0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x30, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0xC0, 0x00, 0xC7, 0x00, 0x03, 0x3C, 0x00, 0x0C, 0xD8, 0x00, 0x36, 0x30,
  0x00, 0xF0, 0xC0, 0x03, 0x81, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0,
  0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFC, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x05, 0xF0, 0x00,
  0x00, 0x05, 0xD0, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0x09, 0xD8, 0x00,
  0x00, 0x19, 0xC8, 0x00, 0x00, 0x19, 0xCC, 0x00, 0x00, 0x11, 0xCC, 0x00,
  0x00, 0x31, 0xC4, 0x00, 0x00, 0x21, 0xC6, 0x00, 0x00, 0x21, 0xC2, 0x00,
  0x00, 0x61, 0xC2, 0x00, 0x00, 0x41, 0xC3, 0x00, 0x00, 0xC1, 0xC1, 0x00,
  0x00, 0xC1, 0xC1, 0x80, 0x00, 0x81, 0xC1, 0x80, 0x01, 0x81, 0xC0, 0x80,
  0x01, 0x81, 0xC0, 0xC0, 0x01, 0x01, 0xC0, 0x40, 0x03, 0x01, 0xC0, 0x40,
  0x02, 0x01, 0xC0, 0x60, 0x06, 0x01, 0xC0, 0x20, 0x06, 0x01, 0xC0, 0x30,
  0x04, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0x10, 0x0C, 0x01, 0xC0, 0x18,
  0x08, 0x01, 0xC0, 0x18, 0x18, 0x01, 0xC0, 0x08, 0x10, 0x01, 0xC0, 0x0C,
  0x10, 0x01, 0xC0, 0x04, 0x30, 0x01, 0xC0, 0x06, 0x20, 0x01, 0xC0, 0x06,
  0x60, 0x01, 0xC0, 0x02, 0x60, 0x01, 0xC0, 0x03, 0x40, 0x01, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xD0, 0x00,
  0x01, 0xD8, 0x00, 0x01, 0xC8, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xC6, 0x00,
  0x01, 0xC2, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x00, 0x01, 0xC1, 0x80,
  0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x40, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x20,
  0x01, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x0C,
  0x01, 0xC0, 0x04, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03,
  0x01, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0x81, 0xC0, 0x00, 0xC1, 0xC0, 0x00,
  0x61, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x11, 0xC0, 0x00,
  0x19, 0xC0, 0x00, 0x09, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x00, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0xF0, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C,
  0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x38, 0xC0, 0x1E, 0x0F, 0xFF, 0x80,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xFF,
  0xFC, 0x03, 0x00, 0x3C, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x13,
  0x00, 0x00, 0x4C, 0x00, 0x01, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x0C, 0x00, 0x18, 0x30, 0x03, 0xC0, 0xFF, 0xFC, 0x03, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x08,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x03, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x40, 0x00, 0x63, 0x80, 0x0E, 0x0F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02,
  0x40, 0x00, 0x03, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x01,
  0x81, 0xC0, 0x01, 0x80, 0x38, 0x03, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x50,
  0x00, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x01, 0x00, 0x01, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0xD0,
  0x00, 0x05, 0x00, 0x00, 0x4C, 0x00, 0x02, 0x80, 0x00, 0x26, 0x00, 0x01,
  0x40, 0x00, 0x31, 0x00, 0x01, 0xB0, 0x00, 0x18, 0x80, 0x00, 0xD8, 0x00,
  0x08, 0x60, 0x00, 0x44, 0x00, 0x04, 0x30, 0x00, 0x22, 0x00, 0x06, 0x08,
  0x00, 0x31, 0x80, 0x03, 0x04, 0x00, 0x18, 0xC0, 0x01, 0x03, 0x00, 0x08,
  0x20, 0x00, 0x81, 0x80, 0x04, 0x10, 0x00, 0xC0, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0x20, 0x03, 0x06, 0x00, 0x20, 0x18, 0x01, 0x01, 0x00, 0x10, 0x0C,
  0x00, 0x80, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x30, 0x04, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x60, 0x10, 0x04, 0x03,
  0x00, 0x10, 0x18, 0x03, 0x01, 0x80, 0x08, 0x0C, 0x01, 0x80, 0x80, 0x06,
  0x06, 0x00, 0x40, 0x40, 0x03, 0x02, 0x00, 0x20, 0x60, 0x00, 0x81, 0x00,
  0x18, 0x30, 0x00, 0x41, 0x80, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x02, 0x18,
  0x00, 0x18, 0x40, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00, 0xC6, 0x00, 0x02,
  0x30, 0x00, 0x62, 0x00, 0x01, 0x98, 0x00, 0x13, 0x00, 0x00, 0xC8, 0x00,
  0x09, 0x80, 0x00, 0x24, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x03, 0x40,
  0x00, 0x0F, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x04, 0x00, 0x18, 0x06, 0x00, 0x30, 0x02, 0x00, 0x20, 0x03, 0x00, 0x60,
  0x01, 0x00, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x00, 0xC1, 0x80,
  0x00, 0x41, 0x00, 0x00, 0x63, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x62, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x00, 0x40, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x62, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x81, 0x80, 0x01, 0x80, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x10, 0x18,
  0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x20,
  0x00, 0xFF, 0xC0, 0x70, 0x0E, 0x08, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0xF8, 0x3E, 0x03,
  0x1C, 0x00, 0x67, 0x00, 0x0C, 0x80, 0x01, 0xB0, 0x00, 0x34, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00, 0xE8, 0x00, 0x15,
  0x80, 0x04, 0x98, 0x01, 0x93, 0x80, 0xE2, 0x1F, 0xF0, 0x40, 0x20, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x06, 0x00, 0x41, 0xFF,
  0x02, 0x38, 0x0E, 0x13, 0x00, 0x18, 0xB0, 0x00, 0x45, 0x00, 0x03, 0x38,
  0x00, 0x09, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x60, 0x00, 0x0A, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x14, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x02, 0x70, 0x00, 0x32, 0xC0, 0x03, 0x13, 0x00, 0x30, 0x8C, 0x07, 0x04,
  0x3F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xF0, 0x38, 0x04,
  0x38, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0xC0, 0xFF,
  0xF0, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x03,
  0x00, 0x81, 0xFF, 0x84, 0x18, 0x06, 0x21, 0x80, 0x19, 0x18, 0x00, 0x69,
  0x80, 0x01, 0x48, 0x00, 0x0E, 0xC0, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0x98, 0x00, 0x14, 0xC0, 0x01, 0xA3, 0x00, 0x19,
  0x0E, 0x03, 0x88, 0x1F, 0xF0, 0x40, 0x08, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0xE0, 0x06, 0x03, 0x80, 0xC0, 0x0C, 0x18, 0x00, 0x43, 0x00, 0x06, 0x20,
  0x00, 0x26, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x07, 0x00, 0xE0, 0x3F, 0xFC, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0x01, 0xC2, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x41, 0x80, 0x62, 0x18, 0x00,
  0x91, 0x80, 0x06, 0x98, 0x00, 0x1C, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40,
  0x00, 0x1A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0D,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x39, 0x80, 0x01, 0x4C, 0x00,
  0x1A, 0x30, 0x01, 0x90, 0xE0, 0x38, 0x81, 0xFF, 0x04, 0x00, 0x80, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0xC1, 0xE0, 0x1C, 0x03, 0xFF, 0x80, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x06, 0x01, 0x0F, 0xFC, 0x23, 0x80, 0xC4, 0xC0, 0x0C, 0xB0, 0x00, 0xD4,
  0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x5F,
  0xA0, 0x00, 0x00, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x01, 0x01, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x91,
  0xCF, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x1A, 0x00, 0x19, 0x00, 0x08,
  0x80, 0x0C, 0x40, 0x0C, 0x20, 0x0C, 0x10, 0x0C, 0x08, 0x04, 0x04, 0x06,
  0x02, 0x06, 0x01, 0x06, 0x00, 0x86, 0x00, 0x43, 0x00, 0x22, 0xC0, 0x13,
  0x20, 0x0B, 0x18, 0x05, 0x06, 0x03, 0x01, 0x01, 0x00, 0xC0, 0x80, 0x30,
  0x40, 0x08, 0x20, 0x06, 0x10, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x32, 0x00,
  0x09, 0x00, 0x06, 0x80, 0x01, 0x40, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x43, 0xFC, 0x07, 0xFC, 0x27, 0x03,
  0x07, 0x03, 0x12, 0x00, 0xC6, 0x00, 0xCA, 0x00, 0x36, 0x00, 0x37, 0x00,
  0x0A, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x05, 0x80, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x10, 0xFF, 0xC2, 0x38,
  0x0C, 0x4C, 0x00, 0xCB, 0x00, 0x0D, 0x40, 0x00, 0xB0, 0x00, 0x16, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x40, 0x00, 0x09, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0x98, 0x00, 0x06,
  0x20, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x02, 0x03, 0x00, 0x18, 0x06,
  0x01, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x04, 0x1F,
  0xF0, 0x23, 0x80, 0xE1, 0x30, 0x01, 0x8B, 0x00, 0x06, 0x50, 0x00, 0x33,
  0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x06, 0xE0,
  0x00, 0x25, 0x00, 0x03, 0x2C, 0x00, 0x31, 0x30, 0x03, 0x08, 0xE0, 0x30,
  0x43, 0xFF, 0x02, 0x01, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x41, 0x80, 0xE2, 0x18, 0x01, 0x91,
  0x80, 0x06, 0x98, 0x00, 0x14, 0x80, 0x00, 0xEC, 0x00, 0x03, 0x40, 0x00,
  0x1A, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x00,
  0x00, 0x68, 0x00, 0x03, 0x60, 0x00, 0x29, 0x00, 0x01, 0x4C, 0x00, 0x12,
  0x30, 0x01, 0x90, 0xE0, 0x38, 0x81, 0xFF, 0x04, 0x01, 0xC0, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x87, 0xFC, 0x60, 0x26, 0x01, 0x60,
  0x0A, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xC1, 0xC0,
  0x18, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1A, 0x00, 0x0E, 0xF0, 0x07, 0x0F,
  0xFF, 0x00, 0x28, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x1F, 0xFF, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x07, 0xF0, 0x04, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x74, 0x00, 0x07, 0x60, 0x00, 0xB6, 0x00, 0x1B, 0x30, 0x03,
  0x31, 0xC0, 0x63, 0x0F, 0xFC, 0x30, 0x18, 0x00, 0xC0, 0x00, 0x1A, 0x00,
  0x00, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x30,
  0xC0, 0x01, 0x82, 0x00, 0x08, 0x10, 0x00, 0xC0, 0xC0, 0x06, 0x02, 0x00,
  0x20, 0x10, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x00,
  0xC0, 0x60, 0x02, 0x02, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x02, 0x08,
  0x00, 0x10, 0xC0, 0x00, 0xC6, 0x00, 0x02, 0x20, 0x00, 0x13, 0x00, 0x00,
  0xD8, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x03, 0x60,
  0x02, 0x60, 0x02, 0x20, 0x06, 0x20, 0x02, 0x20, 0x06, 0x20, 0x06, 0x30,
  0x04, 0x30, 0x04, 0x30, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x0C, 0x10,
  0x0C, 0x18, 0x0C, 0x18, 0x08, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x08, 0x18, 0x0C, 0x18, 0x0C, 0x10, 0x0C, 0x10, 0x0C, 0x10, 0x04,
  0x10, 0x04, 0x30, 0x04, 0x30, 0x04, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06,
  0x20, 0x06, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03,
  0x60, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0x40, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x31,
  0x00, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x01, 0x80, 0x80, 0x08, 0x06, 0x00,
  0xC0, 0x10, 0x0C, 0x00, 0xC0, 0x40, 0x03, 0x06, 0x00, 0x08, 0x20, 0x00,
  0x63, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0A, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0x40, 0x00, 0x43, 0x00, 0x06,
  0x0C, 0x00, 0x20, 0x20, 0x03, 0x01, 0x80, 0x30, 0x06, 0x01, 0x00, 0x10,
  0x18, 0x00, 0xC1, 0x80, 0x02, 0x08, 0x00, 0x18, 0xC0, 0x00, 0x6C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x04, 0x40, 0x00,
  0x62, 0x00, 0x03, 0x18, 0x00, 0x10, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x18,
  0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x30, 0x18, 0x01, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x04, 0x00, 0x40, 0x60, 0x02, 0x03, 0x00, 0x18,
  0x10, 0x00, 0x41, 0x80, 0x02, 0x0C, 0x00, 0x18, 0x40, 0x00, 0x46, 0x00,
  0x02, 0x30, 0x00, 0x19, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x8E,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x01, 0xC0, 0x3C,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x3F,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1C, 0x07, 0x80, 0xE0,
  0x07, 0xDE, 0x80, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 39, 12, 4, -39 },
  { 16, 9, 14, 17, 4, -39 },
  { 32, 29, 39, 31, 1, -39 },
  { 174, 21, 45, 28, 3, -42 },
  { 293, 33, 41, 39, 3, -40 },
  { 463, 28, 41, 32, 3, -40 },
  { 607, 2, 14, 9, 4, -39 },
  { 611, 10, 48, 14, 2, -39 },
  { 671, 10, 48, 14, 2, -39 },
  { 731, 20, 19, 26, 3, -42 },
  { 779, 23, 25, 28, 2, -32 },
  { 851, 5, 13, 10, 2, -6 },
  { 860, 13, 2, 17, 2, -16 },
  { 864, 3, 3, 11, 4, -3 },
  { 866, 16, 39, 18, 1, -39 },
  { 944, 22, 41, 28, 3, -40 },
  { 1057, 11, 39, 28, 5, -39 },
  { 1111, 21, 40, 28, 3, -40 },
  { 1216, 22, 41, 28, 2, -40 },
  { 1329, 26, 39, 28, 1, -39 },
  { 1456, 21, 40, 28, 4, -39 },
  { 1561, 22, 41, 28, 3, -40 },
  { 1674, 22, 39, 28, 3, -39 },
  { 1782, 22, 41, 28, 3, -40 },
  { 1895, 21, 41, 28, 3, -40 },
  { 2003, 3, 29, 11, 4, -29 },
  { 2014, 5, 36, 11, 2, -29 },
  { 2037, 22, 24, 28, 3, -32 },
  { 2103, 23, 13, 28, 2, -26 },
  { 2141, 22, 24, 28, 3, -32 },
  { 2207, 16, 40, 20, 2, -40 },
  { 2287, 37, 44, 43, 3, -39 },
  { 2491, 28, 39, 28, 0, -39 },
  { 2628, 22, 39, 30, 5, -39 },
  { 2736, 25, 41, 30, 3, -40 },
  { 2865, 25, 39, 34, 5, -39 },
  { 2987, 19, 39, 27, 5, -39 },
  { 3080, 19, 39, 24, 5, -39 },
  { 3173, 29, 41, 36, 3, -40 },
  { 3322, 24, 39, 34, 5, -39 },
  { 3439, 8, 39, 14, 3, -39 },
  { 3478, 11, 49, 12, -4, -39 },
  { 3546, 22, 39, 27, 5, -39 },
  { 3654, 18, 39, 25, 5, -39 },
  { 3742, 32, 39, 42, 5, -39 },
  { 3898, 24, 39, 34, 5, -39 },
  { 4015, 30, 41, 37, 3, -40 },
  { 4169, 20, 39, 28, 5, -39 },
  { 4267, 30, 49, 37, 3, -40 },
  { 4451, 22, 39, 28, 5, -39 },
  { 4559, 21, 41, 27, 3, -40 },
  { 4667, 24, 39, 24, 0, -39 },
  { 4784, 25, 40, 35, 5, -39 },
  { 4909, 27, 39, 27, 0, -39 },
  { 5041, 41, 39, 43, 1, -39 },
  { 5241, 24, 39, 24, 0, -39 },
  { 5358, 24, 39, 24, 0, -39 },
  { 5475, 23, 39, 27, 2, -39 },
  { 5588, 10, 48, 17, 5, -39 },
  { 5648, 16, 39, 18, 1, -39 },
  { 5726, 10, 48, 17, 2, -39 },
  { 5786, 24, 22, 28, 2, -39 },
  { 5852, 22, 1, 22, 0, 5 },
  { 5855, 9, 9, 13, 2, -42 },
  { 5866, 19, 31, 25, 2, -30 },
  { 5940, 21, 43, 29, 5, -42 },
  { 6053, 18, 31, 23, 3, -30 },
  { 6123, 21, 43, 29, 3, -42 },
  { 6236, 20, 31, 26, 3, -30 },
  { 6314, 16, 42, 14, 1, -42 },
  { 6398, 21, 43, 29, 3, -30 },
  { 6511, 19, 42, 28, 5, -42 },
  { 6611, 3, 40, 11, 4, -40 },
  { 6626, 9, 53, 11, -2, -40 },
  { 6686, 17, 42, 22, 5, -42 },
  { 6776, 1, 42, 11, 5, -42 },
  { 6782, 33, 30, 42, 5, -30 },
  { 6906, 19, 30, 28, 5, -30 },
  { 6978, 22, 31, 28, 3, -30 },
  { 7064, 21, 43, 29, 5, -30 },
  { 7177, 21, 43, 29, 3, -30 },
  { 7290, 13, 29, 18, 5, -29 },
  { 7338, 18, 31, 22, 2, -30 },
  { 7408, 13, 37, 15, 1, -36 },
  { 7469, 20, 30, 28, 4, -29 },
  { 7544, 21, 29, 21, 0, -29 },
  { 7621, 32, 29, 34, 1, -29 },
  { 7737, 21, 29, 23, 1, -29 },
  { 7814, 21, 42, 21, 0, -29 },
  { 7925, 17, 29, 21, 2, -29 },
  { 7987, 14, 48, 19, 2, -39 },
  { 8071, 2, 56, 26, 12, -42 },
  { 8085, 15, 48, 19, 2, -39 },
  { 8175, 22, 5, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_Thin55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_THIN55PT7B_H_
