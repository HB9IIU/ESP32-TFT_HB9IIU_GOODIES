#ifndef _NOTOSANS_SEMICONDENSED_THIN31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin31pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0x70, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10,
  0x04, 0x10, 0x7F, 0xFF, 0x04, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40, 0x04, 0x00, 0x80, 0x7E,
  0x32, 0x28, 0x41, 0x08, 0x21, 0x04, 0x20, 0x84, 0x10, 0x81, 0x10, 0x1A,
  0x00, 0xC0, 0x0E, 0x01, 0x30, 0x23, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10,
  0x42, 0x08, 0xB9, 0x60, 0xF0, 0x04, 0x00, 0x80, 0x7C, 0x06, 0x21, 0x01,
  0x08, 0x20, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x08, 0x21, 0x02,
  0x08, 0x80, 0x82, 0x23, 0x20, 0x93, 0x28, 0x24, 0x86, 0x12, 0x41, 0x6C,
  0x90, 0x44, 0x44, 0x10, 0x11, 0x04, 0x08, 0x41, 0x02, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x08, 0x86, 0x03, 0xE0, 0x1F, 0x80,
  0x40, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x08,
  0x40, 0x11, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x10, 0x04, 0x10, 0x30, 0x30,
  0x60, 0x21, 0x40, 0x22, 0x80, 0x25, 0x00, 0x32, 0x00, 0x64, 0x01, 0x44,
  0x04, 0x47, 0xF0, 0x40, 0xFF, 0x0C, 0x21, 0x04, 0x20, 0x84, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x40, 0xC1, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x08, 0x21, 0x08, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x08, 0x46, 0xEF, 0x03, 0x00, 0x50, 0x12, 0x04,
  0x21, 0x82, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x25, 0x25, 0x20, 0xFE, 0x70, 0x01, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x00, 0x1F, 0x82, 0x04, 0x40,
  0x24, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40,
  0x24, 0x04, 0x20, 0x41, 0xF8, 0x0C, 0x72, 0x51, 0x84, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x3F, 0x8C,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0x3F, 0xC6, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x06, 0x07,
  0xE0, 0x00, 0x80, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x28, 0x02, 0x3F, 0xE0, 0x00, 0x60, 0x01, 0x80, 0x0A,
  0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x88, 0x02, 0x3F, 0xFF, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x7F, 0xE4,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x07,
  0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x80, 0x47, 0xF8, 0x0F, 0xE1, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x87, 0x09, 0x8C, 0xA0, 0x2C,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x14,
  0x02, 0x20, 0x41, 0xF8, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x3F, 0x84, 0x04, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x40, 0x24,
  0x04, 0x20, 0x81, 0xB0, 0x0E, 0x03, 0x18, 0x40, 0x4C, 0x02, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x43, 0xF8, 0x3F, 0x84,
  0x04, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x34, 0x05, 0x31, 0x90, 0xE1, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x07, 0xE0, 0xD0, 0x00, 0x00, 0x07, 0x64,
  0x00, 0x00, 0x00, 0x00, 0x4A, 0x4A, 0x40, 0x00, 0x08, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x02, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x80, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x00, 0x00, 0x00, 0x01, 0x01, 0x80, 0x01, 0xFC, 0x00, 0x30, 0x18,
  0x02, 0x00, 0x20, 0x20, 0x00, 0x82, 0x00, 0x02, 0x20, 0x00, 0x11, 0x01,
  0xE0, 0x50, 0x30, 0x82, 0x81, 0x04, 0x14, 0x10, 0x20, 0xA0, 0x81, 0x03,
  0x08, 0x08, 0x18, 0x40, 0x40, 0xC2, 0x02, 0x0A, 0x10, 0x10, 0x50, 0x80,
  0x82, 0x82, 0x0C, 0x14, 0x08, 0x93, 0x20, 0x18, 0x60, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0xC0, 0x03, 0xF8,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x08, 0x1F, 0xF8, 0x20, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0xFF, 0x88, 0x06,
  0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x0C,
  0xFF, 0x88, 0x06, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x02, 0x80, 0x4F, 0xF8, 0x07, 0xFC, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0xFF, 0x82, 0x01,
  0x88, 0x03, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x08, 0x80, 0xC3, 0xFC, 0x00,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0F, 0xFE, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xFE, 0x08, 0x01,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01,
  0x08, 0x01, 0x07, 0xFE, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x2F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x2F, 0x00,
  0x80, 0x38, 0x02, 0x80, 0x48, 0x08, 0x81, 0x08, 0x20, 0x84, 0x08, 0xC0,
  0x88, 0x09, 0x00, 0xA8, 0x0C, 0x40, 0x84, 0x08, 0x20, 0x82, 0x08, 0x10,
  0x80, 0x88, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F,
  0xF0, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x80, 0x05, 0xA0, 0x01,
  0x68, 0x00, 0x59, 0x00, 0x26, 0x40, 0x09, 0x90, 0x04, 0x62, 0x01, 0x18,
  0x80, 0x46, 0x10, 0x21, 0x84, 0x08, 0x61, 0x02, 0x18, 0x21, 0x06, 0x08,
  0x41, 0x82, 0x20, 0x60, 0x48, 0x18, 0x12, 0x06, 0x05, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x68, 0x01, 0xA0, 0x06,
  0x40, 0x18, 0x80, 0x62, 0x01, 0x84, 0x06, 0x10, 0x18, 0x20, 0x60, 0x41,
  0x81, 0x06, 0x02, 0x18, 0x08, 0x60, 0x11, 0x80, 0x26, 0x00, 0x98, 0x01,
  0x60, 0x05, 0x80, 0x0E, 0x00, 0x10, 0x0F, 0xF0, 0x08, 0x06, 0x08, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x02, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00, 0x84, 0x00,
  0x81, 0x80, 0x80, 0x3F, 0x80, 0xFF, 0x10, 0x1A, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x41, 0xCF, 0x41, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00,
  0x0F, 0xF0, 0x08, 0x06, 0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x12, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x88, 0x00, 0x84, 0x00, 0x81, 0x00, 0xC0, 0x7F, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0xFF, 0x08,
  0x0C, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x04, 0x80, 0x8F, 0xF0, 0x82, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0x88,
  0x04, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x3F, 0xE4, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x4F, 0xF8, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x90, 0x02, 0x20, 0x10, 0x7F, 0x80, 0x80, 0x03,
  0x00, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10,
  0x04, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x82, 0x01, 0x04,
  0x01, 0x08, 0x02, 0x20, 0x04, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0A, 0x00, 0xC0,
  0x12, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x09, 0x01, 0x10, 0x12, 0x02,
  0x10, 0x22, 0x04, 0x20, 0x44, 0x08, 0x41, 0x08, 0x20, 0x82, 0x10, 0x40,
  0x84, 0x10, 0x81, 0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x40, 0x88, 0x04,
  0x80, 0x90, 0x09, 0x01, 0x20, 0x14, 0x02, 0x80, 0x28, 0x05, 0x00, 0x30,
  0x0A, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x00, 0x40, 0x08, 0x80, 0x42,
  0x01, 0x04, 0x08, 0x10, 0x20, 0x21, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80,
  0x0C, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x80, 0x12, 0x00, 0x84, 0x02, 0x10,
  0x10, 0x20, 0x40, 0x82, 0x01, 0x10, 0x04, 0x40, 0x0A, 0x00, 0x30, 0x80,
  0x0A, 0x00, 0x50, 0x04, 0x40, 0x22, 0x02, 0x08, 0x10, 0x41, 0x01, 0x08,
  0x08, 0x40, 0x44, 0x01, 0x20, 0x0A, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x7F,
  0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x1F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x48, 0x01,
  0x20, 0x08, 0x40, 0x21, 0x01, 0x02, 0x04, 0x08, 0x20, 0x10, 0x80, 0x44,
  0x00, 0xA0, 0x03, 0xFF, 0xF0, 0x82, 0x08, 0x20, 0x80, 0x0F, 0x06, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x0F, 0xE6, 0x05, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xD0, 0x1A, 0x05, 0x3F, 0x20, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x70, 0xB0, 0x8C, 0x04,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0xC0, 0xCB, 0xF0, 0x07, 0x86, 0x12,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0xF1, 0x30, 0x94, 0x05, 0x40, 0x38,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x34, 0x03, 0x60, 0x51, 0xF9, 0x07, 0x06, 0x11, 0x81, 0x20,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x10, 0x01, 0x01, 0x1F, 0xC0, 0x07, 0x84, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0xFE, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0E, 0x03,
  0x09, 0x40, 0x54, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x40, 0x36, 0x05, 0x1F, 0x90,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x80, 0x47, 0xF8, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x38, 0xB1, 0xB0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xD0, 0x05, 0x55, 0x55, 0x55, 0x50, 0x18, 0x40,
  0x00, 0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x44, 0x2F, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x02, 0x81, 0x20, 0x48, 0x22, 0x10, 0x88, 0x24, 0x09, 0x02,
  0xC0, 0xC8, 0x21, 0x08, 0x42, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x03, 0xFF,
  0xFF, 0xFF, 0x1E, 0x06, 0x28, 0x44, 0x6C, 0x0A, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20,
  0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06,
  0x02, 0x01, 0x80, 0x80, 0x40, 0x0E, 0x2C, 0x6C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x0E, 0x03, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02,
  0x40, 0x22, 0x04, 0x1F, 0x80, 0x0F, 0x0B, 0x08, 0xC0, 0x4C, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x28, 0x02, 0xC0, 0x4E, 0x04, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0x03, 0x09, 0x40, 0x54, 0x03, 0x80,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x40, 0x56, 0x05, 0x3F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x0D, 0x67, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x0E, 0x0C, 0x34, 0x01,
  0x00, 0x80, 0x10, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x06, 0x02, 0x7F, 0x00, 0x10, 0x10, 0x20, 0x20, 0xDF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xD0, 0x29, 0xF9,
  0x80, 0x34, 0x02, 0x40, 0x24, 0x02, 0x20, 0x42, 0x04, 0x20, 0x41, 0x08,
  0x10, 0x81, 0x08, 0x09, 0x00, 0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x40,
  0xC0, 0x40, 0x28, 0x0C, 0x09, 0x01, 0x81, 0x20, 0x50, 0x22, 0x09, 0x04,
  0x41, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x11, 0x08, 0x82, 0x21, 0x20,
  0x48, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x50, 0x18, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x10, 0xC0, 0x68, 0x08, 0x82, 0x10, 0x41, 0x10, 0x14, 0x02, 0x80,
  0x20, 0x0A, 0x01, 0x40, 0x44, 0x10, 0x82, 0x08, 0x80, 0x90, 0x14, 0x01,
  0x80, 0x14, 0x02, 0x40, 0x24, 0x02, 0x20, 0x42, 0x04, 0x20, 0x41, 0x08,
  0x10, 0x81, 0x08, 0x09, 0x00, 0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0xB0, 0x04, 0x00,
  0x7F, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x03, 0xFF, 0x07, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x30, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0xE0, 0x7E, 0x0C, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Thin31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 22, 7, 2, -22 },
  { 7, 5, 8, 10, 2, -22 },
  { 12, 16, 22, 18, 1, -22 },
  { 56, 11, 26, 16, 2, -24 },
  { 92, 18, 22, 22, 2, -22 },
  { 142, 15, 22, 18, 2, -22 },
  { 184, 1, 8, 5, 2, -22 },
  { 185, 6, 27, 8, 1, -22 },
  { 206, 6, 27, 8, 1, -22 },
  { 227, 11, 11, 15, 2, -24 },
  { 243, 13, 14, 16, 1, -18 },
  { 266, 3, 7, 6, 1, -3 },
  { 269, 7, 1, 9, 1, -9 },
  { 270, 2, 2, 6, 2, -2 },
  { 271, 9, 22, 10, 1, -22 },
  { 296, 12, 22, 16, 2, -22 },
  { 329, 6, 22, 16, 3, -22 },
  { 346, 12, 22, 16, 2, -22 },
  { 379, 13, 22, 16, 1, -22 },
  { 415, 14, 22, 16, 1, -22 },
  { 454, 12, 22, 16, 2, -22 },
  { 487, 12, 22, 16, 2, -22 },
  { 520, 12, 22, 16, 2, -22 },
  { 553, 12, 22, 16, 2, -22 },
  { 586, 12, 22, 16, 2, -22 },
  { 619, 2, 16, 6, 2, -16 },
  { 623, 3, 20, 6, 1, -16 },
  { 631, 13, 14, 16, 1, -18 },
  { 654, 13, 8, 16, 1, -15 },
  { 667, 13, 14, 16, 1, -18 },
  { 690, 9, 22, 11, 1, -22 },
  { 715, 21, 25, 24, 2, -22 },
  { 781, 16, 22, 16, 0, -22 },
  { 825, 12, 22, 17, 3, -22 },
  { 858, 14, 22, 17, 2, -22 },
  { 897, 14, 22, 19, 3, -22 },
  { 936, 10, 22, 15, 3, -22 },
  { 964, 10, 22, 14, 3, -22 },
  { 992, 16, 22, 20, 2, -22 },
  { 1036, 13, 22, 19, 3, -22 },
  { 1072, 4, 22, 8, 2, -22 },
  { 1083, 6, 27, 7, -2, -22 },
  { 1104, 12, 22, 15, 3, -22 },
  { 1137, 10, 22, 14, 3, -22 },
  { 1165, 18, 22, 24, 3, -22 },
  { 1215, 14, 22, 19, 3, -22 },
  { 1254, 17, 22, 21, 2, -22 },
  { 1301, 11, 22, 16, 3, -22 },
  { 1332, 17, 27, 21, 2, -22 },
  { 1390, 12, 22, 16, 3, -22 },
  { 1423, 12, 22, 15, 2, -22 },
  { 1456, 14, 22, 14, 0, -22 },
  { 1495, 14, 22, 20, 3, -22 },
  { 1534, 15, 22, 15, 0, -22 },
  { 1576, 23, 22, 24, 1, -22 },
  { 1640, 14, 22, 14, 0, -22 },
  { 1679, 13, 22, 13, 0, -22 },
  { 1715, 13, 22, 15, 1, -22 },
  { 1751, 6, 27, 10, 3, -22 },
  { 1772, 9, 22, 10, 1, -22 },
  { 1797, 6, 27, 10, 1, -22 },
  { 1818, 14, 12, 16, 1, -22 },
  { 1839, 12, 1, 12, 0, 3 },
  { 1841, 5, 5, 7, 1, -24 },
  { 1845, 11, 17, 14, 1, -17 },
  { 1869, 12, 24, 16, 3, -24 },
  { 1905, 10, 17, 13, 2, -17 },
  { 1927, 12, 24, 16, 2, -24 },
  { 1963, 11, 17, 15, 2, -17 },
  { 1987, 9, 24, 8, 0, -24 },
  { 2014, 12, 24, 16, 2, -17 },
  { 2050, 10, 24, 16, 3, -24 },
  { 2080, 2, 22, 6, 2, -22 },
  { 2086, 5, 29, 6, -1, -22 },
  { 2105, 10, 24, 13, 3, -24 },
  { 2135, 1, 24, 6, 3, -24 },
  { 2138, 18, 17, 24, 3, -17 },
  { 2177, 10, 17, 16, 3, -17 },
  { 2199, 12, 17, 16, 2, -17 },
  { 2225, 12, 24, 16, 3, -17 },
  { 2261, 12, 24, 16, 2, -17 },
  { 2297, 7, 17, 10, 3, -17 },
  { 2312, 10, 17, 13, 1, -17 },
  { 2334, 8, 20, 9, 0, -20 },
  { 2354, 11, 16, 16, 2, -16 },
  { 2376, 12, 16, 12, 0, -16 },
  { 2400, 19, 16, 19, 0, -16 },
  { 2438, 11, 16, 13, 1, -16 },
  { 2460, 12, 24, 12, 0, -16 },
  { 2496, 10, 16, 12, 1, -16 },
  { 2516, 8, 27, 11, 1, -22 },
  { 2543, 1, 32, 15, 7, -24 },
  { 2547, 8, 27, 11, 1, -22 },
  { 2574, 13, 2, 16, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Thin31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_THIN31PT7B_H_
