#ifndef _NOTOSANS_SEMICONDENSED_THIN49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin49pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x54, 0x00, 0xFC, 0xC1, 0xE0,
  0xF0, 0x78, 0x34, 0x1A, 0x0D, 0x06, 0x83, 0x41, 0xA0, 0xD0, 0x28, 0x14,
  0x08, 0x00, 0x20, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x04,
  0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00,
  0x80, 0x20, 0x00, 0x40, 0x30, 0x00, 0x20, 0x18, 0x00, 0x30, 0x08, 0x07,
  0xFF, 0xFF, 0xF0, 0x08, 0x02, 0x00, 0x04, 0x01, 0x00, 0x02, 0x01, 0x80,
  0x01, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x10,
  0x00, 0x20, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x02,
  0x01, 0xFF, 0xFF, 0xFE, 0x02, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x80,
  0x20, 0x00, 0x40, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x08, 0x00, 0x10,
  0x04, 0x00, 0x08, 0x02, 0x00, 0x04, 0x01, 0x00, 0x02, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x3F, 0xF8,
  0x38, 0x83, 0x98, 0x20, 0x04, 0x08, 0x03, 0x02, 0x00, 0x80, 0x80, 0x20,
  0x20, 0x08, 0x08, 0x02, 0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x0C, 0x08,
  0x01, 0x82, 0x00, 0x30, 0x80, 0x03, 0x20, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0xB8, 0x00, 0x23, 0x80, 0x08, 0x30, 0x02, 0x06, 0x00, 0x80, 0x80,
  0x20, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x0C, 0x02, 0x02, 0x00, 0x81, 0xA0, 0x20, 0xCE, 0x08, 0xE0, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x1F, 0x80, 0x02,
  0x01, 0x06, 0x00, 0x30, 0x18, 0x10, 0x01, 0x00, 0x80, 0xC0, 0x18, 0x0C,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x06,
  0x06, 0x00, 0x80, 0x30, 0x20, 0x04, 0x01, 0x81, 0x00, 0x20, 0x0C, 0x10,
  0x01, 0x00, 0x60, 0x80, 0x08, 0x03, 0x08, 0x00, 0x40, 0x18, 0x40, 0x02,
  0x00, 0x86, 0x3F, 0x10, 0x04, 0x23, 0x04, 0xC0, 0x23, 0x10, 0x32, 0x03,
  0x11, 0x80, 0x98, 0x11, 0x88, 0x06, 0x41, 0x88, 0x40, 0x11, 0xF8, 0xC6,
  0x00, 0x80, 0x04, 0x30, 0x04, 0x00, 0x61, 0x80, 0x20, 0x02, 0x0C, 0x01,
  0x00, 0x30, 0x60, 0x08, 0x01, 0x03, 0x00, 0x40, 0x08, 0x18, 0x02, 0x00,
  0x80, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x30, 0x06, 0x02, 0x01, 0x00, 0x10, 0x30, 0x18, 0x00, 0xC1,
  0x00, 0x80, 0x03, 0xF0, 0x00, 0x40, 0x00, 0x01, 0xFC, 0x00, 0x01, 0x83,
  0x00, 0x01, 0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x06,
  0x00, 0xC0, 0x01, 0x00, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x90, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x33, 0x00, 0xC0,
  0x11, 0x00, 0x30, 0x09, 0x80, 0x08, 0x04, 0x80, 0x02, 0x06, 0x40, 0x01,
  0x82, 0x20, 0x00, 0x61, 0x10, 0x00, 0x19, 0x08, 0x00, 0x07, 0x84, 0x00,
  0x01, 0x82, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xF0, 0x40, 0x00, 0xCC, 0x10,
  0x00, 0xC3, 0x06, 0x01, 0x80, 0x81, 0xFF, 0x80, 0x30, 0xFD, 0x55, 0x55,
  0x40, 0x01, 0x81, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10,
  0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80,
  0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x60, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x06, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03, 0x82, 0x0E,
  0x79, 0x1C, 0x03, 0xF0, 0x00, 0x40, 0x00, 0x50, 0x00, 0x44, 0x00, 0x61,
  0x00, 0x20, 0xC0, 0x20, 0x20, 0x20, 0x08, 0x30, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x01, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x33,
  0x32, 0x26, 0x64, 0x4C, 0x80, 0xFF, 0xE0, 0xFC, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x81, 0x00, 0x10, 0x40, 0x01,
  0x08, 0x00, 0x23, 0x00, 0x06, 0x40, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01,
  0x60, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0B,
  0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0xC0, 0x01, 0x88, 0x00, 0x21,
  0x00, 0x0C, 0x10, 0x01, 0x03, 0x00, 0x60, 0x30, 0x18, 0x01, 0xFC, 0x00,
  0x01, 0x81, 0xC1, 0xA1, 0x93, 0x0B, 0x07, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x0F, 0xF8, 0x0E, 0x03, 0x0E, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFC, 0x07, 0x00, 0xE3, 0x80, 0x06, 0x20, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x80, 0x01, 0x9C, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0x98, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x10,
  0xC0, 0x00, 0x41, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x08, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x40, 0x30, 0x01, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x30, 0x20, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0x86, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x11, 0xFC, 0x03, 0xF0, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x80, 0x03, 0x1C, 0x01,
  0xC0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0xFF, 0x84, 0x60, 0x18, 0x98, 0x01, 0x96, 0x00, 0x1A, 0x80,
  0x01, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00,
  0x06, 0xC0, 0x00, 0x88, 0x00, 0x11, 0x80, 0x04, 0x18, 0x01, 0x81, 0x80,
  0x60, 0x0F, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFC, 0x03, 0x80, 0xC0, 0xC0,
  0x04, 0x10, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x01, 0x90, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x80, 0x02, 0x10, 0x00, 0xC3, 0x00,
  0x10, 0x30, 0x0C, 0x01, 0x83, 0x00, 0x1D, 0x80, 0x00, 0xE0, 0x00, 0x67,
  0x00, 0x30, 0x38, 0x0C, 0x01, 0x82, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00,
  0x14, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x13, 0x00, 0x06, 0x30, 0x01,
  0x83, 0x00, 0xE0, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xC0, 0x60, 0x18,
  0x01, 0x03, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00, 0x44,
  0x00, 0x06, 0x40, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02,
  0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x07, 0x60, 0x00,
  0x72, 0x00, 0x0F, 0x10, 0x01, 0xB0, 0xC0, 0x72, 0x07, 0xFC, 0x20, 0x06,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x3F, 0xF0, 0x00, 0x60, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x33, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x22, 0x66, 0x44, 0xC8, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x70,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x01, 0x18, 0x00, 0x7E, 0x00, 0x8C,
  0x00, 0xE1, 0xC0, 0x64, 0x00, 0x80, 0x60, 0x16, 0x00, 0x80, 0x30, 0x0B,
  0x00, 0xC0, 0x18, 0x05, 0x00, 0x40, 0x08, 0x02, 0x80, 0x60, 0x04, 0x01,
  0xC0, 0x20, 0x02, 0x00, 0xE0, 0x10, 0x01, 0x00, 0x70, 0x08, 0x00, 0x80,
  0x38, 0x04, 0x00, 0x40, 0x14, 0x02, 0x00, 0x20, 0x0A, 0x01, 0x00, 0x10,
  0x05, 0x00, 0x80, 0x18, 0x02, 0x80, 0x40, 0x0C, 0x03, 0x40, 0x30, 0x06,
  0x01, 0x20, 0x08, 0x05, 0x81, 0x98, 0x06, 0x06, 0x41, 0x84, 0x01, 0xFE,
  0x1F, 0x82, 0x00, 0x38, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x60, 0x00, 0x10, 0x10,
  0x00, 0x08, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x01, 0x00, 0x02, 0x00,
  0x80, 0x03, 0x00, 0x60, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x30, 0x00, 0x60, 0x10,
  0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08,
  0xC0, 0x00, 0x06, 0x40, 0x00, 0x03, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x60, 0xFF, 0xF8, 0x10, 0x07, 0xC2, 0x00, 0x0C, 0x40, 0x00, 0x48, 0x00,
  0x0D, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x03, 0x20, 0x00,
  0xC4, 0x00, 0x70, 0xFF, 0xF0, 0x10, 0x03, 0xC2, 0x00, 0x06, 0x40, 0x00,
  0x68, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x14, 0x00, 0x04, 0x80, 0x03, 0x10, 0x03, 0xC3, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x30, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x02, 0x01, 0xF8, 0x08, 0x00, 0x30, 0x20, 0x00,
  0x70, 0x80, 0x00, 0x42, 0x00, 0x01, 0x88, 0x00, 0x03, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x1A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x01,
  0x88, 0x00, 0x0C, 0x20, 0x00, 0x60, 0x80, 0x07, 0x02, 0x00, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x38, 0x01, 0xE0, 0x70, 0x00, 0x20,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x40, 0x70, 0x01,
  0xE0, 0x0F, 0xFF, 0x80, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x4F,
  0xE0, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x06, 0x40, 0x01, 0x88,
  0x00, 0x61, 0x00, 0x18, 0x20, 0x06, 0x04, 0x00, 0x80, 0x80, 0x30, 0x10,
  0x0C, 0x02, 0x03, 0x00, 0x40, 0xC0, 0x08, 0x30, 0x01, 0x0C, 0x00, 0x21,
  0x00, 0x04, 0x70, 0x00, 0x9A, 0x00, 0x16, 0x60, 0x03, 0x86, 0x00, 0x60,
  0x40, 0x08, 0x0C, 0x01, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x80, 0x80,
  0x10, 0x10, 0x03, 0x02, 0x00, 0x30, 0x40, 0x02, 0x08, 0x00, 0x61, 0x00,
  0x06, 0x20, 0x00, 0x44, 0x00, 0x0C, 0x80, 0x00, 0xD0, 0x00, 0x0A, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x05, 0xA0, 0x00, 0x00, 0xDB, 0x00, 0x00, 0x09, 0x90, 0x00, 0x00,
  0x99, 0x00, 0x00, 0x19, 0x98, 0x00, 0x01, 0x18, 0x80, 0x00, 0x11, 0x88,
  0x00, 0x03, 0x18, 0xC0, 0x00, 0x21, 0x84, 0x00, 0x06, 0x18, 0x60, 0x00,
  0x41, 0x82, 0x00, 0x04, 0x18, 0x20, 0x00, 0xC1, 0x83, 0x00, 0x08, 0x18,
  0x10, 0x00, 0x81, 0x81, 0x00, 0x18, 0x18, 0x18, 0x01, 0x01, 0x80, 0x80,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x06, 0x01,
  0x80, 0x60, 0x40, 0x18, 0x02, 0x04, 0x01, 0x80, 0x20, 0xC0, 0x18, 0x03,
  0x08, 0x01, 0x80, 0x10, 0x80, 0x18, 0x01, 0x18, 0x01, 0x80, 0x19, 0x00,
  0x18, 0x00, 0xB0, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1A, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x60, 0x00, 0x31, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x18, 0x10,
  0x00, 0xC0, 0xC0, 0x06, 0x02, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x20, 0x18, 0x01, 0x80, 0xC0, 0x04,
  0x06, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x02, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0x43, 0x00, 0x01, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x26, 0x00, 0x01,
  0xB0, 0x00, 0x05, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x04, 0x04, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x20, 0x1F, 0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01,
  0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00,
  0x04, 0x80, 0x03, 0x20, 0x03, 0x88, 0x03, 0x83, 0xFF, 0x80, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x04, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0xFF, 0xE0, 0x10, 0x07, 0x82, 0x00, 0x18, 0x40, 0x01, 0x88, 0x00,
  0x19, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0xD0, 0x00,
  0x1A, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00,
  0x44, 0x00, 0x18, 0x80, 0x06, 0x10, 0x03, 0x83, 0xFF, 0xC0, 0x40, 0x30,
  0x08, 0x02, 0x01, 0x00, 0x60, 0x20, 0x04, 0x04, 0x00, 0xC0, 0x80, 0x08,
  0x10, 0x01, 0x82, 0x00, 0x10, 0x40, 0x03, 0x08, 0x00, 0x21, 0x00, 0x06,
  0x20, 0x00, 0x64, 0x00, 0x04, 0x80, 0x00, 0xD0, 0x00, 0x0A, 0x00, 0x01,
  0x80, 0x03, 0xFF, 0x81, 0xC0, 0x1C, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x9C, 0x00, 0xE0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x4C, 0x00, 0x01, 0x88, 0x00, 0x02, 0x18, 0x00, 0x08, 0x18, 0x00,
  0x30, 0x1C, 0x01, 0x80, 0x0F, 0xFE, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x0C, 0x00,
  0x30, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x81, 0x80, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x00, 0x90, 0x00, 0x18, 0x00, 0x04, 0x80, 0x00, 0xE0, 0x00, 0x66, 0x00,
  0x0D, 0x00, 0x02, 0x30, 0x00, 0x68, 0x00, 0x10, 0x80, 0x02, 0x40, 0x00,
  0x84, 0x00, 0x13, 0x00, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x41, 0x80, 0x0C,
  0x40, 0x02, 0x04, 0x00, 0x42, 0x00, 0x30, 0x20, 0x02, 0x18, 0x01, 0x81,
  0x80, 0x30, 0x40, 0x08, 0x04, 0x01, 0x82, 0x00, 0x40, 0x20, 0x08, 0x10,
  0x06, 0x01, 0x00, 0x40, 0xC0, 0x30, 0x0C, 0x02, 0x02, 0x01, 0x00, 0x20,
  0x30, 0x10, 0x08, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x08, 0x08, 0x06, 0x06,
  0x00, 0x60, 0x40, 0x10, 0x20, 0x01, 0x06, 0x00, 0x81, 0x00, 0x08, 0x20,
  0x04, 0x18, 0x00, 0x41, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x84, 0x00,
  0x08, 0xC0, 0x04, 0x20, 0x00, 0x44, 0x00, 0x23, 0x00, 0x02, 0x20, 0x01,
  0x98, 0x00, 0x19, 0x00, 0x04, 0x80, 0x00, 0x58, 0x00, 0x24, 0x00, 0x02,
  0x80, 0x01, 0x60, 0x00, 0x14, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x06, 0x00, 0x08, 0x08, 0x00, 0x60,
  0x30, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x20, 0x02, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0x10, 0x20, 0x00, 0x61, 0x80, 0x00, 0x84, 0x00, 0x01, 0x30,
  0x00, 0x04, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x12, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x10, 0x00, 0x18,
  0x60, 0x00, 0x40, 0x80, 0x02, 0x01, 0x00, 0x18, 0x06, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x30, 0x08, 0x00, 0x40, 0x60, 0x01, 0x81, 0x00, 0x02, 0x0C,
  0x00, 0x0C, 0x60, 0x00, 0x11, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0A, 0x00, 0x00, 0xD8, 0x00, 0x04, 0x40, 0x00, 0x63, 0x00, 0x02,
  0x08, 0x00, 0x30, 0x40, 0x01, 0x03, 0x00, 0x18, 0x08, 0x00, 0x80, 0x60,
  0x04, 0x01, 0x00, 0x40, 0x0C, 0x02, 0x00, 0x20, 0x30, 0x01, 0x81, 0x00,
  0x04, 0x18, 0x00, 0x30, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x16,
  0x00, 0x00, 0xA0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0F, 0xFC, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0xFF, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F,
  0xFC, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x16, 0x00, 0x01, 0x90, 0x00,
  0x08, 0xC0, 0x00, 0xC2, 0x00, 0x04, 0x18, 0x00, 0x60, 0x40, 0x02, 0x03,
  0x00, 0x30, 0x08, 0x01, 0x00, 0x60, 0x10, 0x01, 0x00, 0x80, 0x0C, 0x08,
  0x00, 0x20, 0xC0, 0x01, 0x84, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x01,
  0xB0, 0x00, 0x05, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x04, 0x03, 0x07, 0xF8, 0x1E, 0x07, 0x08, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xF0, 0x3F, 0xD8, 0x70, 0x0C,
  0xC0, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1D, 0x00, 0x1E, 0xC0, 0x0B, 0x30, 0x19, 0x8F,
  0xF8, 0x40, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x41, 0xFE, 0x08, 0xC0, 0x61, 0x30, 0x02, 0x2C,
  0x00, 0x65, 0x00, 0x06, 0xE0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xB0, 0x00, 0x16, 0x00, 0x06, 0xA0, 0x00, 0x94, 0x00, 0x32, 0x40,
  0x0C, 0x46, 0x03, 0x08, 0x7F, 0xC0, 0x03, 0xFE, 0x06, 0x01, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x01, 0x07, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x83, 0xFC, 0x30, 0xC0, 0x66, 0x30, 0x06, 0xCC, 0x00, 0x7B, 0x00, 0x07,
  0x40, 0x00, 0xE8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1A,
  0x00, 0x07, 0x60, 0x00, 0xA4, 0x00, 0x34, 0xC0, 0x0C, 0x8E, 0x03, 0x10,
  0x7F, 0xC2, 0x07, 0xF8, 0x03, 0x03, 0x81, 0x80, 0x20, 0xC0, 0x04, 0x60,
  0x01, 0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x02, 0x0C, 0x01, 0x81, 0xFF,
  0xC0, 0x03, 0xFC, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x3F, 0xF0, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x61, 0x80, 0xCC, 0x60,
  0x0D, 0x98, 0x00, 0xF6, 0x00, 0x0E, 0x80, 0x01, 0xD0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x0E, 0xC0, 0x01, 0xC8, 0x00,
  0x59, 0x80, 0x1B, 0x1C, 0x06, 0x60, 0xFF, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x30, 0x01, 0x83, 0xE3, 0xC0, 0x07, 0xE0,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0xFF, 0x88, 0xC0, 0x64, 0xC0, 0x1A, 0xC0, 0x05, 0x40, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0xF8, 0x00, 0x2A, 0xAA,
  0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x06, 0xDC, 0x70, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x10, 0x80, 0x30,
  0x80, 0x60, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x00, 0x83, 0x00, 0x86, 0x00,
  0x8E, 0x00, 0x8B, 0x00, 0x91, 0x00, 0xA1, 0x80, 0xE0, 0x80, 0xC0, 0x40,
  0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x02, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x87,
  0xF0, 0x1F, 0xC2, 0x30, 0x61, 0xC1, 0xC9, 0x00, 0x4C, 0x01, 0x28, 0x01,
  0xA0, 0x06, 0xE0, 0x03, 0x80, 0x0B, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x30,
  0x00, 0xB0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x30, 0x83, 0xFC, 0x46, 0x03, 0x26, 0x00, 0xD6, 0x00, 0x2A, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x07, 0xFC, 0x01,
  0x80, 0xC0, 0x60, 0x04, 0x18, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x00, 0x90,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x04, 0xC0,
  0x01, 0x88, 0x00, 0x20, 0x80, 0x08, 0x0C, 0x06, 0x00, 0xFF, 0x80, 0x83,
  0xFC, 0x11, 0xC0, 0xC2, 0x60, 0x04, 0x48, 0x00, 0x4A, 0x00, 0x0D, 0x40,
  0x00, 0xB0, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x2E, 0x00,
  0x05, 0x40, 0x01, 0x2C, 0x00, 0x64, 0xC0, 0x18, 0x8C, 0x06, 0x10, 0xFF,
  0x82, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xF8, 0x21, 0x80, 0xCC, 0x60, 0x0D, 0x98, 0x00,
  0xB6, 0x00, 0x0E, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x74, 0x00, 0x0E, 0x80, 0x01, 0xC8, 0x00, 0x59, 0x80, 0x1B,
  0x18, 0x06, 0x61, 0xFF, 0x0C, 0x02, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x87, 0xF8, 0xC0, 0x90, 0x0B,
  0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0xFC,
  0x38, 0x06, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x80, 0x06, 0xC0, 0x0C,
  0x7F, 0xF0, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0xFF,
  0xF1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x15, 0x00, 0x0A, 0xC0, 0x09, 0x30, 0x18, 0x8F, 0xF8, 0x40, 0xC0, 0x00,
  0x68, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x08, 0x40, 0x03,
  0x0C, 0x00, 0x40, 0x80, 0x08, 0x10, 0x03, 0x03, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x03, 0x00, 0xC0, 0x40, 0x08, 0x08, 0x01, 0x03, 0x00, 0x20, 0x40,
  0x02, 0x08, 0x00, 0x43, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x13, 0x00,
  0x02, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x80, 0x02, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xB0, 0x01, 0x40, 0x04, 0x80,
  0x0A, 0x00, 0x24, 0x00, 0x50, 0x03, 0x20, 0x06, 0xC0, 0x11, 0x80, 0x22,
  0x00, 0x84, 0x01, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x61, 0x00, 0xC2, 0x02,
  0x0C, 0x04, 0x10, 0x10, 0x20, 0x20, 0x80, 0x81, 0x03, 0x06, 0x0C, 0x08,
  0x10, 0x10, 0x40, 0x60, 0x80, 0x82, 0x01, 0x0C, 0x04, 0x10, 0x08, 0x60,
  0x31, 0x80, 0x62, 0x00, 0x88, 0x01, 0x10, 0x04, 0x40, 0x09, 0x80, 0x32,
  0x00, 0x48, 0x00, 0xB0, 0x03, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x28, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xD8, 0x00, 0x63, 0x00, 0x10, 0x40, 0x0C, 0x18, 0x02, 0x02, 0x01,
  0x80, 0xC0, 0xC0, 0x18, 0x20, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x12, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1A, 0x00, 0x04, 0xC0, 0x02,
  0x10, 0x01, 0x82, 0x00, 0x40, 0xC0, 0x30, 0x10, 0x08, 0x06, 0x04, 0x00,
  0x83, 0x00, 0x10, 0x80, 0x06, 0x60, 0x00, 0xB0, 0x00, 0x30, 0xC0, 0x00,
  0x68, 0x00, 0x09, 0x80, 0x01, 0x10, 0x00, 0x62, 0x00, 0x08, 0x60, 0x01,
  0x04, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x01, 0x00, 0x60, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x60, 0x08, 0x08, 0x01, 0x01, 0x00, 0x10, 0x60,
  0x02, 0x08, 0x00, 0x41, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x01, 0x60, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x09,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x03, 0x80, 0x70, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0F, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x00, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x07, 0xC0, 0x38, 0x00, 0x3F, 0xC0, 0x0B,
  0x03, 0x80, 0xE0, 0x07, 0xB8, 0x00, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 35, 10, 4, -35 },
  { 10, 9, 13, 15, 3, -35 },
  { 25, 25, 35, 28, 1, -35 },
  { 135, 18, 40, 25, 3, -37 },
  { 225, 29, 35, 35, 3, -35 },
  { 352, 25, 36, 29, 3, -36 },
  { 465, 2, 13, 8, 3, -35 },
  { 469, 9, 43, 13, 2, -35 },
  { 518, 8, 43, 13, 2, -35 },
  { 561, 17, 17, 23, 3, -37 },
  { 598, 21, 23, 25, 2, -29 },
  { 659, 4, 11, 9, 2, -5 },
  { 665, 11, 1, 15, 2, -14 },
  { 667, 2, 3, 10, 4, -3 },
  { 668, 14, 35, 16, 1, -35 },
  { 730, 19, 36, 25, 3, -36 },
  { 816, 9, 35, 25, 5, -35 },
  { 856, 18, 35, 25, 3, -35 },
  { 935, 19, 35, 25, 2, -35 },
  { 1019, 23, 35, 25, 1, -35 },
  { 1120, 19, 35, 25, 3, -35 },
  { 1204, 19, 36, 25, 3, -35 },
  { 1290, 19, 35, 25, 3, -35 },
  { 1374, 19, 35, 25, 3, -35 },
  { 1458, 20, 36, 25, 2, -35 },
  { 1548, 2, 26, 10, 4, -26 },
  { 1555, 4, 32, 10, 2, -26 },
  { 1571, 21, 21, 25, 2, -28 },
  { 1627, 21, 11, 25, 2, -23 },
  { 1656, 21, 21, 25, 2, -28 },
  { 1712, 15, 35, 18, 1, -35 },
  { 1778, 33, 40, 38, 3, -35 },
  { 1943, 25, 35, 25, 0, -35 },
  { 2053, 19, 35, 27, 5, -35 },
  { 2137, 22, 35, 27, 3, -35 },
  { 2234, 22, 35, 30, 5, -35 },
  { 2331, 16, 35, 24, 5, -35 },
  { 2401, 16, 35, 22, 5, -35 },
  { 2471, 25, 36, 32, 3, -36 },
  { 2584, 21, 35, 31, 5, -35 },
  { 2676, 7, 35, 13, 3, -35 },
  { 2707, 10, 44, 11, -4, -35 },
  { 2762, 19, 35, 24, 5, -35 },
  { 2846, 16, 35, 22, 5, -35 },
  { 2916, 28, 35, 38, 5, -35 },
  { 3039, 21, 35, 31, 5, -35 },
  { 3131, 27, 36, 33, 3, -36 },
  { 3253, 18, 35, 25, 5, -35 },
  { 3332, 27, 44, 33, 3, -36 },
  { 3481, 19, 35, 25, 5, -35 },
  { 3565, 19, 35, 24, 2, -35 },
  { 3649, 22, 35, 22, 0, -35 },
  { 3746, 23, 35, 31, 4, -35 },
  { 3847, 24, 35, 24, 0, -35 },
  { 3952, 37, 35, 39, 1, -35 },
  { 4114, 22, 35, 22, 0, -35 },
  { 4211, 21, 35, 21, 0, -35 },
  { 4303, 20, 35, 24, 2, -35 },
  { 4391, 10, 43, 15, 4, -35 },
  { 4445, 14, 35, 16, 1, -35 },
  { 4507, 10, 43, 15, 1, -35 },
  { 4561, 21, 20, 25, 2, -35 },
  { 4614, 19, 2, 19, 0, 4 },
  { 4619, 8, 7, 12, 2, -37 },
  { 4626, 17, 26, 22, 2, -26 },
  { 4682, 19, 37, 26, 4, -37 },
  { 4770, 16, 26, 20, 3, -26 },
  { 4822, 19, 37, 26, 3, -37 },
  { 4910, 18, 26, 24, 3, -26 },
  { 4969, 14, 37, 12, 1, -37 },
  { 5034, 19, 38, 26, 3, -26 },
  { 5125, 17, 37, 25, 4, -37 },
  { 5204, 2, 35, 10, 4, -35 },
  { 5213, 8, 47, 10, -2, -35 },
  { 5260, 16, 37, 20, 4, -37 },
  { 5334, 1, 37, 9, 4, -37 },
  { 5339, 30, 26, 37, 4, -26 },
  { 5437, 17, 26, 25, 4, -26 },
  { 5493, 19, 26, 25, 3, -26 },
  { 5555, 19, 37, 26, 4, -26 },
  { 5643, 19, 37, 26, 3, -26 },
  { 5731, 12, 26, 16, 4, -26 },
  { 5770, 16, 26, 20, 2, -26 },
  { 5822, 12, 32, 14, 1, -32 },
  { 5870, 17, 26, 25, 4, -26 },
  { 5926, 19, 26, 19, 0, -26 },
  { 5988, 29, 26, 30, 1, -26 },
  { 6083, 18, 26, 21, 1, -26 },
  { 6142, 19, 38, 19, 0, -26 },
  { 6233, 15, 26, 19, 2, -26 },
  { 6282, 13, 43, 17, 2, -35 },
  { 6352, 1, 49, 23, 11, -37 },
  { 6359, 13, 43, 17, 2, -35 },
  { 6429, 21, 4, 25, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Thin49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_THIN49PT7B_H_
