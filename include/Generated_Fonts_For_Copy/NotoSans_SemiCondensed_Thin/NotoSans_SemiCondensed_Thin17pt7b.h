#ifndef _NOTOSANS_SEMICONDENSED_THIN17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x11, 0x08, 0x84, 0x4F, 0xF1, 0x20, 0x90,
  0x89, 0xFF, 0x22, 0x12, 0x09, 0x04, 0x80, 0x11, 0xF9, 0x24, 0x92, 0x46,
  0x06, 0x14, 0x51, 0x45, 0xF8, 0x40, 0xF1, 0x24, 0x49, 0x22, 0x48, 0x95,
  0xA5, 0x99, 0xA5, 0xA9, 0x12, 0x44, 0x92, 0x24, 0x87, 0x78, 0x22, 0x11,
  0x08, 0x82, 0x81, 0x81, 0x41, 0x12, 0x85, 0x41, 0x20, 0x8F, 0xB0, 0xF0,
  0x6A, 0x49, 0x24, 0x92, 0x44, 0x88, 0x91, 0x22, 0x49, 0x25, 0x25, 0x20,
  0x10, 0x4E, 0xC4, 0x31, 0x20, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08,
  0xF0, 0xF0, 0x80, 0x08, 0x42, 0x21, 0x10, 0x84, 0x42, 0x11, 0x00, 0x7D,
  0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0x13, 0xC0, 0x76, 0x92,
  0x49, 0x24, 0x90, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x84, 0x21, 0x04, 0x3F,
  0xF8, 0x10, 0x41, 0x05, 0xE0, 0xC1, 0x04, 0x10, 0x7E, 0x04, 0x04, 0x0A,
  0x12, 0x12, 0x22, 0x42, 0x42, 0xFF, 0x02, 0x02, 0x02, 0x7D, 0x02, 0x04,
  0x09, 0x1D, 0x81, 0x01, 0x02, 0x04, 0x17, 0xC0, 0x3C, 0x82, 0x04, 0x0B,
  0x98, 0xA0, 0xC1, 0x83, 0x06, 0x13, 0xE0, 0xFE, 0x08, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x00, 0x7D, 0x0A, 0x0C, 0x24, 0xC6, 0x13,
  0x41, 0x83, 0x06, 0x0B, 0xE0, 0x79, 0x0A, 0x14, 0x18, 0x30, 0xD2, 0x99,
  0x04, 0x08, 0x17, 0xC0, 0x80, 0x80, 0x81, 0xE0, 0x02, 0x18, 0xC6, 0x04,
  0x06, 0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0xC6,
  0x10, 0x40, 0xF0, 0x42, 0x11, 0x11, 0x08, 0x40, 0x00, 0x80, 0x1F, 0x84,
  0x09, 0x00, 0xC3, 0x18, 0x93, 0x22, 0x64, 0x4C, 0x89, 0x91, 0x31, 0xFE,
  0x00, 0x20, 0x02, 0x00, 0x3E, 0x00, 0x08, 0x0C, 0x05, 0x02, 0x82, 0x41,
  0x10, 0x88, 0xBC, 0x41, 0x20, 0xA0, 0x50, 0x10, 0xFA, 0x18, 0x61, 0x87,
  0xE8, 0x61, 0x86, 0x18, 0x7E, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x3F, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x17, 0xC0, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x21, 0xF0,
  0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x00, 0x3F, 0xA0, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x1F, 0x01, 0x80, 0xC0, 0x50, 0x27, 0xF0, 0x83, 0x06,
  0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xE9, 0x24, 0x92,
  0x49, 0x70, 0x24, 0x92, 0x49, 0x24, 0x92, 0x70, 0x86, 0x29, 0x28, 0xC3,
  0x0A, 0x24, 0x92, 0x28, 0x61, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0xF0, 0x80, 0xC0, 0x60, 0x38, 0x3C, 0x1D, 0x16, 0x8B, 0x45, 0x94, 0xCA,
  0x65, 0x31, 0x10, 0x83, 0x07, 0x0E, 0x1A, 0x32, 0x64, 0xC5, 0x8B, 0x0E,
  0x0C, 0x10, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x50, 0x47, 0xC0, 0xFA, 0x18, 0x61, 0x86, 0x2F, 0x20, 0x82, 0x08,
  0x20, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x50, 0x47, 0x40, 0x40, 0x10, 0x04, 0xFA, 0x18, 0x61, 0x86, 0x2F, 0x24,
  0x8A, 0x28, 0x61, 0x7E, 0x08, 0x20, 0x81, 0xC0, 0x81, 0x04, 0x10, 0x7E,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E, 0x81,
  0x81, 0x41, 0x42, 0x42, 0x22, 0x24, 0x24, 0x14, 0x18, 0x18, 0x08, 0x82,
  0x0A, 0x10, 0x50, 0xC2, 0x8A, 0x24, 0x51, 0x12, 0x48, 0x92, 0x45, 0x14,
  0x28, 0xA0, 0xC3, 0x04, 0x10, 0x20, 0x80, 0xC2, 0x42, 0x24, 0x24, 0x18,
  0x10, 0x18, 0x28, 0x24, 0x44, 0x42, 0x83, 0x82, 0x85, 0x12, 0x22, 0x85,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xFE, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x07, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0x10, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xF0, 0x10, 0x50, 0xA2, 0x24, 0x50, 0x60, 0x80,
  0xFE, 0x94, 0xF8, 0x42, 0x17, 0xC6, 0x31, 0xF8, 0x81, 0x02, 0x04, 0x0B,
  0xD8, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xC0, 0x7E, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x7C, 0x02, 0x04, 0x08, 0x17, 0xB0, 0xE0, 0xC1, 0x83, 0x06,
  0x0C, 0x37, 0xA0, 0x7A, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x7C, 0x39, 0x10,
  0x8F, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x7B, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xC3, 0x7A, 0x04, 0x08, 0x2F, 0x80, 0x82, 0x08, 0x20, 0xBF, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x84, 0x9F, 0xF0, 0x20, 0x12, 0x49, 0x24, 0x92,
  0x4F, 0x82, 0x08, 0x20, 0x8E, 0x29, 0x28, 0xE2, 0x48, 0xA2, 0x84, 0xFF,
  0xF8, 0xFB, 0xD0, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21,
  0x84, 0x20, 0xBF, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x79, 0x0A, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x78, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE1,
  0xBD, 0x02, 0x04, 0x08, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C,
  0x10, 0x41, 0x04, 0xBC, 0x88, 0x88, 0x88, 0x80, 0xFC, 0x21, 0x83, 0x04,
  0x21, 0xF8, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x30, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x7C, 0x86, 0x14, 0x51, 0x48, 0xA2, 0x84, 0x10, 0x84, 0x63,
  0x14, 0xA5, 0x29, 0x4A, 0x94, 0xA3, 0x18, 0x84, 0x21, 0x00, 0x46, 0x88,
  0xA1, 0x41, 0x05, 0x0A, 0x22, 0x82, 0x83, 0x09, 0x12, 0x24, 0x85, 0x0A,
  0x18, 0x10, 0x20, 0x81, 0x0C, 0x00, 0xF8, 0x84, 0x42, 0x21, 0x10, 0xF8,
  0x34, 0x44, 0x44, 0x48, 0x44, 0x44, 0x44, 0x30, 0xFF, 0xFF, 0x80, 0xC2,
  0x22, 0x22, 0x21, 0x22, 0x22, 0x24, 0x80, 0x63, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_Thin17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 4, 1, -12 },
  { 3, 3, 4, 5, 1, -12 },
  { 5, 9, 12, 10, 0, -12 },
  { 19, 6, 14, 9, 1, -13 },
  { 30, 10, 12, 12, 1, -12 },
  { 45, 9, 12, 10, 1, -12 },
  { 59, 1, 4, 3, 1, -12 },
  { 60, 3, 15, 4, 1, -12 },
  { 66, 3, 15, 4, 1, -12 },
  { 72, 6, 6, 8, 1, -13 },
  { 77, 7, 8, 9, 1, -10 },
  { 84, 1, 4, 3, 1, -2 },
  { 85, 4, 1, 5, 1, -5 },
  { 86, 1, 1, 3, 1, -1 },
  { 87, 5, 12, 6, 0, -12 },
  { 95, 7, 12, 9, 1, -12 },
  { 106, 3, 12, 9, 2, -12 },
  { 111, 6, 12, 9, 1, -12 },
  { 120, 6, 12, 9, 1, -12 },
  { 129, 8, 12, 9, 0, -12 },
  { 141, 7, 12, 9, 1, -12 },
  { 152, 7, 12, 9, 1, -12 },
  { 163, 7, 12, 9, 1, -12 },
  { 174, 7, 12, 9, 1, -12 },
  { 185, 7, 12, 9, 1, -12 },
  { 196, 1, 9, 3, 1, -9 },
  { 198, 1, 11, 3, 1, -9 },
  { 200, 7, 8, 9, 1, -10 },
  { 207, 7, 4, 9, 1, -8 },
  { 211, 7, 8, 9, 1, -10 },
  { 218, 5, 12, 6, 1, -12 },
  { 226, 11, 14, 13, 1, -12 },
  { 246, 9, 12, 9, 0, -12 },
  { 260, 6, 12, 9, 2, -12 },
  { 269, 8, 12, 9, 1, -12 },
  { 281, 7, 12, 10, 2, -12 },
  { 292, 5, 12, 8, 2, -12 },
  { 300, 5, 12, 8, 2, -12 },
  { 308, 9, 12, 11, 1, -12 },
  { 322, 7, 12, 11, 2, -12 },
  { 333, 3, 12, 4, 1, -12 },
  { 338, 3, 15, 4, -1, -12 },
  { 344, 6, 12, 8, 2, -12 },
  { 353, 5, 12, 8, 2, -12 },
  { 361, 9, 12, 13, 2, -12 },
  { 375, 7, 12, 11, 2, -12 },
  { 386, 9, 12, 11, 1, -12 },
  { 400, 6, 12, 9, 2, -12 },
  { 409, 9, 15, 11, 1, -12 },
  { 426, 6, 12, 9, 2, -12 },
  { 435, 6, 12, 8, 1, -12 },
  { 444, 7, 12, 8, 0, -12 },
  { 455, 8, 12, 11, 1, -12 },
  { 467, 8, 12, 8, 0, -12 },
  { 479, 13, 12, 13, 0, -12 },
  { 499, 8, 12, 8, 0, -12 },
  { 511, 7, 12, 7, 0, -12 },
  { 522, 7, 12, 8, 1, -12 },
  { 533, 4, 15, 5, 1, -12 },
  { 541, 5, 12, 6, 0, -12 },
  { 549, 4, 15, 5, 0, -12 },
  { 557, 7, 7, 9, 1, -12 },
  { 564, 7, 1, 7, 0, 1 },
  { 565, 2, 3, 4, 1, -13 },
  { 566, 5, 9, 8, 1, -9 },
  { 572, 7, 13, 9, 1, -13 },
  { 584, 6, 9, 7, 1, -9 },
  { 591, 7, 13, 9, 1, -13 },
  { 603, 6, 9, 8, 1, -9 },
  { 610, 5, 13, 4, 0, -13 },
  { 619, 7, 13, 9, 1, -9 },
  { 631, 6, 13, 9, 1, -13 },
  { 641, 1, 12, 3, 1, -12 },
  { 643, 3, 16, 3, -1, -12 },
  { 649, 6, 13, 7, 1, -13 },
  { 659, 1, 13, 3, 1, -13 },
  { 661, 11, 9, 13, 1, -9 },
  { 674, 6, 9, 9, 1, -9 },
  { 681, 7, 9, 9, 1, -9 },
  { 689, 7, 13, 9, 1, -9 },
  { 701, 6, 13, 9, 1, -9 },
  { 711, 4, 9, 6, 1, -9 },
  { 716, 5, 9, 7, 1, -9 },
  { 722, 4, 11, 5, 0, -11 },
  { 728, 6, 9, 9, 1, -9 },
  { 735, 6, 9, 6, 0, -9 },
  { 742, 10, 9, 11, 0, -9 },
  { 754, 7, 9, 7, 0, -9 },
  { 762, 7, 13, 7, 0, -9 },
  { 774, 5, 9, 7, 1, -9 },
  { 780, 4, 15, 6, 1, -12 },
  { 788, 1, 17, 8, 4, -13 },
  { 791, 4, 15, 6, 1, -12 },
  { 799, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Thin17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_THIN17PT7B_H_
