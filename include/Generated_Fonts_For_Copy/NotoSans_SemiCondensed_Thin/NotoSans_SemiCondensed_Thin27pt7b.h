#ifndef _NOTOSANS_SEMICONDENSED_THIN27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin27pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x2C, 0x99, 0x99, 0x99, 0x90, 0x04, 0x20,
  0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x21, 0x07, 0xFF, 0xC2, 0x10,
  0x08, 0x40, 0x41, 0x01, 0x04, 0x04, 0x20, 0xFF, 0xF8, 0x42, 0x01, 0x08,
  0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10, 0x00, 0x04, 0x00, 0x80, 0x7E,
  0x12, 0x24, 0x41, 0x08, 0x21, 0x04, 0x20, 0x44, 0x04, 0x80, 0x70, 0x03,
  0x00, 0x58, 0x08, 0x81, 0x10, 0x21, 0x04, 0x20, 0x84, 0x11, 0x62, 0xC2,
  0xC0, 0x08, 0x01, 0x00, 0x18, 0x04, 0x12, 0x04, 0x10, 0x82, 0x08, 0x42,
  0x08, 0x21, 0x04, 0x11, 0x02, 0x08, 0x81, 0x04, 0x80, 0x82, 0x4E, 0x21,
  0x28, 0x90, 0xA4, 0x44, 0x94, 0x11, 0x92, 0x08, 0x09, 0x04, 0x08, 0x82,
  0x04, 0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x04, 0x41, 0x01, 0xC0, 0x04,
  0x00, 0x66, 0x02, 0x08, 0x08, 0x10, 0x20, 0x40, 0x82, 0x01, 0x08, 0x04,
  0x40, 0x0A, 0x00, 0x30, 0x01, 0x40, 0x08, 0x81, 0x41, 0x06, 0x02, 0x28,
  0x04, 0xA0, 0x0C, 0x80, 0x11, 0x00, 0xC4, 0x04, 0x8F, 0xE1, 0xFE, 0x18,
  0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x42,
  0x08, 0x60, 0xC2, 0x08, 0x41, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x22,
  0x10, 0x84, 0x42, 0x23, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0E, 0xB8, 0xE0,
  0x50, 0x48, 0x22, 0x20, 0x80, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x55,
  0xA0, 0xFC, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x18, 0x08,
  0xC4, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x90, 0x24, 0x10, 0xF8, 0x19,
  0x53, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x0E,
  0x06, 0x21, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x7F, 0xF0, 0x0E, 0x0E, 0x32, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x83, 0xE0, 0x0E, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x03, 0x7F, 0x80, 0x00, 0x80, 0x18, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x48, 0x08, 0x81, 0x08, 0x10, 0x82, 0x08, 0x40, 0x84,
  0x08, 0x80, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x7F, 0x90, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x70, 0xE3, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xA0, 0x6F, 0xE0,
  0x06, 0x86, 0x12, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x8E, 0x28,
  0x6C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x08,
  0xFC, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x00, 0x0E, 0x02, 0x30, 0x81, 0x20, 0x14, 0x02, 0x80,
  0x50, 0x11, 0x02, 0x11, 0x81, 0xC0, 0x64, 0x10, 0x44, 0x04, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x28, 0x04, 0x81, 0x0F, 0xC0, 0x0E, 0x06, 0x31, 0x02,
  0x20, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x01, 0x98,
  0xD0, 0x62, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x04, 0x3F, 0x00,
  0x80, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x24, 0x94, 0x80, 0x00, 0x20, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x08, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x38, 0xC4, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x20, 0x03, 0xFC, 0x00, 0x80, 0x40, 0x60, 0x04, 0x08, 0x00, 0x42, 0x00,
  0x04, 0x81, 0xE0, 0x90, 0x42, 0x12, 0x10, 0x41, 0x82, 0x08, 0x30, 0x81,
  0x06, 0x10, 0x20, 0xC2, 0x04, 0x18, 0x40, 0x85, 0x04, 0x10, 0x90, 0x86,
  0x12, 0x0F, 0x3C, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xE0, 0xC0, 0x01, 0xA0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x50, 0x01,
  0x20, 0x04, 0x80, 0x22, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x40, 0x81,
  0x02, 0x07, 0xF8, 0x20, 0x10, 0x80, 0x44, 0x01, 0x10, 0x02, 0x40, 0x0A,
  0x00, 0x28, 0x00, 0x40, 0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x02, 0xFF, 0x20, 0xC8, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x2F, 0xF0, 0x03, 0x40, 0xC3, 0x30, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0x08,
  0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48,
  0x18, 0xFE, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F,
  0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F,
  0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x02,
  0xA0, 0x30, 0x61, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x1F, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x40, 0x04, 0x80, 0x11, 0x00, 0x43, 0xFE, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x3E, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x7C, 0x80, 0xE0, 0x28, 0x12, 0x08, 0x84, 0x22, 0x09,
  0x02, 0xC0, 0xB0, 0x34, 0x08, 0x82, 0x10, 0x84, 0x20, 0x88, 0x22, 0x04,
  0x80, 0xA0, 0x28, 0x04, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x3F, 0xE0, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3A, 0x00, 0xB4,
  0x01, 0x68, 0x02, 0xC8, 0x09, 0x90, 0x13, 0x20, 0x46, 0x20, 0x8C, 0x41,
  0x18, 0x84, 0x30, 0x88, 0x61, 0x10, 0xC1, 0x41, 0x82, 0x83, 0x06, 0x06,
  0x04, 0x08, 0x80, 0x30, 0x07, 0x00, 0xD0, 0x1A, 0x03, 0x20, 0x64, 0x0C,
  0x41, 0x88, 0x30, 0x86, 0x08, 0xC1, 0x18, 0x13, 0x02, 0x60, 0x2C, 0x03,
  0x80, 0x70, 0x06, 0x00, 0x80, 0x05, 0x80, 0x61, 0x82, 0x01, 0x10, 0x02,
  0x40, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x09, 0x00,
  0x22, 0x01, 0x07, 0xF8, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC1, 0xBE, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x00, 0x05, 0x80, 0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x09, 0x00, 0x22, 0x01, 0x07,
  0xF8, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0xFE, 0x20,
  0x68, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x3F, 0x88, 0x42,
  0x10, 0x82, 0x20, 0x88, 0x12, 0x04, 0x80, 0xA0, 0x28, 0x04, 0x0F, 0x06,
  0x19, 0x00, 0x20, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x03,
  0x7F, 0x80, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x02, 0x40, 0x11, 0x01,
  0x07, 0xF0, 0x80, 0x0C, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x10, 0x08,
  0x80, 0x84, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x10, 0x80, 0x88, 0x04,
  0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x18, 0x00, 0x80, 0x80, 0x40, 0x18,
  0x04, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x40, 0xA0, 0x24, 0x09, 0x04,
  0x41, 0x10, 0x44, 0x11, 0x04, 0x21, 0x10, 0x42, 0x11, 0x08, 0x22, 0x08,
  0x82, 0x20, 0x88, 0x12, 0x08, 0x81, 0x20, 0x90, 0x14, 0x05, 0x01, 0x40,
  0x50, 0x0C, 0x05, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x40, 0x32, 0x02,
  0x20, 0x41, 0x04, 0x10, 0x80, 0x88, 0x09, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x90, 0x08, 0x81, 0x08, 0x20, 0x42, 0x04, 0x40, 0x24, 0x02,
  0x80, 0x10, 0x80, 0x34, 0x02, 0x40, 0x22, 0x04, 0x20, 0x41, 0x08, 0x10,
  0x80, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xE0, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x03, 0xFF, 0x80, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0xF8,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x87, 0xE0, 0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x10, 0x81, 0x08, 0x20,
  0x44, 0x04, 0x40, 0x28, 0x02, 0x80, 0x10, 0xFF, 0xE0, 0x84, 0x21, 0x10,
  0x0C, 0x39, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x3F, 0x20, 0xA0, 0x60,
  0x30, 0x18, 0x0A, 0x0D, 0xFA, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x23, 0x85, 0x8C, 0xC0, 0x58, 0x0A, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0B, 0x01, 0x50, 0x49, 0xF0, 0x07, 0x0C,
  0x48, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x7E, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41,
  0x08, 0xCD, 0x20, 0x68, 0x05, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x28, 0x05, 0x01, 0x90, 0x31, 0xFA, 0x0E, 0x02, 0x30, 0x81,
  0x20, 0x24, 0x04, 0x80, 0x60, 0x0F, 0xFF, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x07, 0xF0, 0x07, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFC, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x04, 0x03, 0x34, 0x81, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x14, 0x06, 0x40, 0xC7, 0xE8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x26, 0x18, 0x3C, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0xE2, 0xC4, 0xC0, 0xB0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0xC3, 0xFF, 0xF0, 0x11, 0x00, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x12, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x02, 0x82, 0x42, 0x21, 0x11, 0x09, 0x05, 0x83, 0x21, 0x08, 0x84,
  0x41, 0x20, 0x50, 0x28, 0x08, 0xFF, 0xFF, 0xF8, 0x0C, 0x1C, 0x59, 0x91,
  0x30, 0x50, 0x50, 0x10, 0x28, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01,
  0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C,
  0x04, 0x06, 0x02, 0x02, 0x0E, 0x2C, 0x4C, 0x0B, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x04,
  0x03, 0x30, 0x81, 0x20, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x40, 0x87, 0xE0, 0x0E, 0x12, 0x32, 0x81,
  0x60, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x2C, 0x05, 0x41, 0x27, 0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x06, 0x03, 0x34, 0x81, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x06, 0x41, 0x47, 0xC8, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0xBF, 0x83, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x1E, 0x30, 0xD0, 0x10, 0x08,
  0x02, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x20, 0x10, 0x08, 0x0B, 0xF8,
  0x20, 0x40, 0x81, 0x0F, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x3C, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x41, 0x4F, 0x90, 0x80, 0x60,
  0x14, 0x09, 0x02, 0x40, 0x88, 0x42, 0x10, 0x84, 0x12, 0x04, 0x81, 0x20,
  0x30, 0x0C, 0x01, 0x00, 0x80, 0x81, 0x40, 0x81, 0x41, 0x41, 0x41, 0x41,
  0x41, 0x42, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x12, 0x14, 0x14, 0x14,
  0x14, 0x14, 0x14, 0x14, 0x08, 0x08, 0x08, 0x08, 0x80, 0x90, 0x44, 0x10,
  0x88, 0x12, 0x05, 0x00, 0x80, 0x30, 0x14, 0x08, 0x82, 0x11, 0x04, 0x80,
  0xA0, 0x30, 0x80, 0x50, 0x14, 0x05, 0x02, 0x20, 0x88, 0x22, 0x10, 0x44,
  0x11, 0x04, 0x80, 0xA0, 0x28, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x00, 0x7F, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFF, 0x0E, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x86, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x30, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x38, 0x00, 0x30, 0x18, 0xC4, 0x02, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 4, 7, 8, 2, -19 },
  { 10, 14, 19, 15, 1, -19 },
  { 44, 11, 23, 14, 1, -21 },
  { 76, 17, 20, 19, 1, -20 },
  { 119, 14, 20, 16, 1, -20 },
  { 154, 1, 7, 5, 2, -19 },
  { 155, 5, 23, 7, 1, -19 },
  { 170, 5, 23, 7, 1, -19 },
  { 185, 9, 10, 13, 2, -21 },
  { 197, 11, 13, 14, 1, -16 },
  { 215, 2, 6, 5, 1, -3 },
  { 217, 6, 1, 8, 1, -8 },
  { 218, 1, 2, 6, 2, -2 },
  { 219, 8, 19, 9, 0, -19 },
  { 238, 10, 20, 14, 2, -20 },
  { 263, 5, 19, 14, 3, -19 },
  { 275, 11, 20, 14, 1, -20 },
  { 303, 11, 20, 14, 1, -20 },
  { 331, 12, 19, 14, 1, -19 },
  { 360, 10, 19, 14, 2, -19 },
  { 384, 10, 20, 14, 2, -20 },
  { 409, 11, 19, 14, 1, -19 },
  { 436, 11, 20, 14, 1, -20 },
  { 464, 11, 20, 14, 1, -20 },
  { 492, 1, 14, 6, 2, -14 },
  { 494, 3, 17, 6, 1, -14 },
  { 501, 11, 12, 14, 1, -16 },
  { 518, 11, 7, 14, 1, -13 },
  { 528, 11, 12, 14, 1, -16 },
  { 545, 8, 20, 10, 1, -20 },
  { 565, 19, 22, 21, 1, -19 },
  { 618, 14, 19, 14, 0, -19 },
  { 652, 10, 19, 15, 3, -19 },
  { 676, 12, 20, 15, 2, -20 },
  { 706, 12, 19, 17, 3, -19 },
  { 735, 9, 19, 13, 3, -19 },
  { 757, 9, 19, 12, 3, -19 },
  { 779, 14, 20, 17, 2, -20 },
  { 814, 11, 19, 17, 3, -19 },
  { 841, 5, 19, 7, 1, -19 },
  { 853, 5, 24, 6, -2, -19 },
  { 868, 10, 19, 13, 3, -19 },
  { 892, 9, 19, 12, 3, -19 },
  { 914, 15, 19, 21, 3, -19 },
  { 950, 11, 19, 17, 3, -19 },
  { 977, 14, 20, 18, 2, -20 },
  { 1012, 9, 19, 14, 3, -19 },
  { 1034, 14, 25, 18, 2, -20 },
  { 1078, 10, 19, 14, 3, -19 },
  { 1102, 11, 20, 13, 1, -20 },
  { 1130, 12, 19, 12, 0, -19 },
  { 1159, 13, 19, 17, 2, -19 },
  { 1190, 13, 19, 13, 0, -19 },
  { 1221, 20, 19, 21, 1, -19 },
  { 1269, 12, 19, 12, 0, -19 },
  { 1298, 12, 19, 12, 0, -19 },
  { 1327, 11, 19, 13, 1, -19 },
  { 1354, 6, 23, 8, 2, -19 },
  { 1372, 8, 19, 9, 0, -19 },
  { 1391, 5, 23, 8, 1, -19 },
  { 1406, 12, 11, 14, 1, -19 },
  { 1423, 11, 1, 11, 0, 2 },
  { 1425, 4, 5, 6, 1, -21 },
  { 1428, 9, 15, 12, 1, -15 },
  { 1445, 11, 21, 14, 2, -21 },
  { 1474, 9, 15, 11, 1, -15 },
  { 1491, 11, 21, 14, 1, -21 },
  { 1520, 11, 15, 13, 1, -15 },
  { 1541, 8, 21, 7, 0, -21 },
  { 1562, 11, 22, 14, 1, -15 },
  { 1593, 10, 21, 14, 2, -21 },
  { 1620, 1, 20, 5, 2, -20 },
  { 1623, 4, 27, 5, -1, -20 },
  { 1637, 9, 21, 11, 2, -21 },
  { 1661, 1, 21, 5, 2, -21 },
  { 1664, 17, 15, 21, 2, -15 },
  { 1696, 10, 15, 14, 2, -15 },
  { 1715, 11, 15, 14, 1, -15 },
  { 1736, 11, 21, 14, 2, -15 },
  { 1765, 11, 21, 14, 1, -15 },
  { 1794, 7, 14, 9, 2, -14 },
  { 1807, 9, 15, 11, 1, -15 },
  { 1824, 7, 18, 8, 0, -18 },
  { 1840, 10, 14, 14, 2, -14 },
  { 1858, 10, 14, 10, 0, -14 },
  { 1876, 16, 14, 17, 0, -14 },
  { 1904, 10, 14, 11, 1, -14 },
  { 1922, 10, 21, 10, 0, -14 },
  { 1949, 8, 14, 10, 1, -14 },
  { 1963, 7, 23, 9, 1, -19 },
  { 1984, 1, 28, 13, 6, -21 },
  { 1988, 7, 23, 9, 1, -19 },
  { 2009, 11, 3, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Thin27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_THIN27PT7B_H_
