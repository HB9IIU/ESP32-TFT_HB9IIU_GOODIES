#ifndef _NOTOSANS_SEMICONDENSED_THIN43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin43pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x05,
  0xF8, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00,
  0x40, 0x40, 0x01, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80,
  0x40, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x80, 0x80,
  0x04, 0x02, 0x07, 0xFF, 0xFF, 0xC0, 0x40, 0x60, 0x01, 0x01, 0x00, 0x04,
  0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x04,
  0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0xFF, 0xFF, 0xF8, 0x10, 0x08, 0x00,
  0x40, 0x20, 0x01, 0x00, 0x80, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0xC0,
  0x40, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x0F, 0xF8, 0x18, 0x86, 0x20,
  0x80, 0x40, 0x80, 0x40, 0x80, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0,
  0x80, 0x40, 0x80, 0x60, 0x80, 0x30, 0x80, 0x18, 0x80, 0x06, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x9C, 0x00, 0x86, 0x00, 0x83, 0x00, 0x81, 0x00,
  0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x83, 0x00,
  0x82, 0xC0, 0x8C, 0x3F, 0xF0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x1F, 0x00, 0x08, 0x0C, 0x60, 0x06, 0x02, 0x0C, 0x01, 0x01, 0x01,
  0x00, 0xC0, 0x40, 0x40, 0x20, 0x10, 0x18, 0x08, 0x0C, 0x02, 0x04, 0x03,
  0x00, 0x81, 0x00, 0x80, 0x20, 0x80, 0x20, 0x08, 0x20, 0x08, 0x02, 0x10,
  0x03, 0x00, 0x84, 0x00, 0xC0, 0x22, 0x1E, 0x10, 0x18, 0x8C, 0xC4, 0x04,
  0x46, 0x09, 0x01, 0x11, 0x02, 0x20, 0xCC, 0xC0, 0x4C, 0x62, 0x20, 0x11,
  0xF1, 0x88, 0x04, 0x00, 0x42, 0x01, 0x00, 0x30, 0x80, 0x40, 0x08, 0x20,
  0x10, 0x02, 0x08, 0x04, 0x01, 0x02, 0x01, 0x00, 0x40, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x03, 0x03, 0x01, 0x00, 0x40, 0x80,
  0x80, 0x18, 0x60, 0x20, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x18, 0x60, 0x00,
  0x80, 0x40, 0x02, 0x01, 0x00, 0x10, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x18, 0x04, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x80,
  0x01, 0x06, 0x00, 0x02, 0x30, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xB0, 0x00, 0x18, 0x40, 0x00, 0xC0, 0x80, 0x22, 0x01, 0x00, 0x90, 0x06,
  0x02, 0x40, 0x0C, 0x0B, 0x00, 0x18, 0x48, 0x00, 0x21, 0x20, 0x00, 0x48,
  0x80, 0x00, 0xA3, 0x00, 0x03, 0x04, 0x00, 0x0E, 0x10, 0x00, 0x68, 0x20,
  0x03, 0x10, 0x60, 0x30, 0x20, 0xFF, 0x80, 0xC0, 0xFF, 0xE0, 0x03, 0x06,
  0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x04, 0x03,
  0x80, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x20, 0x60,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10,
  0x20, 0x41, 0x82, 0x0C, 0x10, 0x20, 0x83, 0x04, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x81, 0x70, 0x8F,
  0x0E, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x04, 0x20, 0x04, 0x10,
  0x08, 0x10, 0x10, 0x08, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x24, 0xB6, 0x96, 0x92, 0x00, 0xFF, 0xC0, 0x5F, 0x00, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x06,
  0x06, 0x06, 0x01, 0x02, 0x00, 0x42, 0x00, 0x31, 0x00, 0x08, 0x80, 0x04,
  0x80, 0x03, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x03,
  0x60, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC2, 0x00, 0x41, 0x80, 0x40, 0x60,
  0x60, 0x1F, 0xC0, 0x01, 0x03, 0x05, 0x19, 0x31, 0x61, 0x81, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0xE0,
  0x1C, 0x0C, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xF0, 0x1C, 0x0E, 0x30, 0x01, 0x90, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x3F, 0x80,
  0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x66, 0x00, 0x60, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xA0, 0x00, 0x12, 0x00, 0x01,
  0x20, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x08, 0x20, 0x01,
  0x82, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x02, 0x01, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x40, 0x02, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x3F, 0xFE, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x7F, 0xF0, 0x40, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0xC0, 0x18, 0x7F, 0xE0, 0x01, 0xFE, 0x07, 0x02, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x83, 0xE0, 0x8C, 0x18, 0xB0, 0x04,
  0xA0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03,
  0x20, 0x02, 0x30, 0x06, 0x18, 0x0C, 0x0F, 0xF0, 0xFF, 0xFF, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x07, 0xF0, 0x06, 0x06, 0x04, 0x00, 0x84, 0x00, 0x62, 0x00,
  0x13, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x60, 0x01, 0x10, 0x00, 0x8C,
  0x00, 0x83, 0x00, 0xC0, 0xC0, 0xC0, 0x39, 0x80, 0x07, 0x00, 0x06, 0xE0,
  0x0C, 0x18, 0x0C, 0x03, 0x08, 0x00, 0xCC, 0x00, 0x24, 0x00, 0x0A, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x2C,
  0x00, 0x22, 0x00, 0x30, 0xC0, 0x30, 0x3F, 0xE0, 0x07, 0xF0, 0x0C, 0x0C,
  0x0C, 0x01, 0x04, 0x00, 0x44, 0x00, 0x22, 0x00, 0x0B, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1A,
  0x00, 0x0D, 0x00, 0x06, 0xC0, 0x05, 0x20, 0x04, 0x8C, 0x0C, 0x43, 0xFC,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0x00, 0x5D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xF0, 0x27,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x26, 0x64, 0x4C,
  0x88, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0x87, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x11, 0x00, 0x1F, 0x00, 0x98, 0x03, 0x0E, 0x06, 0x80, 0x20,
  0x20, 0x14, 0x02, 0x01, 0x00, 0xA0, 0x20, 0x08, 0x05, 0x01, 0x00, 0x40,
  0x38, 0x18, 0x02, 0x01, 0xC0, 0x80, 0x10, 0x0C, 0x04, 0x00, 0x80, 0x60,
  0x20, 0x04, 0x03, 0x01, 0x00, 0x20, 0x18, 0x08, 0x01, 0x00, 0xE0, 0x60,
  0x18, 0x0D, 0x01, 0x00, 0xC0, 0x48, 0x08, 0x0B, 0x06, 0x40, 0x20, 0xC8,
  0x62, 0x00, 0xFC, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x04, 0x18, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x02, 0x03,
  0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x01, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x40,
  0x01, 0x81, 0x00, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x30, 0x80, 0x00,
  0x42, 0x00, 0x01, 0x10, 0x00, 0x06, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x28,
  0x00, 0x00, 0xC0, 0xFF, 0x80, 0x40, 0x7C, 0x20, 0x01, 0x90, 0x00, 0x68,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x24, 0x00, 0x63, 0xFF, 0xC1, 0x00,
  0xF0, 0x80, 0x06, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x28, 0x00, 0x64, 0x00, 0xE3, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x70, 0x1C, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x40, 0x7F, 0xF0, 0xFF,
  0x80, 0x08, 0x1F, 0x80, 0x80, 0x0E, 0x08, 0x00, 0x30, 0x80, 0x01, 0x88,
  0x00, 0x08, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x04, 0x80,
  0x00, 0x48, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08,
  0x03, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFD,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x06, 0x00, 0xE0, 0x60, 0x00, 0x83,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x60, 0x00, 0x04,
  0x80, 0x00, 0x13, 0x00, 0x00, 0x46, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x0C,
  0x00, 0x70, 0x0F, 0xFE, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x3F, 0x80, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02,
  0xFC, 0x80, 0x01, 0xC0, 0x01, 0xA0, 0x01, 0x90, 0x00, 0x88, 0x00, 0x84,
  0x00, 0x82, 0x00, 0xC1, 0x00, 0xC0, 0x80, 0xC0, 0x40, 0xC0, 0x20, 0x40,
  0x10, 0x40, 0x08, 0x60, 0x04, 0x60, 0x02, 0x78, 0x01, 0x64, 0x00, 0xA3,
  0x00, 0x60, 0x80, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x01, 0x02,
  0x00, 0xC1, 0x00, 0x20, 0x80, 0x08, 0x40, 0x06, 0x20, 0x01, 0x10, 0x00,
  0x48, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F,
  0xFF, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF4,
  0x00, 0x00, 0x5A, 0x00, 0x00, 0x2D, 0x80, 0x00, 0x36, 0x40, 0x00, 0x13,
  0x20, 0x00, 0x09, 0x88, 0x00, 0x08, 0xC4, 0x00, 0x04, 0x63, 0x00, 0x02,
  0x30, 0x80, 0x02, 0x18, 0x40, 0x01, 0x0C, 0x30, 0x01, 0x86, 0x08, 0x00,
  0x83, 0x04, 0x00, 0x41, 0x81, 0x00, 0x60, 0xC0, 0x80, 0x20, 0x60, 0x60,
  0x10, 0x30, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x06, 0x0C, 0x06, 0x01,
  0x04, 0x03, 0x00, 0x82, 0x01, 0x80, 0x23, 0x00, 0xC0, 0x11, 0x00, 0x60,
  0x08, 0x80, 0x30, 0x02, 0x80, 0x18, 0x01, 0x40, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x20, 0x02, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00,
  0x1B, 0x00, 0x03, 0x20, 0x00, 0x66, 0x00, 0x0C, 0x40, 0x01, 0x84, 0x00,
  0x30, 0xC0, 0x06, 0x08, 0x00, 0xC1, 0x80, 0x18, 0x10, 0x03, 0x01, 0x00,
  0x60, 0x20, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x04, 0x06, 0x00, 0x40,
  0xC0, 0x08, 0x18, 0x00, 0x83, 0x00, 0x18, 0x60, 0x01, 0x0C, 0x00, 0x11,
  0x80, 0x02, 0x30, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x0E, 0x03, 0x00, 0x30,
  0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x01, 0x10, 0x00,
  0x02, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x20,
  0x00, 0x02, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x40, 0x80,
  0x01, 0x80, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x81, 0xF0, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08, 0x80, 0x70, 0xFF, 0xC0, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01,
  0x83, 0x00, 0x01, 0x04, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x60, 0x80, 0x01, 0x80, 0x80, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0x80, 0x40, 0x78, 0x20, 0x03, 0x10, 0x00, 0xC8,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x31, 0x00,
  0x70, 0xFF, 0xE0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x0C, 0x08, 0x02, 0x04,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x10, 0x80, 0x0C, 0x40, 0x02, 0x20, 0x01,
  0x90, 0x00, 0x48, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x06, 0x03, 0xFC, 0x0E,
  0x03, 0x8C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x66, 0x00,
  0x61, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00, 0x63,
  0x00, 0x18, 0x30, 0x06, 0x01, 0xFF, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x50, 0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x84, 0x00, 0x04, 0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10,
  0x10, 0x01, 0x00, 0x80, 0x08, 0x04, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x10, 0x18, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x10, 0x60, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x11, 0x80, 0x00, 0x88,
  0x00, 0x04, 0x40, 0x00, 0x36, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x40, 0x01, 0x80, 0x02, 0x40, 0x03, 0x80, 0x02, 0x40, 0x02, 0x80,
  0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x02, 0x40, 0x04, 0x20, 0x02, 0x40,
  0x04, 0x20, 0x04, 0x40, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x10, 0x04, 0x20,
  0x08, 0x10, 0x04, 0x20, 0x08, 0x10, 0x08, 0x20, 0x08, 0x10, 0x08, 0x10,
  0x18, 0x08, 0x08, 0x10, 0x10, 0x08, 0x08, 0x10, 0x10, 0x08, 0x18, 0x10,
  0x10, 0x08, 0x10, 0x08, 0x30, 0x04, 0x10, 0x08, 0x20, 0x04, 0x10, 0x08,
  0x20, 0x04, 0x30, 0x08, 0x20, 0x04, 0x20, 0x04, 0x60, 0x02, 0x20, 0x04,
  0x40, 0x02, 0x20, 0x04, 0x40, 0x02, 0x60, 0x04, 0x40, 0x02, 0x40, 0x06,
  0xC0, 0x01, 0x40, 0x02, 0x80, 0x01, 0x40, 0x02, 0x80, 0x01, 0xC0, 0x02,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x00, 0x80, 0x01, 0x00, 0x60, 0x00, 0x64,
  0x00, 0x08, 0xC0, 0x02, 0x08, 0x00, 0xC1, 0x80, 0x10, 0x10, 0x06, 0x03,
  0x00, 0x80, 0x20, 0x30, 0x02, 0x04, 0x00, 0x41, 0x80, 0x04, 0x20, 0x00,
  0x88, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xA0, 0x00, 0x16, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x20, 0x80, 0x0C,
  0x08, 0x01, 0x01, 0x00, 0x60, 0x10, 0x08, 0x03, 0x02, 0x00, 0x20, 0x40,
  0x06, 0x10, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x00, 0xB0, 0x00, 0x18, 0x80,
  0x00, 0x68, 0x00, 0x09, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x08, 0x60,
  0x02, 0x04, 0x00, 0x40, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x80, 0x80, 0x10,
  0x10, 0x02, 0x06, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x44, 0x00, 0x09,
  0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFC, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x1A, 0x00, 0x04, 0x80, 0x03, 0x10, 0x00, 0x84, 0x00, 0x60, 0x80, 0x10,
  0x20, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x20, 0x40, 0x08, 0x20, 0x03,
  0x08, 0x00, 0x44, 0x00, 0x19, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x10,
  0xFF, 0xFF, 0x80, 0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x0F, 0xE0,
  0xE0, 0x62, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x0F, 0xC3, 0xC1, 0x30, 0x05, 0x80, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x40, 0x15, 0x80,
  0x93, 0xFC, 0x40, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87,
  0xE0, 0x98, 0x18, 0xB0, 0x0C, 0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0xC0,
  0x02, 0xC0, 0x06, 0xA0, 0x0C, 0xB0, 0x18, 0x8F, 0xF0, 0x01, 0xFC, 0x0C,
  0x0C, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x80, 0x41, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0xFC, 0x21, 0x81, 0x91, 0x80, 0x69, 0x80, 0x14, 0x80,
  0x06, 0xC0, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x68, 0x00, 0x36, 0x00, 0x19, 0x00, 0x14, 0xC0, 0x0A, 0x30,
  0x19, 0x07, 0xF8, 0x80, 0x03, 0xF0, 0x0C, 0x18, 0x18, 0x04, 0x30, 0x02,
  0x20, 0x02, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x03,
  0x07, 0xFE, 0x01, 0xF8, 0x18, 0x41, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x3F, 0xF0, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x03, 0xF8, 0x86, 0x06,
  0x46, 0x01, 0xA6, 0x00, 0x52, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x06, 0x80,
  0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0xD8, 0x00,
  0x64, 0x00, 0x53, 0x00, 0x68, 0xC0, 0x64, 0x1F, 0xE2, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0xC0, 0x18, 0x1F, 0xF8, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x1F, 0x84, 0xC0, 0xCA, 0x00, 0x98, 0x00, 0xB0, 0x01, 0x40,
  0x02, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0xF4, 0x00, 0x55,
  0x55, 0x55, 0x55, 0x55, 0x54, 0x0C, 0x30, 0x40, 0x00, 0x00, 0x00, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30, 0x82, 0xF0,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x01, 0xA0, 0x0C, 0x80, 0x22, 0x01,
  0x08, 0x08, 0x20, 0x60, 0x83, 0x02, 0x08, 0x08, 0x40, 0x22, 0x00, 0x9C,
  0x02, 0xD0, 0x0A, 0x20, 0x30, 0xC0, 0x81, 0x02, 0x02, 0x08, 0x08, 0x20,
  0x10, 0x80, 0x62, 0x00, 0x88, 0x01, 0x20, 0x06, 0x80, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x8F, 0xC0, 0xFC, 0x4C, 0x30, 0xC1, 0xA8, 0x04, 0x80,
  0x58, 0x02, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x87, 0xE1, 0x30, 0x32, 0x80, 0x26, 0x00, 0x2C, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0xF8, 0x03, 0x03, 0x01, 0x80, 0x20, 0xC0, 0x0C, 0x20, 0x01, 0x10, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0x90, 0x00, 0x22, 0x00, 0x10, 0x80, 0x04, 0x10, 0x02, 0x02, 0x01,
  0x00, 0x7F, 0x80, 0x87, 0xE0, 0x98, 0x18, 0xB0, 0x0C, 0xA0, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xA0, 0x0C, 0x98, 0x18, 0x8F,
  0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x86,
  0x06, 0x46, 0x01, 0xA6, 0x00, 0x52, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x06,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00, 0xD8,
  0x00, 0x64, 0x00, 0x53, 0x00, 0x68, 0xC0, 0x64, 0x3F, 0xC2, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x8F, 0xE6, 0x0A, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x0F, 0xF0, 0xC0, 0x64, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x1A, 0x00, 0xC7, 0xFE, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x3F, 0xF1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x80, 0x3F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x36, 0x00, 0xA6, 0x02, 0x47, 0xF8,
  0x80, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20,
  0x06, 0x20, 0x04, 0x30, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x18, 0x08, 0x08,
  0x18, 0x08, 0x10, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x20, 0x06, 0x20, 0x02,
  0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x78, 0x02, 0x80, 0x24,
  0x01, 0x40, 0x12, 0x00, 0xB0, 0x09, 0x00, 0x88, 0x0C, 0x40, 0x44, 0x04,
  0x20, 0x22, 0x02, 0x10, 0x30, 0x81, 0x08, 0x10, 0x41, 0x82, 0x08, 0x20,
  0x81, 0x04, 0x18, 0x40, 0x84, 0x04, 0x20, 0x42, 0x02, 0x30, 0x11, 0x01,
  0x10, 0x09, 0x80, 0x48, 0x04, 0x80, 0x24, 0x03, 0x40, 0x16, 0x00, 0xA0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0xC0,
  0x03, 0x40, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x08, 0x10, 0x08,
  0x30, 0x04, 0x20, 0x06, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x08, 0x10, 0x18, 0x18, 0x10,
  0x08, 0x20, 0x0C, 0x20, 0x04, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0xA0,
  0x00, 0x90, 0x00, 0x4C, 0x00, 0x62, 0x00, 0x21, 0x00, 0x10, 0xC0, 0x10,
  0x20, 0x08, 0x10, 0x04, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0xC1,
  0x00, 0x20, 0x80, 0x10, 0x40, 0x0C, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00,
  0xD0, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x00, 0x60,
  0x70, 0x18, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x03, 0x80,
  0x70, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x38, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x07, 0x80,
  0xF0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x07, 0x81,
  0x80, 0x00, 0x3F, 0x00, 0x50, 0x70, 0x18, 0x07, 0xB8, 0x00, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_Thin43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 7, 11, 13, 3, -31 },
  { 23, 22, 31, 24, 1, -31 },
  { 109, 16, 36, 22, 2, -33 },
  { 181, 26, 31, 31, 2, -31 },
  { 282, 22, 31, 25, 2, -31 },
  { 368, 1, 11, 7, 3, -31 },
  { 370, 8, 38, 11, 2, -31 },
  { 408, 7, 38, 11, 2, -31 },
  { 442, 16, 15, 20, 2, -33 },
  { 472, 18, 20, 22, 2, -25 },
  { 517, 3, 11, 8, 2, -5 },
  { 522, 10, 1, 13, 1, -12 },
  { 524, 3, 3, 9, 3, -3 },
  { 526, 12, 31, 14, 1, -31 },
  { 573, 17, 31, 22, 2, -31 },
  { 639, 8, 31, 22, 4, -31 },
  { 670, 17, 31, 22, 2, -31 },
  { 736, 17, 31, 22, 2, -31 },
  { 802, 20, 31, 22, 1, -31 },
  { 880, 16, 31, 22, 3, -31 },
  { 942, 16, 31, 22, 3, -31 },
  { 1004, 17, 31, 22, 2, -31 },
  { 1070, 17, 31, 22, 2, -31 },
  { 1136, 17, 31, 22, 2, -31 },
  { 1202, 3, 23, 9, 3, -23 },
  { 1211, 4, 29, 9, 2, -23 },
  { 1226, 18, 19, 22, 2, -25 },
  { 1269, 18, 10, 22, 2, -20 },
  { 1292, 18, 19, 22, 2, -25 },
  { 1335, 13, 31, 15, 1, -31 },
  { 1386, 29, 35, 33, 2, -31 },
  { 1513, 22, 31, 22, 0, -31 },
  { 1599, 17, 31, 23, 4, -31 },
  { 1665, 19, 31, 23, 3, -31 },
  { 1739, 20, 31, 26, 4, -31 },
  { 1817, 15, 31, 21, 4, -31 },
  { 1876, 15, 31, 19, 4, -31 },
  { 1935, 22, 31, 28, 3, -31 },
  { 2021, 19, 31, 27, 4, -31 },
  { 2095, 7, 31, 11, 2, -31 },
  { 2123, 8, 38, 9, -3, -31 },
  { 2161, 17, 31, 21, 4, -31 },
  { 2227, 14, 31, 19, 4, -31 },
  { 2282, 25, 31, 33, 4, -31 },
  { 2379, 19, 31, 27, 4, -31 },
  { 2453, 23, 31, 29, 3, -31 },
  { 2543, 16, 31, 22, 4, -31 },
  { 2605, 23, 38, 29, 3, -31 },
  { 2715, 17, 31, 22, 4, -31 },
  { 2781, 17, 31, 21, 2, -31 },
  { 2847, 19, 31, 19, 0, -31 },
  { 2921, 19, 31, 27, 4, -31 },
  { 2995, 21, 31, 21, 0, -31 },
  { 3077, 32, 31, 34, 1, -31 },
  { 3201, 19, 31, 19, 0, -31 },
  { 3275, 19, 31, 19, 0, -31 },
  { 3349, 18, 31, 21, 1, -31 },
  { 3419, 8, 38, 13, 4, -31 },
  { 3457, 12, 31, 14, 1, -31 },
  { 3504, 9, 38, 13, 1, -31 },
  { 3547, 18, 18, 22, 2, -31 },
  { 3588, 17, 1, 17, 0, 4 },
  { 3591, 7, 7, 10, 2, -33 },
  { 3598, 14, 23, 20, 2, -23 },
  { 3639, 16, 33, 23, 4, -33 },
  { 3705, 15, 23, 18, 2, -23 },
  { 3749, 17, 33, 23, 2, -33 },
  { 3820, 16, 23, 21, 2, -23 },
  { 3866, 13, 33, 11, 0, -33 },
  { 3920, 17, 33, 23, 2, -23 },
  { 3991, 15, 33, 22, 4, -33 },
  { 4053, 2, 31, 8, 3, -31 },
  { 4061, 6, 41, 8, -1, -31 },
  { 4092, 14, 33, 17, 4, -33 },
  { 4150, 1, 33, 8, 4, -33 },
  { 4155, 25, 23, 33, 4, -23 },
  { 4227, 15, 23, 22, 4, -23 },
  { 4271, 18, 23, 22, 2, -23 },
  { 4323, 16, 33, 23, 4, -23 },
  { 4389, 17, 33, 23, 2, -23 },
  { 4460, 10, 23, 14, 4, -23 },
  { 4489, 14, 23, 17, 2, -23 },
  { 4530, 10, 28, 12, 1, -28 },
  { 4565, 15, 23, 22, 3, -23 },
  { 4609, 16, 23, 16, 0, -23 },
  { 4655, 25, 23, 27, 1, -23 },
  { 4727, 16, 23, 18, 1, -23 },
  { 4773, 17, 33, 17, 0, -23 },
  { 4844, 13, 23, 16, 2, -23 },
  { 4882, 11, 38, 15, 2, -31 },
  { 4935, 1, 44, 21, 10, -33 },
  { 4941, 11, 38, 15, 2, -31 },
  { 4994, 18, 4, 22, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Thin43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_THIN43PT7B_H_
