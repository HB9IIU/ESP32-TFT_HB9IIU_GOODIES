#ifndef _NOTOSANS_SEMICONDENSED_THIN72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin72pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00,
  0x0E, 0xEF, 0xE4, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xF3,
  0x0F, 0xC0, 0x70, 0x60, 0x3C, 0x18, 0x0C, 0x01, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x63, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0x63, 0x00, 0x30, 0x38, 0x7E, 0x06, 0x1E, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x20, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x70, 0x30, 0x00,
  0x03, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x00, 0x18,
  0x18, 0x02, 0x01, 0x80, 0x03, 0x03, 0x03, 0xF8, 0x30, 0x00, 0x60, 0xC0,
  0xE1, 0xC2, 0x00, 0x0C, 0x18, 0x30, 0x1C, 0x60, 0x01, 0x83, 0x0C, 0x01,
  0x8C, 0x00, 0x60, 0xC1, 0x80, 0x19, 0x80, 0x0C, 0x18, 0x60, 0x03, 0x18,
  0x03, 0x86, 0x0C, 0x00, 0x63, 0x80, 0x60, 0xC1, 0x00, 0x06, 0x38, 0x18,
  0x30, 0x60, 0x00, 0xC3, 0xFE, 0x06, 0x0C, 0x00, 0x18, 0x1F, 0x81, 0x81,
  0x80, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0x00, 0xC0, 0x70, 0x01, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x00, 0xDE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x30, 0xE0, 0x01, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x00, 0x0C, 0x60,
  0x00, 0x38, 0x00, 0x63, 0x00, 0x00, 0xC0, 0x06, 0x30, 0x00, 0x03, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x18, 0x60, 0x00,
  0x01, 0xC0, 0xC3, 0x00, 0x00, 0x07, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60,
  0xC0, 0x00, 0x00, 0x66, 0x06, 0x00, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x00, 0x3B, 0x01, 0xC0, 0x00, 0x03, 0x8C, 0x06, 0x00, 0x00, 0x38,
  0x30, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x01, 0xF0,
  0x1F, 0x00, 0x18, 0x03, 0xFF, 0xE0, 0x00, 0x70, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x38, 0x03, 0x00, 0x6F, 0x80, 0xC0, 0x7C, 0x7C, 0x30, 0xF8, 0x01,
  0xED, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x71,
  0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x84, 0x30, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF4, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x06, 0xC0, 0x73, 0x03, 0x8C, 0x1C, 0x31,
  0xC0, 0xCE, 0x03, 0x70, 0x0F, 0x80, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x80, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x1F, 0xC0,
  0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x03,
  0xC0, 0x00, 0xDF, 0xFF, 0xC0, 0x1F, 0xC0, 0x3E, 0x01, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x1F, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x00, 0x10, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x30, 0x3F, 0xFC, 0x01, 0x83, 0xE0, 0xF8, 0x08, 0x70,
  0x00, 0xE0, 0x47, 0x00, 0x01, 0x86, 0x60, 0x00, 0x06, 0x36, 0x00, 0x00,
  0x31, 0xB0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0x80, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1B,
  0x30, 0x00, 0x03, 0xB1, 0x80, 0x00, 0x73, 0x1C, 0x00, 0x0E, 0x30, 0xF0,
  0x03, 0xC3, 0x03, 0xFF, 0xF0, 0x20, 0x0F, 0xFC, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x30, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xD0, 0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x43,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x3C, 0x00, 0xF0, 0x80, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xF0,
  0x00, 0x0C, 0x30, 0x00, 0x07, 0xFF, 0x80, 0x06, 0x30, 0x00, 0x1F, 0x03,
  0xC0, 0x06, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0x00,
  0xC0, 0x03, 0x60, 0x01, 0x80, 0x00, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x06, 0x00, 0x03,
  0x80, 0x06, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x00, 0x06,
  0x80, 0x06, 0xC0, 0x03, 0x00, 0x06, 0x80, 0x0C, 0x40, 0x01, 0x80, 0x0C,
  0xC0, 0x0C, 0x60, 0x01, 0xC0, 0x1C, 0xC0, 0x18, 0x60, 0x00, 0xE0, 0x38,
  0x60, 0x70, 0x60, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x30, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01, 0xC1, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x1F, 0xE0, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x07, 0x83, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x01, 0xE1,
  0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x20, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x07,
  0xFC, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x18, 0x00, 0x00, 0xF0, 0x0C, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x01, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x00, 0x02, 0x1C, 0x00, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x20, 0x1C, 0x00, 0x00,
  0x01, 0x00, 0x70, 0x00, 0x00, 0x08, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xE1, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x0F, 0xFB, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x9E, 0x3E, 0x3F, 0xF0, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38, 0x01, 0x80, 0x03,
  0x80, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x0F, 0x00, 0x00, 0x18, 0xFC, 0x00, 0x00, 0xCE, 0x60, 0x00,
  0x06, 0xE1, 0x80, 0x00, 0x36, 0x0E, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30,
  0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1B, 0xF0, 0x00, 0x00, 0x00, 0x06, 0xF6, 0x00,
  0x00, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x00, 0x00, 0xCF, 0x30, 0x00, 0x00,
  0x00, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x18, 0xF3, 0x00, 0x00, 0x00, 0x06,
  0x3C, 0x60, 0x00, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x00, 0x00, 0xC3, 0xC6,
  0x00, 0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x00, 0x0C, 0x3C, 0x30, 0x00,
  0x00, 0x06, 0x0F, 0x06, 0x00, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x00, 0x00,
  0xC0, 0xF0, 0x60, 0x00, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0x00, 0x0C, 0x0F,
  0x03, 0x00, 0x00, 0x06, 0x03, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xF0, 0x18,
  0x00, 0x00, 0x60, 0x3C, 0x06, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xC0, 0x00,
  0x0C, 0x03, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xF0, 0x0C, 0x00, 0x01, 0x80,
  0x3C, 0x01, 0x80, 0x00, 0x60, 0x0F, 0x00, 0x60, 0x00, 0x30, 0x03, 0xC0,
  0x18, 0x00, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x03, 0x00, 0x3C, 0x00, 0xC0,
  0x01, 0x80, 0x0F, 0x00, 0x30, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xF0, 0x00,
  0x60, 0x18, 0x00, 0x3C, 0x00, 0x18, 0x0C, 0x00, 0x0F, 0x00, 0x06, 0x03,
  0x00, 0x03, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x18, 0x00, 0x0F, 0x00, 0x01, 0x8C, 0x00, 0x03, 0xC0,
  0x00, 0x63, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x07, 0x8C,
  0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x18,
  0x00, 0x00, 0x78, 0x18, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x01, 0xE0, 0x30,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x60, 0x00, 0x0F, 0x00, 0x60,
  0x00, 0x1E, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x78, 0x01, 0x80,
  0x00, 0xF0, 0x01, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x00,
  0x07, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x0C, 0x01,
  0xE0, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x18, 0x07, 0x80, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x60, 0x78,
  0x00, 0x00, 0x60, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0xC3, 0xC0,
  0x00, 0x00, 0xC7, 0x80, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x30, 0x03,
  0xFC, 0x0C, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x0F, 0x0C, 0x00, 0x0F, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0x80, 0x0C, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x3C, 0x0C,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x21, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x03,
  0xC3, 0xF8, 0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x60, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x02, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0x78, 0x1E, 0x00, 0x1C, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0x03, 0x03, 0xC0, 0x03, 0x0F, 0x00, 0x03, 0x1C,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0D, 0x60, 0x00, 0x0D, 0x60,
  0x00, 0x19, 0x30, 0x00, 0x31, 0x38, 0x00, 0x61, 0x1E, 0x03, 0xC1, 0x07,
  0xFF, 0x81, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x1F, 0x80, 0x0C, 0x0F, 0xFF, 0x00, 0xC1, 0xE0, 0x3C, 0x0C,
  0x70, 0x00, 0xE0, 0xCE, 0x00, 0x07, 0x0C, 0xC0, 0x00, 0x38, 0xD8, 0x00,
  0x01, 0x8F, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xCF, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0x8D, 0x80, 0x00, 0x18,
  0xD8, 0x00, 0x03, 0x0C, 0xC0, 0x00, 0x60, 0xC7, 0x00, 0x1C, 0x0C, 0x3C,
  0x07, 0x80, 0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x0F, 0x01, 0xC0, 0x01, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x01,
  0x01, 0xF0, 0x0F, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x30, 0x0F, 0xFF, 0x03,
  0x01, 0xE0, 0x3C, 0x30, 0x78, 0x00, 0xE3, 0x06, 0x00, 0x07, 0x30, 0xC0,
  0x00, 0x33, 0x18, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x00,
  0xF3, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00,
  0xB1, 0x80, 0x00, 0x1B, 0x1C, 0x00, 0x03, 0x30, 0xE0, 0x00, 0x73, 0x07,
  0x00, 0x0E, 0x30, 0x3E, 0x03, 0x83, 0x00, 0xFF, 0xF0, 0x30, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x81, 0xE0, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x38, 0x00, 0x18, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1C, 0x02,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x83,
  0x01, 0xE0, 0x3C, 0x30, 0x70, 0x00, 0xE3, 0x0E, 0x00, 0x03, 0x30, 0xC0,
  0x00, 0x1B, 0x18, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x00,
  0xF3, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00,
  0xB1, 0x80, 0x00, 0x1B, 0x1C, 0x00, 0x03, 0x30, 0xE0, 0x00, 0x73, 0x07,
  0x00, 0x0E, 0x30, 0x3E, 0x07, 0x83, 0x00, 0xFF, 0xF0, 0x30, 0x01, 0xF8,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x20, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xE0, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x0F, 0x00, 0x60, 0x7F, 0xF8, 0x30, 0xF8, 0x1E, 0x18, 0xE0, 0x03, 0x8C,
  0xE0, 0x00, 0x66, 0xE0, 0x00, 0x3B, 0x60, 0x00, 0x0D, 0xE0, 0x00, 0x06,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0E, 0x7F,
  0x8F, 0xE0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0,
  0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x0D, 0x80, 0x06, 0x33, 0x00, 0x0C, 0xC3, 0x00,
  0x1B, 0x07, 0x00, 0x36, 0x06, 0x00, 0x78, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80,
  0x00, 0x63, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x10, 0x3F, 0xF8, 0x01, 0xFF, 0x82, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x63,
  0x00, 0x38, 0x38, 0x01, 0xCC, 0xC0, 0x03, 0x8C, 0x00, 0x19, 0xB0, 0x00,
  0x33, 0x00, 0x01, 0xB4, 0x00, 0x03, 0x60, 0x00, 0x37, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x60, 0x7F, 0xF8, 0x30, 0xF8, 0x1E, 0x18, 0xE0,
  0x03, 0x8C, 0xE0, 0x00, 0x66, 0x60, 0x00, 0x3B, 0x60, 0x00, 0x0D, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x78,
  0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x06, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0C, 0x0F, 0xFF, 0x00, 0xC1,
  0xE0, 0x3C, 0x0C, 0x38, 0x00, 0xE0, 0xC6, 0x00, 0x07, 0x0C, 0xC0, 0x00,
  0x38, 0xD8, 0x00, 0x01, 0x8D, 0x80, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0xCF,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x0C, 0xD0, 0x00, 0x01, 0x8D,
  0x80, 0x00, 0x18, 0xCC, 0x00, 0x03, 0x0C, 0xE0, 0x00, 0x70, 0xC7, 0x00,
  0x1C, 0x0C, 0x3E, 0x07, 0x80, 0xC0, 0xFF, 0xF0, 0x0C, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xFF, 0x03, 0x01, 0xE0, 0x7C, 0x30, 0x78, 0x00, 0xE3, 0x0E, 0x00,
  0x07, 0x30, 0xC0, 0x00, 0x33, 0x18, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x0B,
  0x30, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x30, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x1B, 0x18, 0x00, 0x03, 0x30, 0xC0,
  0x00, 0x63, 0x07, 0x00, 0x1C, 0x30, 0x3C, 0x07, 0x83, 0x01, 0xFF, 0xE0,
  0x30, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x60, 0x7F, 0xF0, 0xF0, 0x78, 0xE0, 0x0C, 0xC0, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x3E, 0x01, 0xF0, 0xE0, 0x00, 0x63, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x34, 0x00, 0x00, 0xCE, 0x00, 0x07, 0x9F, 0x80, 0x3C,
  0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x04, 0x03, 0xFE, 0x00, 0x3C,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0B, 0x60, 0x00, 0x0D, 0xB0, 0x00, 0x0C, 0xCC, 0x00,
  0x0E, 0x67, 0x80, 0x0E, 0x31, 0xF0, 0x3C, 0x18, 0x3F, 0xFC, 0x0C, 0x01,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x09, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x30, 0x00, 0x07, 0x80, 0x00, 0x66, 0x00, 0x00, 0xB0,
  0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x60, 0x00,
  0x61, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x30, 0x00, 0x11, 0x80, 0x01, 0x82,
  0x00, 0x06, 0x10, 0x00, 0x20, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0,
  0xC0, 0x04, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x60, 0x01, 0x82, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x40, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0x68, 0x00, 0x01, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x06, 0x0E,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x13, 0xC1, 0xE0, 0x00, 0x58,
  0x01, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x7A, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xF0, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 52, 15, 6, -51 },
  { 27, 12, 18, 22, 5, -51 },
  { 54, 37, 51, 41, 2, -51 },
  { 290, 27, 59, 36, 4, -55 },
  { 490, 43, 53, 51, 4, -52 },
  { 775, 37, 53, 42, 4, -52 },
  { 1021, 2, 18, 12, 5, -51 },
  { 1026, 13, 62, 19, 3, -51 },
  { 1127, 12, 62, 19, 3, -51 },
  { 1220, 26, 25, 34, 4, -55 },
  { 1302, 30, 33, 37, 3, -42 },
  { 1426, 6, 17, 13, 3, -8 },
  { 1439, 16, 2, 22, 3, -21 },
  { 1443, 3, 5, 15, 6, -4 },
  { 1445, 21, 51, 23, 1, -51 },
  { 1579, 28, 53, 36, 4, -52 },
  { 1765, 14, 51, 36, 7, -51 },
  { 1855, 28, 52, 36, 4, -52 },
  { 2037, 29, 53, 36, 3, -52 },
  { 2230, 34, 52, 36, 2, -52 },
  { 2451, 27, 52, 36, 5, -51 },
  { 2627, 29, 53, 36, 4, -52 },
  { 2820, 28, 51, 36, 4, -51 },
  { 2999, 28, 53, 36, 4, -52 },
  { 3185, 28, 53, 36, 4, -52 },
  { 3371, 3, 39, 15, 6, -38 },
  { 3386, 6, 47, 15, 3, -38 },
  { 3422, 30, 31, 37, 3, -41 },
  { 3539, 30, 17, 37, 3, -34 },
  { 3603, 30, 31, 37, 3, -41 },
  { 3720, 21, 53, 26, 2, -52 },
  { 3860, 48, 58, 56, 4, -51 },
  { 4208, 36, 51, 36, 0, -51 },
  { 4438, 29, 51, 39, 7, -51 },
  { 4623, 33, 53, 39, 4, -52 },
  { 4842, 33, 51, 44, 7, -51 },
  { 5053, 24, 51, 35, 7, -51 },
  { 5206, 24, 51, 32, 7, -51 },
  { 5359, 37, 53, 47, 4, -52 },
  { 5605, 31, 51, 45, 7, -51 },
  { 5803, 11, 51, 19, 4, -51 },
  { 5874, 15, 64, 15, -6, -51 },
  { 5994, 29, 51, 35, 7, -51 },
  { 6179, 24, 51, 32, 7, -51 },
  { 6332, 42, 51, 55, 7, -51 },
  { 6600, 31, 51, 45, 7, -51 },
  { 6798, 40, 53, 48, 4, -52 },
  { 7063, 26, 51, 37, 7, -51 },
  { 7229, 40, 64, 48, 4, -52 },
  { 7549, 28, 51, 37, 7, -51 },
  { 7728, 27, 53, 35, 4, -52 },
  { 7907, 32, 51, 32, 0, -51 },
  { 8111, 33, 52, 45, 6, -51 },
  { 8326, 35, 51, 35, 0, -51 },
  { 8550, 53, 51, 57, 2, -51 },
  { 8888, 32, 51, 32, 0, -51 },
  { 9092, 31, 51, 31, 0, -51 },
  { 9290, 31, 51, 35, 2, -51 },
  { 9488, 14, 62, 22, 6, -51 },
  { 9597, 21, 51, 23, 1, -51 },
  { 9731, 14, 62, 22, 2, -51 },
  { 9840, 31, 30, 36, 3, -52 },
  { 9957, 28, 1, 28, 0, 7 },
  { 9961, 11, 11, 17, 3, -55 },
  { 9977, 24, 40, 33, 3, -39 },
  { 10097, 28, 56, 38, 6, -55 },
  { 10293, 24, 40, 30, 4, -39 },
  { 10413, 28, 56, 38, 4, -55 },
  { 10609, 27, 40, 35, 4, -39 },
  { 10744, 21, 55, 18, 1, -55 },
  { 10889, 28, 56, 38, 4, -39 },
  { 11085, 25, 55, 37, 6, -55 },
  { 11257, 4, 52, 14, 5, -52 },
  { 11283, 11, 69, 14, -2, -52 },
  { 11378, 23, 55, 29, 6, -55 },
  { 11537, 2, 55, 14, 6, -55 },
  { 11551, 43, 39, 55, 6, -39 },
  { 11761, 25, 39, 37, 6, -39 },
  { 11883, 29, 40, 37, 4, -39 },
  { 12028, 28, 56, 38, 6, -39 },
  { 12224, 28, 56, 38, 4, -39 },
  { 12420, 17, 39, 24, 6, -39 },
  { 12503, 23, 40, 29, 3, -39 },
  { 12618, 17, 48, 20, 1, -47 },
  { 12720, 25, 39, 37, 6, -38 },
  { 12842, 27, 38, 27, 0, -38 },
  { 12971, 43, 38, 45, 1, -38 },
  { 13176, 26, 38, 30, 2, -38 },
  { 13300, 28, 56, 28, 0, -38 },
  { 13496, 22, 38, 28, 3, -38 },
  { 13601, 18, 62, 24, 3, -51 },
  { 13741, 2, 73, 34, 16, -55 },
  { 13760, 19, 62, 24, 3, -51 },
  { 13908, 30, 7, 37, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_Thin72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_THIN72PT7B_H_
