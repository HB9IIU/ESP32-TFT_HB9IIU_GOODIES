#ifndef _NOTOSANS_SEMICONDENSED_THIN32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x86, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x02, 0x08,
  0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10,
  0x7F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x08, 0x20, 0x10, 0x20, 0x10, 0x20,
  0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x04, 0x00, 0xD0, 0x34,
  0xE4, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x64,
  0x01, 0xC0, 0x06, 0x00, 0x58, 0x04, 0x40, 0x42, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x20, 0x46, 0xE5, 0x81, 0x60, 0x04, 0x00, 0x40, 0x3C,
  0x02, 0x08, 0x40, 0x42, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81, 0x02,
  0x10, 0x20, 0x44, 0x04, 0x08, 0x80, 0x81, 0x20, 0x10, 0x44, 0xF2, 0x09,
  0x21, 0x41, 0x24, 0x24, 0x48, 0x82, 0x79, 0x20, 0x40, 0x24, 0x08, 0x08,
  0x81, 0x01, 0x10, 0x20, 0x42, 0x04, 0x08, 0x40, 0x82, 0x08, 0x10, 0x40,
  0x82, 0x10, 0x10, 0x82, 0x01, 0xE0, 0x0F, 0x80, 0x10, 0x40, 0x20, 0x40,
  0x20, 0x40, 0x20, 0x20, 0x20, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10, 0x80,
  0x0B, 0x00, 0x04, 0x00, 0x1A, 0x00, 0x22, 0x00, 0x41, 0x02, 0x80, 0x82,
  0x80, 0x42, 0x80, 0x24, 0x80, 0x14, 0x80, 0x18, 0x80, 0x08, 0x80, 0x14,
  0x40, 0x62, 0x3F, 0x81, 0xFF, 0x04, 0x21, 0x04, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x02, 0x08, 0x10,
  0x40, 0x81, 0x81, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x84, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x42, 0x16, 0x4C, 0x3E, 0x02, 0x80, 0x50, 0x11, 0x04,
  0x10, 0x82, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x3F, 0xFF, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x24, 0xA4, 0x94, 0xFF, 0x70, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x00, 0x1F, 0x82, 0x04, 0x20, 0x24, 0x02, 0x40, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x20, 0x22, 0x04, 0x1F, 0x80,
  0x04, 0x31, 0x59, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x3F, 0x0C, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0xFF, 0xF0, 0x1F, 0xC3, 0x01, 0x10, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x70, 0x3F,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x40, 0x11, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20,
  0x10, 0x40, 0x40, 0x80, 0x81, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0x40,
  0x10, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x05, 0xF0, 0x60, 0xC0, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x28, 0x04,
  0x7F, 0x80, 0x07, 0xE0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x7C, 0x2C, 0x19, 0x80, 0x4C, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x01, 0x80, 0x0C, 0x00, 0x90, 0x04, 0x80, 0x24, 0x02,
  0x10, 0x10, 0x7F, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x00, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x02, 0x20, 0x41, 0x08, 0x0F, 0x00, 0x90, 0x30, 0xC4, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x16, 0x02,
  0x1F, 0xC0, 0x1F, 0x06, 0x0C, 0x40, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x40, 0x53, 0xF9, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x7E,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x24, 0x00, 0x00, 0x00, 0x00, 0x49,
  0x49, 0x28, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0xE0,
  0x00, 0x7E, 0x40, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x40, 0x00, 0xFC, 0x00, 0x18, 0x18, 0x03, 0x00, 0x30, 0x20,
  0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x0F, 0xC1,
  0x81, 0x82, 0x0C, 0x08, 0x10, 0x60, 0x80, 0x83, 0x04, 0x04, 0x18, 0x20,
  0x20, 0xC2, 0x01, 0x06, 0x10, 0x10, 0x30, 0x40, 0x81, 0x82, 0x06, 0x0C,
  0x10, 0x50, 0xA0, 0x64, 0x48, 0x80, 0xC1, 0x84, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x10, 0x08, 0x1F, 0xF8, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0xFF, 0x84,
  0x03, 0x20, 0x0D, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x01, 0x3F, 0xF1, 0x07, 0x88, 0x02, 0x40, 0x0A, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x33, 0xFE, 0x00,
  0x03, 0xF8, 0x30, 0x11, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x7F, 0xC0, 0xFF, 0x01, 0x01, 0xC2, 0x00, 0xC4, 0x00,
  0xC8, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0xC8, 0x03, 0x10, 0x08, 0x3F, 0xE0,
  0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0F, 0xFD, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x00, 0x03, 0xFE, 0x0C, 0x01, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08,
  0x01, 0x07, 0xFE, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x13, 0xE0, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x14, 0x66,
  0x00, 0x80, 0x1C, 0x01, 0x20, 0x19, 0x00, 0x88, 0x08, 0x40, 0x82, 0x08,
  0x10, 0x80, 0x88, 0x04, 0xC0, 0x26, 0x01, 0x50, 0x0C, 0x40, 0x41, 0x02,
  0x08, 0x10, 0x20, 0x80, 0x84, 0x04, 0x20, 0x11, 0x00, 0xC8, 0x02, 0x40,
  0x0A, 0x00, 0x60, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x02, 0xD0, 0x00, 0x5A, 0x00, 0x0B, 0x40,
  0x02, 0x64, 0x00, 0x4C, 0x80, 0x09, 0x90, 0x02, 0x31, 0x00, 0x46, 0x20,
  0x10, 0xC2, 0x02, 0x18, 0x40, 0x43, 0x08, 0x10, 0x60, 0x82, 0x0C, 0x10,
  0x41, 0x82, 0x10, 0x30, 0x22, 0x06, 0x04, 0x80, 0xC0, 0x50, 0x18, 0x0A,
  0x03, 0x01, 0x80, 0x60, 0x10, 0x08, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x68,
  0x01, 0xA0, 0x06, 0x40, 0x18, 0x80, 0x62, 0x01, 0x84, 0x06, 0x10, 0x18,
  0x20, 0x60, 0x41, 0x81, 0x06, 0x02, 0x18, 0x08, 0x60, 0x11, 0x80, 0x46,
  0x00, 0x98, 0x01, 0x60, 0x05, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x40, 0x07,
  0xF0, 0x04, 0x06, 0x04, 0x00, 0x84, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0A,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x44, 0x00, 0x23, 0x00, 0x20, 0xC0, 0x20, 0x1F, 0xE0,
  0xFE, 0x08, 0x0C, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x02, 0x80, 0x28, 0x0C, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07,
  0xF0, 0x04, 0x06, 0x04, 0x00, 0x84, 0x00, 0x24, 0x00, 0x12, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x44, 0x00, 0x23, 0x00, 0x20, 0xC0, 0x20, 0x1F, 0xE0,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0xFE,
  0x04, 0x06, 0x20, 0x09, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x24, 0x01, 0x20, 0x11, 0x03, 0x0F, 0xE0, 0x41, 0x02, 0x04, 0x10,
  0x10, 0x80, 0x84, 0x02, 0x20, 0x11, 0x00, 0x48, 0x02, 0x40, 0x0A, 0x00,
  0x60, 0x1F, 0xE6, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x28, 0x04, 0xFF, 0x80,
  0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x40, 0x08, 0x80, 0x41, 0xFE, 0x00, 0x80, 0x01,
  0x80, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x08, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x02, 0x80, 0x28, 0x02, 0x40, 0x28, 0x02, 0x40, 0x28, 0x04, 0x40,
  0x28, 0x04, 0x40, 0x44, 0x04, 0x20, 0x44, 0x04, 0x20, 0x44, 0x08, 0x20,
  0x44, 0x08, 0x20, 0x42, 0x08, 0x10, 0x82, 0x08, 0x10, 0x82, 0x10, 0x10,
  0x82, 0x10, 0x10, 0x81, 0x10, 0x09, 0x01, 0x10, 0x09, 0x01, 0x20, 0x09,
  0x01, 0x20, 0x09, 0x00, 0xA0, 0x06, 0x00, 0xA0, 0x06, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0x40, 0x40, 0x04, 0x80, 0x22, 0x00, 0x84, 0x04,
  0x10, 0x20, 0x20, 0x80, 0x84, 0x01, 0x10, 0x04, 0x80, 0x0A, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x80, 0x12, 0x00, 0x44, 0x02, 0x10, 0x08, 0x20, 0x40,
  0x81, 0x01, 0x08, 0x04, 0x40, 0x09, 0x00, 0x28, 0x00, 0x40, 0x80, 0x05,
  0x00, 0x24, 0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x81, 0x02, 0x04, 0x08,
  0x08, 0x40, 0x21, 0x00, 0x48, 0x01, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x7F, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x03, 0xFF, 0xE0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x3F, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x02, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x7F, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20, 0x04, 0x40, 0x21, 0x00,
  0x82, 0x04, 0x08, 0x20, 0x10, 0x80, 0x44, 0x00, 0x90, 0x02, 0x80, 0x04,
  0xFF, 0xF8, 0xC1, 0x04, 0x10, 0x80, 0x1F, 0x84, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x0F, 0x1E, 0x24, 0x05, 0x00, 0xA0, 0x18, 0x03,
  0x00, 0x50, 0x1A, 0x05, 0x3F, 0x20, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x09, 0xF8, 0xA0, 0x4C, 0x02, 0x80, 0x28, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x2C, 0x02, 0xE0, 0x49, 0xF8, 0x0F, 0xCC, 0x06, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x1F, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x11, 0xF9, 0x20, 0x54, 0x03, 0x40, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14,
  0x03, 0x20, 0x51, 0xF9, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x02, 0x1F, 0xE0, 0x0F, 0xC2, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x03, 0xF8, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x1F, 0x92, 0x05, 0x40, 0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x32, 0x05,
  0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x2E, 0x0C,
  0x0F, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0xFC, 0xA0, 0x58, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xF0,
  0x05, 0x55, 0x55, 0x55, 0x54, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0x0B,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x02, 0x81,
  0x20, 0x48, 0x22, 0x10, 0x88, 0x24, 0x09, 0x02, 0xA0, 0xC8, 0x21, 0x08,
  0x22, 0x08, 0x81, 0x20, 0x28, 0x0A, 0x01, 0xFF, 0xFF, 0xFF, 0x9F, 0x0F,
  0x9C, 0x16, 0x0B, 0x02, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x9F, 0x94, 0x0B, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x1F, 0x81, 0x03, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01,
  0x20, 0x09, 0x00, 0x84, 0x0C, 0x1F, 0x80, 0x9F, 0x8A, 0x04, 0xC0, 0x28,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x02, 0xC0, 0x2A, 0x04, 0x9F, 0x88, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x1F, 0x92, 0x05, 0x40, 0x34,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x40, 0x36, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x9F, 0x43, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1F, 0xCC,
  0x09, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x14, 0x02, 0x7F, 0x80, 0x10, 0x10,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x03, 0x40, 0x36, 0x05, 0x3F, 0x90, 0x80, 0x18, 0x01,
  0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08,
  0x10, 0x80, 0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0x80,
  0x20, 0x28, 0x0C, 0x05, 0x01, 0x80, 0xA0, 0x28, 0x12, 0x09, 0x04, 0x41,
  0x20, 0x88, 0x24, 0x11, 0x04, 0x42, 0x11, 0x08, 0x82, 0x21, 0x10, 0x44,
  0x12, 0x09, 0x02, 0x40, 0xA0, 0x50, 0x14, 0x0A, 0x02, 0x80, 0xC0, 0x20,
  0x18, 0x04, 0x02, 0x00, 0x80, 0x24, 0x04, 0x40, 0x42, 0x08, 0x10, 0x81,
  0x10, 0x0A, 0x00, 0x60, 0x04, 0x00, 0xA0, 0x09, 0x01, 0x10, 0x20, 0x82,
  0x08, 0x40, 0x44, 0x02, 0x80, 0x30, 0x80, 0x14, 0x01, 0x40, 0x14, 0x02,
  0x20, 0x22, 0x02, 0x20, 0x41, 0x04, 0x10, 0x41, 0x08, 0x08, 0x80, 0x88,
  0x09, 0x00, 0x50, 0x05, 0x00, 0x60, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x01, 0x00, 0xFF, 0xC0, 0x03, 0x86, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x03, 0x03, 0x80, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x10, 0x0E, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x1C, 0x00, 0x3C, 0x01, 0x0C, 0x18, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 23, 7, 3, -23 },
  { 4, 6, 8, 10, 2, -23 },
  { 10, 16, 23, 18, 1, -23 },
  { 56, 12, 26, 16, 2, -24 },
  { 95, 19, 23, 23, 2, -23 },
  { 150, 16, 23, 19, 2, -23 },
  { 196, 1, 8, 5, 2, -23 },
  { 197, 6, 28, 8, 1, -23 },
  { 218, 6, 28, 8, 1, -23 },
  { 239, 11, 11, 15, 2, -24 },
  { 255, 14, 15, 16, 1, -19 },
  { 282, 3, 8, 6, 1, -4 },
  { 285, 8, 1, 10, 1, -9 },
  { 286, 2, 2, 7, 2, -2 },
  { 287, 9, 23, 10, 1, -23 },
  { 313, 12, 23, 16, 2, -23 },
  { 348, 6, 23, 16, 3, -23 },
  { 366, 12, 23, 16, 2, -23 },
  { 401, 13, 23, 16, 1, -23 },
  { 439, 15, 23, 16, 1, -23 },
  { 483, 12, 23, 16, 2, -23 },
  { 518, 13, 23, 16, 2, -23 },
  { 556, 12, 23, 16, 2, -23 },
  { 591, 12, 23, 16, 2, -23 },
  { 626, 12, 23, 16, 2, -23 },
  { 661, 2, 17, 7, 2, -17 },
  { 666, 3, 21, 7, 1, -17 },
  { 674, 14, 13, 16, 1, -18 },
  { 697, 14, 7, 16, 1, -15 },
  { 710, 14, 13, 16, 1, -18 },
  { 733, 9, 23, 11, 1, -23 },
  { 759, 21, 26, 25, 2, -23 },
  { 828, 16, 23, 16, 0, -23 },
  { 874, 13, 23, 17, 3, -23 },
  { 912, 14, 23, 17, 2, -23 },
  { 953, 15, 23, 20, 3, -23 },
  { 997, 11, 23, 16, 3, -23 },
  { 1029, 11, 23, 14, 3, -23 },
  { 1061, 16, 23, 21, 2, -23 },
  { 1107, 14, 23, 20, 3, -23 },
  { 1148, 5, 23, 8, 2, -23 },
  { 1163, 7, 29, 7, -3, -23 },
  { 1189, 13, 23, 16, 3, -23 },
  { 1227, 11, 23, 14, 3, -23 },
  { 1259, 19, 23, 25, 3, -23 },
  { 1314, 14, 23, 20, 3, -23 },
  { 1355, 17, 23, 21, 2, -23 },
  { 1404, 12, 23, 16, 3, -23 },
  { 1439, 17, 28, 21, 2, -23 },
  { 1499, 13, 23, 16, 3, -23 },
  { 1537, 12, 23, 16, 2, -23 },
  { 1572, 14, 23, 14, 0, -23 },
  { 1613, 14, 23, 20, 3, -23 },
  { 1654, 16, 23, 16, 0, -23 },
  { 1700, 24, 23, 25, 1, -23 },
  { 1769, 14, 23, 14, 0, -23 },
  { 1810, 14, 23, 14, 0, -23 },
  { 1851, 13, 23, 16, 1, -23 },
  { 1889, 6, 28, 10, 3, -23 },
  { 1910, 9, 23, 10, 1, -23 },
  { 1936, 6, 28, 10, 1, -23 },
  { 1957, 14, 13, 16, 1, -23 },
  { 1980, 13, 1, 13, 0, 3 },
  { 1982, 5, 5, 8, 1, -24 },
  { 1986, 11, 17, 15, 1, -17 },
  { 2010, 12, 24, 17, 3, -24 },
  { 2046, 10, 17, 13, 2, -17 },
  { 2068, 12, 24, 17, 2, -24 },
  { 2104, 12, 17, 15, 2, -17 },
  { 2130, 10, 24, 8, 0, -24 },
  { 2160, 12, 25, 17, 2, -17 },
  { 2198, 11, 24, 16, 3, -24 },
  { 2231, 2, 23, 6, 2, -23 },
  { 2237, 5, 31, 6, -1, -23 },
  { 2257, 10, 24, 13, 3, -24 },
  { 2287, 1, 24, 6, 3, -24 },
  { 2290, 19, 17, 24, 3, -17 },
  { 2331, 11, 17, 16, 3, -17 },
  { 2355, 13, 17, 16, 2, -17 },
  { 2383, 12, 24, 17, 3, -17 },
  { 2419, 12, 24, 17, 2, -17 },
  { 2455, 7, 17, 11, 3, -17 },
  { 2470, 11, 17, 13, 1, -17 },
  { 2494, 8, 21, 9, 0, -21 },
  { 2515, 12, 17, 16, 2, -17 },
  { 2541, 12, 17, 12, 0, -17 },
  { 2567, 19, 17, 20, 0, -17 },
  { 2608, 12, 17, 13, 1, -17 },
  { 2634, 12, 25, 12, 0, -17 },
  { 2672, 10, 17, 12, 1, -17 },
  { 2694, 9, 28, 11, 1, -23 },
  { 2726, 1, 32, 15, 7, -24 },
  { 2730, 9, 28, 11, 1, -23 },
  { 2762, 14, 3, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Thin32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_THIN32PT7B_H_
