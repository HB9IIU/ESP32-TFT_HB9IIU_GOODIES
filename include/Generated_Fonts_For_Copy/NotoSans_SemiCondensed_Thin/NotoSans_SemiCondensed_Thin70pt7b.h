#ifndef _NOTOSANS_SEMICONDENSED_THIN70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xA4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0xE0, 0x80, 0xF0, 0x60, 0x20, 0x08, 0x30, 0x08,
  0x00, 0x18, 0x02, 0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00, 0xC0,
  0x08, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00,
  0xC0, 0x08, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x20,
  0x00, 0x60, 0x08, 0x00, 0x1C, 0x02, 0x00, 0x03, 0x80, 0x80, 0x00, 0x70,
  0x20, 0x00, 0x0F, 0x08, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x02, 0x78, 0x00, 0x00, 0x87,
  0x80, 0x00, 0x20, 0x70, 0x00, 0x08, 0x0E, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x80, 0x38, 0x00, 0x20, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x30,
  0x00, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00,
  0x30, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x08, 0x01, 0x80, 0x02,
  0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x20, 0x1C, 0xC0, 0x08, 0x0E, 0x3E,
  0x02, 0x1E, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x30,
  0x01, 0xC1, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x30, 0x00, 0x04, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x00, 0x18, 0x08, 0x00, 0x03, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0x01, 0x81, 0x00, 0xE0, 0x30, 0x00, 0x60, 0xC0, 0xFF, 0x0C, 0x00, 0x10,
  0x30, 0x60, 0xE3, 0x00, 0x0C, 0x18, 0x30, 0x18, 0x60, 0x03, 0x06, 0x18,
  0x03, 0x18, 0x00, 0xC3, 0x06, 0x00, 0x46, 0x00, 0x60, 0xC3, 0x00, 0x18,
  0xC0, 0x18, 0x60, 0xC0, 0x06, 0x38, 0x0C, 0x18, 0x20, 0x00, 0x87, 0x0E,
  0x0C, 0x18, 0x00, 0x30, 0xFF, 0x03, 0x06, 0x00, 0x0C, 0x0F, 0x01, 0x81,
  0x80, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x03, 0x83,
  0x80, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x01, 0x80, 0x01, 0x8C, 0x00,
  0x38, 0x00, 0x33, 0x00, 0x03, 0x80, 0x06, 0x60, 0x00, 0x30, 0x00, 0x98,
  0x00, 0x03, 0x00, 0x33, 0x00, 0x00, 0x30, 0x06, 0x60, 0x00, 0x03, 0x00,
  0x8C, 0x00, 0x00, 0x70, 0x31, 0x00, 0x00, 0x06, 0x04, 0x20, 0x00, 0x00,
  0x61, 0x84, 0x00, 0x00, 0x06, 0x30, 0xC0, 0x00, 0x00, 0x6C, 0x18, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0x01, 0x8C, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0xC0, 0x00, 0x38, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0xF0, 0x0F,
  0x00, 0x18, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x08, 0x01,
  0xF8, 0x04, 0x03, 0xCF, 0x82, 0x0F, 0x00, 0x79, 0x3C, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x44, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x20, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x71, 0x86, 0x18, 0x63,
  0x0C, 0x30, 0xC6, 0x18, 0x61, 0x0C, 0x30, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF7, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x01,
  0xE0, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0x3C, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x1A, 0x03, 0x90, 0x38, 0x83, 0x8C, 0x70, 0x67, 0x03,
  0x70, 0x1E, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x7C,
  0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x88, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x0E, 0x07, 0xF0, 0x07, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00,
  0xE2, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x1C, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x08, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x60, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x07, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x20, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE0, 0x7E, 0x00, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3E, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0x04, 0x07, 0xFF, 0x80, 0x41,
  0xE0, 0x3C, 0x0C, 0x38, 0x00, 0x60, 0xC6, 0x00, 0x03, 0x0C, 0xC0, 0x00,
  0x18, 0xD8, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0x80, 0x07, 0x00, 0xC0,
  0x00, 0x70, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x00,
  0x3C, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x72, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x1B,
  0x18, 0x00, 0x03, 0x30, 0xC0, 0x00, 0x73, 0x0E, 0x00, 0x0E, 0x30, 0x3C,
  0x07, 0x83, 0x01, 0xFF, 0xF0, 0x30, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x3C, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x70, 0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x61, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x84, 0x30, 0xC2,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0x80, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x78, 0x00, 0x06, 0x18, 0x00, 0x07, 0xFF, 0x80,
  0x0C, 0x30, 0x00, 0x3E, 0x07, 0x80, 0x0C, 0xE0, 0x00, 0xE0, 0x03, 0x00,
  0x19, 0x80, 0x03, 0x80, 0x06, 0x00, 0x33, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x66, 0x00, 0x18, 0x00, 0x10, 0x00, 0x58, 0x00, 0x60, 0x00, 0x20, 0x00,
  0xF0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x0F,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x18, 0x00, 0x3C,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x78, 0x00, 0x80, 0x00, 0x60, 0x00, 0xF0,
  0x01, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x02, 0x00, 0x01, 0x80, 0x02, 0xC0,
  0x04, 0x00, 0x03, 0x00, 0x0D, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x1B, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x36, 0x00, 0x30, 0x00, 0x28, 0x00, 0xCC, 0x00,
  0x60, 0x00, 0xD0, 0x01, 0x98, 0x00, 0x60, 0x01, 0x30, 0x07, 0x10, 0x00,
  0xE0, 0x06, 0x60, 0x0C, 0x30, 0x00, 0xE0, 0x18, 0x60, 0x30, 0x60, 0x00,
  0xF1, 0xE0, 0xF3, 0xC0, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x40, 0x06,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x80, 0x00, 0x3C, 0x08, 0x00, 0x00, 0xF0, 0x80, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x48, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x07, 0x08, 0x00, 0x01, 0xC0, 0x80, 0x00,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x01, 0xE0,
  0x80, 0x00, 0x07, 0x08, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x38, 0x80, 0x00,
  0x0E, 0x08, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x02, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0x00, 0xFC, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x80, 0x00, 0x07, 0x80,
  0x80, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x38, 0x80, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x70, 0x80, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x03, 0x80, 0x80, 0x00, 0x07, 0x00, 0x80, 0x00, 0x1E, 0x00,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF4, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x20, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x03,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0xEF, 0xF0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x3F, 0x1F, 0xFC, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x64, 0x03, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x00, 0xE8,
  0x00, 0x00, 0x1C, 0x80, 0x00, 0x03, 0x88, 0x00, 0x00, 0x70, 0x80, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x08, 0x00, 0x03, 0x80,
  0x80, 0x00, 0x70, 0x08, 0x00, 0x0E, 0x00, 0x80, 0x01, 0xC0, 0x08, 0x00,
  0x18, 0x00, 0x80, 0x03, 0x00, 0x08, 0x00, 0x70, 0x00, 0x80, 0x0E, 0x00,
  0x08, 0x01, 0xC0, 0x00, 0x80, 0x38, 0x00, 0x08, 0x07, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x08, 0x38, 0x00,
  0x00, 0x87, 0xC0, 0x00, 0x08, 0xEC, 0x00, 0x00, 0x8C, 0x60, 0x00, 0x09,
  0x87, 0x00, 0x00, 0xB0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x70, 0x00,
  0x80, 0x03, 0x00, 0x08, 0x00, 0x18, 0x00, 0x80, 0x01, 0xC0, 0x08, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30,
  0x08, 0x00, 0x03, 0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x0E, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x38, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xE8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x00, 0x0F, 0xB0,
  0x00, 0x00, 0x00, 0x0F, 0xB0, 0x00, 0x00, 0x00, 0x1B, 0x98, 0x00, 0x00,
  0x00, 0x1B, 0x98, 0x00, 0x00, 0x00, 0x1B, 0x8C, 0x00, 0x00, 0x00, 0x33,
  0x8C, 0x00, 0x00, 0x00, 0x33, 0x8C, 0x00, 0x00, 0x00, 0x33, 0x86, 0x00,
  0x00, 0x00, 0x63, 0x86, 0x00, 0x00, 0x00, 0x63, 0x86, 0x00, 0x00, 0x00,
  0xC3, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x81,
  0x00, 0x00, 0x01, 0x83, 0x81, 0x80, 0x00, 0x01, 0x83, 0x81, 0x80, 0x00,
  0x01, 0x83, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x03,
  0x80, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x60, 0x00, 0x06, 0x03, 0x80, 0x60,
  0x00, 0x06, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x30, 0x00, 0x0C,
  0x03, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x18, 0x00, 0x18, 0x03, 0x80,
  0x18, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00, 0x10, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x06, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x60, 0x03, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0xC0,
  0x03, 0x80, 0x01, 0x81, 0x80, 0x03, 0x80, 0x01, 0x81, 0x80, 0x03, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x80, 0x00, 0xC3,
  0x00, 0x03, 0x80, 0x00, 0x46, 0x00, 0x03, 0x80, 0x00, 0x66, 0x00, 0x03,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xC0, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x20, 0x00,
  0x3C, 0x10, 0x00, 0x07, 0x88, 0x00, 0x00, 0xE4, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x68, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x19, 0x00, 0x00, 0x18, 0x80, 0x00, 0x1C, 0x40, 0x00,
  0x3C, 0x20, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x02,
  0x00, 0x03, 0xE0, 0x40, 0x00, 0x0E, 0x08, 0x00, 0x00, 0xE1, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x04, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x70, 0x10, 0x00, 0x7C, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x08, 0x00, 0x70, 0x01, 0x00, 0x06, 0x00, 0x20, 0x00,
  0xE0, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x02,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x0C, 0x10,
  0x00, 0x01, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0x80, 0x7F, 0x07, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x30, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x02, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x18, 0x00, 0x06, 0x08, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x80, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x08,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x20,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x10, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0xF0,
  0x1C, 0x00, 0x38, 0x10, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0x03, 0xF0, 0x03, 0x0F, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x38, 0x00, 0x03,
  0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x60, 0x00, 0x1B, 0x60, 0x00, 0x13, 0x70, 0x00, 0x33,
  0x38, 0x00, 0xE3, 0x1E, 0x03, 0xC3, 0x07, 0xFF, 0x03, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xE0, 0x18, 0x78, 0x0F,
  0x03, 0x1C, 0x00, 0x70, 0x66, 0x00, 0x03, 0x0D, 0x80, 0x00, 0x31, 0xB0,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x3C,
  0x00, 0x00, 0x67, 0x80, 0x00, 0x18, 0x98, 0x00, 0x06, 0x11, 0x80, 0x01,
  0xC2, 0x18, 0x00, 0x70, 0x41, 0xE0, 0x78, 0x08, 0x1F, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0x78,
  0x1E, 0x00, 0x10, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x10, 0x1E,
  0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x78, 0x03, 0x00, 0xFF, 0xE0, 0x60, 0x7C, 0x0F, 0x0C, 0x1C, 0x00, 0x71,
  0x87, 0x00, 0x03, 0x31, 0xC0, 0x00, 0x36, 0x30, 0x00, 0x06, 0xCC, 0x00,
  0x00, 0x79, 0x80, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x79, 0x80,
  0x00, 0x1B, 0x18, 0x00, 0x03, 0x61, 0x80, 0x00, 0xCC, 0x3C, 0x00, 0x71,
  0x81, 0xE0, 0x3C, 0x30, 0x1F, 0xFE, 0x06, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x08, 0x1C, 0x00, 0x0C, 0x03, 0xE0, 0x1F, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x00,
  0x78, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFE, 0x0C, 0x0F, 0x81, 0xE1, 0x83, 0x80, 0x06, 0x30, 0xE0,
  0x00, 0x66, 0x38, 0x00, 0x06, 0xC6, 0x00, 0x00, 0x79, 0x80, 0x00, 0x0F,
  0x30, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x79, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0x63, 0x00, 0x00, 0x6C, 0x30, 0x00, 0x39, 0x83, 0x80, 0x0E, 0x30, 0x3C,
  0x07, 0x86, 0x01, 0xFF, 0xC0, 0xC0, 0x07, 0xC0, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x71, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0xFF, 0xE0, 0xC3, 0xC0, 0xF8, 0xC7, 0x00, 0x1C,
  0xCC, 0x00, 0x0C, 0xD8, 0x00, 0x06, 0xD0, 0x00, 0x06, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x4F, 0xFF, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x80, 0x3C, 0x07,
  0x80, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x90, 0xE3, 0xF8, 0x3E, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x38, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x80,
  0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0xC0,
  0x03, 0x1B, 0x80, 0x0C, 0xC6, 0x00, 0x33, 0x0C, 0x00, 0xD8, 0x30, 0x03,
  0xC0, 0x60, 0x0E, 0x01, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x20, 0x7F, 0xE0, 0x07, 0xFE, 0x08, 0x78, 0x1C, 0x07,
  0x81, 0xC2, 0x38, 0x01, 0x83, 0x80, 0x18, 0x9C, 0x00, 0x31, 0x80, 0x03,
  0x26, 0x00, 0x0C, 0xE0, 0x00, 0x6B, 0x00, 0x01, 0xB0, 0x00, 0x1A, 0x80,
  0x00, 0x78, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x80, 0xFF, 0xE0,
  0x83, 0xC0, 0xF8, 0x87, 0x00, 0x1C, 0x8C, 0x00, 0x0C, 0x98, 0x00, 0x06,
  0x90, 0x00, 0x06, 0xB0, 0x00, 0x03, 0xA0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x70,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x10, 0x1F, 0xFC, 0x02,
  0x0F, 0x81, 0xE0, 0x43, 0x80, 0x0E, 0x08, 0xE0, 0x00, 0x61, 0x18, 0x00,
  0x06, 0x26, 0x00, 0x00, 0xC5, 0x80, 0x00, 0x0C, 0xB0, 0x00, 0x01, 0x94,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x67, 0x80, 0x00, 0x0C, 0xD8, 0x00, 0x03, 0x1B, 0x00, 0x00, 0xE3,
  0x30, 0x00, 0x38, 0x63, 0x80, 0x0E, 0x0C, 0x3C, 0x07, 0x81, 0x81, 0xFF,
  0xC0, 0x30, 0x07, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xFC, 0x0C, 0x0F, 0x81, 0xE1, 0x83, 0x80, 0x0E, 0x30, 0xE0, 0x00,
  0x66, 0x38, 0x00, 0x06, 0xC6, 0x00, 0x00, 0xD9, 0x80, 0x00, 0x0F, 0x30,
  0x00, 0x01, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x79, 0x80, 0x00, 0x0B, 0x30, 0x00, 0x03, 0x63,
  0x00, 0x00, 0xCC, 0x70, 0x00, 0x39, 0x87, 0x00, 0x0E, 0x30, 0x3C, 0x07,
  0x06, 0x03, 0xFF, 0xC0, 0xC0, 0x0F, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x81, 0xFF, 0x83, 0xC3, 0x86, 0x00, 0xCC, 0x00, 0xD8, 0x00, 0xD0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC7,
  0x00, 0x02, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x68, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0xFC, 0x03, 0xE0, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x1C, 0x08, 0x07, 0xFC, 0x00, 0xF8, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x1E, 0xC0, 0x00, 0x0B, 0x30,
  0x00, 0x0D, 0x9C, 0x00, 0x0C, 0xC7, 0x00, 0x1C, 0x61, 0xE0, 0x3C, 0x10,
  0x3F, 0xF8, 0x08, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE0, 0x00, 0x19, 0x80,
  0x00, 0x78, 0x00, 0x06, 0x60, 0x00, 0x1A, 0x00, 0x01, 0x18, 0x00, 0x06,
  0xC0, 0x00, 0xC3, 0x00, 0x01, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0x30, 0x00, 0x31, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x18, 0x00, 0x60, 0x60, 0x01, 0x82, 0x00, 0x18, 0x18, 0x00,
  0x60, 0xC0, 0x04, 0x02, 0x00, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x01, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x18,
  0x06, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x10, 0x00, 0x80, 0xC0,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0x8C,
  0x00, 0x0C, 0x40, 0x00, 0x33, 0x00, 0x01, 0x30, 0x00, 0x0C, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x58, 0x00, 0x06, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x98, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0x30, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x08, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x08,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x01, 0x80,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x5E, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80,
  0x7C, 0x00, 0x1F, 0xBE, 0x40, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 3, 50, 15, 6, -50 },
  { 20, 12, 18, 22, 5, -50 },
  { 47, 36, 50, 40, 2, -50 },
  { 272, 26, 57, 35, 4, -53 },
  { 458, 42, 52, 50, 4, -51 },
  { 731, 35, 52, 41, 4, -51 },
  { 959, 2, 18, 12, 5, -50 },
  { 964, 12, 61, 18, 3, -50 },
  { 1056, 12, 61, 18, 3, -50 },
  { 1148, 25, 24, 33, 4, -53 },
  { 1223, 29, 32, 35, 3, -41 },
  { 1339, 6, 17, 13, 3, -8 },
  { 1352, 17, 2, 21, 2, -20 },
  { 1357, 4, 4, 14, 5, -4 },
  { 1359, 21, 50, 23, 1, -50 },
  { 1491, 27, 52, 35, 4, -51 },
  { 1667, 13, 50, 35, 7, -50 },
  { 1749, 27, 51, 35, 4, -51 },
  { 1922, 28, 52, 35, 3, -51 },
  { 2104, 34, 50, 35, 1, -50 },
  { 2317, 27, 51, 35, 4, -50 },
  { 2490, 28, 52, 35, 4, -51 },
  { 2672, 27, 50, 35, 4, -50 },
  { 2841, 27, 52, 35, 4, -51 },
  { 3017, 28, 52, 35, 3, -51 },
  { 3199, 4, 37, 14, 5, -37 },
  { 3218, 6, 46, 14, 3, -37 },
  { 3253, 29, 30, 35, 3, -40 },
  { 3362, 29, 16, 35, 3, -33 },
  { 3420, 29, 30, 35, 3, -40 },
  { 3529, 21, 51, 25, 2, -51 },
  { 3663, 47, 57, 54, 4, -50 },
  { 3998, 35, 50, 35, 0, -50 },
  { 4217, 28, 50, 38, 7, -50 },
  { 4392, 32, 52, 38, 4, -51 },
  { 4600, 32, 50, 43, 7, -50 },
  { 4800, 23, 50, 34, 7, -50 },
  { 4944, 23, 50, 31, 7, -50 },
  { 5088, 36, 52, 45, 4, -51 },
  { 5322, 30, 50, 44, 7, -50 },
  { 5510, 11, 50, 18, 4, -50 },
  { 5579, 15, 62, 15, -6, -50 },
  { 5696, 28, 50, 34, 7, -50 },
  { 5871, 23, 50, 31, 7, -50 },
  { 6015, 40, 50, 54, 7, -50 },
  { 6265, 30, 50, 44, 7, -50 },
  { 6453, 38, 52, 47, 4, -51 },
  { 6700, 25, 50, 36, 7, -50 },
  { 6857, 38, 63, 47, 4, -51 },
  { 7157, 27, 50, 36, 7, -50 },
  { 7326, 27, 52, 34, 4, -51 },
  { 7502, 31, 50, 31, 0, -50 },
  { 7696, 32, 51, 44, 6, -50 },
  { 7900, 34, 50, 34, 0, -50 },
  { 8113, 52, 50, 55, 2, -50 },
  { 8438, 31, 50, 31, 0, -50 },
  { 8632, 30, 50, 30, 0, -50 },
  { 8820, 30, 50, 34, 2, -50 },
  { 9008, 14, 61, 22, 6, -50 },
  { 9115, 21, 50, 23, 1, -50 },
  { 9247, 14, 61, 22, 2, -50 },
  { 9354, 30, 28, 35, 3, -50 },
  { 9459, 28, 2, 27, 0, 6 },
  { 9466, 11, 12, 17, 3, -54 },
  { 9483, 24, 39, 32, 3, -38 },
  { 9600, 27, 54, 37, 6, -53 },
  { 9783, 23, 39, 29, 4, -38 },
  { 9896, 27, 54, 37, 4, -53 },
  { 10079, 26, 39, 34, 4, -38 },
  { 10206, 20, 54, 18, 1, -54 },
  { 10341, 27, 55, 37, 4, -38 },
  { 10527, 24, 53, 36, 6, -53 },
  { 10686, 4, 51, 14, 5, -51 },
  { 10712, 11, 68, 14, -2, -51 },
  { 10806, 22, 53, 28, 6, -53 },
  { 10952, 2, 53, 13, 6, -53 },
  { 10966, 42, 38, 53, 6, -38 },
  { 11166, 24, 38, 36, 6, -38 },
  { 11280, 28, 39, 36, 4, -38 },
  { 11417, 27, 54, 37, 6, -38 },
  { 11600, 27, 54, 37, 4, -38 },
  { 11783, 16, 38, 23, 6, -38 },
  { 11859, 22, 39, 28, 3, -38 },
  { 11967, 17, 47, 20, 1, -46 },
  { 12067, 25, 38, 36, 5, -37 },
  { 12186, 26, 37, 27, 0, -37 },
  { 12307, 42, 37, 44, 1, -37 },
  { 12502, 26, 37, 29, 2, -37 },
  { 12623, 27, 54, 27, 0, -37 },
  { 12806, 21, 37, 27, 3, -37 },
  { 12904, 18, 61, 24, 3, -50 },
  { 13042, 2, 70, 33, 16, -53 },
  { 13060, 18, 61, 24, 3, -50 },
  { 13198, 29, 6, 35, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Thin70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_THIN70PT7B_H_
