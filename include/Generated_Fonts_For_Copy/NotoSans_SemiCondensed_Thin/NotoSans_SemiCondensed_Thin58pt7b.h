#ifndef _NOTOSANS_SEMICONDENSED_THIN58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin58pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x64,
  0x90, 0x00, 0x00, 0x37, 0xE0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0x60, 0x04, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x00, 0x40,
  0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x60, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x02, 0x00,
  0x20, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x03, 0x00, 0x20, 0x00, 0x08, 0x00, 0x80, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0,
  0x70, 0x81, 0xC3, 0x02, 0x01, 0x08, 0x08, 0x00, 0x60, 0x20, 0x01, 0x00,
  0x80, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80,
  0x0C, 0x02, 0x00, 0x30, 0x08, 0x00, 0x40, 0x20, 0x01, 0x80, 0x80, 0x03,
  0x02, 0x00, 0x06, 0x08, 0x00, 0x0E, 0x20, 0x00, 0x0E, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x87, 0x00, 0x02, 0x0E,
  0x00, 0x08, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x80, 0x20, 0x02, 0x00, 0xC0,
  0x08, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x08,
  0x03, 0x00, 0x20, 0x08, 0x00, 0x80, 0x60, 0x02, 0x01, 0x80, 0x08, 0x0C,
  0xC0, 0x20, 0xE3, 0xF8, 0x9E, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x06, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0x18, 0x0C, 0x00,
  0x30, 0x06, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x60, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x60, 0x02, 0x03, 0x00,
  0x0C, 0x00, 0x40, 0x60, 0x01, 0x80, 0x08, 0x08, 0x00, 0x30, 0x01, 0x03,
  0x00, 0x06, 0x00, 0x20, 0x40, 0x00, 0xC0, 0x04, 0x18, 0x00, 0x18, 0x01,
  0x82, 0x0F, 0xC1, 0x00, 0x30, 0xC3, 0x0C, 0x20, 0x06, 0x10, 0xC0, 0xC6,
  0x00, 0x86, 0x10, 0x0C, 0xC0, 0x30, 0x86, 0x00, 0x8C, 0x06, 0x30, 0x80,
  0x11, 0x81, 0x84, 0x10, 0x03, 0x1E, 0xE1, 0x86, 0x00, 0x60, 0xF8, 0x30,
  0xC0, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x80, 0x01, 0x83, 0x00, 0x10, 0x00,
  0x60, 0x60, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x40, 0x01, 0x01, 0x80, 0x08,
  0x00, 0x60, 0x30, 0x01, 0x00, 0x08, 0x06, 0x00, 0x20, 0x03, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x10, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x80, 0x00, 0xC3, 0x80, 0x30, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x80, 0x00, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x60, 0x00, 0x18, 0x01, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x06, 0x30,
  0x06, 0x00, 0x10, 0x80, 0x0C, 0x00, 0x46, 0x00, 0x18, 0x03, 0x10, 0x00,
  0x30, 0x0C, 0xC0, 0x00, 0x60, 0x23, 0x00, 0x00, 0xC1, 0x8C, 0x00, 0x03,
  0x06, 0x30, 0x00, 0x06, 0x30, 0xC0, 0x00, 0x0C, 0xC3, 0x00, 0x00, 0x1E,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x07, 0x81,
  0x80, 0x00, 0x33, 0x03, 0x00, 0x01, 0x86, 0x06, 0x00, 0x1C, 0x0C, 0x0E,
  0x01, 0xC0, 0x18, 0x0F, 0xFE, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x40, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00,
  0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x1C, 0x04, 0x03, 0x7C, 0x20, 0xF0, 0x39, 0x3C, 0x00,
  0x3E, 0x00, 0x00, 0x60, 0x00, 0x05, 0x80, 0x00, 0x44, 0x00, 0x06, 0x10,
  0x00, 0x60, 0xC0, 0x02, 0x03, 0x00, 0x30, 0x08, 0x03, 0x00, 0x60, 0x30,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x18,
  0xC6, 0x21, 0x18, 0xC4, 0x23, 0x18, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xCF, 0x00, 0x1C,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x80, 0x03, 0x03, 0x00, 0x02, 0x04, 0x00,
  0x06, 0x18, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0xD0, 0x00, 0x01,
  0xA0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00,
  0x02, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00,
  0xC1, 0x80, 0x01, 0x03, 0x00, 0x06, 0x03, 0x00, 0x08, 0x03, 0x00, 0x30,
  0x03, 0x81, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x0F,
  0x01, 0xB0, 0x73, 0x0E, 0x31, 0x83, 0x30, 0x3E, 0x03, 0x40, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0xFC, 0x00, 0x3F, 0x7C, 0x03, 0xC0, 0x1C, 0x1C, 0x00, 0x18, 0x20, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x7E,
  0x03, 0x80, 0x0C, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x20, 0x00, 0x18, 0xF8, 0x03, 0xC0,
  0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x18,
  0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xF0,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x88, 0x00, 0x1C, 0x3C, 0x01, 0xE0, 0x3F,
  0xFE, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF7, 0xC0, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x07, 0xFC, 0x08, 0x70, 0x1C, 0x23, 0x00, 0x18,
  0x98, 0x00, 0x32, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0D,
  0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x20, 0x00, 0x18, 0xC0,
  0x00, 0x41, 0x80, 0x03, 0x03, 0x00, 0x18, 0x07, 0x01, 0xC0, 0x0F, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x38, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x01, 0x08, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x31, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x86, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0E, 0x00, 0x18,
  0x0E, 0x00, 0xE0, 0x06, 0x03, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x70, 0x06, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x60, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x26, 0x00, 0x00,
  0xC4, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0F, 0x00, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x30, 0x07, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x02, 0x04, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x68, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00,
  0x01, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x3A, 0x00, 0x00, 0x76, 0x00, 0x01, 0xE6, 0x00, 0x06, 0xC4, 0x00, 0x19,
  0x0E, 0x00, 0x62, 0x07, 0xDF, 0x84, 0x03, 0xFC, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x20, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x18, 0x71, 0xC6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x20, 0x86, 0x18, 0x43, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x7C,
  0x30, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x20, 0x00,
  0x63, 0x00, 0x07, 0xFE, 0x00, 0xC4, 0x00, 0x38, 0x0C, 0x00, 0x98, 0x00,
  0xC0, 0x08, 0x01, 0x30, 0x03, 0x00, 0x10, 0x03, 0x40, 0x04, 0x00, 0x20,
  0x06, 0x80, 0x18, 0x00, 0x40, 0x0F, 0x00, 0x20, 0x00, 0x80, 0x1E, 0x00,
  0xC0, 0x01, 0x00, 0x1C, 0x01, 0x80, 0x06, 0x00, 0x38, 0x02, 0x00, 0x0C,
  0x00, 0x70, 0x04, 0x00, 0x18, 0x01, 0xE0, 0x08, 0x00, 0x30, 0x03, 0xC0,
  0x10, 0x00, 0x60, 0x07, 0x80, 0x20, 0x00, 0xC0, 0x0F, 0x00, 0x40, 0x01,
  0x80, 0x1E, 0x00, 0x80, 0x03, 0x00, 0x2C, 0x01, 0x80, 0x0E, 0x00, 0xD8,
  0x03, 0x00, 0x14, 0x01, 0x90, 0x02, 0x00, 0x68, 0x02, 0x20, 0x06, 0x00,
  0x98, 0x0C, 0x60, 0x06, 0x06, 0x18, 0x30, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0x80, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x80,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x00, 0x60, 0x00, 0x08,
  0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x04, 0x00, 0x60, 0x00, 0x20, 0x03,
  0x00, 0x03, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x40, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0x80,
  0xC0, 0x01, 0xE0, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x70, 0xC0, 0x0F, 0xC0, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xC0, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0x40, 0x00, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x7C, 0x03, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x38, 0x06, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x38,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0xFF, 0xD0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x40, 0x38, 0x00, 0x03, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0x84, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0xFF, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xCF, 0x7C, 0x7F, 0x00, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC1,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x80, 0x00, 0xCC, 0xC0, 0x00, 0xD8,
  0xC0, 0x00, 0xD0, 0x60, 0x00, 0xF0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x17, 0x40, 0x00,
  0x00, 0x0D, 0xD8, 0x00, 0x00, 0x03, 0x76, 0x00, 0x00, 0x00, 0x9C, 0x80,
  0x00, 0x00, 0x67, 0x30, 0x00, 0x00, 0x19, 0xCC, 0x00, 0x00, 0x04, 0x71,
  0x00, 0x00, 0x03, 0x1C, 0x60, 0x00, 0x00, 0x87, 0x08, 0x00, 0x00, 0x61,
  0xC3, 0x00, 0x00, 0x18, 0x70, 0xC0, 0x00, 0x04, 0x1C, 0x10, 0x00, 0x03,
  0x07, 0x06, 0x00, 0x00, 0xC1, 0xC1, 0x80, 0x00, 0x20, 0x70, 0x20, 0x00,
  0x18, 0x1C, 0x0C, 0x00, 0x04, 0x07, 0x01, 0x00, 0x03, 0x01, 0xC0, 0x60,
  0x00, 0xC0, 0x70, 0x18, 0x00, 0x20, 0x1C, 0x02, 0x00, 0x18, 0x07, 0x00,
  0xC0, 0x06, 0x01, 0xC0, 0x30, 0x01, 0x00, 0x70, 0x04, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x20, 0x07, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x08, 0x06, 0x00,
  0x70, 0x03, 0x01, 0x00, 0x1C, 0x00, 0x40, 0xC0, 0x07, 0x00, 0x18, 0x30,
  0x01, 0xC0, 0x06, 0x08, 0x00, 0x70, 0x00, 0x86, 0x00, 0x1C, 0x00, 0x31,
  0x80, 0x07, 0x00, 0x0C, 0x40, 0x01, 0xC0, 0x01, 0x30, 0x00, 0x70, 0x00,
  0x68, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xD8, 0x00, 0x00, 0xF2, 0x00, 0x00, 0x3C,
  0xC0, 0x00, 0x0F, 0x18, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xF0, 0xC0, 0x00,
  0x3C, 0x10, 0x00, 0x0F, 0x06, 0x00, 0x03, 0xC0, 0x80, 0x00, 0xF0, 0x30,
  0x00, 0x3C, 0x06, 0x00, 0x0F, 0x01, 0x80, 0x03, 0xC0, 0x30, 0x00, 0xF0,
  0x04, 0x00, 0x3C, 0x01, 0x80, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00,
  0xF0, 0x01, 0x80, 0x3C, 0x00, 0x20, 0x0F, 0x00, 0x0C, 0x03, 0xC0, 0x01,
  0x80, 0xF0, 0x00, 0x60, 0x3C, 0x00, 0x0C, 0x0F, 0x00, 0x01, 0x03, 0xC0,
  0x00, 0x60, 0xF0, 0x00, 0x0C, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x08, 0xF0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x4F, 0x00, 0x00,
  0x1B, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFE,
  0x03, 0x00, 0x1E, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x4C,
  0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x01, 0xC3, 0x00, 0x3E, 0x0F, 0xFF,
  0xC0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFE, 0x01, 0x80, 0x0F,
  0x83, 0x00, 0x03, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x03,
  0x30, 0x00, 0x02, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x30,
  0x00, 0x02, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x63, 0x00,
  0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x78, 0x1F, 0xFF, 0xC0, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x08,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0xFF, 0x80, 0x0F, 0xDF, 0xC0, 0xE0,
  0x01, 0x86, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x20, 0x00, 0x38, 0xF0, 0x03, 0xC0, 0xFF, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x03,
  0x00, 0x3C, 0x01, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x08, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30,
  0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x08, 0x01, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x22, 0x00, 0x00, 0xB0,
  0x00, 0x04, 0x40, 0x00, 0x16, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x40, 0x00,
  0x31, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x10, 0x00, 0x11, 0x80, 0x00, 0x82,
  0x00, 0x02, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x40, 0x00, 0x80, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x10, 0x00, 0x41,
  0x80, 0x06, 0x03, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x60, 0x03, 0x02, 0x00,
  0x10, 0x04, 0x00, 0x40, 0x60, 0x06, 0x00, 0x80, 0x08, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x10, 0x02, 0x00, 0x20,
  0x08, 0x03, 0x00, 0xC0, 0x04, 0x01, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60,
  0x04, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x40, 0x01, 0x01, 0x00, 0x18,
  0x18, 0x00, 0x20, 0x20, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x20, 0x60,
  0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0xC3, 0x00, 0x01,
  0x04, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x00, 0x00, 0x44, 0x00, 0x06, 0x60, 0x00, 0x08, 0x80, 0x00,
  0xCC, 0x00, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0x36, 0x00, 0x01, 0x20,
  0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x50, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x20, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18,
  0x20, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x40, 0x08, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x43, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x02, 0x00,
  0x0C, 0x01, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x00, 0x08,
  0x03, 0x00, 0x06, 0x01, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x30, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1F, 0xFC, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0xFF, 0xE0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x02, 0x40, 0x00, 0x03, 0x30, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x20, 0x00,
  0x60, 0x18, 0x00, 0x20, 0x04, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x03, 0xFC, 0x03, 0xF1, 0xE0, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x3F,
  0xF8, 0x3F, 0x01, 0x1C, 0x00, 0x26, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x17, 0x00, 0x06, 0xE0, 0x00, 0x96, 0x00, 0x32, 0x70, 0x1C,
  0x47, 0xFE, 0x08, 0x0E, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x07, 0xF8, 0x08, 0x78, 0x38, 0x23, 0x00,
  0x30, 0x98, 0x00, 0x62, 0xC0, 0x00, 0xCA, 0x00, 0x01, 0x28, 0x00, 0x06,
  0xC0, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x6E, 0x00, 0x01, 0x2C, 0x00, 0x0C, 0x90, 0x00, 0x62, 0x60, 0x03,
  0x08, 0xE0, 0x38, 0x20, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xC0,
  0x3E, 0x1C, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xC0, 0x7F, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x1F, 0xE0, 0xC0, 0xF0, 0xF1, 0x83, 0x00, 0x33, 0x0C,
  0x00, 0x36, 0x30, 0x00, 0x2C, 0xC0, 0x00, 0x79, 0x00, 0x00, 0x76, 0x00,
  0x00, 0xEC, 0x00, 0x01, 0xD0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC,
  0x00, 0x01, 0xC8, 0x00, 0x07, 0x98, 0x00, 0x0B, 0x18, 0x00, 0x36, 0x18,
  0x00, 0xCC, 0x1C, 0x07, 0x18, 0x1F, 0xF8, 0x30, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0x1E, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x88, 0x00, 0x06, 0x60, 0x00, 0x09,
  0x00, 0x00, 0x24, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x08, 0x1E, 0x01, 0xE0, 0x1F, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0x01, 0xC1, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x06, 0x07, 0x87,
  0x8C, 0x38, 0x01, 0x98, 0x60, 0x01, 0xB1, 0x80, 0x01, 0x66, 0x00, 0x03,
  0xC8, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x80, 0x00, 0x0D,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x40, 0x00, 0x3C, 0xC0, 0x00,
  0x58, 0xC0, 0x01, 0xB0, 0xC0, 0x06, 0x60, 0xE0, 0x38, 0xC0, 0xFF, 0xC1,
  0x80, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x60, 0xC0, 0x03, 0x80, 0xFE,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x1F, 0xE0, 0x87, 0x87, 0x88, 0xC0, 0x0C, 0x98, 0x00, 0x6B,
  0x00, 0x06, 0xA0, 0x00, 0x2E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x7F, 0xB0, 0x00, 0x00, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x01,
  0x81, 0xC0, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x13,
  0xF9, 0xF0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01, 0xA0,
  0x00, 0x64, 0x00, 0x18, 0x80, 0x06, 0x10, 0x01, 0x82, 0x00, 0x30, 0x40,
  0x0C, 0x08, 0x03, 0x01, 0x00, 0xC0, 0x20, 0x30, 0x04, 0x06, 0x00, 0x81,
  0x80, 0x10, 0x60, 0x02, 0x1C, 0x00, 0x42, 0x80, 0x08, 0x98, 0x01, 0x31,
  0x80, 0x2C, 0x10, 0x07, 0x03, 0x00, 0xC0, 0x30, 0x10, 0x06, 0x02, 0x00,
  0x60, 0x40, 0x04, 0x08, 0x00, 0xC1, 0x00, 0x0C, 0x20, 0x00, 0x84, 0x00,
  0x18, 0x80, 0x01, 0x10, 0x00, 0x32, 0x00, 0x03, 0x40, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0xF8, 0x01, 0xFC, 0x10, 0xE1, 0xC0,
  0xF1, 0xE2, 0x70, 0x0C, 0x30, 0x0E, 0x48, 0x00, 0xCC, 0x00, 0xCA, 0x00,
  0x1B, 0x00, 0x0D, 0x40, 0x01, 0x40, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x16,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x08, 0x00,
  0x0E, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x1C, 0x00,
  0x02, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x70, 0x00, 0x08, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x38, 0x00, 0x04, 0x00,
  0x07, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x02,
  0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x70, 0x00, 0x08, 0x00, 0x0E, 0x00,
  0x01, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x38, 0x00, 0x04, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x18, 0x81, 0xFE, 0x08,
  0x78, 0x78, 0x8C, 0x00, 0xC9, 0x80, 0x06, 0xB0, 0x00, 0x6A, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x03, 0xC3, 0xC0, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x18,
  0x18, 0x00, 0x10, 0x0C, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x81, 0xFE, 0x02, 0x1F, 0x0E, 0x08, 0xE0, 0x0E, 0x26,
  0x00, 0x18, 0x90, 0x00, 0x32, 0xC0, 0x00, 0x6A, 0x00, 0x01, 0xB8, 0x00,
  0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xE0, 0x00, 0x1A,
  0x80, 0x00, 0x4B, 0x00, 0x03, 0x26, 0x00, 0x18, 0x8C, 0x00, 0xC2, 0x1C,
  0x0E, 0x08, 0x3F, 0xF0, 0x20, 0x08, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0x06, 0x07, 0x87, 0x8C, 0x38, 0x03,
  0x98, 0xE0, 0x01, 0xB1, 0x80, 0x01, 0x66, 0x00, 0x03, 0xC8, 0x00, 0x03,
  0xB0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xB0, 0x00,
  0x07, 0x60, 0x00, 0x0E, 0x40, 0x00, 0x3C, 0xC0, 0x00, 0x58, 0xC0, 0x01,
  0x30, 0xC0, 0x06, 0x60, 0xE0, 0x38, 0xC0, 0xFF, 0xC1, 0x80, 0x1C, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x81,
  0xFE, 0x1E, 0x68, 0xC0, 0x26, 0x00, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xE0, 0xF8, 0x60,
  0x01, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x68, 0x00, 0x19, 0xE0, 0x0E, 0x0F, 0xFF, 0x80, 0x0E, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x04, 0x0F, 0xF0, 0x0E, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00,
  0x3B, 0x00, 0x01, 0x58, 0x00, 0x1A, 0x60, 0x01, 0x93, 0x80, 0x18, 0x8E,
  0x03, 0x84, 0x1F, 0xF8, 0x20, 0x08, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0x80, 0x00, 0x43,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80,
  0x06, 0x02, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x08, 0x04, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x01, 0x02, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x21,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x02,
  0x80, 0x03, 0x40, 0x00, 0xA0, 0x00, 0x98, 0x00, 0x6C, 0x00, 0x66, 0x00,
  0x13, 0x00, 0x18, 0x80, 0x04, 0x40, 0x06, 0x20, 0x03, 0x10, 0x01, 0x0C,
  0x00, 0xC6, 0x00, 0xC3, 0x00, 0x21, 0x80, 0x30, 0x40, 0x18, 0x20, 0x0C,
  0x18, 0x06, 0x0C, 0x02, 0x06, 0x01, 0x03, 0x01, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x04, 0x03, 0x02, 0x01,
  0x83, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x10, 0x60, 0x0C, 0x30, 0x06, 0x10,
  0x03, 0x08, 0x01, 0x84, 0x00, 0x46, 0x00, 0x23, 0x00, 0x11, 0x80, 0x08,
  0xC0, 0x06, 0x60, 0x03, 0x20, 0x01, 0x90, 0x00, 0xD8, 0x00, 0x24, 0x00,
  0x16, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x40, 0x08, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0x21, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0x20, 0x00, 0x0C,
  0xC0, 0x00, 0x61, 0x80, 0x01, 0x82, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x18,
  0x01, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x20, 0x01, 0x01, 0x80, 0x06, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x05, 0x00, 0x00, 0x36, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x20, 0x00,
  0x18, 0xC0, 0x00, 0x61, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x20, 0x00, 0x80, 0x80, 0x06, 0x03, 0x00, 0x18, 0x04, 0x00, 0x40, 0x10,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x20, 0x02, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x10, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x83, 0x00, 0x02, 0x08, 0x00,
  0x08, 0x60, 0x00, 0x31, 0x80, 0x00, 0x44, 0x00, 0x01, 0x30, 0x00, 0x06,
  0xC0, 0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x37, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x79, 0xF0, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0x0F, 0xBC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Thin58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 41, 12, 5, -41 },
  { 17, 10, 15, 18, 4, -41 },
  { 36, 30, 41, 33, 1, -41 },
  { 190, 22, 47, 29, 3, -44 },
  { 320, 35, 43, 41, 3, -42 },
  { 509, 30, 43, 34, 3, -42 },
  { 671, 2, 15, 10, 4, -41 },
  { 675, 10, 50, 15, 3, -41 },
  { 738, 10, 50, 15, 2, -41 },
  { 801, 21, 20, 27, 3, -44 },
  { 854, 24, 27, 29, 3, -34 },
  { 935, 5, 13, 10, 2, -6 },
  { 944, 13, 2, 17, 2, -17 },
  { 948, 2, 3, 12, 5, -3 },
  { 949, 17, 41, 19, 1, -41 },
  { 1037, 23, 43, 29, 3, -42 },
  { 1161, 12, 41, 29, 5, -41 },
  { 1223, 22, 42, 29, 3, -42 },
  { 1339, 22, 43, 29, 3, -42 },
  { 1458, 28, 42, 29, 1, -42 },
  { 1605, 22, 42, 29, 4, -41 },
  { 1721, 22, 43, 29, 4, -42 },
  { 1840, 23, 41, 29, 3, -41 },
  { 1958, 23, 43, 29, 3, -42 },
  { 2082, 23, 43, 29, 3, -42 },
  { 2206, 2, 31, 12, 5, -31 },
  { 2214, 6, 38, 12, 2, -31 },
  { 2243, 24, 25, 29, 3, -33 },
  { 2318, 24, 13, 29, 3, -27 },
  { 2357, 24, 25, 29, 3, -33 },
  { 2432, 17, 42, 21, 2, -42 },
  { 2522, 39, 47, 45, 3, -41 },
  { 2752, 29, 41, 29, 0, -41 },
  { 2901, 24, 41, 32, 5, -41 },
  { 3024, 27, 43, 31, 3, -42 },
  { 3170, 27, 41, 35, 5, -41 },
  { 3309, 20, 41, 28, 5, -41 },
  { 3412, 20, 41, 26, 5, -41 },
  { 3515, 30, 43, 38, 3, -42 },
  { 3677, 26, 41, 36, 5, -41 },
  { 3811, 9, 41, 15, 3, -41 },
  { 3858, 12, 51, 12, -5, -41 },
  { 3935, 24, 41, 29, 5, -41 },
  { 4058, 20, 41, 26, 5, -41 },
  { 4161, 34, 41, 45, 5, -41 },
  { 4336, 26, 41, 36, 5, -41 },
  { 4470, 32, 43, 39, 3, -42 },
  { 4642, 22, 41, 29, 5, -41 },
  { 4755, 32, 52, 39, 3, -42 },
  { 4963, 23, 41, 30, 5, -41 },
  { 5081, 22, 43, 28, 3, -42 },
  { 5200, 25, 41, 26, 0, -41 },
  { 5329, 27, 42, 36, 5, -41 },
  { 5471, 28, 41, 28, 0, -41 },
  { 5615, 43, 41, 46, 1, -41 },
  { 5836, 26, 41, 26, 0, -41 },
  { 5970, 25, 41, 25, 0, -41 },
  { 6099, 24, 41, 28, 2, -41 },
  { 6222, 11, 50, 18, 5, -41 },
  { 6291, 17, 41, 19, 1, -41 },
  { 6379, 11, 50, 18, 2, -41 },
  { 6448, 25, 24, 29, 2, -42 },
  { 6523, 23, 2, 23, 0, 5 },
  { 6529, 10, 9, 14, 2, -44 },
  { 6541, 19, 32, 27, 3, -31 },
  { 6617, 22, 45, 30, 5, -44 },
  { 6741, 19, 32, 24, 3, -31 },
  { 6817, 23, 45, 30, 3, -44 },
  { 6947, 22, 32, 28, 3, -31 },
  { 7035, 16, 44, 15, 1, -44 },
  { 7123, 23, 45, 30, 3, -31 },
  { 7253, 20, 44, 30, 5, -44 },
  { 7363, 3, 42, 11, 4, -42 },
  { 7379, 9, 56, 11, -2, -42 },
  { 7442, 19, 44, 24, 5, -44 },
  { 7547, 1, 44, 11, 5, -44 },
  { 7553, 35, 31, 44, 5, -31 },
  { 7689, 20, 31, 30, 5, -31 },
  { 7767, 24, 32, 30, 3, -31 },
  { 7863, 22, 44, 30, 5, -31 },
  { 7984, 23, 44, 30, 3, -31 },
  { 8111, 14, 31, 19, 5, -31 },
  { 8166, 19, 32, 23, 2, -31 },
  { 8242, 14, 39, 16, 1, -38 },
  { 8311, 21, 32, 30, 4, -31 },
  { 8395, 22, 31, 22, 0, -31 },
  { 8481, 34, 31, 36, 1, -31 },
  { 8613, 22, 31, 24, 1, -31 },
  { 8699, 22, 45, 22, 0, -31 },
  { 8823, 18, 31, 22, 2, -31 },
  { 8893, 15, 50, 20, 2, -41 },
  { 8987, 2, 58, 28, 13, -44 },
  { 9002, 16, 50, 20, 2, -41 },
  { 9102, 24, 5, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_Thin58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_THIN58PT7B_H_
