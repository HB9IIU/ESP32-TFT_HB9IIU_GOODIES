#ifndef _NOTOSANS_SEMICONDENSED_THIN53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin53pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x00, 0x00, 0x7F, 0xC0, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x00, 0x10, 0x02, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x10, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30,
  0x04, 0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x06,
  0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x80, 0x00, 0x40, 0x18,
  0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x08, 0x02,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x02, 0x00, 0x01, 0x00, 0x20, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60,
  0x08, 0x00, 0x04, 0x00, 0x80, 0x00, 0x40, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xF0, 0x1C, 0x43, 0xC3, 0x04, 0x04,
  0x60, 0x40, 0x04, 0x04, 0x00, 0xC0, 0x40, 0x08, 0x04, 0x00, 0x80, 0x40,
  0x08, 0x04, 0x00, 0x80, 0x40, 0x08, 0x04, 0x00, 0xC0, 0x40, 0x04, 0x04,
  0x00, 0x60, 0x40, 0x03, 0x04, 0x00, 0x1C, 0x40, 0x00, 0x74, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x4E, 0x00, 0x04, 0x30, 0x00, 0x41, 0xC0,
  0x04, 0x04, 0x00, 0x40, 0x60, 0x04, 0x02, 0x00, 0x40, 0x30, 0x04, 0x03,
  0x00, 0x40, 0x30, 0x04, 0x03, 0x00, 0x40, 0x30, 0x04, 0x02, 0x00, 0x40,
  0x60, 0x04, 0x0C, 0x80, 0x41, 0x8F, 0x84, 0x70, 0x1F, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x1F, 0x80, 0x00,
  0xC0, 0x30, 0xC0, 0x01, 0x80, 0x20, 0x20, 0x01, 0x00, 0x60, 0x30, 0x03,
  0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x18, 0x04, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x80, 0x18, 0x08,
  0x00, 0x80, 0x18, 0x18, 0x00, 0x80, 0x18, 0x10, 0x00, 0x80, 0x18, 0x30,
  0x00, 0x80, 0x18, 0x20, 0x00, 0x80, 0x18, 0x60, 0x00, 0x80, 0x18, 0x41,
  0xF0, 0xC0, 0x10, 0xC3, 0x18, 0xC0, 0x10, 0x84, 0x0C, 0x40, 0x31, 0x8C,
  0x06, 0x60, 0x31, 0x08, 0x02, 0x20, 0x63, 0x08, 0x02, 0x30, 0xC2, 0x18,
  0x02, 0x1F, 0x82, 0x18, 0x03, 0x00, 0x06, 0x10, 0x03, 0x00, 0x04, 0x10,
  0x03, 0x00, 0x0C, 0x10, 0x03, 0x00, 0x08, 0x10, 0x03, 0x00, 0x18, 0x10,
  0x03, 0x00, 0x10, 0x10, 0x03, 0x00, 0x30, 0x10, 0x03, 0x00, 0x20, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x08,
  0x02, 0x00, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x04, 0x04, 0x01, 0x00, 0x06,
  0x0C, 0x03, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFC, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x10, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x80,
  0x08, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x01, 0x00, 0x10, 0x00, 0x20, 0x02, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x07, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x10, 0x01, 0x98,
  0x03, 0x00, 0x32, 0x00, 0x30, 0x04, 0xC0, 0x03, 0x00, 0x98, 0x00, 0x30,
  0x32, 0x00, 0x03, 0x04, 0x40, 0x00, 0x20, 0x88, 0x00, 0x06, 0x31, 0x00,
  0x00, 0x64, 0x20, 0x00, 0x07, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C,
  0x08, 0x00, 0x06, 0x41, 0x80, 0x01, 0x8C, 0x18, 0x00, 0x60, 0xC1, 0xC0,
  0x38, 0x0C, 0x0F, 0xFC, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x70, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30,
  0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x30, 0x10, 0x1B, 0xC2, 0x1E, 0x0E, 0x4E, 0x00, 0x3E,
  0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x11, 0x00, 0x04, 0x10, 0x01, 0x83,
  0x00, 0x60, 0x20, 0x08, 0x02, 0x03, 0x00, 0x60, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x18, 0x84, 0x63, 0x18, 0x8C, 0x62, 0x11, 0x88, 0x00, 0xFF,
  0xF0, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x30,
  0x01, 0x81, 0x00, 0x04, 0x18, 0x00, 0x30, 0x80, 0x00, 0x8C, 0x00, 0x04,
  0x60, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x2C, 0x00,
  0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00,
  0x84, 0x00, 0x04, 0x30, 0x00, 0x60, 0x80, 0x02, 0x06, 0x00, 0x30, 0x18,
  0x03, 0x00, 0x60, 0x30, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x70, 0x34, 0x19,
  0x0C, 0x4E, 0x16, 0x07, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xFC, 0x01, 0xC0, 0x60,
  0x70, 0x01, 0x04, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0xF0, 0x1C, 0x0C,
  0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x19, 0x00, 0x01, 0x8F, 0x00, 0x38, 0x0F, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00,
  0x06, 0x04, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x03, 0x00, 0x80,
  0x03, 0x00, 0x40, 0x01, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x01, 0x00, 0x60, 0x00,
  0x80, 0x60, 0x00, 0x40, 0x20, 0x00, 0x20, 0x30, 0x00, 0x10, 0x30, 0x00,
  0x08, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x1F, 0xFF, 0xE0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x7F, 0xFE, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x31, 0x00, 0x03, 0x0F, 0x00,
  0x70, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0x01,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x3F,
  0xC0, 0xC7, 0x03, 0x86, 0x60, 0x06, 0x36, 0x00, 0x19, 0xE0, 0x00, 0x6E,
  0x00, 0x01, 0x70, 0x00, 0x0B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0,
  0x00, 0x0D, 0x80, 0x00, 0x64, 0x00, 0x02, 0x30, 0x00, 0x30, 0x80, 0x01,
  0x86, 0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x18, 0x01, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x1C, 0x06,
  0x00, 0x30, 0x60, 0x00, 0x82, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00,
  0xC8, 0x00, 0x06, 0x40, 0x00, 0x32, 0x00, 0x01, 0x98, 0x00, 0x08, 0x40,
  0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x30, 0x06, 0x00, 0xC0, 0xE0,
  0x03, 0x8C, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x0E, 0x1C, 0x00, 0xC0,
  0x38, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x36,
  0x00, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x02, 0xC0, 0x00, 0x13, 0x00, 0x01, 0x88,
  0x00, 0x18, 0x60, 0x01, 0x80, 0xC0, 0x38, 0x03, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0xC0, 0x70, 0x18, 0x01, 0x83, 0x00, 0x08, 0x60,
  0x00, 0xC4, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00,
  0x52, 0x00, 0x0D, 0x30, 0x01, 0x91, 0xC0, 0x71, 0x07, 0xFC, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x40, 0x1C, 0x07, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x62, 0x31, 0x8C, 0x62, 0x31, 0x88, 0x46, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x72, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x03, 0x10, 0x00, 0x7F, 0x00, 0x26, 0x00, 0x3C,
  0x78, 0x06, 0xC0, 0x0C, 0x03, 0x00, 0xD0, 0x03, 0x00, 0x60, 0x0A, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x10, 0x01, 0x80, 0x38, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x80, 0x04, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x18, 0x02, 0x00, 0x10,
  0x03, 0x00, 0x40, 0x02, 0x00, 0x60, 0x08, 0x00, 0x40, 0x0C, 0x01, 0x00,
  0x08, 0x01, 0x80, 0x20, 0x03, 0x00, 0x30, 0x04, 0x00, 0x60, 0x0E, 0x00,
  0x80, 0x0C, 0x01, 0xE0, 0x18, 0x01, 0x80, 0x2C, 0x03, 0x00, 0x58, 0x0D,
  0x80, 0x30, 0x19, 0x03, 0x10, 0x03, 0x0E, 0x30, 0xC2, 0x00, 0x3F, 0x03,
  0xF0, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x20, 0x02, 0x00, 0x04, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x01, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x60, 0x04,
  0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x04, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x30, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x0C, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xC0, 0xFF,
  0xF8, 0x04, 0x03, 0xF8, 0x20, 0x00, 0x71, 0x00, 0x00, 0xC8, 0x00, 0x02,
  0x40, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00,
  0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x12,
  0x00, 0x01, 0x90, 0x00, 0x18, 0x80, 0x01, 0x87, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0x00, 0x03, 0x88, 0x00, 0x06, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x19, 0x00, 0x03, 0x88, 0x00, 0xF0,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x01,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x00,
  0xFF, 0xF0, 0x00, 0x80, 0xFF, 0x00, 0x80, 0x03, 0xC0, 0x80, 0x00, 0xE0,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x08, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0xE0, 0x80, 0x03, 0x80,
  0x80, 0x3E, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFA, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xA0, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x12, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x44, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x10,
  0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x19, 0x06, 0x3F, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xA0, 0x00, 0x19, 0x00, 0x01, 0x88, 0x00, 0x18, 0x40, 0x01, 0x82, 0x00,
  0x18, 0x10, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0xC0, 0x20, 0x0C, 0x01,
  0x00, 0xC0, 0x08, 0x0C, 0x00, 0x40, 0xC0, 0x02, 0x06, 0x00, 0x10, 0x60,
  0x00, 0x86, 0x00, 0x04, 0x78, 0x00, 0x26, 0x60, 0x01, 0x63, 0x00, 0x0A,
  0x0C, 0x00, 0x60, 0x20, 0x03, 0x01, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x04, 0x00, 0xC0, 0x20, 0x03, 0x01, 0x00, 0x08, 0x08, 0x00, 0x60, 0x40,
  0x01, 0x82, 0x00, 0x04, 0x10, 0x00, 0x30, 0x80, 0x00, 0xC4, 0x00, 0x02,
  0x20, 0x00, 0x19, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x0C, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3D, 0x00, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x01, 0xF2, 0x00, 0x00, 0x02,
  0xE4, 0x00, 0x00, 0x0D, 0xCC, 0x00, 0x00, 0x13, 0x88, 0x00, 0x00, 0x27,
  0x18, 0x00, 0x00, 0xCE, 0x30, 0x00, 0x01, 0x1C, 0x20, 0x00, 0x06, 0x38,
  0x60, 0x00, 0x0C, 0x70, 0x40, 0x00, 0x10, 0xE0, 0x80, 0x00, 0x61, 0xC1,
  0x80, 0x00, 0x83, 0x81, 0x00, 0x01, 0x07, 0x03, 0x00, 0x06, 0x0E, 0x06,
  0x00, 0x08, 0x1C, 0x04, 0x00, 0x30, 0x38, 0x0C, 0x00, 0x60, 0x70, 0x08,
  0x00, 0x80, 0xE0, 0x10, 0x03, 0x01, 0xC0, 0x30, 0x04, 0x03, 0x80, 0x20,
  0x08, 0x07, 0x00, 0x40, 0x30, 0x0E, 0x00, 0xC0, 0x40, 0x1C, 0x00, 0x80,
  0x80, 0x38, 0x01, 0x83, 0x00, 0x70, 0x03, 0x04, 0x00, 0xE0, 0x02, 0x18,
  0x01, 0xC0, 0x06, 0x30, 0x03, 0x80, 0x04, 0x40, 0x07, 0x00, 0x09, 0x80,
  0x0E, 0x00, 0x1A, 0x00, 0x1C, 0x00, 0x14, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0D, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x32, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x84, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x10, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x20, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x00, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x02, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x04, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x13, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x40, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x10, 0x3F, 0xC2, 0x00, 0x1C,
  0x40, 0x00, 0xC8, 0x00, 0x0D, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x1A,
  0x00, 0x06, 0x40, 0x03, 0x88, 0x1F, 0xC1, 0xFF, 0xC0, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x04, 0x0F, 0xF0, 0x20, 0x00, 0xC1, 0x00,
  0x03, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x04,
  0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0xC4,
  0x00, 0x0C, 0x20, 0x00, 0xC1, 0x00, 0x38, 0x0F, 0xFF, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x10, 0x03, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20,
  0x01, 0x81, 0x00, 0x04, 0x08, 0x00, 0x30, 0x40, 0x00, 0x82, 0x00, 0x06,
  0x10, 0x00, 0x10, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00,
  0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x0C, 0x03, 0xFF, 0x80, 0xE0, 0x0E,
  0x18, 0x00, 0x23, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0xE0, 0x07, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60,
  0x00, 0x04, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0E,
  0x00, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x60, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x10, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x20, 0x00, 0x10, 0x08,
  0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0x80, 0x10, 0x00, 0x20,
  0x06, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x00, 0x20, 0x00, 0x40, 0x08, 0x00, 0x18, 0x06, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x30, 0x00, 0x04, 0x08, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02, 0x10,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x40, 0x00, 0x18, 0x00, 0x02, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x60, 0x00, 0x38, 0x00, 0x06, 0x60, 0x00, 0x2C, 0x00,
  0x06, 0x20, 0x00, 0x2C, 0x00, 0x04, 0x20, 0x00, 0x24, 0x00, 0x04, 0x30,
  0x00, 0x64, 0x00, 0x0C, 0x30, 0x00, 0x46, 0x00, 0x0C, 0x10, 0x00, 0x46,
  0x00, 0x08, 0x10, 0x00, 0x42, 0x00, 0x18, 0x18, 0x00, 0xC2, 0x00, 0x18,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x08, 0x00, 0x83, 0x00, 0x10, 0x08, 0x00,
  0x81, 0x00, 0x30, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x0C, 0x01, 0x81, 0x80,
  0x20, 0x04, 0x01, 0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x80, 0x60, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x40, 0x02, 0x02, 0x00,
  0xC0, 0x40, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x03, 0x06, 0x00, 0x40, 0xC0,
  0x03, 0x06, 0x00, 0x40, 0x80, 0x01, 0x04, 0x00, 0x60, 0x80, 0x01, 0x04,
  0x00, 0x21, 0x80, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x01, 0x8C, 0x00, 0x21,
  0x00, 0x00, 0x88, 0x00, 0x31, 0x00, 0x00, 0x88, 0x00, 0x13, 0x00, 0x00,
  0x98, 0x00, 0x13, 0x00, 0x00, 0xD8, 0x00, 0x12, 0x00, 0x00, 0x50, 0x00,
  0x1A, 0x00, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x08, 0x40, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x80, 0x01,
  0x01, 0x80, 0x06, 0x01, 0x00, 0x08, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x06, 0x01, 0x80, 0x04, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x10, 0x00,
  0x08, 0x60, 0x00, 0x19, 0x80, 0x00, 0x12, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x10, 0x80, 0x00, 0x61, 0x80, 0x00, 0x81, 0x00, 0x03, 0x03,
  0x00, 0x04, 0x02, 0x00, 0x18, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x0C,
  0x03, 0x00, 0x08, 0x04, 0x00, 0x18, 0x18, 0x00, 0x10, 0x20, 0x00, 0x30,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x80, 0x00, 0x31, 0x00, 0x00, 0x63,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x08,
  0x00, 0x20, 0x18, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x30, 0x06, 0x00, 0x20,
  0x08, 0x00, 0x60, 0x30, 0x00, 0x40, 0x40, 0x00, 0xC1, 0x80, 0x00, 0x83,
  0x00, 0x01, 0x84, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x02, 0xC0,
  0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0xFF, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xB0, 0x00, 0x03, 0x20, 0x00, 0x04, 0x60, 0x00, 0x18, 0x40,
  0x00, 0x20, 0xC0, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x06, 0x01, 0x00,
  0x08, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x06, 0x01, 0x80, 0x0C, 0x02,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x10, 0x60, 0x00, 0x31, 0x80,
  0x00, 0x22, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xF8, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x07, 0xFE,
  0x07, 0x01, 0xC1, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x1F, 0xC0, 0xFF, 0x10, 0xE0, 0x04, 0x60, 0x01, 0x30, 0x00,
  0x58, 0x00, 0x14, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0D, 0x00, 0x05, 0x60, 0x03, 0x58, 0x00, 0x93, 0x80, 0xC4, 0x3F,
  0xE1, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x60, 0x0C,
  0x3F, 0xE0, 0x63, 0x01, 0xC3, 0x30, 0x03, 0x1B, 0x00, 0x0C, 0xF0, 0x00,
  0x27, 0x00, 0x01, 0xB8, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x02, 0xC0, 0x00, 0x17, 0x00, 0x01, 0xB8, 0x00, 0x09,
  0xE0, 0x00, 0xCD, 0x00, 0x04, 0x6C, 0x00, 0x63, 0x38, 0x0E, 0x18, 0x7F,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xF0, 0x70, 0x08, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x02, 0x03, 0xFF, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x02, 0x01, 0x03, 0xFE, 0x10, 0xE0, 0x31, 0x18,
  0x00, 0x91, 0x00, 0x05, 0x30, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x34,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00,
  0x03, 0x60, 0x00, 0x32, 0x00, 0x07, 0x30, 0x00, 0x51, 0x80, 0x09, 0x0E,
  0x03, 0x10, 0x7F, 0xE1, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0,
  0x0E, 0x03, 0x01, 0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00,
  0x46, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x20, 0xE0, 0x0E, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x10,
  0x03, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0xFC,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xE1, 0x0E, 0x03, 0x91, 0x80,
  0x0D, 0x30, 0x00, 0x53, 0x00, 0x07, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x03, 0x40, 0x00,
  0x36, 0x00, 0x03, 0x20, 0x00, 0x53, 0x00, 0x0D, 0x18, 0x01, 0x90, 0xE0,
  0x31, 0x07, 0xFE, 0x10, 0x04, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x40, 0x00, 0xC7, 0x00, 0x18, 0x3F, 0xFF, 0x00, 0x3F, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x10, 0x0C, 0x3F, 0xE1, 0x8C, 0x06, 0x32, 0x00, 0x66,
  0x80, 0x06, 0xF0, 0x00, 0x5C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xDF,
  0x00, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0x80, 0x03, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x7E, 0x1C, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x30,
  0xC0, 0x18, 0x30, 0x04, 0x0C, 0x02, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30,
  0x60, 0x0C, 0x10, 0x03, 0x08, 0x00, 0xC7, 0x00, 0x33, 0x60, 0x0D, 0x88,
  0x03, 0x43, 0x00, 0xE0, 0x60, 0x38, 0x08, 0x0C, 0x03, 0x03, 0x00, 0x40,
  0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x18, 0xC0, 0x02, 0x30,
  0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0xC0, 0x87, 0xFC, 0x0F, 0xF8,
  0xCC, 0x06, 0x1C, 0x0C, 0xD8, 0x02, 0x30, 0x06, 0xD0, 0x01, 0x60, 0x02,
  0xE0, 0x01, 0x40, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01,
  0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01,
  0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01,
  0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01,
  0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01,
  0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01,
  0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x20, 0x18, 0x7F, 0xC3, 0x18, 0x0E, 0x64, 0x00, 0xCD, 0x00, 0x0D,
  0xE0, 0x00, 0xB8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x1F, 0xF8, 0x03, 0x80, 0xE0, 0x30, 0x01, 0x81, 0x00, 0x06, 0x18, 0x00,
  0x11, 0x80, 0x00, 0xC8, 0x00, 0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x4C, 0x00, 0x06,
  0x20, 0x00, 0x21, 0x80, 0x03, 0x06, 0x00, 0x30, 0x1C, 0x07, 0x00, 0x3F,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x30, 0x06, 0x1F, 0xF8, 0x31, 0xC0, 0xE1,
  0x98, 0x01, 0x8D, 0x80, 0x06, 0x68, 0x00, 0x13, 0x80, 0x00, 0xDC, 0x00,
  0x02, 0xE0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x60,
  0x00, 0x0B, 0x80, 0x00, 0xDC, 0x00, 0x04, 0xF0, 0x00, 0x66, 0xC0, 0x02,
  0x33, 0x00, 0x31, 0x8C, 0x07, 0x0C, 0x3F, 0xE0, 0x60, 0x18, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE1, 0x0E, 0x03, 0x11,
  0x80, 0x19, 0x30, 0x00, 0xD2, 0x00, 0x07, 0x60, 0x00, 0x34, 0x00, 0x03,
  0x40, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40,
  0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x53, 0x00, 0x0D, 0x18, 0x01, 0x90,
  0xC0, 0x31, 0x07, 0xFE, 0x10, 0x04, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0xC3,
  0xFE, 0x70, 0x32, 0x01, 0xA0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x40, 0x07,
  0xFF, 0x06, 0x00, 0xE6, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0xDC, 0x01, 0xC3, 0xFF, 0x80, 0x18,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x1F, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0xFE, 0x01, 0x00,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3A, 0x00, 0x05, 0x60, 0x01, 0x26,
  0x00, 0x44, 0x60, 0x30, 0x87, 0xFC, 0x10, 0x0C, 0x00, 0xC0, 0x00, 0x34,
  0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x04,
  0x30, 0x00, 0xC1, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x80, 0x18, 0x08, 0x01,
  0x80, 0x80, 0x10, 0x0C, 0x03, 0x00, 0x40, 0x30, 0x04, 0x02, 0x00, 0x60,
  0x60, 0x02, 0x06, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x01,
  0x08, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x09, 0x00, 0x00, 0xD0, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1A, 0x00, 0x14, 0x00, 0x24, 0x00,
  0x2C, 0x00, 0x4C, 0x00, 0x48, 0x01, 0x98, 0x01, 0x90, 0x03, 0x10, 0x02,
  0x30, 0x04, 0x20, 0x04, 0x60, 0x08, 0x60, 0x18, 0x40, 0x30, 0xC0, 0x30,
  0x80, 0x60, 0x80, 0x41, 0x80, 0x81, 0x00, 0x81, 0x01, 0x03, 0x03, 0x02,
  0x06, 0x02, 0x04, 0x06, 0x0C, 0x04, 0x08, 0x0C, 0x10, 0x08, 0x30, 0x08,
  0x20, 0x18, 0x60, 0x10, 0xC0, 0x10, 0x80, 0x31, 0x80, 0x21, 0x00, 0x22,
  0x00, 0x66, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xD8, 0x00, 0x90, 0x01, 0xB0,
  0x01, 0x60, 0x01, 0x40, 0x03, 0xC0, 0x02, 0x80, 0x07, 0x00, 0x05, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x60, 0x00, 0x62, 0x00,
  0x04, 0x30, 0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x04,
  0x02, 0x00, 0x60, 0x60, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x98, 0x00,
  0x09, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0D, 0x00,
  0x01, 0x98, 0x00, 0x10, 0x80, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x04, 0x02,
  0x00, 0xC0, 0x30, 0x08, 0x01, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC2, 0x00,
  0x04, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x14, 0x00, 0x03, 0x60,
  0x00, 0x32, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x06, 0x10, 0x00, 0x41,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x01, 0x80, 0xC0, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x06, 0x03, 0x00, 0x20, 0x20, 0x02, 0x06,
  0x00, 0x30, 0x60, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x8C, 0x00, 0x08,
  0x80, 0x00, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x50, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1C, 0x03,
  0xF0, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x03,
  0x80, 0x3C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xE0, 0x03, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x0E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x04, 0xE3, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 38, 11, 4, -38 },
  { 16, 9, 14, 16, 4, -38 },
  { 32, 28, 38, 30, 1, -38 },
  { 165, 20, 43, 27, 3, -40 },
  { 273, 32, 39, 38, 3, -38 },
  { 429, 27, 39, 31, 3, -38 },
  { 561, 1, 14, 9, 4, -38 },
  { 563, 10, 46, 14, 2, -38 },
  { 621, 9, 46, 14, 2, -38 },
  { 673, 19, 18, 25, 3, -40 },
  { 716, 22, 24, 27, 2, -31 },
  { 782, 5, 13, 10, 2, -6 },
  { 791, 12, 1, 16, 2, -15 },
  { 793, 3, 3, 11, 4, -3 },
  { 795, 15, 38, 17, 1, -38 },
  { 867, 21, 38, 27, 3, -38 },
  { 967, 10, 38, 27, 5, -38 },
  { 1015, 20, 38, 27, 3, -38 },
  { 1110, 21, 39, 27, 2, -38 },
  { 1213, 25, 38, 27, 1, -38 },
  { 1332, 21, 39, 27, 3, -38 },
  { 1435, 21, 39, 27, 3, -38 },
  { 1538, 21, 38, 27, 3, -38 },
  { 1638, 21, 39, 27, 3, -38 },
  { 1741, 20, 39, 27, 3, -38 },
  { 1839, 3, 28, 11, 4, -28 },
  { 1850, 5, 35, 11, 2, -28 },
  { 1872, 22, 23, 27, 2, -31 },
  { 1936, 22, 12, 27, 2, -25 },
  { 1969, 22, 23, 27, 2, -31 },
  { 2033, 15, 38, 19, 2, -38 },
  { 2105, 35, 43, 41, 3, -38 },
  { 2294, 27, 38, 27, 0, -38 },
  { 2423, 21, 38, 29, 5, -38 },
  { 2523, 24, 39, 29, 3, -38 },
  { 2640, 24, 38, 32, 5, -38 },
  { 2754, 18, 38, 26, 5, -38 },
  { 2840, 18, 38, 23, 5, -38 },
  { 2926, 27, 39, 34, 3, -38 },
  { 3058, 23, 38, 33, 5, -38 },
  { 3168, 8, 38, 14, 3, -38 },
  { 3206, 11, 47, 11, -4, -38 },
  { 3271, 21, 38, 26, 5, -38 },
  { 3371, 18, 38, 24, 5, -38 },
  { 3457, 31, 38, 41, 5, -38 },
  { 3605, 23, 38, 33, 5, -38 },
  { 3715, 29, 39, 35, 3, -38 },
  { 3857, 19, 38, 27, 5, -38 },
  { 3948, 29, 47, 35, 3, -38 },
  { 4119, 21, 38, 27, 5, -38 },
  { 4219, 20, 39, 26, 3, -38 },
  { 4317, 23, 38, 23, 0, -38 },
  { 4427, 24, 39, 33, 5, -38 },
  { 4544, 26, 38, 26, 0, -38 },
  { 4668, 40, 38, 42, 1, -38 },
  { 4858, 23, 38, 24, 0, -38 },
  { 4968, 23, 38, 23, 0, -38 },
  { 5078, 22, 38, 26, 2, -38 },
  { 5183, 10, 46, 16, 5, -38 },
  { 5241, 15, 38, 17, 1, -38 },
  { 5313, 10, 46, 16, 2, -38 },
  { 5371, 23, 21, 27, 2, -38 },
  { 5432, 21, 1, 21, 0, 5 },
  { 5435, 9, 9, 13, 2, -41 },
  { 5446, 18, 29, 24, 2, -28 },
  { 5512, 21, 41, 28, 4, -40 },
  { 5620, 18, 30, 22, 3, -29 },
  { 5688, 20, 41, 28, 3, -40 },
  { 5791, 20, 30, 26, 3, -29 },
  { 5866, 15, 41, 13, 1, -41 },
  { 5943, 20, 42, 28, 3, -29 },
  { 6048, 19, 40, 27, 4, -40 },
  { 6143, 3, 38, 10, 4, -38 },
  { 6158, 9, 51, 10, -2, -38 },
  { 6216, 18, 40, 22, 4, -40 },
  { 6306, 2, 40, 10, 4, -40 },
  { 6316, 32, 29, 40, 4, -29 },
  { 6432, 19, 29, 27, 4, -29 },
  { 6501, 21, 30, 27, 3, -29 },
  { 6580, 21, 41, 28, 4, -29 },
  { 6688, 20, 41, 28, 3, -29 },
  { 6791, 13, 28, 18, 4, -28 },
  { 6837, 17, 30, 21, 2, -29 },
  { 6901, 13, 36, 15, 1, -35 },
  { 6960, 19, 29, 27, 4, -28 },
  { 7029, 20, 28, 20, 0, -28 },
  { 7099, 31, 28, 33, 1, -28 },
  { 7208, 20, 28, 22, 1, -28 },
  { 7278, 20, 41, 21, 0, -28 },
  { 7381, 16, 28, 20, 2, -28 },
  { 7437, 14, 46, 18, 2, -38 },
  { 7518, 1, 53, 25, 12, -40 },
  { 7525, 14, 46, 18, 2, -38 },
  { 7606, 22, 5, 27, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Thin53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_THIN53PT7B_H_
