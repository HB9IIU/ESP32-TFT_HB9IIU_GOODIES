#ifndef _NOTOSANS_SEMICONDENSED_THIN39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin39pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x40, 0x0F, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x00, 0x80, 0x80, 0x08, 0x10, 0x01, 0x01, 0x00,
  0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x20,
  0x02, 0x02, 0x07, 0xFF, 0xFF, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x02,
  0x00, 0x20, 0x40, 0x06, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40,
  0x40, 0xFF, 0xFF, 0xE0, 0x40, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x08,
  0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0xFF, 0xE3, 0x10, 0x88,
  0x20, 0x30, 0x40, 0x40, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x06, 0x08,
  0x04, 0x10, 0x06, 0x20, 0x06, 0x40, 0x03, 0x80, 0x01, 0xC0, 0x02, 0x60,
  0x04, 0x60, 0x08, 0x20, 0x10, 0x40, 0x20, 0x40, 0x40, 0x80, 0x81, 0x01,
  0x02, 0x02, 0x08, 0x04, 0x34, 0x08, 0xC7, 0xFE, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x1E, 0x00, 0x20, 0x21, 0x00, 0x40, 0x40, 0x80, 0x40, 0x40,
  0x80, 0x80, 0xC0, 0x80, 0x80, 0x80, 0x81, 0x00, 0x80, 0x41, 0x00, 0x80,
  0x43, 0x00, 0x80, 0x42, 0x00, 0x80, 0x42, 0x00, 0x80, 0x44, 0x00, 0x80,
  0x84, 0x78, 0x80, 0x88, 0x84, 0x40, 0x89, 0x02, 0x40, 0x91, 0x02, 0x21,
  0x13, 0x02, 0x1E, 0x22, 0x02, 0x00, 0x22, 0x01, 0x00, 0x42, 0x01, 0x00,
  0x42, 0x01, 0x00, 0x82, 0x01, 0x00, 0x82, 0x01, 0x01, 0x02, 0x02, 0x01,
  0x02, 0x02, 0x03, 0x01, 0x02, 0x02, 0x01, 0x02, 0x02, 0x00, 0x84, 0x04,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x81, 0x00, 0x10, 0x18, 0x01, 0x00, 0x80,
  0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x18,
  0x00, 0x81, 0x00, 0x0C, 0x20, 0x00, 0x4C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x18, 0x80, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x24, 0x02, 0x02, 0x80,
  0x10, 0x28, 0x00, 0x84, 0x80, 0x04, 0x48, 0x00, 0x68, 0x80, 0x03, 0x88,
  0x00, 0x10, 0x40, 0x02, 0x86, 0x00, 0x44, 0x30, 0x18, 0x21, 0xFE, 0x03,
  0xFF, 0xC0, 0x06, 0x18, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x81, 0x01, 0x02, 0x06, 0x04, 0x04, 0x08, 0x0C, 0xC0, 0xC0, 0x80, 0x81,
  0x01, 0x02, 0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x60, 0x83, 0x04, 0x18,
  0x21, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0x04,
  0x33, 0x97, 0x01, 0xE0, 0x03, 0x00, 0x12, 0x00, 0x44, 0x02, 0x18, 0x10,
  0x20, 0xC0, 0x40, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x33, 0x22, 0x26, 0x44, 0xC0, 0xFF, 0x80, 0xF0, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x00, 0x07, 0xE0, 0x30, 0x20, 0x40, 0x21, 0x00, 0x22, 0x00, 0x48,
  0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x01, 0x10, 0x02, 0x20,
  0x04, 0x20, 0x10, 0x60, 0x40, 0x3F, 0x00, 0x02, 0x0C, 0x69, 0x96, 0x30,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x0F, 0xE0, 0x60, 0x61,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x07, 0xFF,
  0xF0, 0x1F, 0xE0, 0xC0, 0x22, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x1A, 0x00, 0x63, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x40, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x02, 0x10,
  0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x10, 0x10, 0x04, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x20, 0x04, 0x18, 0x01, 0x04, 0x00,
  0x42, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x3F, 0xFC, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x38, 0x07, 0xCF, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x13, 0x00, 0x41,
  0xFF, 0x00, 0x01, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x47, 0xF0, 0x48, 0x18, 0x90, 0x04, 0xA0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x02,
  0x20, 0x02, 0x20, 0x06, 0x10, 0x04, 0x18, 0x08, 0x07, 0xF0, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x0F, 0xE0, 0x18, 0x18, 0x20, 0x0C, 0x60, 0x04, 0x40,
  0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0x20, 0x04, 0x10,
  0x08, 0x0C, 0x30, 0x07, 0xC0, 0x03, 0xC0, 0x0C, 0x60, 0x10, 0x18, 0x20,
  0x04, 0x40, 0x06, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x40, 0x02, 0x60, 0x04, 0x30, 0x08, 0x0F, 0xF0, 0x0F,
  0xE0, 0x20, 0x60, 0x80, 0x22, 0x00, 0x64, 0x00, 0x50, 0x00, 0xA0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x68,
  0x00, 0xD8, 0x02, 0x98, 0x09, 0x0F, 0xE2, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x83, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x13, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x32, 0x22, 0x64, 0x4C, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x7F, 0x8C, 0x0C,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x02, 0x20, 0x0F, 0x80, 0x90, 0x0C, 0x10, 0x14,
  0x06, 0x04, 0x05, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x10, 0x04, 0x06, 0x04, 0x01, 0x01, 0x81, 0x00, 0x40, 0x60, 0x40,
  0x10, 0x18, 0x10, 0x04, 0x06, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0xB0,
  0x20, 0x48, 0x24, 0x06, 0x73, 0x31, 0x00, 0xF0, 0x78, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00,
  0x09, 0x00, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x20, 0x40, 0x04, 0x06, 0x00, 0x40, 0x20, 0x04, 0x02,
  0x00, 0x80, 0x30, 0x0F, 0xFF, 0x00, 0x80, 0x10, 0x10, 0x01, 0x81, 0x00,
  0x08, 0x10, 0x00, 0x82, 0x00, 0x0C, 0x20, 0x00, 0x42, 0x00, 0x04, 0x40,
  0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x03, 0xFF, 0xC1, 0x00,
  0x62, 0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x03, 0x1F, 0xFC, 0x20,
  0x06, 0x40, 0x02, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x1A, 0x00, 0xC7,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x30, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x04, 0x07, 0xFE, 0xFF, 0x80, 0x40, 0x38, 0x20, 0x06, 0x10,
  0x00, 0x88, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x04, 0x40, 0x04,
  0x20, 0x1C, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x7F, 0xFA, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x03, 0xFF, 0xD0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x30, 0x03, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x11, 0x00,
  0x01, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x03, 0x00, 0x10, 0x1F, 0xFE, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0xFC,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3F, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x8C, 0x78, 0x80, 0x07, 0x00, 0x1A, 0x00,
  0x24, 0x00, 0x88, 0x02, 0x10, 0x08, 0x20, 0x30, 0x40, 0xC0, 0x83, 0x01,
  0x04, 0x02, 0x10, 0x04, 0x40, 0x09, 0x80, 0x16, 0x80, 0x39, 0x80, 0x61,
  0x00, 0x81, 0x01, 0x02, 0x02, 0x02, 0x04, 0x06, 0x08, 0x04, 0x10, 0x04,
  0x20, 0x0C, 0x40, 0x08, 0x80, 0x09, 0x00, 0x1A, 0x00, 0x14, 0x00, 0x10,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xA0, 0x00, 0x16,
  0x80, 0x00, 0x5B, 0x00, 0x03, 0x64, 0x00, 0x09, 0x90, 0x00, 0x26, 0x20,
  0x01, 0x18, 0x80, 0x04, 0x62, 0x00, 0x11, 0x84, 0x00, 0x86, 0x10, 0x02,
  0x18, 0x60, 0x18, 0x60, 0x80, 0x41, 0x82, 0x01, 0x06, 0x04, 0x08, 0x18,
  0x10, 0x20, 0x60, 0x40, 0x81, 0x80, 0x84, 0x06, 0x02, 0x10, 0x18, 0x0C,
  0xC0, 0x60, 0x12, 0x01, 0x80, 0x48, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1A,
  0x00, 0x0C, 0x80, 0x06, 0x40, 0x03, 0x10, 0x01, 0x8C, 0x00, 0xC2, 0x00,
  0x60, 0x80, 0x30, 0x40, 0x18, 0x10, 0x0C, 0x08, 0x06, 0x02, 0x03, 0x01,
  0x81, 0x80, 0x40, 0xC0, 0x10, 0x60, 0x08, 0x30, 0x02, 0x18, 0x01, 0x8C,
  0x00, 0x46, 0x00, 0x13, 0x00, 0x09, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x10, 0x01, 0xFE, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x04, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x30, 0x80, 0x00, 0x42, 0x00, 0x01, 0x10, 0x00,
  0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0xA0, 0x00, 0x02,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00,
  0x09, 0x80, 0x00, 0x42, 0x00, 0x01, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x20,
  0x20, 0x01, 0x00, 0x60, 0x18, 0x00, 0x7F, 0x80, 0xFF, 0x82, 0x03, 0x88,
  0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x06, 0x3F, 0xE0,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0xFE, 0x00,
  0x18, 0x06, 0x00, 0xC0, 0x04, 0x04, 0x00, 0x08, 0x10, 0x00, 0x30, 0x80,
  0x00, 0x42, 0x00, 0x01, 0x10, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00,
  0x24, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09, 0x80, 0x00, 0x42, 0x00, 0x01,
  0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x20, 0x01, 0x00, 0x60, 0x18, 0x00,
  0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0xFF, 0x81,
  0x01, 0xC2, 0x00, 0x44, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x48, 0x01, 0x10, 0x06,
  0x3F, 0xF0, 0x40, 0x80, 0x80, 0x81, 0x01, 0x02, 0x01, 0x04, 0x02, 0x08,
  0x02, 0x10, 0x06, 0x20, 0x04, 0x40, 0x0C, 0x80, 0x09, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x10, 0x0F, 0xF8, 0x30, 0x08, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x1A, 0x00, 0x63, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05,
  0x00, 0x02, 0x20, 0x00, 0x8C, 0x00, 0x41, 0x80, 0x60, 0x1F, 0xF0, 0x80,
  0x00, 0x30, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x40,
  0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40,
  0x04, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x01, 0x80, 0x20,
  0x20, 0x04, 0x04, 0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x11,
  0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xF0, 0x01, 0x80, 0x04, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x50, 0x01,
  0x20, 0x06, 0x80, 0x19, 0x80, 0x24, 0x00, 0x84, 0x01, 0x10, 0x04, 0x20,
  0x08, 0x80, 0x21, 0x00, 0xC4, 0x03, 0x0C, 0x04, 0x20, 0x10, 0x20, 0x20,
  0x80, 0x81, 0x01, 0x04, 0x04, 0x08, 0x18, 0x20, 0x60, 0x60, 0x81, 0x02,
  0x01, 0x04, 0x04, 0x10, 0x08, 0x20, 0x20, 0x80, 0x41, 0x01, 0x08, 0x03,
  0x10, 0x08, 0x40, 0x08, 0x80, 0x22, 0x00, 0x44, 0x01, 0x10, 0x02, 0x20,
  0x09, 0x00, 0x1A, 0x00, 0x48, 0x00, 0x50, 0x01, 0x40, 0x02, 0x80, 0x0A,
  0x00, 0x14, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC2, 0x00, 0x41, 0x80, 0x40, 0x40,
  0x20, 0x30, 0x20, 0x08, 0x10, 0x06, 0x10, 0x01, 0x08, 0x00, 0x48, 0x00,
  0x2C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0xC0, 0x01, 0x20,
  0x01, 0x18, 0x01, 0x84, 0x00, 0x81, 0x00, 0x80, 0x80, 0x40, 0x20, 0x40,
  0x10, 0x20, 0x04, 0x20, 0x02, 0x30, 0x00, 0x90, 0x00, 0x58, 0x00, 0x10,
  0x80, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00, 0x21, 0x80,
  0x30, 0x40, 0x10, 0x30, 0x18, 0x08, 0x08, 0x04, 0x04, 0x01, 0x04, 0x00,
  0x82, 0x00, 0x22, 0x00, 0x11, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xF0,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x68, 0x00, 0x24, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x10, 0x20, 0x08, 0x10, 0x08, 0x04, 0x04, 0x02, 0x04, 0x00, 0x82, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x09, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFE, 0x83,
  0x06, 0x08, 0x10, 0x30, 0x0F, 0xC3, 0x83, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x07, 0xC3, 0xC2, 0x60, 0x14,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0A, 0x80,
  0x93, 0xF8, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x0F, 0xC2, 0x60, 0xC5,
  0x80, 0x4A, 0x00, 0x58, 0x00, 0xB0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x0B, 0x00, 0x15, 0x00, 0x49, 0x01, 0x91, 0xFC, 0x00,
  0x03, 0xF0, 0x60, 0x44, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x0F, 0xC4, 0x60, 0xC9, 0x80, 0x52, 0x00, 0x68,
  0x00, 0xD0, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x40, 0x02, 0x80, 0x0D,
  0x00, 0x19, 0x00, 0x51, 0x01, 0xA1, 0xFC, 0x40, 0x07, 0xC0, 0x30, 0x60,
  0xC0, 0x21, 0x00, 0x44, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80,
  0x03, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0xC0, 0x20, 0xFF, 0x80,
  0x01, 0xE0, 0x61, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x0F, 0xF8, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xE2, 0x30,
  0x24, 0xC0, 0x29, 0x00, 0x34, 0x00, 0x68, 0x00, 0x50, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x0C, 0x80, 0x28, 0x80, 0xD0, 0xFE,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x24, 0x01, 0x87, 0xFE, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x1F, 0x89,
  0x83, 0x2C, 0x02, 0xA0, 0x0B, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xF0,
  0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x02,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0xF0, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0xA0, 0x09, 0x00, 0xC8, 0x0C, 0x40, 0x42, 0x04, 0x10, 0x40,
  0x86, 0x04, 0x60, 0x23, 0x01, 0x28, 0x0A, 0x20, 0x61, 0x83, 0x04, 0x10,
  0x10, 0x80, 0xC4, 0x02, 0x20, 0x09, 0x00, 0x48, 0x01, 0x40, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFC, 0x87, 0x80, 0xF8, 0x98, 0x63, 0x0C, 0xA0, 0x24, 0x02,
  0xC0, 0x14, 0x02, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01,
  0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01,
  0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x80, 0x08, 0x01,
  0x80, 0x08, 0x01, 0x80, 0x08, 0x01, 0x87, 0xE2, 0x60, 0xCB, 0x00, 0xA8,
  0x02, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x07, 0xE0, 0x18, 0x18, 0x30,
  0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x04, 0x20, 0x04, 0x18, 0x18, 0x0F,
  0xF0, 0x87, 0xE1, 0x10, 0x62, 0x40, 0x25, 0x00, 0x2C, 0x00, 0x58, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x05, 0x40, 0x0A, 0x80,
  0x24, 0xC0, 0xC8, 0xFE, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE2,
  0x30, 0x64, 0xC0, 0x29, 0x00, 0x34, 0x00, 0x68, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xA0, 0x01, 0x40, 0x06, 0x80, 0x0C, 0x80, 0x28, 0x80, 0x90,
  0xFE, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x87, 0xCC, 0x28, 0x14, 0x0C,
  0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0x0F, 0xE0, 0x80, 0xC8, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x07, 0x80, 0x67, 0xFE, 0x00, 0x20, 0x10, 0x08, 0x04, 0x02, 0x07,
  0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x07, 0xC0,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x54, 0x01, 0x58, 0x09, 0x1F,
  0xC4, 0x80, 0x03, 0x00, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x84, 0x01,
  0x08, 0x02, 0x10, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x41, 0x00,
  0x82, 0x01, 0x08, 0x01, 0x10, 0x02, 0x20, 0x04, 0x80, 0x05, 0x00, 0x0A,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x0A, 0x00,
  0xC0, 0x14, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x09, 0x01, 0x10, 0x11,
  0x02, 0x20, 0x22, 0x04, 0x20, 0x44, 0x08, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x81, 0x10, 0x21, 0x02, 0x20, 0x24, 0x04, 0x40, 0x48,
  0x05, 0x80, 0x90, 0x0A, 0x01, 0x20, 0x14, 0x01, 0x80, 0x28, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x05, 0x00, 0x26, 0x01, 0x88,
  0x04, 0x10, 0x20, 0x60, 0x80, 0x84, 0x01, 0x30, 0x04, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x04, 0x80, 0x11, 0x00, 0x84, 0x04, 0x08, 0x10, 0x30,
  0x80, 0x46, 0x00, 0x90, 0x02, 0x80, 0x04, 0x80, 0x02, 0x80, 0x05, 0x00,
  0x12, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x08, 0x04, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x41, 0x00, 0x82, 0x00, 0x84, 0x01, 0x10, 0x02,
  0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0xE0, 0x60, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x70, 0x1E, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x03, 0x80, 0x70, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x38, 0x00, 0x7F, 0x01, 0x81, 0xC3, 0x80, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_Thin39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 28, 8, 3, -28 },
  { 8, 6, 10, 12, 3, -28 },
  { 16, 20, 28, 22, 1, -28 },
  { 86, 15, 32, 20, 2, -30 },
  { 146, 24, 28, 28, 2, -28 },
  { 230, 20, 28, 23, 2, -28 },
  { 300, 1, 10, 7, 3, -28 },
  { 302, 7, 34, 10, 2, -28 },
  { 332, 7, 34, 10, 1, -28 },
  { 362, 14, 14, 18, 2, -30 },
  { 387, 16, 18, 20, 2, -23 },
  { 423, 4, 9, 7, 1, -4 },
  { 428, 9, 1, 12, 1, -11 },
  { 430, 2, 2, 8, 3, -2 },
  { 431, 11, 28, 13, 1, -28 },
  { 470, 15, 28, 20, 2, -28 },
  { 523, 7, 28, 20, 4, -28 },
  { 548, 15, 28, 20, 2, -28 },
  { 601, 15, 28, 20, 2, -28 },
  { 654, 18, 28, 20, 1, -28 },
  { 717, 15, 28, 20, 2, -28 },
  { 770, 16, 28, 20, 2, -28 },
  { 826, 15, 28, 20, 2, -28 },
  { 879, 16, 28, 20, 2, -28 },
  { 935, 15, 28, 20, 2, -28 },
  { 988, 2, 21, 8, 3, -21 },
  { 994, 4, 26, 8, 1, -21 },
  { 1007, 16, 16, 20, 2, -22 },
  { 1039, 16, 9, 20, 2, -18 },
  { 1057, 16, 16, 20, 2, -22 },
  { 1089, 12, 28, 14, 1, -28 },
  { 1131, 26, 32, 30, 2, -28 },
  { 1235, 20, 28, 20, 0, -28 },
  { 1305, 15, 28, 21, 4, -28 },
  { 1358, 18, 28, 21, 2, -28 },
  { 1421, 17, 28, 24, 4, -28 },
  { 1481, 13, 28, 19, 4, -28 },
  { 1527, 13, 28, 17, 4, -28 },
  { 1573, 20, 28, 25, 2, -28 },
  { 1643, 17, 28, 24, 4, -28 },
  { 1703, 6, 28, 10, 2, -28 },
  { 1724, 8, 35, 8, -3, -28 },
  { 1759, 15, 28, 19, 4, -28 },
  { 1812, 13, 28, 17, 4, -28 },
  { 1858, 22, 28, 30, 4, -28 },
  { 1935, 17, 28, 24, 4, -28 },
  { 1995, 22, 28, 26, 2, -28 },
  { 2072, 14, 28, 20, 4, -28 },
  { 2121, 22, 35, 26, 2, -28 },
  { 2218, 15, 28, 20, 4, -28 },
  { 2271, 15, 28, 19, 2, -28 },
  { 2324, 17, 28, 17, 0, -28 },
  { 2384, 18, 28, 25, 3, -28 },
  { 2447, 19, 28, 19, 0, -28 },
  { 2514, 29, 28, 31, 1, -28 },
  { 2616, 17, 28, 17, 0, -28 },
  { 2676, 17, 28, 17, 0, -28 },
  { 2736, 17, 28, 19, 1, -28 },
  { 2796, 8, 34, 12, 3, -28 },
  { 2830, 11, 28, 13, 1, -28 },
  { 2869, 8, 34, 12, 1, -28 },
  { 2903, 17, 16, 20, 1, -28 },
  { 2937, 15, 1, 15, 0, 4 },
  { 2939, 6, 6, 9, 2, -30 },
  { 2944, 13, 21, 18, 2, -21 },
  { 2979, 15, 30, 20, 3, -30 },
  { 3036, 13, 21, 16, 2, -21 },
  { 3071, 15, 30, 20, 2, -30 },
  { 3128, 15, 21, 19, 2, -21 },
  { 3168, 12, 30, 10, 0, -30 },
  { 3213, 15, 30, 20, 2, -21 },
  { 3270, 14, 30, 20, 3, -30 },
  { 3323, 2, 28, 8, 3, -28 },
  { 3330, 6, 37, 8, -1, -28 },
  { 3358, 13, 30, 16, 3, -30 },
  { 3407, 1, 30, 7, 3, -30 },
  { 3411, 24, 21, 30, 3, -21 },
  { 3474, 14, 21, 20, 3, -21 },
  { 3511, 16, 21, 20, 2, -21 },
  { 3553, 15, 30, 20, 3, -21 },
  { 3610, 15, 30, 20, 2, -21 },
  { 3667, 9, 21, 13, 3, -21 },
  { 3691, 13, 21, 16, 1, -21 },
  { 3726, 9, 26, 11, 1, -26 },
  { 3756, 14, 21, 20, 3, -21 },
  { 3793, 15, 21, 15, 0, -21 },
  { 3833, 23, 21, 24, 1, -21 },
  { 3894, 14, 21, 16, 1, -21 },
  { 3931, 15, 30, 15, 0, -21 },
  { 3988, 13, 21, 15, 1, -21 },
  { 4023, 11, 34, 13, 1, -28 },
  { 4070, 1, 40, 19, 9, -30 },
  { 4075, 10, 34, 13, 2, -28 },
  { 4118, 16, 3, 20, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Thin39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_THIN39PT7B_H_
