#ifndef _NOTOSANS_SEMICONDENSED_THIN12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x24, 0x92, 0x9F, 0x28, 0xAD, 0xD2, 0x50, 0x6D,
  0xCC, 0x65, 0x55, 0xA4, 0xC5, 0x52, 0xA5, 0xAB, 0xBD, 0x4A, 0xA5, 0x4E,
  0x62, 0x49, 0x18, 0x42, 0x99, 0x62, 0xF4, 0xF0, 0x6A, 0xAA, 0xA4, 0x89,
  0x12, 0x49, 0x4A, 0x00, 0x4F, 0x4A, 0x21, 0x3E, 0x42, 0x10, 0xE0, 0xE0,
  0x80, 0x11, 0x22, 0x24, 0x48, 0x80, 0x69, 0x99, 0x99, 0x99, 0xF0, 0x75,
  0x55, 0x40, 0xE1, 0x11, 0x12, 0x48, 0xF0, 0xE1, 0x11, 0x61, 0x11, 0xF0,
  0x08, 0x61, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF8, 0x88, 0x71, 0x11, 0xF0,
  0x78, 0x8E, 0x99, 0x99, 0xF0, 0xF1, 0x11, 0x22, 0x44, 0x40, 0x69, 0x99,
  0x69, 0x99, 0xF0, 0x69, 0x99, 0x97, 0x11, 0xE0, 0x84, 0x40, 0x1A, 0x1B,
  0x20, 0x83, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0x6C, 0x00, 0xE1, 0x11, 0x24,
  0x40, 0x40, 0x3C, 0x42, 0x81, 0xBD, 0xA5, 0xC5, 0xA9, 0x96, 0x80, 0x7C,
  0x10, 0x43, 0x12, 0x49, 0xE8, 0x61, 0x84, 0xF4, 0x63, 0x1F, 0x46, 0x31,
  0xF0, 0x3E, 0x21, 0x08, 0x42, 0x10, 0x78, 0xF2, 0x28, 0x61, 0x86, 0x18,
  0x62, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0x80,
  0x3F, 0x08, 0x20, 0x9A, 0x18, 0x61, 0x7C, 0x8C, 0x63, 0x1F, 0xC6, 0x31,
  0x88, 0xEA, 0xAA, 0xC0, 0x55, 0x55, 0x5C, 0x8C, 0xA9, 0x8C, 0x52, 0x52,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x83, 0x06, 0x0E, 0x3C, 0x75, 0x6A,
  0xC9, 0x92, 0x8C, 0x73, 0x5A, 0xCE, 0x71, 0x88, 0x7A, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x78, 0xF4, 0x63, 0x19, 0x72, 0x10, 0x80, 0x7A, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x68, 0x40, 0x80, 0xF4, 0x63, 0x1D, 0x52, 0x52, 0x88,
  0x78, 0x88, 0x61, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x86, 0x18, 0x52, 0x49, 0x23, 0x0C,
  0x20, 0x88, 0xC4, 0x62, 0x2A, 0x95, 0x52, 0xA9, 0x4C, 0x44, 0x22, 0x00,
  0x8A, 0x54, 0x42, 0x11, 0x49, 0x88, 0x8C, 0x52, 0xA2, 0x10, 0x84, 0x20,
  0x78, 0x42, 0x22, 0x11, 0x08, 0xF8, 0xEA, 0xAA, 0xAC, 0x88, 0x44, 0x42,
  0x22, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0xC2, 0x92, 0x84, 0xF8,
  0xD0, 0xF1, 0x79, 0x9F, 0x84, 0x39, 0x28, 0xC6, 0x31, 0xF0, 0xF8, 0x88,
  0x8F, 0x11, 0x79, 0x99, 0x99, 0xF0, 0xF9, 0xF8, 0x8F, 0x74, 0xE4, 0x44,
  0x44, 0x40, 0xF9, 0x99, 0x9F, 0x11, 0xF0, 0x88, 0xE9, 0x99, 0x99, 0x90,
  0x9F, 0x80, 0x41, 0x55, 0x56, 0x88, 0x9A, 0xAC, 0xAA, 0x90, 0xFF, 0x80,
  0xFF, 0x26, 0x4C, 0x99, 0x32, 0x40, 0xF9, 0x99, 0x99, 0xF9, 0x99, 0x9F,
  0xF4, 0x63, 0x18, 0xFA, 0x10, 0x80, 0xF9, 0x99, 0x9F, 0x11, 0x10, 0xF2,
  0x49, 0x00, 0xF8, 0x61, 0x1F, 0x5D, 0x24, 0x93, 0x99, 0x99, 0x9F, 0x8C,
  0x94, 0xA6, 0x10, 0x93, 0x25, 0xAB, 0x56, 0x48, 0x80, 0xDA, 0x88, 0xC5,
  0x44, 0x8C, 0x94, 0xA6, 0x10, 0x88, 0x80, 0x71, 0x24, 0x4F, 0x34, 0x44,
  0x4C, 0x44, 0x44, 0x30, 0xFF, 0xF0, 0xC2, 0x22, 0x23, 0x22, 0x22, 0xC0,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Thin12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 6, 9, 7, 0, -9 },
  { 11, 4, 10, 6, 1, -9 },
  { 16, 7, 9, 9, 1, -9 },
  { 24, 6, 9, 7, 1, -9 },
  { 31, 1, 4, 2, 1, -9 },
  { 32, 2, 11, 3, 1, -9 },
  { 35, 3, 11, 3, 0, -9 },
  { 40, 4, 4, 6, 1, -9 },
  { 42, 5, 6, 6, 1, -7 },
  { 46, 1, 3, 2, 0, -1 },
  { 47, 3, 1, 4, 0, -4 },
  { 48, 1, 1, 2, 1, -1 },
  { 49, 4, 9, 4, 0, -9 },
  { 54, 4, 9, 6, 1, -9 },
  { 59, 2, 9, 6, 1, -9 },
  { 62, 4, 9, 6, 1, -9 },
  { 67, 4, 9, 6, 1, -9 },
  { 72, 6, 9, 6, 0, -9 },
  { 79, 4, 9, 6, 1, -9 },
  { 84, 4, 9, 6, 1, -9 },
  { 89, 4, 9, 6, 1, -9 },
  { 94, 4, 9, 6, 1, -9 },
  { 99, 4, 9, 6, 1, -9 },
  { 104, 1, 6, 2, 1, -6 },
  { 105, 2, 8, 2, 0, -6 },
  { 107, 5, 5, 6, 1, -7 },
  { 111, 5, 3, 6, 1, -6 },
  { 113, 5, 5, 6, 1, -7 },
  { 117, 4, 9, 4, 0, -9 },
  { 122, 8, 10, 9, 1, -9 },
  { 132, 6, 9, 6, 0, -9 },
  { 139, 5, 9, 7, 1, -9 },
  { 145, 5, 9, 6, 1, -9 },
  { 151, 6, 9, 7, 1, -9 },
  { 158, 4, 9, 6, 1, -9 },
  { 163, 4, 9, 5, 1, -9 },
  { 168, 6, 9, 8, 1, -9 },
  { 175, 5, 9, 8, 1, -9 },
  { 181, 2, 9, 3, 1, -9 },
  { 184, 2, 11, 3, -1, -9 },
  { 187, 5, 9, 6, 1, -9 },
  { 193, 4, 9, 5, 1, -9 },
  { 198, 7, 9, 9, 1, -9 },
  { 206, 5, 9, 8, 1, -9 },
  { 212, 6, 9, 8, 1, -9 },
  { 219, 5, 9, 6, 1, -9 },
  { 225, 6, 11, 8, 1, -9 },
  { 234, 5, 9, 6, 1, -9 },
  { 240, 4, 9, 6, 1, -9 },
  { 245, 5, 9, 5, 0, -9 },
  { 251, 6, 9, 8, 1, -9 },
  { 258, 6, 9, 6, 0, -9 },
  { 265, 9, 9, 9, 0, -9 },
  { 276, 5, 9, 5, 0, -9 },
  { 282, 5, 9, 5, 0, -9 },
  { 288, 5, 9, 6, 0, -9 },
  { 294, 2, 11, 4, 1, -9 },
  { 297, 4, 9, 4, 0, -9 },
  { 302, 3, 11, 4, 0, -9 },
  { 307, 6, 5, 6, 0, -9 },
  { 311, 5, 1, 5, 0, 1 },
  { 312, 2, 2, 3, 0, -9 },
  { 313, 4, 6, 6, 1, -6 },
  { 316, 5, 9, 6, 1, -9 },
  { 322, 4, 6, 5, 1, -6 },
  { 325, 4, 9, 6, 1, -9 },
  { 330, 4, 6, 6, 1, -6 },
  { 333, 4, 9, 3, 0, -9 },
  { 338, 4, 9, 6, 1, -6 },
  { 343, 4, 9, 6, 1, -9 },
  { 348, 1, 9, 2, 1, -9 },
  { 350, 2, 12, 2, 0, -9 },
  { 353, 4, 9, 5, 1, -9 },
  { 358, 1, 9, 2, 1, -9 },
  { 360, 7, 6, 9, 1, -6 },
  { 366, 4, 6, 6, 1, -6 },
  { 369, 4, 6, 6, 1, -6 },
  { 372, 5, 9, 6, 1, -6 },
  { 378, 4, 9, 6, 1, -6 },
  { 383, 3, 6, 4, 1, -6 },
  { 386, 4, 6, 5, 0, -6 },
  { 389, 3, 8, 3, 0, -8 },
  { 392, 4, 6, 6, 1, -6 },
  { 395, 5, 6, 5, 0, -6 },
  { 399, 7, 6, 7, 0, -6 },
  { 405, 5, 6, 5, 0, -6 },
  { 409, 5, 9, 5, 0, -6 },
  { 415, 4, 6, 5, 0, -6 },
  { 418, 4, 11, 4, 0, -9 },
  { 424, 1, 12, 6, 2, -9 },
  { 426, 4, 11, 4, 0, -9 },
  { 432, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_Thin12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_THIN12PT7B_H_
