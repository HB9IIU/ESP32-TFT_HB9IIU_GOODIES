#ifndef _NOTOSANS_SEMICONDENSED_THIN35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin35pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x03, 0xC0, 0xC6, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x01, 0x02, 0x00, 0x40, 0x80, 0x20, 0x40, 0x08, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x7F, 0xFF, 0xC1,
  0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41,
  0x00, 0x20, 0x40, 0xFF, 0xFF, 0x82, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40,
  0x08, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x00,
  0x02, 0x00, 0x10, 0x03, 0xC0, 0x64, 0xE4, 0x20, 0x61, 0x02, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x20, 0x80, 0x84, 0x02, 0x20, 0x0D, 0x00, 0x1C,
  0x00, 0x58, 0x02, 0x20, 0x10, 0x80, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04,
  0x08, 0x20, 0x42, 0x82, 0x37, 0xDE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x3E, 0x00, 0x82, 0x10, 0x08, 0x10, 0x40, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x02, 0x04, 0x10, 0x10, 0x21, 0x00, 0x81, 0x08, 0x04,
  0x08, 0x80, 0x20, 0x44, 0x79, 0x02, 0x44, 0x24, 0x12, 0x41, 0x21, 0x12,
  0x04, 0xF1, 0x10, 0x20, 0x08, 0x81, 0x00, 0x88, 0x08, 0x04, 0x40, 0x40,
  0x42, 0x02, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x10,
  0x40, 0x80, 0x42, 0x08, 0x03, 0xE0, 0x0F, 0xC0, 0x04, 0x08, 0x01, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x40, 0x80,
  0x10, 0x40, 0x02, 0x30, 0x00, 0x50, 0x00, 0x18, 0x00, 0x1A, 0x00, 0x08,
  0x40, 0x04, 0x08, 0x0B, 0x01, 0x02, 0x80, 0x21, 0x20, 0x0C, 0x48, 0x01,
  0x12, 0x00, 0x28, 0x80, 0x06, 0x20, 0x01, 0x84, 0x00, 0x91, 0x80, 0xC6,
  0x1F, 0xC0, 0xC0, 0xFA, 0xAA, 0x80, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x20, 0x40, 0xC1, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x41, 0x0C, 0x21, 0x08, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x0E, 0x27, 0x1F, 0x80, 0x20, 0x05, 0x00, 0x88, 0x10, 0x82, 0x04,
  0x20, 0x60, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x24, 0x94, 0x92, 0x80, 0xFF, 0xB0,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x40, 0x82,
  0x01, 0x10, 0x04, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x42, 0x01,
  0x04, 0x08, 0x0F, 0xC0, 0x02, 0x1C, 0x69, 0x1C, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x1F, 0xC7, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x18, 0x00, 0xFF, 0xF8, 0x3F, 0xC6, 0x01, 0x20, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x07, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x50, 0x04, 0x7F, 0xC0,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0x90, 0x00, 0x90,
  0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x10, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x80, 0x10,
  0x7F, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x3F, 0xF0, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x05, 0xF8, 0x18, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x20, 0x08, 0x7F, 0xC0, 0x03, 0xF0,
  0x30, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0xFE, 0x24, 0x04, 0xA0, 0x0B, 0x00, 0x28, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00,
  0x22, 0x00, 0x84, 0x04, 0x0F, 0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x1F, 0xC0, 0x80, 0xC4, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x00, 0x90, 0x02, 0x20, 0x10, 0xC0, 0x80, 0x8C, 0x01, 0xC0, 0x0D,
  0x80, 0x41, 0x86, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x24, 0x00, 0x88, 0x0C, 0x1F, 0xC0, 0x1F, 0xC1,
  0x01, 0x10, 0x04, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x14, 0x01, 0x90, 0x14, 0x7F, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x7F, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x2C, 0x23, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x22, 0x24, 0x44, 0x48, 0x00, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x08, 0x00, 0x00, 0x7F, 0x20, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0x01, 0x80, 0x18, 0x00, 0x80, 0x40, 0x00, 0x81,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x88, 0x00, 0x01, 0x20, 0x0F, 0x01, 0x40,
  0x61, 0x03, 0x81, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x20,
  0x10, 0x30, 0x40, 0x20, 0x60, 0x80, 0x40, 0xC1, 0x00, 0x81, 0x82, 0x01,
  0x03, 0x04, 0x06, 0x06, 0x04, 0x0C, 0x14, 0x0C, 0x24, 0x24, 0x0F, 0x8F,
  0x88, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x02, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x21,
  0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xC0, 0x40, 0x08, 0x10, 0x02, 0x04,
  0x00, 0x82, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x24, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xC0, 0xFF, 0xC2, 0x00, 0xC8, 0x00, 0xA0,
  0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28,
  0x01, 0x3F, 0xF8, 0x80, 0x62, 0x00, 0x68, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x0C,
  0xFF, 0xC0, 0x03, 0xFE, 0x04, 0x01, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x01, 0x03, 0xFE, 0xFF, 0x80, 0x80, 0x70, 0x80, 0x08, 0x80, 0x04,
  0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x18, 0x80, 0x70, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x01, 0xFF,
  0x01, 0x80, 0x30, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x11,
  0x80, 0x04, 0x10, 0x01, 0x03, 0xFF, 0x80, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0xF8, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0xBE, 0x00, 0x80, 0x0E, 0x00, 0x68, 0x01, 0x20, 0x08,
  0x80, 0x42, 0x02, 0x08, 0x10, 0x20, 0xC0, 0x86, 0x02, 0x10, 0x08, 0x80,
  0x27, 0x00, 0xA4, 0x03, 0x08, 0x0C, 0x30, 0x20, 0x40, 0x80, 0x82, 0x02,
  0x08, 0x04, 0x20, 0x08, 0x80, 0x22, 0x00, 0x48, 0x00, 0xA0, 0x02, 0x80,
  0x04, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE8, 0x00, 0x0B, 0x40,
  0x00, 0x5A, 0x00, 0x02, 0xC8, 0x00, 0x26, 0x40, 0x01, 0x32, 0x00, 0x11,
  0x88, 0x00, 0x8C, 0x40, 0x04, 0x61, 0x00, 0x43, 0x08, 0x02, 0x18, 0x40,
  0x10, 0xC1, 0x01, 0x06, 0x08, 0x08, 0x30, 0x40, 0x81, 0x81, 0x04, 0x0C,
  0x08, 0x20, 0x60, 0x22, 0x03, 0x01, 0x10, 0x18, 0x08, 0x80, 0xC0, 0x28,
  0x06, 0x01, 0x40, 0x30, 0x0A, 0x01, 0x80, 0x20, 0x08, 0x80, 0x01, 0xC0,
  0x01, 0xA0, 0x01, 0xA0, 0x01, 0x90, 0x01, 0x90, 0x01, 0x88, 0x01, 0x8C,
  0x01, 0x84, 0x01, 0x82, 0x01, 0x82, 0x01, 0x81, 0x01, 0x81, 0x81, 0x80,
  0x81, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21, 0x80, 0x21, 0x80, 0x11, 0x80,
  0x09, 0x80, 0x09, 0x80, 0x05, 0x80, 0x05, 0x80, 0x03, 0x80, 0x01, 0x03,
  0xFC, 0x01, 0x80, 0x40, 0x40, 0x04, 0x10, 0x00, 0x42, 0x00, 0x04, 0x80,
  0x00, 0x90, 0x00, 0x12, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x01, 0x04, 0x00, 0x40, 0x60, 0x10, 0x03, 0xFC, 0x00, 0xFF,
  0x84, 0x03, 0x20, 0x05, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x28, 0x06, 0x7F, 0xE2, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x03, 0xFC, 0x01, 0x80, 0x40, 0x40, 0x04, 0x10,
  0x00, 0x42, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x01, 0x20, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x04, 0x00, 0x40, 0x60,
  0x10, 0x03, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0xFF, 0x82, 0x01, 0x88, 0x01, 0x20,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28,
  0x01, 0x20, 0x08, 0x80, 0xC3, 0xFC, 0x08, 0x10, 0x20, 0x20, 0x80, 0xC2,
  0x01, 0x08, 0x06, 0x20, 0x08, 0x80, 0x12, 0x00, 0x48, 0x00, 0xA0, 0x02,
  0x80, 0x04, 0x1F, 0xF1, 0x00, 0x50, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x50, 0x04, 0xFF, 0xC0, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02,
  0x40, 0x02, 0x20, 0x04, 0x30, 0x0C, 0x0F, 0xF0, 0x80, 0x00, 0xC0, 0x00,
  0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x04, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x10, 0x20, 0x08, 0x20, 0x04, 0x10, 0x01, 0x08, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00, 0x28, 0x00, 0xC0, 0x09,
  0x00, 0x50, 0x02, 0x40, 0x14, 0x00, 0x90, 0x04, 0x80, 0x44, 0x01, 0x20,
  0x10, 0x80, 0x88, 0x04, 0x20, 0x22, 0x01, 0x08, 0x08, 0x40, 0x82, 0x02,
  0x10, 0x20, 0x41, 0x04, 0x08, 0x10, 0x41, 0x02, 0x04, 0x10, 0x21, 0x01,
  0x04, 0x08, 0x40, 0x22, 0x02, 0x10, 0x08, 0x80, 0x84, 0x02, 0x20, 0x12,
  0x00, 0x88, 0x04, 0x80, 0x14, 0x01, 0x20, 0x05, 0x00, 0x48, 0x01, 0x40,
  0x0C, 0x00, 0x50, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00,
  0x40, 0x02, 0x40, 0x08, 0x80, 0x10, 0x80, 0x41, 0x00, 0x81, 0x02, 0x02,
  0x0C, 0x02, 0x10, 0x06, 0x40, 0x04, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x90, 0x02, 0x20, 0x04, 0x20, 0x10, 0x40, 0x20, 0x40,
  0x80, 0x81, 0x00, 0x84, 0x00, 0x98, 0x01, 0x20, 0x01, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x0D, 0x00, 0x11, 0x00, 0x22, 0x00, 0x82, 0x01, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x20, 0x10, 0x40, 0x11, 0x00, 0x22, 0x00, 0x28, 0x00,
  0x50, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x7F, 0xFC,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xFF, 0xFE, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0x80, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0xFE, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x09, 0x00, 0x12, 0x00, 0x42, 0x00, 0x84,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x08, 0x20, 0x10, 0x80, 0x11, 0x00, 0x24,
  0x00, 0x38, 0x00, 0x40, 0xFF, 0xFC, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x0F,
  0x0E, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x63,
  0xF5, 0x80, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x78, 0x15,
  0xFC, 0x80, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x87, 0x84, 0xC3, 0x28, 0x05, 0x80, 0x2C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x02, 0xC0, 0x15, 0x01, 0x27, 0xF0, 0x07, 0xC1,
  0x83, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x07, 0x84, 0x61, 0x92, 0x01, 0x50, 0x05,
  0x40, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xD0, 0x03, 0x40, 0x14, 0x80,
  0x91, 0xFC, 0x40, 0x07, 0x80, 0xC3, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x83, 0xFC, 0x03, 0xC0,
  0x84, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x3F, 0x1A, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00,
  0x07, 0x80, 0xC3, 0x48, 0x06, 0x80, 0x34, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x28, 0x03, 0x40, 0x19, 0x01, 0x47, 0xF2, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x12, 0x01, 0x9F, 0xF0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x89, 0x06, 0xA0,
  0x2C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0xC1, 0xFF, 0xFF, 0x80, 0x08, 0x40, 0x00, 0x00, 0x01, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x22, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x0A, 0x02, 0x40, 0x88, 0x21, 0x04, 0x21, 0x04, 0x40,
  0x98, 0x15, 0x02, 0x90, 0x61, 0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x80,
  0x50, 0x0A, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x03, 0xC5, 0x84,
  0x61, 0xA8, 0x14, 0x05, 0x80, 0xA0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x0F, 0x89,
  0x06, 0xA0, 0x2C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x07, 0x80, 0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x14, 0x00, 0x90, 0x02, 0x60, 0x10, 0xC0, 0xC0, 0xFC,
  0x00, 0x07, 0x82, 0x61, 0x8A, 0x01, 0x30, 0x04, 0xC0, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x00, 0xB0, 0x04, 0xC0, 0x12, 0xC0, 0x89, 0xFC, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x00, 0x07, 0x80, 0xC3, 0x48, 0x06, 0x80, 0x34, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x28, 0x03, 0x40, 0x19, 0x01, 0x47, 0xF2, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x0F, 0x90, 0xA0,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x0F, 0xC3, 0x02, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x28, 0x06, 0x7F, 0xC0, 0x10, 0x08, 0x04,
  0x02, 0x03, 0xFE, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x3E, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x05, 0x40,
  0xD3, 0xF9, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x22, 0x01, 0x10, 0x10,
  0x80, 0x82, 0x04, 0x10, 0x40, 0x82, 0x02, 0x10, 0x11, 0x00, 0x88, 0x02,
  0x40, 0x14, 0x00, 0xA0, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x30, 0x0A, 0x01,
  0x80, 0x50, 0x0C, 0x02, 0x80, 0x90, 0x22, 0x04, 0x81, 0x10, 0x24, 0x08,
  0x81, 0x10, 0x42, 0x10, 0x84, 0x10, 0x84, 0x20, 0x84, 0x21, 0x04, 0x40,
  0x88, 0x12, 0x04, 0x80, 0x90, 0x24, 0x04, 0x81, 0x20, 0x28, 0x05, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x12, 0x01, 0x08,
  0x08, 0x20, 0x81, 0x08, 0x04, 0x40, 0x24, 0x00, 0xE0, 0x02, 0x00, 0x30,
  0x03, 0x40, 0x11, 0x01, 0x08, 0x08, 0x20, 0x80, 0x88, 0x04, 0x40, 0x14,
  0x00, 0xC0, 0xC0, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00, 0x48, 0x02,
  0x40, 0x14, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x05, 0x80, 0x10, 0x00, 0x7F, 0xE0,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x1F, 0xFC, 0x03,
  0x82, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0xC1, 0xC0, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x38, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x30, 0x07, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x1C, 0x08, 0x00, 0x7C, 0x06, 0x0C, 0x18, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 25, 7, 3, -25 },
  { 8, 6, 9, 11, 2, -25 },
  { 15, 18, 25, 20, 1, -25 },
  { 72, 13, 29, 18, 2, -27 },
  { 120, 21, 25, 25, 2, -25 },
  { 186, 18, 25, 21, 2, -25 },
  { 243, 2, 9, 6, 2, -25 },
  { 246, 6, 31, 9, 2, -25 },
  { 270, 6, 31, 9, 1, -25 },
  { 294, 12, 13, 17, 2, -27 },
  { 314, 14, 16, 18, 2, -20 },
  { 342, 3, 9, 6, 1, -4 },
  { 346, 8, 1, 11, 1, -10 },
  { 347, 2, 2, 7, 3, -2 },
  { 348, 10, 25, 11, 1, -25 },
  { 380, 14, 25, 18, 2, -25 },
  { 424, 7, 25, 18, 3, -25 },
  { 446, 13, 25, 18, 2, -25 },
  { 487, 13, 25, 18, 2, -25 },
  { 528, 16, 25, 18, 1, -25 },
  { 578, 14, 25, 18, 2, -25 },
  { 622, 14, 25, 18, 2, -25 },
  { 666, 14, 25, 18, 2, -25 },
  { 710, 14, 25, 18, 2, -25 },
  { 754, 13, 25, 18, 2, -25 },
  { 795, 2, 19, 7, 3, -19 },
  { 800, 4, 24, 7, 1, -19 },
  { 812, 14, 15, 18, 2, -20 },
  { 839, 14, 8, 18, 2, -16 },
  { 853, 14, 15, 18, 2, -20 },
  { 880, 10, 25, 13, 1, -25 },
  { 912, 23, 28, 27, 2, -25 },
  { 993, 18, 25, 18, 0, -25 },
  { 1050, 14, 25, 19, 3, -25 },
  { 1094, 16, 25, 19, 2, -25 },
  { 1144, 16, 25, 21, 3, -25 },
  { 1194, 12, 25, 17, 3, -25 },
  { 1232, 12, 25, 15, 3, -25 },
  { 1270, 18, 25, 23, 2, -25 },
  { 1327, 16, 25, 22, 3, -25 },
  { 1377, 5, 25, 9, 2, -25 },
  { 1393, 7, 31, 8, -3, -25 },
  { 1421, 14, 25, 17, 3, -25 },
  { 1465, 12, 25, 16, 3, -25 },
  { 1503, 21, 25, 27, 3, -25 },
  { 1569, 16, 25, 22, 3, -25 },
  { 1619, 19, 25, 23, 2, -25 },
  { 1679, 13, 25, 18, 3, -25 },
  { 1720, 19, 31, 23, 2, -25 },
  { 1794, 14, 25, 18, 3, -25 },
  { 1838, 13, 25, 17, 2, -25 },
  { 1879, 15, 25, 16, 0, -25 },
  { 1926, 16, 25, 22, 3, -25 },
  { 1976, 17, 25, 17, 0, -25 },
  { 2030, 26, 25, 28, 1, -25 },
  { 2112, 15, 25, 16, 0, -25 },
  { 2159, 15, 25, 15, 0, -25 },
  { 2206, 15, 25, 17, 1, -25 },
  { 2253, 7, 31, 11, 3, -25 },
  { 2281, 10, 25, 11, 1, -25 },
  { 2313, 7, 31, 11, 1, -25 },
  { 2341, 15, 14, 18, 1, -25 },
  { 2368, 14, 1, 14, 0, 3 },
  { 2370, 6, 6, 8, 1, -27 },
  { 2375, 11, 19, 16, 2, -19 },
  { 2402, 13, 27, 18, 3, -27 },
  { 2446, 12, 19, 14, 2, -19 },
  { 2475, 14, 27, 18, 2, -27 },
  { 2523, 13, 19, 17, 2, -19 },
  { 2554, 11, 27, 9, 0, -27 },
  { 2592, 13, 27, 18, 2, -19 },
  { 2636, 12, 27, 18, 3, -27 },
  { 2677, 1, 25, 7, 3, -25 },
  { 2681, 5, 33, 7, -1, -25 },
  { 2702, 11, 27, 14, 3, -27 },
  { 2740, 1, 27, 7, 3, -27 },
  { 2744, 21, 19, 27, 3, -19 },
  { 2794, 12, 19, 18, 3, -19 },
  { 2823, 14, 19, 18, 2, -19 },
  { 2857, 14, 27, 18, 3, -19 },
  { 2905, 13, 27, 18, 2, -19 },
  { 2949, 8, 19, 12, 3, -19 },
  { 2968, 12, 19, 14, 1, -19 },
  { 2997, 9, 23, 10, 0, -23 },
  { 3023, 12, 18, 18, 3, -18 },
  { 3050, 13, 18, 13, 0, -18 },
  { 3080, 21, 18, 22, 0, -18 },
  { 3128, 13, 18, 15, 1, -18 },
  { 3158, 13, 27, 14, 0, -18 },
  { 3202, 11, 18, 13, 1, -18 },
  { 3227, 9, 31, 12, 1, -25 },
  { 3262, 1, 36, 17, 8, -27 },
  { 3267, 10, 31, 12, 1, -25 },
  { 3306, 14, 3, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_Thin35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_THIN35PT7B_H_
