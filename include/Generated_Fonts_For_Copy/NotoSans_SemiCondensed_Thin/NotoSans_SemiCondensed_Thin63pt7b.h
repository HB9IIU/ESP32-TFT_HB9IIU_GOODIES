#ifndef _NOTOSANS_SEMICONDENSED_THIN63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin63pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6C, 0x00, 0x00, 0x0F, 0xFE, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xD0, 0x1A, 0x03, 0x40, 0x68, 0x0D, 0x01, 0xA0, 0x34, 0x06,
  0x80, 0x50, 0x0A, 0x01, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x01, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x08, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0x98, 0xF8, 0x0C, 0x18,
  0x1C, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x40, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x18,
  0x00, 0x03, 0xD8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x19, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x02, 0x00, 0x18, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x02, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x0C, 0x80, 0x18, 0x18, 0xF0, 0x18, 0x70, 0x7F, 0xDF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x18, 0x01, 0xC3, 0x80, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0x08, 0x00, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x01, 0x80, 0x04, 0x00, 0x30, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x03, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x00, 0x30, 0x60, 0x30, 0x10, 0x00,
  0xC3, 0x07, 0xF0, 0x60, 0x02, 0x0C, 0x30, 0x71, 0x80, 0x18, 0x21, 0x80,
  0xC6, 0x00, 0x61, 0x86, 0x01, 0x88, 0x01, 0x84, 0x30, 0x06, 0x30, 0x0C,
  0x30, 0xC0, 0x0C, 0x60, 0x30, 0x82, 0x00, 0x31, 0xC3, 0x86, 0x08, 0x00,
  0xC3, 0xFC, 0x10, 0x60, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x04, 0x00, 0x02,
  0x06, 0x00, 0x10, 0x00, 0x18, 0x18, 0x00, 0x40, 0x00, 0x60, 0x60, 0x01,
  0x00, 0x03, 0x01, 0x80, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x10, 0x00, 0x60,
  0x18, 0x00, 0x40, 0x01, 0x80, 0x60, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x02, 0x00, 0x06, 0x01, 0x80, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x40, 0x00,
  0x38, 0x60, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x08, 0x00, 0x10, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x80, 0x01,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x86, 0x00, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x63,
  0x00, 0x03, 0x00, 0x31, 0x80, 0x00, 0xC0, 0x10, 0x80, 0x00, 0x30, 0x18,
  0xC0, 0x00, 0x1C, 0x0C, 0x60, 0x00, 0x06, 0x0C, 0x30, 0x00, 0x01, 0x86,
  0x18, 0x00, 0x00, 0x66, 0x0C, 0x00, 0x00, 0x1B, 0x06, 0x00, 0x00, 0x07,
  0x01, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x01,
  0xB0, 0x18, 0x00, 0x03, 0x8C, 0x06, 0x00, 0x03, 0x83, 0x01, 0x80, 0x03,
  0x01, 0xC0, 0x70, 0x0F, 0x00, 0x60, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xD5, 0x55, 0x55, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0xE0, 0x20, 0x1D, 0xE0, 0x83, 0xE0, 0xF2, 0x38, 0x00, 0x7F, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x61, 0x00, 0x01, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0xC0,
  0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC2, 0x18, 0x61,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x5F, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x81, 0xE0, 0x06,
  0x00, 0x70, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30,
  0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x03, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x07, 0x00, 0xD0, 0x39, 0x07, 0x10, 0xC1, 0x18, 0x17, 0x01, 0xE0,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xC0, 0x38, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x0F, 0xC0, 0x1E, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x61, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x60, 0xF8, 0x03, 0xC0, 0x1F,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x1E, 0x01, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x3F, 0xF8, 0x0C, 0x38, 0x07, 0x06, 0x70,
  0x00, 0xC3, 0x60, 0x00, 0x31, 0xA0, 0x00, 0x08, 0xF0, 0x00, 0x06, 0x70,
  0x00, 0x01, 0x38, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x0F, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x08, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x10, 0x00, 0x01,
  0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x07, 0x00,
  0x0C, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC7, 0x80, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0x1C, 0x03, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x20, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xC0, 0x78, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x01, 0x81,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x1E, 0x60, 0x00, 0x1B, 0x18,
  0x00, 0x19, 0x86, 0x00, 0x18, 0xC1, 0xC0, 0x38, 0x60, 0x7F, 0xF0, 0x20,
  0x03, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x02, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x5F,
  0xF4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0xFC,
  0x08, 0x71, 0xC7, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x61, 0x86,
  0x18, 0x63, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0x0F, 0x00, 0xE2,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x1F, 0xE0, 0x01, 0x0C, 0x00, 0x0F, 0xFF, 0x00, 0x31, 0x80, 0x07,
  0x00, 0x60, 0x06, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0xCC, 0x00, 0x30, 0x01,
  0x80, 0x09, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x30, 0x03, 0x00, 0x06, 0x00,
  0x36, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x80, 0x08, 0x00, 0x18, 0x00, 0xD0,
  0x03, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x60, 0x03, 0xC0, 0x0C,
  0x00, 0x08, 0x00, 0x78, 0x01, 0x80, 0x01, 0x00, 0x0F, 0x00, 0x30, 0x00,
  0x20, 0x01, 0xE0, 0x06, 0x00, 0x04, 0x00, 0x2C, 0x00, 0xC0, 0x01, 0x80,
  0x05, 0x80, 0x18, 0x00, 0x30, 0x01, 0xB0, 0x03, 0x00, 0x06, 0x00, 0x32,
  0x00, 0x60, 0x00, 0xC0, 0x06, 0x40, 0x04, 0x00, 0x3C, 0x01, 0x8C, 0x00,
  0xC0, 0x05, 0x80, 0x31, 0x80, 0x18, 0x01, 0x90, 0x0C, 0x30, 0x01, 0x80,
  0x63, 0x03, 0x82, 0x00, 0x1E, 0x78, 0x3F, 0xE0, 0x60, 0x00, 0xFC, 0x03,
  0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x30, 0x00, 0x1E, 0x18, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x0E, 0x0C, 0x00, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0x00, 0x07, 0xC1,
  0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x30,
  0x00, 0x1E, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x30, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x06, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x02, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01,
  0x01, 0xC0, 0x00, 0x01, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xC3,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x40, 0x73, 0xFF,
  0x0F, 0xE0, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x8C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x01, 0xC0,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x18, 0x70, 0x00, 0x0C, 0x78, 0x00, 0x06, 0x66, 0x00, 0x03, 0x63,
  0x80, 0x01, 0xE0, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE8, 0x00, 0x00, 0x00, 0x1F,
  0x60, 0x00, 0x00, 0x00, 0xBF, 0x00, 0x00, 0x00, 0x0D, 0xE8, 0x00, 0x00,
  0x00, 0x6F, 0x60, 0x00, 0x00, 0x02, 0x7B, 0x00, 0x00, 0x00, 0x33, 0xCC,
  0x00, 0x00, 0x01, 0x9E, 0x60, 0x00, 0x00, 0x18, 0xF1, 0x00, 0x00, 0x00,
  0xC7, 0x8C, 0x00, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x00, 0x61, 0xE1, 0x00,
  0x00, 0x03, 0x0F, 0x0C, 0x00, 0x00, 0x10, 0x78, 0x60, 0x00, 0x01, 0x83,
  0xC1, 0x80, 0x00, 0x0C, 0x1E, 0x0C, 0x00, 0x00, 0x40, 0xF0, 0x20, 0x00,
  0x06, 0x07, 0x81, 0x80, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0x03, 0x01, 0xE0,
  0x20, 0x00, 0x18, 0x0F, 0x01, 0x80, 0x00, 0x80, 0x78, 0x0C, 0x00, 0x0C,
  0x03, 0xC0, 0x30, 0x00, 0x60, 0x1E, 0x01, 0x80, 0x02, 0x00, 0xF0, 0x0C,
  0x00, 0x30, 0x07, 0x80, 0x30, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x18, 0x01,
  0xE0, 0x04, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x04, 0x00, 0x78, 0x01, 0x80,
  0x60, 0x03, 0xC0, 0x04, 0x03, 0x00, 0x1E, 0x00, 0x30, 0x10, 0x00, 0xF0,
  0x01, 0x81, 0x80, 0x07, 0x80, 0x06, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0xC0,
  0x01, 0xE0, 0x00, 0x86, 0x00, 0x0F, 0x00, 0x06, 0x30, 0x00, 0x78, 0x00,
  0x33, 0x00, 0x03, 0xC0, 0x00, 0x98, 0x00, 0x1E, 0x00, 0x06, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x03,
  0xD8, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0xC4, 0x00, 0x00, 0x3C, 0x60,
  0x00, 0x03, 0xC3, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x3C, 0x08, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0,
  0x60, 0x00, 0x3C, 0x03, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x3C, 0x01, 0x80,
  0x03, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x18, 0x03, 0xC0, 0x01,
  0x80, 0x3C, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0xC0, 0x3C, 0x00, 0x06, 0x03,
  0xC0, 0x00, 0x20, 0x3C, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x18, 0x3C, 0x00,
  0x01, 0x83, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x43, 0xC0, 0x00, 0x06,
  0x3C, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x1B, 0xC0,
  0x00, 0x01, 0xBC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x38, 0x00, 0x03, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x07, 0x86, 0x00, 0x03,
  0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x38, 0x60, 0x01, 0xE0, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x78, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x07, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC1, 0xC0, 0x00, 0x41,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x10, 0x00, 0x07, 0x0F, 0x80, 0x1F, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x58, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x18, 0x00, 0x03, 0x20, 0x00, 0x04, 0x10, 0x00, 0x04,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x31,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC3,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x06, 0x00, 0x06, 0x03, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x04, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x04, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x01, 0x00, 0x60, 0x06, 0x01,
  0x80, 0x03, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x10, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x10, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x83, 0x00, 0x00, 0x41, 0x80, 0x01, 0x86, 0x00,
  0x00, 0xC2, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x04, 0x60, 0x00, 0x02, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x04, 0x40, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x08, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x20, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x08, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0x80, 0x70, 0x20, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x3E, 0x00, 0xC7, 0x80, 0x06, 0x70, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x2D, 0x80, 0x03, 0x6E, 0x00, 0x33, 0x38, 0x07, 0x08, 0x7F,
  0xE0, 0x40, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0xFC, 0x01, 0x83, 0xFF, 0x80, 0xC7, 0x00, 0x70, 0x67, 0x00, 0x0C,
  0x37, 0x00, 0x03, 0x1B, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0x70, 0x00, 0x03, 0x3C, 0x00, 0x03, 0x1B, 0x00, 0x01, 0x8D, 0x80, 0x01,
  0x86, 0x70, 0x01, 0x83, 0x1C, 0x03, 0x81, 0x83, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x70, 0x02, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x38, 0x07, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xFC, 0x06, 0x03, 0xFF, 0xC3,
  0x03, 0x80, 0x71, 0x83, 0x00, 0x0C, 0xC3, 0x00, 0x03, 0x63, 0x00, 0x00,
  0xB1, 0x00, 0x00, 0x79, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0x20, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x01,
  0xE3, 0x00, 0x00, 0xB0, 0xC0, 0x00, 0x98, 0x70, 0x00, 0xCC, 0x0E, 0x01,
  0x86, 0x03, 0xFF, 0x83, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0x80, 0x70, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x04, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x20,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x06, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x3C, 0x70, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x03, 0xFF, 0xF0, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0xC0,
  0xE0, 0x0C, 0x60, 0xC0, 0x03, 0x30, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x3C,
  0x40, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0xC8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x78,
  0xC0, 0x00, 0x6C, 0x30, 0x00, 0x66, 0x0C, 0x00, 0x73, 0x03, 0x80, 0xE1,
  0x80, 0xFF, 0xE0, 0xC0, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x3F, 0x87, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x07, 0xF0, 0x30, 0x7F, 0xF0, 0xC7,
  0x00, 0xE3, 0x30, 0x00, 0xCD, 0x80, 0x01, 0xB4, 0x00, 0x06, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0xA0, 0x00, 0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x01, 0xC0, 0x70, 0x1C,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xCD, 0xE3, 0xF0, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x58, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x1B, 0x00, 0x19, 0x8C, 0x00, 0xD8,
  0x60, 0x06, 0x81, 0x80, 0x3C, 0x0C, 0x01, 0xC0, 0x30, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x40, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x60, 0x00, 0x33,
  0x00, 0x00, 0xD8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0x0F, 0xFC,
  0x03, 0xFF, 0x0C, 0x60, 0x18, 0x18, 0x07, 0x33, 0x00, 0x30, 0xC0, 0x0C,
  0xD8, 0x00, 0x66, 0x00, 0x1B, 0xC0, 0x01, 0xB0, 0x00, 0x2E, 0x00, 0x02,
  0x80, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x7F, 0x03, 0x07, 0xFF, 0x0C, 0x70, 0x0E, 0x33, 0x80, 0x0C, 0xD8, 0x00,
  0x1B, 0x40, 0x00, 0x6F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0x70, 0x0C, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x70, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x60, 0xFF, 0xF0, 0x30, 0xE0, 0x1C,
  0x18, 0xC0, 0x03, 0x0C, 0xC0, 0x00, 0xC6, 0xC0, 0x00, 0x63, 0x40, 0x00,
  0x19, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x9E, 0x00, 0x00, 0xCD, 0x00, 0x00, 0x46, 0xC0, 0x00,
  0x63, 0x30, 0x00, 0x61, 0x9C, 0x00, 0x60, 0xC3, 0x80, 0xE0, 0x60, 0xFF,
  0xC0, 0x30, 0x07, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0xC0, 0xE0, 0x1C, 0x60, 0xC0,
  0x03, 0x30, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x2C, 0xC0, 0x00, 0x1E, 0x60,
  0x00, 0x07, 0x20, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x58, 0xC0, 0x00, 0x6C, 0x70,
  0x00, 0x66, 0x1C, 0x00, 0x63, 0x07, 0x80, 0xE1, 0x80, 0xFF, 0xE0, 0xC0,
  0x0F, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x7D, 0x87, 0xFF, 0x1C, 0x06, 0x60, 0x0D, 0x80, 0x1A, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0x80, 0x1C, 0x30,
  0x00, 0x23, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xD8, 0x00, 0x1C, 0xF8, 0x03, 0xC0, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0xFF, 0xFE, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x81, 0x01, 0xFE, 0x00, 0x60, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x50, 0x00, 0x0D, 0x60,
  0x00, 0x25, 0xC0, 0x01, 0x93, 0x80, 0x1C, 0x47, 0x01, 0xE1, 0x0F, 0xFE,
  0x04, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x10, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x08, 0x00,
  0x10, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x00, 0x81,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x42, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x00, 0xD0, 0x00, 0x1E, 0x00, 0x06, 0xC0, 0x00, 0xF0,
  0x00, 0x26, 0x00, 0x05, 0x80, 0x03, 0x30, 0x00, 0x24, 0x00, 0x18, 0x80,
  0x03, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x03, 0x04, 0x00, 0x61, 0x80, 0x18, 0x30, 0x02,
  0x0C, 0x00, 0x81, 0x80, 0x10, 0x20, 0x0C, 0x04, 0x01, 0x81, 0x80, 0x60,
  0x20, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01,
  0x01, 0x80, 0x20, 0x30, 0x0C, 0x0C, 0x01, 0x01, 0x00, 0x60, 0x60, 0x0C,
  0x18, 0x01, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x61,
  0x80, 0x0C, 0x20, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x08, 0x40, 0x03, 0x18,
  0x00, 0x66, 0x00, 0x08, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x09, 0x80,
  0x03, 0x60, 0x00, 0x68, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x50, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x08, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x26, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x62, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x81, 0x80, 0x01, 0x81,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x08, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x04, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00,
  0x40, 0x01, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x00, 0x81,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x43, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x26, 0x00, 0x00, 0x36, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1C,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xFC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x0E, 0x80, 0x01,
  0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 45, 13, 5, -45 },
  { 18, 11, 16, 20, 4, -45 },
  { 40, 32, 45, 36, 2, -45 },
  { 220, 24, 52, 32, 3, -48 },
  { 376, 38, 47, 45, 3, -46 },
  { 600, 33, 47, 37, 3, -46 },
  { 794, 2, 16, 11, 4, -45 },
  { 798, 11, 55, 16, 3, -45 },
  { 874, 11, 55, 16, 2, -45 },
  { 950, 22, 22, 30, 4, -48 },
  { 1011, 26, 29, 32, 3, -37 },
  { 1106, 6, 15, 11, 2, -7 },
  { 1118, 15, 2, 19, 2, -18 },
  { 1122, 3, 4, 13, 5, -4 },
  { 1124, 18, 45, 20, 1, -45 },
  { 1226, 24, 47, 32, 4, -46 },
  { 1367, 12, 45, 32, 6, -45 },
  { 1435, 25, 46, 32, 3, -46 },
  { 1579, 25, 47, 32, 3, -46 },
  { 1726, 30, 45, 32, 1, -45 },
  { 1895, 24, 46, 32, 4, -45 },
  { 2033, 25, 47, 32, 4, -46 },
  { 2180, 25, 45, 32, 3, -45 },
  { 2321, 25, 47, 32, 3, -46 },
  { 2468, 25, 47, 32, 3, -46 },
  { 2615, 3, 34, 13, 5, -34 },
  { 2628, 6, 42, 13, 2, -34 },
  { 2660, 26, 27, 32, 3, -36 },
  { 2748, 26, 15, 32, 3, -30 },
  { 2797, 26, 27, 32, 3, -36 },
  { 2885, 18, 46, 23, 2, -46 },
  { 2989, 43, 51, 49, 3, -45 },
  { 3264, 32, 45, 32, 0, -45 },
  { 3444, 25, 45, 34, 6, -45 },
  { 3585, 28, 47, 34, 4, -46 },
  { 3750, 29, 45, 39, 6, -45 },
  { 3914, 21, 45, 31, 6, -45 },
  { 4033, 21, 45, 28, 6, -45 },
  { 4152, 32, 47, 41, 4, -46 },
  { 4340, 28, 45, 39, 6, -45 },
  { 4498, 10, 45, 16, 3, -45 },
  { 4555, 13, 56, 14, -5, -45 },
  { 4646, 25, 45, 31, 6, -45 },
  { 4787, 21, 45, 28, 6, -45 },
  { 4906, 37, 45, 48, 6, -45 },
  { 5115, 28, 45, 40, 6, -45 },
  { 5273, 34, 47, 42, 4, -46 },
  { 5473, 23, 45, 32, 6, -45 },
  { 5603, 34, 57, 42, 4, -46 },
  { 5846, 25, 45, 32, 6, -45 },
  { 5987, 25, 47, 31, 3, -46 },
  { 6134, 28, 45, 28, 0, -45 },
  { 6292, 29, 46, 40, 5, -45 },
  { 6459, 31, 45, 31, 0, -45 },
  { 6634, 47, 45, 50, 1, -45 },
  { 6899, 28, 45, 28, 0, -45 },
  { 7057, 27, 45, 27, 0, -45 },
  { 7209, 26, 45, 31, 2, -45 },
  { 7356, 13, 55, 20, 5, -45 },
  { 7446, 18, 45, 20, 1, -45 },
  { 7548, 12, 55, 20, 2, -45 },
  { 7631, 28, 25, 32, 2, -45 },
  { 7719, 25, 1, 25, 0, 6 },
  { 7723, 10, 10, 15, 3, -48 },
  { 7736, 21, 35, 29, 3, -34 },
  { 7828, 25, 49, 33, 5, -48 },
  { 7982, 21, 35, 26, 3, -34 },
  { 8074, 25, 49, 33, 3, -48 },
  { 8228, 24, 35, 30, 3, -34 },
  { 8333, 18, 48, 16, 1, -48 },
  { 8441, 25, 49, 33, 3, -34 },
  { 8595, 22, 48, 32, 5, -48 },
  { 8727, 3, 45, 12, 5, -45 },
  { 8744, 10, 60, 12, -2, -45 },
  { 8819, 21, 48, 26, 5, -48 },
  { 8945, 2, 48, 12, 5, -48 },
  { 8957, 38, 34, 48, 5, -34 },
  { 9119, 22, 34, 32, 5, -34 },
  { 9213, 26, 35, 32, 3, -34 },
  { 9327, 25, 49, 33, 5, -34 },
  { 9481, 25, 49, 33, 3, -34 },
  { 9635, 15, 34, 21, 5, -34 },
  { 9699, 21, 35, 25, 2, -34 },
  { 9791, 15, 42, 18, 1, -41 },
  { 9870, 22, 34, 32, 5, -33 },
  { 9964, 24, 33, 24, 0, -33 },
  { 10063, 37, 33, 39, 1, -33 },
  { 10216, 24, 33, 26, 1, -33 },
  { 10315, 24, 48, 24, 0, -33 },
  { 10459, 20, 33, 24, 2, -33 },
  { 10542, 17, 55, 21, 2, -45 },
  { 10659, 2, 64, 30, 14, -48 },
  { 10675, 16, 55, 21, 3, -45 },
  { 10785, 26, 5, 32, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_Thin63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_THIN63PT7B_H_
