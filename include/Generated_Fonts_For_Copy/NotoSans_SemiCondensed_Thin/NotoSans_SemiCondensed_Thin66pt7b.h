#ifndef _NOTOSANS_SEMICONDENSED_THIN66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin66pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x06, 0xFF,
  0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x06, 0x00, 0x10, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x06, 0x00, 0x00, 0x20, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x3E, 0x43, 0xF0, 0x38, 0x20, 0x38, 0x30, 0x10, 0x00, 0x30, 0x08,
  0x00, 0x18, 0x04, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x01, 0x00, 0x04, 0x00,
  0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x40,
  0x08, 0x00, 0x30, 0x04, 0x00, 0x18, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03,
  0x00, 0x80, 0x00, 0xE0, 0x40, 0x00, 0x38, 0x20, 0x00, 0x07, 0x10, 0x00,
  0x01, 0xE8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x78,
  0x00, 0x00, 0x8F, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x10,
  0x0C, 0x00, 0x08, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x01,
  0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x03, 0x00, 0x08, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x02, 0x00, 0x40,
  0x01, 0x00, 0x60, 0x00, 0x80, 0x62, 0x00, 0x40, 0x61, 0xE0, 0x20, 0xE0,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x60, 0xE0, 0x00, 0x18,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x01, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x01, 0x80, 0x04, 0x00, 0x18, 0x03, 0x00, 0x08, 0x00, 0x30, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x60, 0x00, 0x40,
  0x01, 0x80, 0xC0, 0x00, 0x80, 0x03, 0x03, 0x00, 0x01, 0x00, 0x06, 0x06,
  0x00, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x00, 0x10, 0x30, 0x3E, 0x0C,
  0x00, 0x20, 0xC1, 0xFF, 0x18, 0x00, 0xC1, 0x87, 0x07, 0x30, 0x01, 0x82,
  0x0C, 0x06, 0x20, 0x03, 0x0C, 0x30, 0x06, 0x60, 0x0C, 0x10, 0x40, 0x0C,
  0xC0, 0x18, 0x61, 0x80, 0x08, 0xC0, 0x60, 0x83, 0x00, 0x18, 0xC1, 0xC3,
  0x06, 0x00, 0x30, 0xFE, 0x06, 0x08, 0x00, 0x60, 0x78, 0x18, 0x10, 0x00,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x80, 0x00, 0xC0, 0xC0, 0x01, 0x00, 0x01,
  0x81, 0x80, 0x02, 0x00, 0x06, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x18, 0x00, 0x20, 0x01,
  0x80, 0x30, 0x00, 0x40, 0x03, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x10, 0x01, 0x00, 0x03, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x0C, 0x00,
  0x60, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x70, 0x06, 0x00, 0x06, 0x18, 0x00, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0x00, 0x42, 0x00, 0x03, 0x00, 0x11, 0x80, 0x00, 0x60,
  0x0C, 0x60, 0x00, 0x1C, 0x03, 0x10, 0x00, 0x03, 0x01, 0x8C, 0x00, 0x00,
  0x60, 0x63, 0x00, 0x00, 0x0C, 0x10, 0xC0, 0x00, 0x01, 0x8C, 0x30, 0x00,
  0x00, 0x36, 0x04, 0x00, 0x00, 0x0F, 0x81, 0x00, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x00, 0x1C, 0xC0,
  0xC0, 0x00, 0x0E, 0x38, 0x18, 0x00, 0x07, 0x06, 0x03, 0x80, 0x03, 0x00,
  0xC0, 0x78, 0x07, 0x80, 0x18, 0x07, 0xFF, 0x80, 0x03, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0xAA, 0xAA, 0x80, 0x00, 0x70, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x70, 0xE0, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x10,
  0x0E, 0xF0, 0x20, 0x78, 0x3C, 0x47, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x05, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x63, 0x00, 0x00, 0x82, 0x00,
  0x03, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x03,
  0x80, 0x0E, 0x02, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0xC6, 0x33, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0x62, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0x6E, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x02, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x60,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x04, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x3E, 0x03, 0xB0, 0x39, 0x87, 0x0C, 0x70, 0x67,
  0x03, 0xE0, 0x1A, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xF0, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xF0, 0x07, 0x80, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x07, 0xC0,
  0x0F, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x8F, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x1F, 0x00, 0x78, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0x80, 0x20, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0xFE, 0x00, 0xC1, 0xFF,
  0xF0, 0x30, 0xE0, 0x0E, 0x0C, 0x60, 0x00, 0xC3, 0x30, 0x00, 0x18, 0xD8,
  0x00, 0x03, 0x3C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x07, 0x00, 0x38, 0x00,
  0x70, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xE0,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x38,
  0x07, 0x00, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0F, 0x30, 0x00,
  0x06, 0xC6, 0x00, 0x03, 0x30, 0xC0, 0x01, 0xCC, 0x1C, 0x01, 0xC3, 0x03,
  0xFF, 0xE0, 0xC0, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0x00, 0x78,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x6F, 0xEE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0xEF, 0xE0, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC3, 0x08, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x83, 0xC0,
  0x3C, 0x40, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x30, 0x60, 0x00, 0x3F, 0xF8, 0x00,
  0xC6, 0x00, 0x07, 0x81, 0xE0, 0x06, 0x30, 0x00, 0x60, 0x02, 0x00, 0x31,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x98, 0x00, 0x60, 0x00, 0x80, 0x04, 0xC0,
  0x02, 0x00, 0x04, 0x00, 0x36, 0x00, 0x30, 0x00, 0x20, 0x01, 0xB0, 0x01,
  0x00, 0x03, 0x00, 0x0D, 0x80, 0x18, 0x00, 0x18, 0x00, 0x6C, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x40, 0x06, 0x00, 0x06, 0x00, 0x1A, 0x00, 0x20, 0x00,
  0x30, 0x00, 0xF0, 0x01, 0x00, 0x01, 0x80, 0x07, 0x80, 0x08, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x40, 0x00, 0x60, 0x01, 0xA0, 0x02, 0x00, 0x03, 0x00,
  0x0D, 0x00, 0x10, 0x00, 0x18, 0x00, 0x48, 0x00, 0xC0, 0x01, 0xC0, 0x06,
  0x40, 0x06, 0x00, 0x0E, 0x00, 0x33, 0x00, 0x30, 0x00, 0x50, 0x01, 0x98,
  0x00, 0x80, 0x06, 0x80, 0x18, 0xC0, 0x06, 0x00, 0x26, 0x00, 0xC6, 0x00,
  0x18, 0x03, 0x30, 0x0C, 0x10, 0x00, 0xE0, 0x70, 0xC0, 0xC0, 0xC0, 0x03,
  0xFF, 0x03, 0xFC, 0x06, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0xF0, 0x60,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x81,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x06, 0x00, 0x03, 0xC0, 0xC0, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x07, 0x0C, 0x00, 0x03, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x03, 0xE0, 0x07,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xF9, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x03, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x60, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x1C, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0xC1, 0xC7, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x07, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x33, 0x98, 0x00,
  0x06, 0x63, 0x00, 0x00, 0xD8, 0x30, 0x00, 0x1E, 0x03, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xBD, 0x80, 0x00, 0x00, 0x03, 0x7B, 0x00, 0x00, 0x00,
  0x06, 0xF6, 0x00, 0x00, 0x00, 0x19, 0xE6, 0x00, 0x00, 0x00, 0x33, 0xCC,
  0x00, 0x00, 0x00, 0x67, 0x88, 0x00, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x00,
  0x03, 0x1E, 0x30, 0x00, 0x00, 0x04, 0x3C, 0x30, 0x00, 0x00, 0x18, 0x78,
  0x60, 0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x00, 0xC1, 0xE0, 0xC0, 0x00,
  0x01, 0x83, 0xC1, 0x80, 0x00, 0x03, 0x07, 0x81, 0x00, 0x00, 0x0C, 0x0F,
  0x03, 0x00, 0x00, 0x18, 0x1E, 0x06, 0x00, 0x00, 0x20, 0x3C, 0x04, 0x00,
  0x00, 0xC0, 0x78, 0x0C, 0x00, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x02, 0x01,
  0xE0, 0x18, 0x00, 0x0C, 0x03, 0xC0, 0x30, 0x00, 0x18, 0x07, 0x80, 0x60,
  0x00, 0x60, 0x0F, 0x00, 0x60, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x01, 0x80,
  0x3C, 0x00, 0x80, 0x06, 0x00, 0x78, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x03,
  0x00, 0x10, 0x01, 0xE0, 0x03, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0xC0,
  0x07, 0x80, 0x0C, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x06, 0x00, 0x1E, 0x00,
  0x18, 0x0C, 0x00, 0x3C, 0x00, 0x10, 0x30, 0x00, 0x78, 0x00, 0x30, 0x60,
  0x00, 0xF0, 0x00, 0x60, 0x80, 0x01, 0xE0, 0x00, 0x63, 0x00, 0x03, 0xC0,
  0x00, 0xC6, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x0F, 0x00, 0x01, 0xB0,
  0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3D, 0x80, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x79,
  0x80, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00, 0xF0, 0xC0,
  0x00, 0x07, 0x83, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xE0, 0x60, 0x00,
  0x0F, 0x03, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x1E,
  0x01, 0x80, 0x00, 0xF0, 0x06, 0x00, 0x07, 0x80, 0x30, 0x00, 0x3C, 0x00,
  0xC0, 0x01, 0xE0, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x78, 0x00, 0x60,
  0x03, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x30, 0x07,
  0x80, 0x01, 0x80, 0x3C, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x30, 0x0F, 0x00,
  0x00, 0xC0, 0x78, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x18, 0x1E, 0x00, 0x00,
  0x60, 0xF0, 0x00, 0x03, 0x07, 0x80, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x61,
  0xE0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0x33, 0xC0,
  0x00, 0x00, 0xDE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x70, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0C,
  0x00, 0x0F, 0x03, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3C, 0x00, 0xF8,
  0x38, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x0F, 0xC0, 0x0F, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xD0, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x40, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x64, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x60, 0x00, 0x04,
  0x18, 0x00, 0x02, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x40, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x08, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x02, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x00, 0x40, 0x03, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x04, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x00, 0x81, 0x80,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x40,
  0x00, 0x20, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x04, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x01, 0x88,
  0x00, 0x01, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x05, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x01, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0xFF, 0x80, 0x3E, 0x07, 0x81, 0xC0, 0x07, 0x04, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xFC,
  0x0F, 0x80, 0x30, 0xF0, 0x00, 0xC7, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80,
  0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF6,
  0x00, 0x02, 0xD8, 0x00, 0x19, 0x30, 0x00, 0xC4, 0x70, 0x1E, 0x10, 0xFF,
  0xE0, 0x40, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x03, 0x03, 0xFF, 0x80, 0xC1, 0xE0, 0xF0, 0x31,
  0xC0, 0x07, 0x0C, 0xE0, 0x00, 0xE3, 0x30, 0x00, 0x18, 0xD8, 0x00, 0x03,
  0x34, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x02, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x13,
  0xC0, 0x00, 0x0C, 0xD0, 0x00, 0x03, 0x36, 0x00, 0x01, 0x8C, 0xC0, 0x00,
  0xC3, 0x18, 0x00, 0xE0, 0xC3, 0x80, 0xF0, 0x30, 0x7F, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0x03, 0xC0, 0xE0,
  0x01, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x10,
  0x3C, 0x03, 0x80, 0x3F, 0xFE, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x30, 0x02, 0x01, 0xFF, 0x81, 0x03, 0xC0,
  0xF0, 0x83, 0x00, 0x1C, 0x43, 0x00, 0x07, 0x23, 0x00, 0x01, 0x93, 0x00,
  0x00, 0x69, 0x80, 0x00, 0x15, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x40,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x53, 0x00, 0x00, 0x69, 0x80, 0x00, 0x64, 0x60, 0x00, 0x32, 0x1C,
  0x00, 0x71, 0x07, 0x80, 0xF0, 0x80, 0xFF, 0xE0, 0x40, 0x07, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x06, 0x03, 0xC0, 0x3E, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE0, 0x1E, 0x0C, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x40, 0xF0, 0x3C, 0x20,
  0xC0, 0x03, 0x10, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x2C, 0xC0, 0x00, 0x1E,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x3C,
  0xC0, 0x00, 0x1E, 0x70, 0x00, 0x1B, 0x18, 0x00, 0x19, 0x87, 0x00, 0x1C,
  0xC1, 0xE0, 0x38, 0x60, 0x3F, 0xF8, 0x30, 0x01, 0xE0, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x3E,
  0x00, 0x38, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0xFF, 0xC0, 0xC3, 0xC0, 0xF0,
  0xC7, 0x00, 0x38, 0xCC, 0x00, 0x1C, 0xC8, 0x00, 0x0C, 0xD8, 0x00, 0x06,
  0xF0, 0x00, 0x06, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x02, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x5F, 0xF4, 0x00, 0x00, 0x00, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x80, 0x70,
  0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xCF, 0xE1, 0xE0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x0E, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x60,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0,
  0x03, 0x06, 0x00, 0x0C, 0x3C, 0x00, 0x30, 0xF8, 0x00, 0xC6, 0x60, 0x03,
  0x30, 0xC0, 0x0D, 0x83, 0x00, 0x3C, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0x80,
  0x30, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0xC1,
  0xFF, 0x00, 0x3F, 0xE0, 0xC3, 0x83, 0xC0, 0xF0, 0x78, 0xC6, 0x00, 0xE1,
  0xC0, 0x1C, 0xCC, 0x00, 0x63, 0x80, 0x0E, 0xD8, 0x00, 0x33, 0x00, 0x06,
  0xD0, 0x00, 0x16, 0x00, 0x02, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0,
  0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08,
  0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03,
  0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00,
  0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0,
  0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08,
  0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03,
  0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00,
  0x03, 0xC0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x04, 0x00, 0xC0, 0xFF, 0xC0,
  0xC3, 0xC0, 0xF0, 0xC7, 0x00, 0x38, 0xCC, 0x00, 0x1C, 0xC8, 0x00, 0x0C,
  0xD8, 0x00, 0x06, 0xD0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x02,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0x38, 0x07, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x40, 0x7F,
  0xE0, 0x20, 0xF0, 0x78, 0x10, 0xC0, 0x07, 0x08, 0xC0, 0x01, 0xC4, 0xC0,
  0x00, 0x62, 0xC0, 0x00, 0x19, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x35, 0x00, 0x00, 0x32, 0xC0, 0x00, 0x19, 0x30, 0x00, 0x18, 0x98,
  0x00, 0x18, 0x47, 0x00, 0x18, 0x21, 0xE0, 0x38, 0x10, 0x3F, 0xF0, 0x08,
  0x03, 0xC0, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0xF8, 0x10, 0x1E, 0x0F, 0x04, 0x0E, 0x00, 0x71,
  0x06, 0x00, 0x0C, 0x43, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x3C, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xF1, 0x80, 0x00, 0x2C, 0x60, 0x00, 0x1B, 0x0C, 0x00, 0x0C, 0xC1, 0x80,
  0x06, 0x30, 0x38, 0x07, 0x0C, 0x07, 0xFF, 0x83, 0x00, 0x1E, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x81, 0xFF, 0x0F,
  0x0E, 0x30, 0x04, 0xC0, 0x09, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFE, 0x03, 0xC0, 0x7C, 0x70,
  0x00, 0x63, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x80, 0x00, 0x76, 0x00, 0x07, 0x3E, 0x00, 0xF0, 0x7F,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x81, 0x01, 0xFF, 0x00, 0x78, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x74, 0x00, 0x00, 0xAC, 0x00, 0x03, 0x58,
  0x00, 0x04, 0x98, 0x00, 0x19, 0x18, 0x00, 0xE2, 0x1C, 0x07, 0x84, 0x1F,
  0xFC, 0x08, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x02, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x20, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x30, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x80, 0x00, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x60, 0x00, 0x1B, 0x00, 0x01,
  0xE0, 0x00, 0x26, 0x00, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x04, 0x80, 0x01,
  0x88, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x04, 0x30, 0x00,
  0x46, 0x00, 0x18, 0x60, 0x01, 0x84, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x18, 0x00, 0x81, 0x80, 0x08, 0x10, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x00, 0x80, 0xC0,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x10,
  0x0C, 0x03, 0x01, 0x80, 0x30, 0x10, 0x06, 0x02, 0x00, 0x60, 0x60, 0x04,
  0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0x18, 0x30, 0x01,
  0x86, 0x00, 0x10, 0x40, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x02, 0x18, 0x00,
  0x63, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0x88, 0x00,
  0x19, 0x80, 0x01, 0xB0, 0x00, 0x12, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x02, 0xC0, 0x00, 0x78, 0x00, 0x05, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x01, 0x80, 0x01, 0x83, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x64, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x03, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x64, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x18, 0x40, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x04,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0x40, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x04, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x41,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x58, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xF0,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x27, 0xDF, 0x00, 0x05, 0x80, 0x38, 0x01, 0xE0, 0x01, 0xE0,
  0xE8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Thin66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 47, 14, 5, -47 },
  { 25, 11, 17, 20, 5, -47 },
  { 49, 34, 47, 37, 2, -47 },
  { 249, 25, 54, 33, 3, -50 },
  { 418, 39, 49, 47, 4, -48 },
  { 657, 34, 49, 39, 3, -48 },
  { 866, 2, 17, 11, 5, -47 },
  { 871, 12, 57, 17, 3, -47 },
  { 957, 12, 57, 17, 2, -47 },
  { 1043, 23, 23, 31, 4, -50 },
  { 1110, 27, 30, 33, 3, -38 },
  { 1212, 5, 16, 12, 3, -7 },
  { 1222, 16, 2, 20, 2, -19 },
  { 1226, 4, 4, 14, 5, -4 },
  { 1228, 19, 47, 21, 1, -47 },
  { 1340, 26, 49, 33, 4, -48 },
  { 1500, 13, 47, 33, 6, -47 },
  { 1577, 26, 48, 33, 3, -48 },
  { 1733, 26, 49, 33, 3, -48 },
  { 1893, 32, 47, 33, 1, -47 },
  { 2081, 26, 48, 33, 4, -47 },
  { 2237, 26, 49, 33, 4, -48 },
  { 2397, 27, 47, 33, 3, -47 },
  { 2556, 26, 49, 33, 4, -48 },
  { 2716, 26, 49, 33, 3, -48 },
  { 2876, 4, 35, 14, 5, -35 },
  { 2894, 6, 44, 13, 3, -35 },
  { 2927, 27, 29, 33, 3, -38 },
  { 3025, 27, 15, 33, 3, -31 },
  { 3076, 27, 29, 33, 3, -38 },
  { 3174, 19, 48, 24, 2, -48 },
  { 3288, 45, 53, 51, 3, -47 },
  { 3587, 33, 47, 33, 0, -47 },
  { 3781, 27, 47, 36, 6, -47 },
  { 3940, 30, 49, 36, 4, -48 },
  { 4124, 30, 47, 40, 6, -47 },
  { 4301, 22, 47, 32, 6, -47 },
  { 4431, 23, 47, 29, 6, -47 },
  { 4567, 34, 49, 43, 4, -48 },
  { 4776, 29, 47, 41, 6, -47 },
  { 4947, 11, 47, 17, 3, -47 },
  { 5012, 13, 58, 14, -5, -47 },
  { 5107, 27, 47, 32, 6, -47 },
  { 5266, 22, 47, 29, 6, -47 },
  { 5396, 39, 47, 51, 6, -47 },
  { 5626, 29, 47, 41, 6, -47 },
  { 5797, 36, 49, 44, 4, -48 },
  { 6018, 24, 47, 34, 6, -47 },
  { 6159, 36, 59, 44, 4, -48 },
  { 6425, 26, 47, 34, 6, -47 },
  { 6578, 26, 49, 32, 3, -48 },
  { 6738, 29, 47, 29, 0, -47 },
  { 6909, 30, 48, 42, 6, -47 },
  { 7089, 32, 47, 32, 0, -47 },
  { 7277, 49, 47, 52, 2, -47 },
  { 7565, 29, 47, 29, 0, -47 },
  { 7736, 29, 47, 29, 0, -47 },
  { 7907, 28, 47, 32, 2, -47 },
  { 8072, 13, 57, 20, 6, -47 },
  { 8165, 19, 47, 21, 1, -47 },
  { 8277, 13, 57, 20, 2, -47 },
  { 8370, 29, 26, 33, 2, -47 },
  { 8465, 26, 2, 26, 0, 6 },
  { 8472, 10, 10, 16, 3, -50 },
  { 8485, 22, 36, 30, 3, -35 },
  { 8584, 26, 51, 35, 5, -50 },
  { 8750, 22, 37, 27, 4, -36 },
  { 8852, 25, 51, 35, 4, -50 },
  { 9012, 24, 37, 32, 4, -36 },
  { 9123, 19, 50, 17, 1, -50 },
  { 9242, 25, 52, 35, 4, -36 },
  { 9405, 24, 50, 34, 5, -50 },
  { 9555, 3, 48, 13, 5, -48 },
  { 9573, 10, 64, 13, -2, -48 },
  { 9653, 22, 50, 27, 5, -50 },
  { 9791, 1, 50, 13, 6, -50 },
  { 9798, 40, 36, 50, 5, -36 },
  { 9978, 24, 36, 34, 5, -36 },
  { 10086, 26, 37, 34, 4, -36 },
  { 10207, 25, 51, 35, 6, -36 },
  { 10367, 26, 51, 35, 3, -36 },
  { 10533, 15, 35, 22, 6, -35 },
  { 10599, 21, 37, 27, 3, -36 },
  { 10697, 16, 44, 18, 1, -43 },
  { 10785, 23, 36, 34, 5, -35 },
  { 10889, 25, 35, 25, 0, -35 },
  { 10999, 39, 35, 41, 1, -35 },
  { 11170, 24, 35, 28, 2, -35 },
  { 11275, 25, 51, 26, 0, -35 },
  { 11435, 21, 35, 25, 2, -35 },
  { 11527, 18, 57, 22, 2, -47 },
  { 11656, 2, 66, 31, 15, -50 },
  { 11673, 17, 57, 22, 3, -47 },
  { 11795, 27, 6, 33, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_Thin66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_THIN66PT7B_H_
