#ifndef _NOTOSANS_SEMICONDENSED_THIN16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x12, 0x09, 0x04, 0x8F, 0xF1, 0x21, 0x10,
  0x91, 0xFE, 0x24, 0x12, 0x09, 0x00, 0x33, 0xBA, 0x28, 0xA1, 0x81, 0x0B,
  0x24, 0x92, 0x7E, 0x20, 0x61, 0x24, 0x89, 0x22, 0x48, 0x94, 0x25, 0xE9,
  0xA5, 0xB1, 0x14, 0x45, 0x12, 0x24, 0x8E, 0x30, 0x48, 0x44, 0x48, 0x48,
  0x30, 0x50, 0x89, 0x89, 0x86, 0x86, 0x79, 0xF0, 0x6A, 0x49, 0x24, 0x92,
  0x24, 0x40, 0x95, 0x55, 0x55, 0xA0, 0x20, 0x9D, 0x88, 0x58, 0x10, 0x41,
  0x3F, 0x10, 0x41, 0x00, 0xF0, 0xE0, 0x80, 0x08, 0x44, 0x22, 0x10, 0x88,
  0x42, 0x20, 0x31, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x3D,
  0x11, 0x11, 0x11, 0x11, 0x10, 0x72, 0x20, 0x41, 0x04, 0x20, 0x84, 0x21,
  0x04, 0x3F, 0x72, 0x20, 0x41, 0x04, 0x27, 0x81, 0x04, 0x10, 0x7E, 0x04,
  0x0C, 0x14, 0x14, 0x24, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x04, 0xFE, 0x08,
  0x20, 0xF8, 0x10, 0x41, 0x04, 0x1F, 0x80, 0x1D, 0x84, 0x20, 0x83, 0xE8,
  0x61, 0x86, 0x18, 0x5E, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x84,
  0x00, 0x3B, 0x18, 0x61, 0x85, 0xE4, 0xA1, 0x86, 0x18, 0x5E, 0x72, 0x28,
  0x61, 0x86, 0x18, 0xDD, 0x04, 0x10, 0xBC, 0xC0, 0x80, 0xC1, 0xE0, 0x0C,
  0xC4, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0x81, 0x19,
  0x88, 0x00, 0xF0, 0x42, 0x10, 0x88, 0x84, 0x20, 0x00, 0x40, 0x3F, 0x88,
  0x0A, 0x01, 0x47, 0x99, 0x13, 0x22, 0x68, 0x8C, 0x91, 0x97, 0x51, 0x11,
  0x00, 0x10, 0x81, 0xE0, 0x08, 0x18, 0x14, 0x24, 0x24, 0x22, 0x3E, 0x42,
  0x41, 0x81, 0x81, 0xFD, 0x06, 0x0C, 0x1E, 0xD2, 0xA0, 0xC1, 0x83, 0x07,
  0xF0, 0x1E, 0x41, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x01, 0xF0,
  0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0xFE,
  0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83,
  0xF8, 0x20, 0x82, 0x08, 0x00, 0x1E, 0x21, 0x40, 0x80, 0x80, 0x80, 0x8F,
  0x81, 0x81, 0x81, 0x41, 0x3F, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xD5, 0x55, 0x5C, 0x24, 0x92, 0x49, 0x24, 0x93,
  0x80, 0x87, 0x12, 0x44, 0x8A, 0x1A, 0x24, 0x44, 0x85, 0x0A, 0x08, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80, 0x70, 0x3C, 0x0E,
  0x85, 0xA1, 0x64, 0x59, 0x26, 0x49, 0x8A, 0x63, 0x18, 0x44, 0x81, 0xC1,
  0xA1, 0xA1, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x81, 0x1C, 0x31, 0x20,
  0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x90, 0x47, 0xC0, 0xFE,
  0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x08, 0x00, 0x1C, 0x31, 0x20, 0x50,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x90, 0x47, 0x40, 0x40, 0x10,
  0x08, 0xFD, 0x0A, 0x0C, 0x18, 0x5F, 0x22, 0x44, 0x85, 0x0A, 0x08, 0x7A,
  0x18, 0x20, 0x81, 0x03, 0x81, 0x04, 0x10, 0x7E, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x42, 0x3C, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24,
  0x24, 0x18, 0x18, 0x10, 0x82, 0x14, 0x61, 0x46, 0x14, 0x51, 0x45, 0x22,
  0x92, 0x29, 0x22, 0x8A, 0x28, 0xC1, 0x04, 0x10, 0x40, 0xC2, 0x88, 0x91,
  0x41, 0x02, 0x0A, 0x14, 0x44, 0x86, 0x08, 0x82, 0x89, 0x11, 0x42, 0x86,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xFC, 0x20, 0x84, 0x10, 0x82, 0x10, 0x82,
  0x0F, 0xC0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x82, 0x10, 0x82,
  0x10, 0x42, 0x10, 0x42, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x30,
  0x51, 0x22, 0x28, 0x50, 0x40, 0xFC, 0x90, 0x74, 0x42, 0x17, 0xC6, 0x31,
  0xF8, 0x81, 0x02, 0x05, 0xCC, 0x50, 0x60, 0xC1, 0x83, 0x06, 0x17, 0xC0,
  0x3A, 0x21, 0x08, 0x42, 0x10, 0x78, 0x04, 0x10, 0x4F, 0x46, 0x18, 0x61,
  0x86, 0x18, 0x5F, 0x31, 0x28, 0x61, 0xFE, 0x08, 0x20, 0x7C, 0x3A, 0x11,
  0xE4, 0x21, 0x08, 0x42, 0x10, 0x80, 0x39, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x7C, 0x10, 0x41, 0xF8, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x8F, 0xF0, 0x20, 0x02, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x08, 0x20,
  0x8A, 0x4A, 0x38, 0x92, 0x48, 0xA3, 0xFF, 0xF0, 0x33, 0xB3, 0x18, 0x46,
  0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x84, 0x40, 0x3B, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x39, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x39, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC2, 0xF9, 0x02, 0x04, 0x08, 0x00, 0x3B, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x7C, 0x10, 0x41, 0x04, 0x3C, 0x88, 0x88, 0x88,
  0x80, 0x7C, 0x21, 0x06, 0x08, 0x21, 0xF0, 0x44, 0xF4, 0x44, 0x44, 0x44,
  0x70, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x86, 0x14, 0x92, 0x48, 0xC3,
  0x04, 0x84, 0x63, 0x14, 0xC9, 0x4A, 0x52, 0x94, 0xA2, 0x10, 0x84, 0xC5,
  0x22, 0x84, 0x30, 0xA4, 0x61, 0x86, 0x14, 0x92, 0x48, 0xC3, 0x04, 0x20,
  0x82, 0x30, 0xF8, 0x88, 0x44, 0x22, 0x1F, 0x74, 0x44, 0x44, 0x84, 0x44,
  0x44, 0x43, 0xFF, 0xFF, 0xC4, 0x44, 0x42, 0x12, 0x44, 0x44, 0x48, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Thin16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 9, 11, 9, 0, -11 },
  { 18, 6, 13, 8, 1, -12 },
  { 28, 10, 12, 11, 1, -12 },
  { 43, 8, 12, 9, 1, -12 },
  { 55, 1, 4, 3, 1, -11 },
  { 56, 3, 14, 4, 1, -11 },
  { 62, 2, 14, 4, 1, -11 },
  { 66, 6, 5, 8, 1, -12 },
  { 70, 6, 7, 8, 1, -9 },
  { 76, 1, 4, 3, 1, -2 },
  { 77, 3, 1, 5, 1, -5 },
  { 78, 1, 1, 3, 1, -1 },
  { 79, 5, 11, 5, 0, -11 },
  { 86, 6, 12, 8, 1, -12 },
  { 95, 4, 11, 8, 1, -11 },
  { 101, 6, 12, 8, 1, -12 },
  { 110, 6, 12, 8, 1, -12 },
  { 119, 8, 11, 8, 0, -11 },
  { 130, 6, 11, 8, 1, -11 },
  { 139, 6, 12, 8, 1, -12 },
  { 148, 6, 11, 8, 1, -11 },
  { 157, 6, 12, 8, 1, -12 },
  { 166, 6, 12, 8, 1, -12 },
  { 175, 1, 9, 3, 1, -9 },
  { 177, 1, 11, 3, 1, -9 },
  { 179, 6, 7, 8, 1, -9 },
  { 185, 6, 4, 8, 1, -8 },
  { 188, 6, 7, 8, 1, -9 },
  { 194, 5, 12, 6, 0, -12 },
  { 202, 11, 13, 12, 1, -11 },
  { 220, 8, 11, 8, 0, -11 },
  { 231, 7, 11, 9, 1, -11 },
  { 241, 7, 12, 9, 1, -12 },
  { 252, 8, 11, 10, 1, -11 },
  { 263, 6, 11, 8, 1, -11 },
  { 272, 6, 11, 7, 1, -11 },
  { 281, 8, 12, 10, 1, -12 },
  { 293, 8, 11, 10, 1, -11 },
  { 304, 2, 11, 4, 1, -11 },
  { 307, 3, 14, 3, -1, -11 },
  { 313, 7, 11, 8, 1, -11 },
  { 323, 6, 11, 7, 1, -11 },
  { 332, 10, 11, 12, 1, -11 },
  { 346, 8, 11, 10, 1, -11 },
  { 357, 9, 12, 11, 1, -12 },
  { 371, 6, 11, 8, 1, -11 },
  { 380, 9, 15, 11, 1, -12 },
  { 397, 7, 11, 8, 1, -11 },
  { 407, 6, 12, 8, 1, -12 },
  { 416, 7, 11, 7, 0, -11 },
  { 426, 8, 11, 10, 1, -11 },
  { 437, 8, 11, 8, 0, -11 },
  { 448, 12, 11, 13, 0, -11 },
  { 465, 7, 11, 7, 0, -11 },
  { 475, 7, 11, 7, 0, -11 },
  { 485, 6, 11, 8, 1, -11 },
  { 494, 4, 14, 5, 1, -11 },
  { 501, 5, 11, 5, 0, -11 },
  { 508, 4, 14, 5, 0, -11 },
  { 515, 7, 6, 8, 1, -11 },
  { 521, 6, 1, 6, 0, 1 },
  { 522, 2, 2, 4, 1, -12 },
  { 523, 5, 9, 7, 1, -9 },
  { 529, 7, 12, 8, 1, -12 },
  { 540, 5, 9, 7, 1, -9 },
  { 546, 6, 12, 8, 1, -12 },
  { 555, 6, 9, 8, 1, -9 },
  { 562, 5, 12, 4, 0, -12 },
  { 570, 6, 13, 8, 1, -9 },
  { 580, 6, 12, 8, 1, -12 },
  { 589, 1, 12, 3, 1, -12 },
  { 591, 3, 16, 3, -1, -12 },
  { 597, 6, 12, 7, 1, -12 },
  { 606, 1, 12, 3, 1, -12 },
  { 608, 10, 9, 12, 1, -9 },
  { 620, 6, 9, 8, 1, -9 },
  { 627, 6, 9, 8, 1, -9 },
  { 634, 7, 13, 8, 1, -9 },
  { 646, 6, 13, 8, 1, -9 },
  { 656, 4, 9, 5, 1, -9 },
  { 661, 5, 9, 6, 1, -9 },
  { 667, 4, 11, 4, 0, -11 },
  { 673, 6, 8, 8, 1, -8 },
  { 679, 6, 8, 6, 0, -8 },
  { 685, 10, 8, 10, 0, -8 },
  { 695, 6, 8, 7, 0, -8 },
  { 701, 6, 12, 6, 0, -8 },
  { 710, 5, 8, 6, 1, -8 },
  { 715, 4, 14, 5, 1, -11 },
  { 722, 1, 16, 8, 3, -12 },
  { 724, 4, 14, 5, 1, -11 },
  { 731, 6, 1, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Thin16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_THIN16PT7B_H_
