#ifndef _NOTOSANS_SEMICONDENSED_THIN46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x0B, 0xC0, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x60,
  0x10, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40,
  0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x60, 0x00, 0x80,
  0x40, 0x00, 0x80, 0x40, 0x3F, 0xFF, 0xFF, 0x00, 0x80, 0x40, 0x01, 0x80,
  0x40, 0x01, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80, 0x02, 0x01, 0x80, 0x02, 0x01,
  0x00, 0xFF, 0xFF, 0xFC, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x06, 0x01,
  0x00, 0x06, 0x03, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02,
  0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x18, 0x83,
  0x0C, 0x20, 0x06, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30, 0x20, 0x0C,
  0x08, 0x03, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x42,
  0x00, 0x0C, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x02, 0xE0, 0x00, 0x8E,
  0x00, 0x20, 0xC0, 0x08, 0x18, 0x02, 0x02, 0x00, 0x80, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x20, 0x08, 0x18, 0x02,
  0x0C, 0x60, 0x86, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0F, 0x80, 0x06, 0x03, 0x0C, 0x00, 0x40, 0x20, 0x40,
  0x0C, 0x06, 0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x30, 0x30, 0x04, 0x03, 0x02, 0x00, 0xC0, 0x30, 0x20, 0x0C, 0x03,
  0x04, 0x00, 0xC0, 0x30, 0x40, 0x0C, 0x03, 0x08, 0x00, 0x40, 0x30, 0x80,
  0x04, 0x03, 0x10, 0xF8, 0x40, 0x21, 0x18, 0x44, 0x02, 0x33, 0x02, 0x60,
  0x22, 0x20, 0x22, 0x04, 0x62, 0x03, 0x30, 0xC4, 0x60, 0x11, 0xF8, 0xC4,
  0x01, 0x00, 0x08, 0x40, 0x10, 0x01, 0x84, 0x01, 0x00, 0x10, 0x40, 0x10,
  0x01, 0x04, 0x01, 0x00, 0x20, 0x40, 0x10, 0x02, 0x04, 0x01, 0x00, 0x40,
  0x40, 0x10, 0x04, 0x06, 0x01, 0x00, 0x80, 0x20, 0x30, 0x08, 0x02, 0x02,
  0x01, 0x00, 0x30, 0x20, 0x10, 0x01, 0x04, 0x03, 0x00, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x08, 0x02, 0x00, 0x08,
  0x03, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08,
  0x03, 0x00, 0x08, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x03, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x40, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x10, 0x02, 0x20, 0x18, 0x02, 0x60,
  0x0C, 0x06, 0x40, 0x06, 0x04, 0x40, 0x02, 0x04, 0xC0, 0x01, 0x0C, 0xC0,
  0x00, 0x88, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x70, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x70, 0x60, 0x00, 0xC8, 0x30, 0x01, 0x8C, 0x18, 0x06, 0x06, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0xAA, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20,
  0x20, 0x30, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x80, 0x40, 0x60,
  0x20, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02,
  0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x81,
  0x01, 0xE1, 0x07, 0x1D, 0x38, 0x03, 0xC0, 0x01, 0x80, 0x02, 0x40, 0x04,
  0x40, 0x0C, 0x20, 0x08, 0x10, 0x10, 0x18, 0x30, 0x08, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0x80,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x32,
  0x22, 0x66, 0x44, 0xC8, 0x80, 0xFF, 0xC0, 0xBC, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x07, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x60, 0x80, 0x08, 0x20,
  0x03, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0xC0, 0x00, 0x90, 0x00,
  0x64, 0x00, 0x11, 0x00, 0x04, 0x20, 0x03, 0x0C, 0x00, 0x81, 0x00, 0x60,
  0x30, 0x30, 0x07, 0xF0, 0x00, 0x00, 0x80, 0xC1, 0xA1, 0x91, 0x8B, 0x07,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x07, 0xF8, 0x06, 0x03, 0x06,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x0E, 0x03, 0x86, 0x00, 0x32, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x3F, 0xC0, 0x00, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x68, 0x00, 0x33, 0x80, 0x18, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40,
  0x00, 0x0D, 0x00, 0x00, 0x24, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x00,
  0x21, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40, 0x01, 0x01,
  0x00, 0x0C, 0x04, 0x00, 0x20, 0x10, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x40, 0x20, 0x01, 0x01, 0x80,
  0x04, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x60, 0x07, 0xFF, 0x81, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x70, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0xFE, 0x08, 0xC0, 0xE2, 0x40, 0x0C, 0xA0,
  0x01, 0x30, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x09,
  0x00, 0x02, 0x60, 0x01, 0x88, 0x00, 0x41, 0x00, 0x30, 0x30, 0x18, 0x07,
  0xF8, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xFC, 0x01, 0x80, 0xC0, 0x60, 0x04, 0x18, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x20, 0x00, 0xC4, 0x00, 0x10, 0xC0,
  0x02, 0x08, 0x00, 0x80, 0x80, 0x20, 0x0C, 0x18, 0x00, 0xEE, 0x00, 0x07,
  0x00, 0x03, 0xB8, 0x01, 0xC1, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC2, 0x00,
  0x0C, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0D, 0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x04, 0x40, 0x01, 0x0C, 0x00,
  0x60, 0xE0, 0x38, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0x03, 0x01, 0x00,
  0x20, 0x80, 0x04, 0x60, 0x01, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x50,
  0x00, 0x14, 0x00, 0x0D, 0x80, 0x03, 0x20, 0x01, 0x4C, 0x00, 0xD1, 0x80,
  0xE4, 0x1F, 0xE1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x2F, 0x33, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x22, 0x26, 0x64, 0x4C, 0x88, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x3F,
  0xC3, 0x80, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08,
  0x80, 0x1F, 0xF0, 0x19, 0x00, 0x60, 0x20, 0x16, 0x01, 0x80, 0x40, 0x28,
  0x06, 0x00, 0x80, 0x50, 0x08, 0x01, 0x00, 0xA0, 0x30, 0x02, 0x01, 0x40,
  0x40, 0x04, 0x03, 0x80, 0x80, 0x08, 0x07, 0x01, 0x00, 0x30, 0x0E, 0x02,
  0x00, 0x60, 0x1C, 0x04, 0x00, 0xC0, 0x38, 0x08, 0x01, 0x80, 0x50, 0x10,
  0x03, 0x00, 0xA0, 0x30, 0x0A, 0x02, 0x40, 0x20, 0x14, 0x04, 0x80, 0x60,
  0x68, 0x11, 0x80, 0x61, 0x88, 0x61, 0x00, 0x7C, 0x0F, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x11, 0x80, 0x00, 0x21, 0x00, 0x00, 0x82, 0x00, 0x01,
  0x06, 0x00, 0x02, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x18, 0x00, 0x20,
  0x10, 0x00, 0x80, 0x20, 0x01, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x3F, 0xFF, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04,
  0x02, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x30,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x90,
  0x00, 0x01, 0x60, 0x00, 0x03, 0x80, 0x00, 0x02, 0xFF, 0xE0, 0x18, 0x07,
  0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0xB0, 0x00,
  0x16, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00,
  0x4C, 0x00, 0x19, 0x80, 0x02, 0x30, 0x01, 0x87, 0xFF, 0xC0, 0xC0, 0x1E,
  0x18, 0x00, 0x63, 0x00, 0x02, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x2C, 0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0xC6, 0x00, 0xF0,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0E, 0x01, 0xC1, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x02, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x06, 0x03, 0xE0, 0x30,
  0x01, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00,
  0x98, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x02, 0xC0, 0x00, 0x16,
  0x00, 0x01, 0xB0, 0x00, 0x09, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00,
  0xC3, 0x00, 0x0C, 0x18, 0x07, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0x80, 0x1C, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x04,
  0x80, 0x00, 0x09, 0x80, 0x00, 0x11, 0x80, 0x00, 0x21, 0x80, 0x00, 0x41,
  0x80, 0x00, 0x81, 0xC0, 0x07, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x1A, 0x0C, 0x7C, 0x00, 0xC0, 0x00, 0xD8, 0x00,
  0x13, 0x00, 0x04, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06,
  0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x08, 0x03, 0x03, 0x00, 0x60, 0xC0,
  0x0C, 0x30, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x06, 0x50, 0x00, 0xD1, 0x00,
  0x1C, 0x30, 0x03, 0x82, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x08, 0x18, 0x01, 0x83, 0x00, 0x10,
  0x60, 0x01, 0x0C, 0x00, 0x31, 0x80, 0x02, 0x30, 0x00, 0x26, 0x00, 0x06,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x03, 0xD0, 0x00, 0x00, 0x5F, 0x00,
  0x00, 0x0B, 0xA0, 0x00, 0x03, 0x76, 0x00, 0x00, 0x4E, 0x40, 0x00, 0x19,
  0xC8, 0x00, 0x02, 0x39, 0x80, 0x00, 0x47, 0x10, 0x00, 0x18, 0xE2, 0x00,
  0x02, 0x1C, 0x60, 0x00, 0x43, 0x84, 0x00, 0x18, 0x70, 0x80, 0x02, 0x0E,
  0x08, 0x00, 0xC1, 0xC1, 0x00, 0x10, 0x38, 0x30, 0x02, 0x07, 0x02, 0x00,
  0xC0, 0xE0, 0x40, 0x10, 0x1C, 0x0C, 0x02, 0x03, 0x80, 0x80, 0xC0, 0x70,
  0x10, 0x10, 0x0E, 0x01, 0x02, 0x01, 0xC0, 0x20, 0x80, 0x38, 0x06, 0x10,
  0x07, 0x00, 0x46, 0x00, 0xE0, 0x08, 0x80, 0x1C, 0x01, 0x90, 0x03, 0x80,
  0x16, 0x00, 0x70, 0x02, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x20, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x40, 0x00, 0x3D,
  0x00, 0x01, 0xEC, 0x00, 0x0F, 0x20, 0x00, 0x79, 0x80, 0x03, 0xC4, 0x00,
  0x1E, 0x10, 0x00, 0xF0, 0xC0, 0x07, 0x82, 0x00, 0x3C, 0x18, 0x01, 0xE0,
  0x40, 0x0F, 0x01, 0x00, 0x78, 0x0C, 0x03, 0xC0, 0x20, 0x1E, 0x01, 0x80,
  0xF0, 0x04, 0x07, 0x80, 0x30, 0x3C, 0x00, 0x81, 0xE0, 0x02, 0x0F, 0x00,
  0x18, 0x78, 0x00, 0x43, 0xC0, 0x03, 0x1E, 0x00, 0x08, 0xF0, 0x00, 0x27,
  0x80, 0x01, 0xBC, 0x00, 0x05, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x70, 0x01, 0x00,
  0x0C, 0x01, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x03, 0x20, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02, 0x40, 0x00, 0x03, 0x20, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x40, 0x30, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x60, 0x7C, 0x30, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x16, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x04, 0xC0, 0x06,
  0x60, 0x1C, 0x3F, 0xF8, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0x80, 0x70, 0x01, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x01,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x04,
  0x40, 0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x02, 0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x40,
  0x06, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x18, 0x0F,
  0x83, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x11, 0x80, 0x03, 0x30, 0x00,
  0x26, 0x00, 0x04, 0xC0, 0x00, 0x98, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00,
  0x4C, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x1C,
  0x1F, 0xFE, 0x03, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x20,
  0x30, 0x06, 0x06, 0x00, 0x40, 0xC0, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x08,
  0x60, 0x01, 0x8C, 0x00, 0x11, 0x80, 0x03, 0x30, 0x00, 0x26, 0x00, 0x06,
  0xC0, 0x00, 0x60, 0x03, 0xFE, 0x03, 0x00, 0x61, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x33, 0x00, 0x38, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xD0, 0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x03, 0x10, 0x00, 0x10,
  0x40, 0x01, 0x01, 0x80, 0x30, 0x07, 0xFE, 0x00, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x66, 0x00, 0x00, 0x84, 0x00,
  0x01, 0x08, 0x00, 0x06, 0x18, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x60, 0x60, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x06, 0x01, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0x80, 0x04, 0x01, 0x00,
  0x08, 0x06, 0x00, 0x18, 0x08, 0x00, 0x10, 0x10, 0x00, 0x20, 0x60, 0x00,
  0x40, 0x80, 0x00, 0x41, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x0D, 0x00, 0x03, 0x00, 0x02,
  0x40, 0x01, 0xE0, 0x00, 0x98, 0x00, 0x48, 0x00, 0x22, 0x00, 0x12, 0x00,
  0x18, 0x80, 0x04, 0x80, 0x04, 0x20, 0x03, 0x30, 0x01, 0x0C, 0x00, 0x84,
  0x00, 0x41, 0x00, 0x21, 0x00, 0x30, 0x40, 0x08, 0x40, 0x08, 0x10, 0x06,
  0x18, 0x02, 0x06, 0x01, 0x02, 0x00, 0x80, 0x80, 0x40, 0x80, 0x60, 0x20,
  0x10, 0x20, 0x10, 0x08, 0x0C, 0x0C, 0x04, 0x03, 0x02, 0x01, 0x01, 0x00,
  0x40, 0x80, 0x40, 0xC0, 0x10, 0x20, 0x10, 0x20, 0x04, 0x18, 0x06, 0x08,
  0x01, 0x84, 0x00, 0x86, 0x00, 0x21, 0x00, 0x21, 0x80, 0x08, 0x40, 0x08,
  0x40, 0x02, 0x30, 0x03, 0x10, 0x00, 0xC8, 0x00, 0x4C, 0x00, 0x12, 0x00,
  0x13, 0x00, 0x04, 0x80, 0x04, 0x80, 0x01, 0x60, 0x01, 0xA0, 0x00, 0x70,
  0x00, 0x28, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x32, 0x00, 0x02, 0x30, 0x00, 0x61,
  0x00, 0x04, 0x08, 0x00, 0x80, 0x80, 0x08, 0x04, 0x01, 0x00, 0x60, 0x30,
  0x02, 0x02, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00, 0x18, 0xC0, 0x00, 0x88,
  0x00, 0x0D, 0x80, 0x00, 0x50, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x05,
  0x00, 0x00, 0xD8, 0x00, 0x08, 0x80, 0x01, 0x0C, 0x00, 0x10, 0x40, 0x02,
  0x06, 0x00, 0x60, 0x20, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x81,
  0x80, 0x08, 0x10, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0x24, 0x00, 0x03,
  0xC0, 0x00, 0x10, 0x80, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00,
  0x04, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x80, 0x18, 0x08,
  0x01, 0x00, 0xC0, 0x30, 0x04, 0x02, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00,
  0x30, 0x40, 0x01, 0x08, 0x00, 0x10, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xB0, 0x00, 0x09, 0x00, 0x01, 0x18, 0x00, 0x10, 0x80,
  0x02, 0x0C, 0x00, 0x20, 0x40, 0x04, 0x06, 0x00, 0xC0, 0x20, 0x08, 0x03,
  0x01, 0x80, 0x10, 0x10, 0x01, 0x83, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00,
  0x04, 0x40, 0x00, 0x6C, 0x00, 0x02, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xC0,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x01, 0xC0, 0x3E, 0xF0, 0xC0,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x01, 0xF0, 0x7E, 0x23, 0x00, 0x4C, 0x00, 0xA0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x78, 0x00,
  0xD0, 0x02, 0x90, 0x09, 0x1F, 0xE2, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x1E, 0x02, 0x3C, 0xF0, 0x98, 0x06, 0x2C,
  0x00, 0xCA, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xB0,
  0x00, 0x6C, 0x00, 0x12, 0x80, 0x0C, 0xB0, 0x06, 0x26, 0x03, 0x08, 0xFF,
  0x80, 0x00, 0xF8, 0x0F, 0x3C, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0E, 0x01, 0x07, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0F,
  0x04, 0x1E, 0x71, 0x0C, 0x02, 0x46, 0x00, 0x53, 0x00, 0x1C, 0x80, 0x03,
  0x60, 0x00, 0xD0, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x05, 0x00, 0x01, 0x40, 0x00, 0x58, 0x00, 0x32, 0x00, 0x0C, 0xC0, 0x05,
  0x10, 0x01, 0x43, 0x01, 0x90, 0x7F, 0xC4, 0x03, 0xC0, 0x07, 0xBC, 0x06,
  0x03, 0x06, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x19, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x07, 0xFE,
  0x00, 0x01, 0xFC, 0x0C, 0x10, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x3F, 0xF8, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x00, 0xF0, 0x01, 0xE7, 0x10, 0xC0, 0x34, 0x40, 0x05,
  0x30, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x14, 0x00,
  0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80, 0x03,
  0x20, 0x00, 0xCC, 0x00, 0x51, 0x80, 0x34, 0x30, 0x19, 0x07, 0xFC, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x90, 0x00, 0xC3, 0x80, 0xE0, 0x3F, 0xE0,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x83, 0xE0, 0x8F, 0x78,
  0x98, 0x0C, 0xA0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFD, 0x00,
  0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x0E,
  0x1C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x1A,
  0x67, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x14, 0x00,
  0x48, 0x01, 0x90, 0x06, 0x20, 0x18, 0x40, 0x20, 0x80, 0x81, 0x03, 0x02,
  0x0C, 0x04, 0x30, 0x08, 0x40, 0x11, 0x80, 0x24, 0x80, 0x59, 0x80, 0xE1,
  0x01, 0x81, 0x02, 0x03, 0x04, 0x02, 0x08, 0x06, 0x10, 0x04, 0x20, 0x04,
  0x40, 0x0C, 0x80, 0x09, 0x00, 0x1A, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x1C, 0x08, 0xE7, 0x07, 0x38, 0x90, 0x18, 0x80, 0xCA,
  0x00, 0x90, 0x06, 0xC0, 0x0E, 0x00, 0x2C, 0x00, 0x60, 0x02, 0x80, 0x06,
  0x00, 0x28, 0x00, 0x40, 0x02, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03,
  0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00,
  0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00,
  0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80,
  0x04, 0x00, 0x38, 0x00, 0x40, 0x03, 0x80, 0x04, 0x00, 0x38, 0x00, 0x40,
  0x03, 0x80, 0x04, 0x00, 0x30, 0x01, 0xE0, 0x8F, 0x78, 0x98, 0x0C, 0xA0,
  0x06, 0xA0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0xF0, 0x00, 0xF3, 0xC0,
  0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0x68, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x68,
  0x00, 0x0D, 0x00, 0x01, 0x30, 0x00, 0x22, 0x00, 0x0C, 0x60, 0x01, 0x06,
  0x00, 0x40, 0x60, 0x30, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x23, 0xCF, 0x09,
  0x80, 0x62, 0xC0, 0x0C, 0xA0, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0B, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x2C,
  0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0x28, 0x00, 0xCB, 0x00, 0x62, 0x60,
  0x30, 0x87, 0xF8, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xEF, 0x10, 0xC0, 0x24, 0x40,
  0x05, 0x30, 0x01, 0xC8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x01, 0x40, 0x00,
  0x50, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x80,
  0x03, 0x20, 0x00, 0xCC, 0x00, 0x51, 0x00, 0x34, 0x30, 0x19, 0x07, 0xF8,
  0x40, 0x30, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x03, 0x91, 0xFE, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00,
  0x03, 0xC0, 0x3C, 0xF8, 0x80, 0x12, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x60, 0x0C, 0x7F, 0xF0, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x3F, 0xF8, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x0F, 0xC0, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x05, 0xC0, 0x05, 0x40,
  0x09, 0x60, 0x31, 0x1F, 0xE1, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x4C,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0xC0, 0x08, 0x20, 0x04, 0x10, 0x04,
  0x0C, 0x02, 0x02, 0x01, 0x01, 0x01, 0x00, 0xC0, 0x80, 0x20, 0x40, 0x10,
  0x40, 0x0C, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0xC8, 0x00, 0x24, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x01, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x0F, 0x00, 0x28, 0x01, 0x20, 0x05, 0x00, 0x24, 0x00, 0xB0,
  0x04, 0x80, 0x32, 0x01, 0x98, 0x04, 0x40, 0x21, 0x00, 0x88, 0x04, 0x20,
  0x11, 0x80, 0x84, 0x04, 0x10, 0x30, 0xC0, 0x82, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x06, 0x04, 0x10, 0x20, 0x80, 0x86, 0x02, 0x10, 0x10, 0x80, 0x46,
  0x03, 0x10, 0x08, 0x80, 0x22, 0x01, 0x90, 0x04, 0xC0, 0x12, 0x00, 0x90,
  0x02, 0xC0, 0x0A, 0x00, 0x50, 0x01, 0x40, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x90, 0x01, 0x8C, 0x00, 0x82,
  0x00, 0x81, 0x80, 0xC0, 0x40, 0x40, 0x10, 0x40, 0x0C, 0x60, 0x02, 0x20,
  0x00, 0xB0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x0B, 0x00, 0x08,
  0x80, 0x0C, 0x60, 0x04, 0x10, 0x04, 0x04, 0x06, 0x03, 0x02, 0x00, 0x83,
  0x00, 0x61, 0x00, 0x19, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x00, 0xD0, 0x00,
  0x26, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x0C, 0x00, 0x41, 0x00, 0x20,
  0x40, 0x08, 0x18, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x10, 0x04,
  0x08, 0x01, 0x02, 0x00, 0x61, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0xCC,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0x00, 0x70, 0x1C,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x18, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x0E, 0x00, 0xF0, 0x18, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x0F, 0x00, 0x3F, 0x80, 0x2C,
  0x1C, 0x06, 0x00, 0xF7, 0x00, 0x03, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 33, 10, 4, -33 },
  { 10, 8, 12, 14, 3, -33 },
  { 22, 24, 33, 26, 1, -33 },
  { 121, 18, 38, 23, 2, -35 },
  { 207, 28, 33, 33, 2, -33 },
  { 323, 24, 33, 27, 2, -33 },
  { 422, 2, 12, 8, 3, -33 },
  { 425, 8, 40, 12, 2, -33 },
  { 465, 8, 40, 12, 2, -33 },
  { 505, 16, 16, 22, 3, -35 },
  { 537, 19, 21, 23, 2, -27 },
  { 587, 4, 11, 8, 2, -5 },
  { 593, 10, 1, 14, 2, -13 },
  { 595, 2, 3, 9, 4, -3 },
  { 596, 13, 33, 15, 1, -33 },
  { 650, 18, 33, 23, 3, -33 },
  { 725, 9, 33, 23, 4, -33 },
  { 763, 18, 33, 23, 2, -33 },
  { 838, 18, 33, 23, 2, -33 },
  { 913, 22, 33, 23, 1, -33 },
  { 1004, 18, 33, 23, 3, -33 },
  { 1079, 18, 34, 23, 3, -33 },
  { 1156, 19, 33, 23, 2, -33 },
  { 1235, 19, 33, 23, 2, -33 },
  { 1314, 18, 34, 23, 2, -33 },
  { 1391, 2, 24, 9, 4, -24 },
  { 1397, 4, 30, 9, 2, -24 },
  { 1412, 19, 20, 23, 2, -27 },
  { 1460, 19, 11, 23, 2, -22 },
  { 1487, 19, 20, 23, 2, -27 },
  { 1535, 14, 33, 16, 1, -33 },
  { 1593, 31, 37, 36, 2, -33 },
  { 1737, 23, 33, 23, 0, -33 },
  { 1832, 19, 33, 25, 4, -33 },
  { 1911, 21, 33, 25, 3, -33 },
  { 1998, 21, 33, 28, 4, -33 },
  { 2085, 16, 33, 22, 4, -33 },
  { 2151, 16, 33, 20, 4, -33 },
  { 2217, 23, 33, 30, 3, -33 },
  { 2312, 20, 33, 29, 4, -33 },
  { 2395, 8, 33, 12, 2, -33 },
  { 2428, 10, 41, 10, -4, -33 },
  { 2480, 19, 33, 23, 4, -33 },
  { 2559, 16, 33, 21, 4, -33 },
  { 2625, 27, 33, 35, 4, -33 },
  { 2737, 21, 33, 29, 4, -33 },
  { 2824, 25, 33, 31, 3, -33 },
  { 2928, 17, 33, 23, 4, -33 },
  { 2999, 25, 41, 31, 3, -33 },
  { 3128, 19, 33, 24, 4, -33 },
  { 3207, 18, 33, 22, 2, -33 },
  { 3282, 20, 33, 20, 0, -33 },
  { 3365, 21, 33, 29, 4, -33 },
  { 3452, 23, 33, 23, 0, -33 },
  { 3547, 34, 33, 36, 1, -33 },
  { 3688, 20, 33, 20, 0, -33 },
  { 3771, 20, 33, 20, 0, -33 },
  { 3854, 19, 33, 22, 2, -33 },
  { 3933, 9, 40, 14, 4, -33 },
  { 3978, 13, 33, 15, 1, -33 },
  { 4032, 9, 40, 14, 1, -33 },
  { 4077, 20, 19, 23, 2, -33 },
  { 4125, 18, 1, 18, 0, 4 },
  { 4128, 7, 7, 11, 2, -35 },
  { 4135, 15, 25, 21, 2, -25 },
  { 4182, 18, 35, 24, 4, -35 },
  { 4261, 15, 25, 19, 3, -25 },
  { 4308, 18, 35, 24, 2, -35 },
  { 4387, 17, 25, 22, 3, -25 },
  { 4441, 14, 35, 12, 0, -35 },
  { 4503, 18, 36, 24, 2, -25 },
  { 4584, 16, 35, 24, 4, -35 },
  { 4654, 3, 33, 9, 3, -33 },
  { 4667, 7, 44, 9, -1, -33 },
  { 4706, 15, 35, 19, 4, -35 },
  { 4772, 1, 35, 9, 4, -35 },
  { 4777, 28, 25, 35, 4, -25 },
  { 4865, 16, 25, 24, 4, -25 },
  { 4915, 19, 25, 24, 2, -25 },
  { 4975, 18, 36, 24, 4, -25 },
  { 5056, 18, 36, 24, 2, -25 },
  { 5137, 11, 25, 15, 4, -25 },
  { 5172, 15, 25, 19, 2, -25 },
  { 5219, 11, 30, 13, 1, -30 },
  { 5261, 16, 24, 24, 4, -24 },
  { 5309, 17, 24, 17, 0, -24 },
  { 5360, 27, 24, 29, 1, -24 },
  { 5441, 17, 24, 19, 1, -24 },
  { 5492, 18, 35, 18, 0, -24 },
  { 5571, 14, 24, 18, 2, -24 },
  { 5613, 12, 40, 16, 2, -33 },
  { 5673, 2, 46, 22, 10, -35 },
  { 5685, 12, 40, 16, 2, -33 },
  { 5745, 19, 4, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Thin46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_THIN46PT7B_H_
