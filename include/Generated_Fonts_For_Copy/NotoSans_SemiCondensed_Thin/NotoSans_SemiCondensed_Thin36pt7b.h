#ifndef _NOTOSANS_SEMICONDENSED_THIN36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin36pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04,
  0x08, 0x02, 0x02, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x7F, 0xFF,
  0xC0, 0x81, 0x00, 0x40, 0x40, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00,
  0x40, 0x80, 0x10, 0x20, 0x08, 0x08, 0x3F, 0xFF, 0xE0, 0x81, 0x00, 0x20,
  0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x40, 0x40, 0x10, 0x20,
  0x04, 0x08, 0x00, 0x02, 0x00, 0x10, 0x07, 0xF8, 0x44, 0x24, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x10, 0x80, 0xC4, 0x01, 0x20,
  0x07, 0x00, 0x0E, 0x00, 0x4C, 0x02, 0x10, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x82, 0x37, 0xDF, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x81, 0x88, 0x02, 0x04, 0x10, 0x10, 0x20,
  0x40, 0x40, 0x81, 0x02, 0x02, 0x02, 0x08, 0x08, 0x08, 0x40, 0x20, 0x21,
  0x00, 0x80, 0x84, 0x02, 0x02, 0x20, 0x08, 0x08, 0x8E, 0x20, 0x44, 0x44,
  0x81, 0x12, 0x09, 0x04, 0x90, 0x26, 0x22, 0x40, 0x8F, 0x11, 0x01, 0x00,
  0x44, 0x04, 0x02, 0x10, 0x10, 0x08, 0x40, 0x40, 0x41, 0x01, 0x01, 0x04,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x00, 0x82, 0x04, 0x02, 0x10,
  0x30, 0x07, 0xC0, 0x07, 0xC0, 0x02, 0x08, 0x01, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x40, 0x10, 0x20, 0x02,
  0x10, 0x00, 0xC8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x40, 0x02, 0x08,
  0x05, 0x03, 0x02, 0x80, 0x60, 0xA0, 0x08, 0x28, 0x01, 0x0A, 0x00, 0x24,
  0x80, 0x07, 0x20, 0x00, 0x88, 0x00, 0x61, 0x00, 0x24, 0x20, 0x30, 0x87,
  0xF8, 0x10, 0xFF, 0xC0, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x81, 0xC0, 0x80, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x0C, 0x21, 0x9D, 0x70, 0x1C, 0x00, 0xA0, 0x08, 0x80, 0x44,
  0x04, 0x10, 0x40, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x24, 0x96, 0x92, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x00, 0x0F, 0xC0, 0x60, 0x82, 0x01, 0x08, 0x02, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x22, 0x00, 0x88, 0x04, 0x10, 0x20,
  0x3F, 0x00, 0x02, 0x0C, 0x28, 0x96, 0x38, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x1F, 0x81, 0x81, 0x84, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x1F,
  0xC1, 0x80, 0x88, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x10, 0x1F, 0x80, 0x03, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x80, 0x31, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0x40, 0x06, 0x20,
  0x02, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x80, 0x40, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08, 0x40, 0x04, 0x3F,
  0xFF, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x3F, 0xF8, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x1F, 0xF8, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x80,
  0x21, 0xFF, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x7C, 0x26, 0x0C,
  0xA0, 0x0A, 0x80, 0x2C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x50, 0x01, 0x40, 0x05, 0x00, 0x12, 0x00, 0x88, 0x02, 0x10, 0x10, 0x3F,
  0x80, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0F,
  0xC0, 0x40, 0xC2, 0x01, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90,
  0x02, 0x40, 0x08, 0x80, 0x41, 0x82, 0x03, 0x30, 0x03, 0x80, 0x31, 0x03,
  0x03, 0x18, 0x06, 0x40, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x50, 0x02, 0x20, 0x10, 0x7F, 0x80, 0x0F, 0x80, 0xC1,
  0x86, 0x01, 0x10, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x40, 0x0D, 0x00, 0x52, 0x02, 0x47,
  0xE1, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0xC1, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x26, 0x44, 0x48,
  0x00, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x7F, 0x10, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x02,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x20,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x3F, 0x82, 0x40, 0x40, 0x81, 0x80,
  0x80, 0x81, 0x81, 0x00, 0x81, 0x81, 0x00, 0x81, 0x81, 0x00, 0x81, 0x81,
  0x00, 0x81, 0x82, 0x00, 0x81, 0x82, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81,
  0x01, 0x82, 0x81, 0x02, 0x82, 0x80, 0x86, 0x84, 0x40, 0x78, 0x78, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x11, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xF8, 0x10, 0x02, 0x04, 0x00,
  0x81, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x24, 0x00, 0x09,
  0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFF, 0x01, 0x00, 0xE2, 0x00,
  0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x24, 0x01, 0x8F, 0xFC, 0x10, 0x06, 0x20, 0x03, 0x40,
  0x02, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xA0, 0x01, 0x40, 0x04, 0x80, 0x31, 0xFF, 0x80, 0x01, 0xFE, 0x06, 0x01,
  0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x04, 0x01, 0x03, 0xFF,
  0xFF, 0x00, 0x40, 0x78, 0x20, 0x06, 0x10, 0x00, 0x88, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x12, 0x00,
  0x11, 0x00, 0x10, 0x80, 0x30, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x0F, 0xFF, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x7F, 0xFA, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x60, 0x18, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x44, 0x00, 0x08, 0x40, 0x01, 0x06, 0x00, 0x60, 0x3F, 0xF0,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x7E, 0x80, 0x05, 0x00, 0x12, 0x00, 0x64, 0x01, 0x88, 0x02, 0x10, 0x08,
  0x20, 0x20, 0x40, 0x80, 0x83, 0x01, 0x0C, 0x02, 0x30, 0x04, 0x40, 0x09,
  0x40, 0x14, 0x40, 0x30, 0x80, 0x40, 0x80, 0x81, 0x81, 0x01, 0x02, 0x01,
  0x04, 0x03, 0x08, 0x02, 0x10, 0x02, 0x20, 0x06, 0x40, 0x04, 0x80, 0x05,
  0x00, 0x0C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE8, 0x00,
  0x07, 0x40, 0x00, 0x3A, 0x00, 0x02, 0xC8, 0x00, 0x16, 0x40, 0x00, 0xB3,
  0x00, 0x09, 0x88, 0x00, 0x4C, 0x40, 0x04, 0x61, 0x00, 0x23, 0x08, 0x01,
  0x18, 0x40, 0x10, 0xC1, 0x00, 0x86, 0x08, 0x04, 0x30, 0x40, 0x41, 0x81,
  0x02, 0x0C, 0x08, 0x20, 0x60, 0x21, 0x03, 0x01, 0x08, 0x18, 0x08, 0x80,
  0xC0, 0x24, 0x06, 0x01, 0x20, 0x30, 0x0A, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x40, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xA0, 0x01, 0x90, 0x01,
  0x90, 0x01, 0x88, 0x01, 0x8C, 0x01, 0x84, 0x01, 0x82, 0x01, 0x82, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21,
  0x80, 0x21, 0x80, 0x11, 0x80, 0x09, 0x80, 0x09, 0x80, 0x05, 0x80, 0x05,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x01, 0xFC, 0x00, 0x60, 0x20, 0x08,
  0x01, 0x81, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x04, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x14, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00,
  0x04, 0x30, 0x00, 0x81, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x3F, 0xC0, 0xFE,
  0x02, 0x03, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x01, 0x8F,
  0xF8, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x60, 0x20, 0x08, 0x01, 0x81, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x04,
  0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x22, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x03, 0x00,
  0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x18, 0xFF, 0x01, 0x01, 0xC2, 0x00, 0x44, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x24, 0x00, 0x88, 0x03, 0x1F, 0xF8, 0x20, 0x40, 0x40, 0x40, 0x80,
  0x81, 0x00, 0x82, 0x01, 0x84, 0x01, 0x08, 0x03, 0x10, 0x02, 0x20, 0x02,
  0x40, 0x04, 0x80, 0x05, 0x00, 0x0C, 0x0F, 0xF0, 0xC0, 0x26, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x80, 0x33, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x28, 0x00, 0x12, 0x00, 0x09, 0x00, 0x0C, 0x40, 0x04, 0x10,
  0x0C, 0x07, 0xF8, 0x00, 0x80, 0x00, 0x60, 0x00, 0x24, 0x00, 0x09, 0x00,
  0x02, 0x40, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x08, 0x10, 0x02,
  0x04, 0x00, 0x81, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00,
  0x40, 0x80, 0x10, 0x20, 0x04, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08,
  0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x14, 0x00, 0x05, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x30,
  0x01, 0x20, 0x06, 0x00, 0x24, 0x00, 0xA0, 0x04, 0x80, 0x24, 0x01, 0x10,
  0x04, 0x80, 0x21, 0x00, 0x90, 0x04, 0x20, 0x11, 0x01, 0x04, 0x04, 0x20,
  0x20, 0x80, 0x84, 0x04, 0x08, 0x10, 0x80, 0x81, 0x02, 0x08, 0x30, 0x20,
  0x81, 0x04, 0x04, 0x10, 0x20, 0x80, 0x42, 0x04, 0x10, 0x08, 0x40, 0x44,
  0x01, 0x10, 0x08, 0x80, 0x22, 0x01, 0x10, 0x02, 0x40, 0x22, 0x00, 0x48,
  0x02, 0x80, 0x0A, 0x00, 0x50, 0x01, 0x40, 0x0A, 0x00, 0x18, 0x01, 0x40,
  0x03, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x40, 0x03, 0x20, 0x02, 0x20,
  0x04, 0x10, 0x04, 0x10, 0x08, 0x08, 0x08, 0x08, 0x10, 0x04, 0x10, 0x04,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10,
  0x08, 0x10, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x80, 0x01, 0x80,
  0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10,
  0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x7F, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0xFF, 0xFC, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08,
  0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x60, 0x02, 0x40,
  0x02, 0xC0, 0x01, 0xFF, 0xFC, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC4,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x03, 0xF1,
  0xC1, 0x60, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x5C,
  0x09, 0x3F, 0x10, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x8F, 0xE2, 0xC0, 0xCA, 0x01, 0x30, 0x02,
  0xC0, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0xC0, 0x12, 0xC0,
  0x89, 0xFC, 0x00, 0x0F, 0xF1, 0x80, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x0F, 0xE4,
  0xC0, 0xD2, 0x01, 0x50, 0x03, 0x40, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00,
  0xD0, 0x03, 0x60, 0x14, 0xC0, 0xD1, 0xFC, 0x40, 0x0F, 0xC0, 0x81, 0x08,
  0x04, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x43, 0xFC, 0x01, 0x80, 0xCC, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x1F, 0xE0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0F, 0xE4, 0xC0, 0x52, 0x00, 0xD0,
  0x03, 0x40, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0xD0, 0x03, 0x60, 0x14,
  0xC0, 0xD1, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x0A, 0x00, 0x47, 0x0E, 0x01, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x8F, 0xC5, 0x81, 0x28,
  0x05, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0xB0, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x08, 0x30,
  0x00, 0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0A, 0x4C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x68, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x60, 0x84, 0x08,
  0x80, 0x98, 0x0A, 0x40, 0xA4, 0x0C, 0x20, 0x81, 0x08, 0x10, 0x80, 0x88,
  0x0C, 0x80, 0x48, 0x02, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xE0, 0x9F, 0x87,
  0xF2, 0x81, 0x30, 0x6C, 0x02, 0x80, 0xB0, 0x0C, 0x02, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00,
  0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80,
  0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18,
  0x02, 0x00, 0x40, 0x8F, 0xC5, 0x81, 0x28, 0x05, 0x80, 0x28, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x0F, 0xE0,
  0xC0, 0x42, 0x00, 0x90, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00,
  0x50, 0x02, 0x20, 0x08, 0xC0, 0x40, 0xFE, 0x00, 0x8F, 0xE2, 0x40, 0xCA,
  0x01, 0xB0, 0x02, 0xC0, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xB0, 0x02,
  0xA0, 0x12, 0xC0, 0xC8, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC4, 0xC0, 0xD2,
  0x01, 0x50, 0x03, 0x40, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xD0, 0x03,
  0x60, 0x14, 0xC0, 0x91, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x9F, 0xD0, 0x28, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1F, 0xE2, 0x01, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x38, 0x02, 0x7F, 0xC0, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x07, 0xFC, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0xC0, 0x34, 0x05, 0x3F, 0x90, 0x80, 0x0D, 0x00, 0x24, 0x00,
  0x90, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x00, 0x84, 0x02, 0x10, 0x08, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x10, 0x05, 0x00, 0x40, 0x14, 0x02,
  0x80, 0x90, 0x0A, 0x02, 0x20, 0x28, 0x08, 0x81, 0x20, 0x22, 0x04, 0x41,
  0x08, 0x11, 0x04, 0x10, 0x84, 0x10, 0x42, 0x08, 0x41, 0x08, 0x22, 0x02,
  0x20, 0x88, 0x09, 0x02, 0x20, 0x24, 0x04, 0x80, 0x90, 0x14, 0x01, 0x80,
  0x50, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x1A,
  0x00, 0x88, 0x08, 0x40, 0x41, 0x04, 0x04, 0x40, 0x22, 0x00, 0xA0, 0x07,
  0x00, 0x10, 0x01, 0x40, 0x1A, 0x00, 0x88, 0x08, 0x20, 0x41, 0x04, 0x04,
  0x40, 0x32, 0x00, 0xA0, 0x02, 0x80, 0x05, 0x00, 0x24, 0x00, 0x90, 0x02,
  0x20, 0x10, 0x80, 0x42, 0x01, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x84,
  0x02, 0x10, 0x08, 0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x09, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xE0, 0x00,
  0xC1, 0xC0, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x81, 0xC0, 0xF0, 0x04, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0E, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x07, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x03, 0x83, 0x00,
  0x7E, 0x03, 0x03, 0x0A, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 6, 10, 11, 3, -26 },
  { 16, 18, 26, 20, 1, -26 },
  { 75, 13, 29, 18, 2, -27 },
  { 123, 22, 26, 26, 2, -26 },
  { 195, 18, 26, 21, 2, -26 },
  { 254, 1, 10, 6, 3, -26 },
  { 256, 6, 32, 9, 2, -26 },
  { 280, 7, 32, 9, 1, -26 },
  { 308, 13, 12, 17, 2, -27 },
  { 328, 15, 17, 18, 2, -21 },
  { 360, 3, 9, 6, 1, -4 },
  { 364, 9, 1, 11, 1, -10 },
  { 366, 2, 2, 7, 3, -2 },
  { 367, 10, 26, 12, 1, -26 },
  { 400, 14, 26, 18, 2, -26 },
  { 446, 7, 26, 18, 3, -26 },
  { 469, 14, 26, 18, 2, -26 },
  { 515, 14, 26, 18, 2, -26 },
  { 561, 17, 26, 18, 1, -26 },
  { 617, 14, 26, 18, 2, -26 },
  { 663, 14, 26, 18, 2, -26 },
  { 709, 14, 26, 18, 2, -26 },
  { 755, 14, 26, 18, 2, -26 },
  { 801, 14, 26, 18, 2, -26 },
  { 847, 2, 19, 7, 3, -19 },
  { 852, 4, 24, 7, 1, -19 },
  { 864, 15, 16, 18, 2, -21 },
  { 894, 15, 9, 18, 2, -17 },
  { 911, 15, 16, 18, 2, -21 },
  { 941, 11, 26, 13, 1, -26 },
  { 977, 24, 29, 28, 2, -26 },
  { 1064, 18, 26, 18, 0, -26 },
  { 1123, 15, 26, 20, 3, -26 },
  { 1172, 16, 26, 19, 2, -26 },
  { 1224, 17, 26, 22, 3, -26 },
  { 1280, 13, 26, 18, 3, -26 },
  { 1323, 13, 26, 16, 3, -26 },
  { 1366, 19, 26, 23, 2, -26 },
  { 1428, 16, 26, 23, 3, -26 },
  { 1480, 5, 26, 9, 2, -26 },
  { 1497, 7, 32, 8, -3, -26 },
  { 1525, 15, 26, 18, 3, -26 },
  { 1574, 12, 26, 16, 3, -26 },
  { 1613, 21, 26, 28, 3, -26 },
  { 1682, 16, 26, 23, 3, -26 },
  { 1734, 20, 26, 24, 2, -26 },
  { 1799, 14, 26, 18, 3, -26 },
  { 1845, 20, 32, 24, 2, -26 },
  { 1925, 15, 26, 19, 3, -26 },
  { 1974, 14, 26, 18, 2, -26 },
  { 2020, 16, 26, 16, 0, -26 },
  { 2072, 17, 26, 23, 3, -26 },
  { 2128, 18, 26, 18, 0, -26 },
  { 2187, 27, 26, 28, 1, -26 },
  { 2275, 16, 26, 16, 0, -26 },
  { 2327, 16, 26, 16, 0, -26 },
  { 2379, 15, 26, 17, 1, -26 },
  { 2428, 7, 32, 11, 3, -26 },
  { 2456, 10, 26, 12, 1, -26 },
  { 2489, 7, 32, 11, 1, -26 },
  { 2517, 16, 15, 18, 1, -26 },
  { 2547, 14, 1, 14, 0, 3 },
  { 2549, 6, 6, 9, 1, -28 },
  { 2554, 12, 19, 16, 2, -19 },
  { 2583, 14, 27, 19, 3, -27 },
  { 2631, 12, 19, 15, 2, -19 },
  { 2660, 14, 27, 19, 2, -27 },
  { 2708, 13, 19, 17, 2, -19 },
  { 2739, 11, 28, 9, 0, -28 },
  { 2778, 14, 28, 19, 2, -19 },
  { 2827, 13, 27, 18, 3, -27 },
  { 2871, 2, 26, 7, 3, -26 },
  { 2878, 6, 35, 7, -1, -26 },
  { 2905, 12, 27, 15, 3, -27 },
  { 2946, 1, 27, 7, 3, -27 },
  { 2950, 22, 19, 27, 3, -19 },
  { 3003, 13, 19, 18, 3, -19 },
  { 3034, 14, 19, 18, 2, -19 },
  { 3068, 14, 27, 19, 3, -19 },
  { 3116, 14, 27, 19, 2, -19 },
  { 3164, 9, 19, 12, 3, -19 },
  { 3186, 12, 19, 15, 1, -19 },
  { 3215, 9, 24, 10, 0, -24 },
  { 3242, 12, 19, 18, 3, -19 },
  { 3271, 14, 19, 14, 0, -19 },
  { 3305, 22, 19, 22, 0, -19 },
  { 3358, 13, 19, 15, 1, -19 },
  { 3389, 14, 28, 14, 0, -19 },
  { 3438, 12, 19, 14, 1, -19 },
  { 3467, 10, 32, 12, 1, -26 },
  { 3507, 1, 36, 17, 8, -27 },
  { 3512, 10, 32, 12, 1, -26 },
  { 3552, 15, 3, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_Thin36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_THIN36PT7B_H_
