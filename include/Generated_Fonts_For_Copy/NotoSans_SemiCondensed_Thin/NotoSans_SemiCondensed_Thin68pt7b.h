#ifndef _NOTOSANS_SEMICONDENSED_THIN68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin68pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x06,
  0xFF, 0x70, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x40, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3C, 0x60, 0xF8,
  0x38, 0x30, 0x0C, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x02, 0x00, 0x60,
  0x01, 0x00, 0x30, 0x00, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0,
  0x60, 0x00, 0x38, 0x30, 0x00, 0x0F, 0x18, 0x00, 0x01, 0xEC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xCF, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x03,
  0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x19, 0x00, 0x30, 0x38, 0xF8, 0x18, 0x78, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0x80, 0x0F, 0x3C, 0x00, 0x01, 0x80, 0x06, 0x07, 0x00, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x06, 0x00, 0x04, 0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x03, 0x01, 0x80, 0x00,
  0x40, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x00,
  0x60, 0x60, 0x3C, 0x0C, 0x00, 0x30, 0x60, 0xFF, 0x86, 0x00, 0x18, 0x30,
  0xE0, 0xE3, 0x00, 0x0C, 0x30, 0x60, 0x30, 0x80, 0x0C, 0x18, 0x60, 0x0C,
  0x60, 0x06, 0x18, 0x20, 0x06, 0x30, 0x03, 0x0C, 0x30, 0x01, 0x8C, 0x03,
  0x0C, 0x18, 0x00, 0xC7, 0x03, 0x06, 0x0C, 0x00, 0x61, 0xFF, 0x82, 0x04,
  0x00, 0x10, 0x3F, 0x03, 0x06, 0x00, 0x08, 0x00, 0x01, 0x03, 0x00, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x01, 0x00, 0x01, 0x80, 0x30, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x80,
  0x00, 0x38, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x06, 0x30, 0x01, 0xC0, 0x01, 0x9C, 0x00, 0x30, 0x00, 0x66, 0x00, 0x06,
  0x00, 0x13, 0x00, 0x00, 0xC0, 0x0C, 0xC0, 0x00, 0x18, 0x03, 0x30, 0x00,
  0x07, 0x00, 0x88, 0x00, 0x00, 0xE0, 0x62, 0x00, 0x00, 0x18, 0x18, 0x80,
  0x00, 0x03, 0x0C, 0x20, 0x00, 0x00, 0x63, 0x08, 0x00, 0x00, 0x0D, 0x82,
  0x00, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x0D, 0x81, 0x80, 0x00, 0x06, 0x30, 0x30, 0x00, 0x03,
  0x06, 0x0E, 0x00, 0x01, 0x81, 0xC1, 0xC0, 0x01, 0xC0, 0x30, 0x3E, 0x03,
  0xE0, 0x06, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x18, 0x01,
  0xF0, 0x18, 0x0F, 0x3C, 0x18, 0x3C, 0x07, 0x99, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x42, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x18, 0xC6, 0x31, 0x9C, 0xC6, 0x31, 0x98, 0xC6, 0x23, 0x18, 0x80,
  0xFF, 0xFF, 0x6F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x3B, 0x01, 0xCC, 0x0E,
  0x30, 0xE0, 0xC7, 0x03, 0x38, 0x0F, 0x80, 0x34, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x01, 0xFF, 0x80, 0x01, 0xFD, 0xF8, 0x01, 0xE0,
  0x07, 0x01, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x31, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x0F, 0xC0, 0x04, 0x0F,
  0xFF, 0x01, 0x87, 0x80, 0x78, 0x31, 0xC0, 0x03, 0x86, 0x60, 0x00, 0x18,
  0xD8, 0x00, 0x03, 0x1A, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x02, 0x70, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x7E, 0x00, 0x1C, 0x00, 0xF0, 0x06, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x03, 0x63, 0x00, 0x00,
  0xEC, 0x30, 0x00, 0x39, 0x83, 0x80, 0x1E, 0x30, 0x3F, 0x3F, 0x06, 0x01,
  0xFF, 0x80, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x80, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x6F, 0xF6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x6F, 0xFF, 0x1C, 0xF3, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x0C,
  0x30, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x07, 0xF7, 0xF0, 0xE0, 0x03, 0x88, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0xC6, 0x00, 0x07, 0x81, 0xE0, 0x06, 0x60, 0x00, 0xE0, 0x03, 0x00,
  0x1B, 0x00, 0x06, 0x00, 0x10, 0x00, 0xD8, 0x00, 0x60, 0x00, 0x80, 0x07,
  0x80, 0x06, 0x00, 0x04, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x20, 0x01, 0xE0,
  0x03, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x18, 0x00, 0x78, 0x00,
  0x80, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x18, 0x00, 0x78, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x16, 0x00, 0x20, 0x00, 0x50, 0x01,
  0xB0, 0x01, 0x80, 0x02, 0x80, 0x0D, 0x80, 0x0C, 0x00, 0x34, 0x00, 0xCC,
  0x00, 0x30, 0x03, 0x30, 0x06, 0x20, 0x01, 0xC0, 0x31, 0x80, 0x61, 0x80,
  0x07, 0x07, 0x87, 0x0E, 0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x60, 0x00,
  0x08, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x20, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0xFC, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x01, 0xFC, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x3E,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x20,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x07, 0xE0, 0x06, 0x00, 0x00,
  0xF0, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1F, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF6, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x7C, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0xA0, 0x39, 0xFF,
  0x87, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x0C,
  0x66, 0x00, 0x00, 0xCC, 0x30, 0x00, 0x0D, 0xC3, 0x00, 0x00, 0xD8, 0x18,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xD8, 0x00, 0x00, 0x00, 0x0F, 0xD8, 0x00, 0x00, 0x00, 0x1B, 0xD8, 0x00,
  0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00, 0x00, 0x13, 0xCC, 0x00, 0x00, 0x00,
  0x33, 0xC4, 0x00, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00, 0x00, 0x63, 0xC6,
  0x00, 0x00, 0x00, 0x63, 0xC3, 0x00, 0x00, 0x00, 0x63, 0xC3, 0x00, 0x00,
  0x00, 0xC3, 0xC3, 0x00, 0x00, 0x00, 0xC3, 0xC1, 0x80, 0x00, 0x00, 0xC3,
  0xC1, 0x80, 0x00, 0x01, 0x83, 0xC0, 0x80, 0x00, 0x01, 0x83, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0xC0, 0x60, 0x00, 0x03,
  0x03, 0xC0, 0x60, 0x00, 0x06, 0x03, 0xC0, 0x60, 0x00, 0x06, 0x03, 0xC0,
  0x30, 0x00, 0x06, 0x03, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0xC0, 0x18, 0x00, 0x08, 0x03, 0xC0, 0x18, 0x00, 0x18, 0x03,
  0xC0, 0x0C, 0x00, 0x18, 0x03, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x40, 0x03, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0xC0, 0x01, 0x81, 0x80, 0x03, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0xC0, 0x00,
  0x62, 0x00, 0x03, 0xC0, 0x00, 0x66, 0x00, 0x03, 0xC0, 0x00, 0x26, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x00, 0xF3,
  0x00, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x3C, 0x30,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0F, 0x03, 0x00,
  0x00, 0x3C, 0x0C, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x00, 0xC0, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xF0, 0x06, 0x00, 0x03,
  0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x60, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0xF0, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x60, 0x0F, 0x00, 0x01,
  0x80, 0x3C, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x18,
  0x0F, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x01, 0x83,
  0xC0, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0x63, 0xC0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x03, 0x3C, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x30,
  0x00, 0xFC, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x78, 0x30, 0x0F, 0xF8, 0x1F, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0B, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0x00, 0x0F, 0xC0, 0x60, 0x00, 0x1E, 0x0C,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x41, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x07, 0xF0,
  0x07, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x06, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x02, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x04, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x01, 0x80, 0x04, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x02, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x10, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x41, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x16, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0x07, 0x80, 0xE0, 0x01, 0x81, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFC, 0x07, 0xFC,
  0x18, 0x3C, 0x00, 0x30, 0xE0, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0B, 0x60, 0x00, 0x36, 0xE0, 0x00, 0xCC, 0xE0, 0x03, 0x18, 0xE0,
  0x1C, 0x30, 0xFF, 0xF0, 0x60, 0x1F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x80, 0xFF, 0xE0, 0x20, 0xF0, 0x3C, 0x08, 0x60, 0x01, 0x82, 0x30, 0x00,
  0x30, 0x98, 0x00, 0x06, 0x2C, 0x00, 0x00, 0xCB, 0x00, 0x00, 0x32, 0x80,
  0x00, 0x04, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x28, 0x00,
  0x00, 0xCB, 0x00, 0x00, 0x62, 0x60, 0x00, 0x38, 0x98, 0x00, 0x1C, 0x23,
  0x80, 0x0E, 0x08, 0x78, 0x0F, 0x02, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0x01, 0xC0, 0xE0, 0x01,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x40, 0xF8, 0x07, 0x00, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x10, 0x03, 0x00, 0xFF, 0xE0, 0xC0, 0xF0, 0x3C, 0x30, 0x70, 0x01, 0x8C,
  0x30, 0x00, 0x33, 0x18, 0x00, 0x06, 0xC6, 0x00, 0x00, 0xF3, 0x00, 0x00,
  0x3C, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x74, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x34, 0x60, 0x00, 0x19, 0x1C, 0x00,
  0x0C, 0x43, 0x80, 0x06, 0x10, 0x78, 0x07, 0x04, 0x07, 0xFF, 0x81, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x78, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0x80, 0x80, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8,
  0x30, 0x3C, 0x07, 0x8C, 0x1C, 0x00, 0x73, 0x0C, 0x00, 0x0E, 0xC6, 0x00,
  0x01, 0xB3, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x73, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x0B, 0x18, 0x00, 0x06, 0xC7, 0x00, 0x03, 0x30, 0xE0, 0x01, 0x8C,
  0x1E, 0x03, 0xC3, 0x01, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x10, 0x00, 0x03,
  0x87, 0x80, 0x01, 0xC0, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x1E, 0x00, 0x81,
  0xFF, 0xC0, 0x83, 0xC0, 0xF0, 0x8E, 0x00, 0x38, 0x8C, 0x00, 0x1C, 0x98,
  0x00, 0x0C, 0xB0, 0x00, 0x06, 0xA0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xEE,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC6, 0x78, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x3A, 0x00, 0x01, 0x88, 0x00, 0x0E, 0x20, 0x00,
  0x30, 0x80, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x03, 0x80,
  0x80, 0x0C, 0x02, 0x00, 0x60, 0x08, 0x03, 0x00, 0x20, 0x18, 0x00, 0x80,
  0xE0, 0x02, 0x03, 0x00, 0x08, 0x18, 0x00, 0x20, 0xE0, 0x00, 0x86, 0xC0,
  0x02, 0x33, 0x00, 0x08, 0xC6, 0x00, 0x26, 0x1C, 0x00, 0xB0, 0x30, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x80, 0x06, 0x02, 0x00,
  0x18, 0x08, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x01, 0x82, 0x00, 0x03,
  0x08, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0xA0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x40, 0xFF, 0x80, 0x1F, 0xF8, 0x21, 0xE0,
  0xE0, 0x3C, 0x1E, 0x11, 0x80, 0x18, 0x38, 0x03, 0x89, 0x80, 0x06, 0x38,
  0x00, 0x64, 0x80, 0x01, 0x98, 0x00, 0x32, 0x80, 0x00, 0xD8, 0x00, 0x0D,
  0xC0, 0x00, 0x28, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xB0, 0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x1E,
  0x00, 0x81, 0xFF, 0xC0, 0x83, 0xC0, 0xF0, 0x86, 0x00, 0x38, 0x8C, 0x00,
  0x1C, 0x98, 0x00, 0x0C, 0xB0, 0x00, 0x06, 0xA0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x20, 0x3F, 0xF8, 0x08, 0x3C, 0x0F, 0x02, 0x1C, 0x00, 0x60, 0x8C,
  0x00, 0x0C, 0x26, 0x00, 0x01, 0x89, 0x80, 0x00, 0x32, 0xC0, 0x00, 0x0C,
  0xA0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xA8, 0x00, 0x00, 0xCB,
  0x00, 0x00, 0x32, 0xC0, 0x00, 0x18, 0x98, 0x00, 0x06, 0x23, 0x00, 0x03,
  0x08, 0xE0, 0x03, 0x82, 0x0E, 0x03, 0xC0, 0x81, 0xFF, 0xC0, 0x20, 0x07,
  0x80, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x30, 0x3C, 0x0F,
  0x0C, 0x1C, 0x00, 0x63, 0x0C, 0x00, 0x0C, 0xC6, 0x00, 0x01, 0xB3, 0x80,
  0x00, 0x2C, 0xC0, 0x00, 0x0F, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x1B, 0x38,
  0x00, 0x06, 0xC7, 0x00, 0x03, 0x30, 0xE0, 0x03, 0x8C, 0x1E, 0x03, 0xC3,
  0x01, 0xFF, 0xC0, 0xC0, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x81, 0xFF, 0x87, 0xC6,
  0x8E, 0x00, 0x8C, 0x00, 0x98, 0x00, 0xB0, 0x00, 0xA0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0x80, 0xF0, 0x1F, 0x86, 0x00, 0x04, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x3E, 0x00, 0xF0, 0x3F,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x81, 0x01, 0xFF, 0x00,
  0x3C, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x40, 0x00, 0x05, 0x60, 0x00, 0x0D, 0x60, 0x00, 0x09, 0x30, 0x00,
  0x19, 0x30, 0x00, 0x31, 0x1C, 0x00, 0x61, 0x0F, 0x03, 0xC1, 0x07, 0xFF,
  0x81, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x80, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x00,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x10, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x40,
  0x00, 0x1C, 0x00, 0x03, 0x60, 0x00, 0x14, 0x00, 0x03, 0x60, 0x00, 0x16,
  0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x06, 0x20, 0x00, 0x36, 0x00, 0x06,
  0x30, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x00, 0x0C, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x0C,
  0x00, 0x80, 0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x04, 0x01, 0x80, 0x40, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60, 0x02, 0x02,
  0x00, 0x20, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00,
  0x08, 0x80, 0x00, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80,
  0x00, 0xD0, 0x00, 0x0D, 0x80, 0x00, 0x50, 0x00, 0x05, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x38,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x02,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x08, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x40, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0x70, 0x0E, 0x00, 0x3C, 0x00, 0x3C, 0x06,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Thin68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 49, 14, 5, -49 },
  { 26, 11, 18, 21, 5, -49 },
  { 51, 35, 49, 38, 2, -49 },
  { 266, 25, 56, 34, 4, -52 },
  { 441, 41, 50, 48, 4, -49 },
  { 698, 34, 50, 40, 4, -49 },
  { 911, 2, 18, 11, 5, -49 },
  { 916, 12, 60, 18, 3, -49 },
  { 1006, 11, 60, 18, 3, -49 },
  { 1089, 24, 24, 32, 4, -52 },
  { 1161, 28, 32, 34, 3, -40 },
  { 1273, 5, 17, 12, 3, -8 },
  { 1284, 16, 1, 20, 2, -19 },
  { 1286, 4, 4, 14, 5, -4 },
  { 1288, 20, 49, 22, 1, -49 },
  { 1411, 26, 50, 34, 4, -49 },
  { 1574, 14, 49, 34, 6, -49 },
  { 1660, 26, 49, 34, 4, -49 },
  { 1820, 27, 50, 34, 3, -49 },
  { 1989, 33, 49, 34, 1, -49 },
  { 2192, 26, 50, 34, 4, -49 },
  { 2355, 27, 50, 34, 4, -49 },
  { 2524, 26, 49, 34, 4, -49 },
  { 2684, 27, 50, 34, 4, -49 },
  { 2853, 27, 50, 34, 3, -49 },
  { 3022, 4, 36, 14, 5, -36 },
  { 3040, 6, 45, 14, 3, -36 },
  { 3074, 28, 29, 34, 3, -39 },
  { 3176, 28, 16, 34, 3, -32 },
  { 3232, 28, 29, 34, 3, -39 },
  { 3334, 20, 49, 24, 2, -49 },
  { 3457, 45, 55, 53, 4, -48 },
  { 3767, 34, 49, 34, 0, -49 },
  { 3976, 28, 49, 37, 6, -49 },
  { 4148, 31, 50, 37, 4, -49 },
  { 4342, 31, 49, 42, 6, -49 },
  { 4532, 23, 49, 33, 6, -49 },
  { 4673, 23, 49, 30, 6, -49 },
  { 4814, 35, 50, 44, 4, -49 },
  { 5033, 30, 49, 43, 6, -49 },
  { 5217, 10, 49, 18, 4, -49 },
  { 5279, 13, 61, 15, -5, -49 },
  { 5379, 28, 49, 33, 6, -49 },
  { 5551, 23, 49, 30, 6, -49 },
  { 5692, 40, 49, 52, 6, -49 },
  { 5937, 30, 49, 43, 6, -49 },
  { 6121, 37, 50, 45, 4, -49 },
  { 6353, 25, 49, 35, 6, -49 },
  { 6507, 37, 61, 45, 4, -49 },
  { 6790, 27, 49, 35, 6, -49 },
  { 6956, 27, 50, 33, 3, -49 },
  { 7125, 30, 49, 30, 0, -49 },
  { 7309, 31, 50, 43, 6, -49 },
  { 7503, 33, 49, 33, 0, -49 },
  { 7706, 50, 49, 54, 2, -49 },
  { 8013, 30, 49, 30, 0, -49 },
  { 8197, 30, 49, 30, 0, -49 },
  { 8381, 29, 49, 33, 2, -49 },
  { 8559, 13, 60, 21, 6, -49 },
  { 8657, 20, 49, 22, 1, -49 },
  { 8780, 13, 60, 21, 2, -49 },
  { 8878, 30, 28, 34, 2, -49 },
  { 8983, 27, 2, 27, 0, 6 },
  { 8990, 11, 11, 16, 3, -52 },
  { 9006, 23, 38, 31, 3, -37 },
  { 9116, 26, 53, 36, 6, -52 },
  { 9289, 22, 38, 28, 4, -37 },
  { 9394, 26, 53, 36, 4, -52 },
  { 9567, 25, 38, 33, 4, -37 },
  { 9686, 19, 52, 17, 1, -52 },
  { 9810, 26, 53, 36, 4, -37 },
  { 9983, 24, 52, 35, 6, -52 },
  { 10139, 4, 49, 13, 5, -49 },
  { 10164, 11, 65, 13, -2, -49 },
  { 10254, 22, 52, 28, 6, -52 },
  { 10397, 1, 52, 13, 6, -52 },
  { 10404, 41, 37, 52, 6, -37 },
  { 10594, 24, 37, 35, 6, -37 },
  { 10705, 27, 38, 35, 4, -37 },
  { 10834, 26, 53, 36, 6, -37 },
  { 11007, 26, 53, 36, 4, -37 },
  { 11180, 16, 36, 23, 6, -36 },
  { 11252, 22, 38, 27, 3, -37 },
  { 11357, 16, 46, 19, 1, -45 },
  { 11449, 24, 37, 35, 5, -36 },
  { 11560, 26, 36, 26, 0, -36 },
  { 11677, 40, 36, 42, 1, -36 },
  { 11857, 25, 36, 28, 2, -36 },
  { 11970, 26, 53, 26, 0, -36 },
  { 12143, 21, 36, 26, 3, -36 },
  { 12238, 18, 60, 23, 2, -49 },
  { 12373, 2, 69, 32, 15, -52 },
  { 12391, 18, 60, 23, 3, -49 },
  { 12526, 28, 6, 34, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_Thin68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_THIN68PT7B_H_
