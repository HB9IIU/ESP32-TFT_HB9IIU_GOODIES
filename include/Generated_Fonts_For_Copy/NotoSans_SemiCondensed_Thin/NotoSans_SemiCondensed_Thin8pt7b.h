#ifndef _NOTOSANS_SEMICONDENSED_THIN8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0x55, 0xF6, 0xF6, 0x7B, 0x37, 0xC0, 0xCD, 0xAB, 0xB3,
  0xAC, 0x63, 0x19, 0x59, 0x7C, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0x5D, 0x80,
  0x22, 0xF2, 0xC0, 0xC0, 0x00, 0x55, 0xA0, 0x69, 0x99, 0x96, 0xFC, 0x61,
  0x12, 0x4F, 0xE1, 0x25, 0x1F, 0x22, 0x6A, 0xF2, 0xD3, 0x13, 0xC0, 0x78,
  0xE9, 0x97, 0xF1, 0x22, 0x44, 0x69, 0x66, 0x9F, 0x69, 0x96, 0x16, 0x00,
  0x18, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0xC4, 0xA4, 0x00, 0x39, 0x1B, 0xF3,
  0xB6, 0x27, 0x00, 0x42, 0x6F, 0x99, 0xD7, 0xDB, 0xC0, 0x78, 0x88, 0x87,
  0xD6, 0xDB, 0xC0, 0xEE, 0xB0, 0xEB, 0xA0, 0x7C, 0x21, 0x38, 0xBC, 0xB7,
  0xDB, 0x40, 0xD5, 0x70, 0x55, 0x5C, 0xBA, 0x4D, 0x40, 0xAA, 0xB0, 0x99,
  0x9B, 0xFD, 0xB6, 0xFB, 0x40, 0x74, 0x63, 0x18, 0xB8, 0xD6, 0xE9, 0x00,
  0x74, 0x63, 0x18, 0xB8, 0x40, 0xD6, 0xED, 0x40, 0x78, 0xC2, 0x1F, 0xF4,
  0x44, 0x44, 0xB6, 0xDB, 0xC0, 0x99, 0x96, 0x64, 0x96, 0x5B, 0x55, 0x49,
  0x20, 0x9A, 0x44, 0xA9, 0xB5, 0x24, 0x80, 0xF2, 0x24, 0x4F, 0xFE, 0xA5,
  0x50, 0xD5, 0x5C, 0x26, 0x99, 0xE0, 0xC0, 0x6E, 0xF0, 0x9A, 0xDB, 0xC0,
  0xF2, 0x70, 0x17, 0x99, 0x9F, 0xFE, 0x70, 0xFA, 0xA0, 0xF9, 0x9F, 0x1E,
  0xAF, 0xF0, 0xBC, 0xBF, 0xAE, 0xB0, 0xFC, 0xFB, 0xBB, 0xFF, 0xF9, 0x9F,
  0xF6, 0xF9, 0x00, 0xF9, 0x9F, 0x11, 0xEA, 0xF8, 0xF0, 0xEA, 0xC0, 0xFF,
  0xB5, 0x20, 0xAD, 0x74, 0xA0, 0xA9, 0x50, 0xB5, 0x25, 0x00, 0xE9, 0x70,
  0x57, 0x54, 0xFF, 0x95, 0x5C, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Thin8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 4, 6, 5, 0, -6 },
  { 6, 3, 6, 4, 0, -6 },
  { 9, 5, 6, 6, 0, -6 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 1, 2, 1, 0, -6 },
  { 18, 2, 7, 2, 0, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 3, 3, 4, 0, -6 },
  { 24, 4, 4, 4, 0, -5 },
  { 26, 1, 2, 1, 0, -1 },
  { 27, 2, 1, 2, 0, -3 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 2, 6, 3, 0, -6 },
  { 31, 4, 6, 4, 0, -6 },
  { 34, 1, 6, 4, 1, -6 },
  { 35, 4, 6, 4, 0, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 3, 6, 4, 1, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 1, 4, 2, 0, -4 },
  { 60, 1, 5, 2, 0, -4 },
  { 61, 4, 4, 4, 0, -5 },
  { 63, 4, 2, 4, 0, -4 },
  { 64, 4, 4, 4, 0, -5 },
  { 66, 3, 6, 3, 0, -6 },
  { 69, 6, 7, 6, 0, -6 },
  { 75, 4, 6, 4, 0, -6 },
  { 78, 3, 6, 4, 1, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 3, 6, 5, 1, -6 },
  { 87, 2, 6, 4, 1, -6 },
  { 89, 2, 6, 4, 1, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 3, 6, 5, 1, -6 },
  { 98, 2, 6, 2, 0, -6 },
  { 100, 2, 7, 2, -1, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 2, 6, 4, 1, -6 },
  { 107, 4, 6, 6, 1, -6 },
  { 110, 3, 6, 5, 1, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 3, 6, 4, 1, -6 },
  { 120, 5, 7, 5, 0, -6 },
  { 125, 3, 6, 4, 1, -6 },
  { 128, 4, 6, 4, 0, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 3, 6, 5, 1, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 6, 6, 6, 0, -6 },
  { 145, 4, 6, 4, 0, -6 },
  { 148, 3, 6, 3, 0, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 1, 7, 2, 1, -6 },
  { 155, 2, 6, 3, 0, -6 },
  { 157, 2, 7, 2, 0, -6 },
  { 159, 4, 4, 4, 0, -6 },
  { 161, 3, 1, 3, 0, 0 },
  { 162, 2, 1, 2, 0, -6 },
  { 163, 3, 4, 4, 0, -4 },
  { 165, 3, 6, 4, 1, -6 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 4, 6, 4, 0, -6 },
  { 173, 3, 4, 4, 0, -4 },
  { 175, 2, 6, 2, 0, -6 },
  { 177, 4, 6, 4, 0, -4 },
  { 180, 2, 6, 4, 1, -6 },
  { 182, 1, 6, 2, 0, -6 },
  { 183, 1, 8, 2, 0, -6 },
  { 184, 2, 6, 3, 1, -6 },
  { 186, 1, 6, 2, 0, -6 },
  { 187, 4, 4, 6, 1, -4 },
  { 189, 2, 4, 4, 1, -4 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 3, 6, 4, 1, -4 },
  { 195, 4, 6, 4, 0, -4 },
  { 198, 2, 4, 3, 1, -4 },
  { 199, 3, 4, 3, 0, -4 },
  { 201, 2, 5, 2, 0, -5 },
  { 203, 2, 4, 4, 1, -4 },
  { 204, 3, 4, 3, 0, -4 },
  { 206, 5, 4, 5, 0, -4 },
  { 209, 3, 4, 3, 0, -4 },
  { 211, 3, 6, 3, 0, -4 },
  { 214, 3, 4, 3, 0, -4 },
  { 216, 2, 7, 3, 0, -6 },
  { 218, 1, 8, 4, 1, -6 },
  { 219, 2, 7, 3, 0, -6 },
  { 221, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Thin8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_THIN8PT7B_H_
