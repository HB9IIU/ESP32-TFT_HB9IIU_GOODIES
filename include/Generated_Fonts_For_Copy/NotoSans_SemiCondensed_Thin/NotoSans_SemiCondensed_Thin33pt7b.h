#ifndef _NOTOSANS_SEMICONDENSED_THIN33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xC3, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x02,
  0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40,
  0x10, 0x20, 0x08, 0x10, 0x7F, 0xFF, 0x82, 0x08, 0x01, 0x04, 0x00, 0x82,
  0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0xFF, 0xEF, 0x04,
  0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x04, 0x00, 0x40, 0x1F, 0xC4, 0x42, 0x84, 0x08, 0x40, 0x84,
  0x08, 0x40, 0x84, 0x08, 0x40, 0x44, 0x03, 0x40, 0x0C, 0x00, 0x70, 0x04,
  0xC0, 0x42, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x2F, 0x5C, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x38, 0x01, 0x04, 0x60, 0x20,
  0x42, 0x02, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x80, 0x81, 0x08,
  0x08, 0x11, 0x00, 0x81, 0x10, 0x08, 0x11, 0x10, 0x81, 0x26, 0xC8, 0x22,
  0x42, 0x42, 0x48, 0x24, 0x64, 0x82, 0x38, 0x88, 0x10, 0x08, 0x81, 0x01,
  0x08, 0x10, 0x10, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20,
  0x40, 0x82, 0x08, 0x04, 0x20, 0x80, 0x7C, 0x07, 0x00, 0x08, 0x60, 0x08,
  0x10, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x80,
  0x10, 0x40, 0x04, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x20, 0x03, 0x08,
  0x09, 0x02, 0x05, 0x00, 0x82, 0x80, 0x42, 0x40, 0x11, 0x20, 0x05, 0x10,
  0x01, 0x88, 0x00, 0xC2, 0x00, 0x91, 0x80, 0x88, 0x3F, 0x03, 0xFF, 0x80,
  0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x81, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0x02, 0x04, 0x81, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x10, 0x42, 0x08, 0xC0, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0xC4, 0x73, 0xF8, 0x04, 0x00, 0xA0, 0x09, 0x01, 0x08, 0x20,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x3F, 0xFF, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x24, 0xA4, 0x94, 0xFF, 0xC0, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x0F, 0x80, 0x82, 0x08, 0x08, 0x80, 0x44, 0x01, 0x20, 0x0A, 0x00, 0x50,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x04, 0x80, 0x24, 0x01, 0x10, 0x10,
  0xC1, 0x01, 0xF0, 0x02, 0x1C, 0x69, 0x14, 0x30, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x1F, 0x06, 0x0C, 0x80, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF,
  0x0F, 0x81, 0x83, 0x10, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x18, 0x1F, 0x00, 0x0E, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0A,
  0x00, 0xCF, 0xF8, 0x00, 0x20, 0x00, 0x40, 0x01, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x22, 0x00, 0x44, 0x01, 0x08, 0x04, 0x10, 0x08, 0x20, 0x20, 0x40,
  0x80, 0x81, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0xFF,
  0xFC, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x3F, 0xE2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x1F, 0xE0, 0x80, 0xC0, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x12,
  0x01, 0x8F, 0xF0, 0x03, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x18, 0x27, 0x31, 0x40, 0x4C, 0x01,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x14,
  0x01, 0x10, 0x08, 0xC0, 0x83, 0xF8, 0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x0F, 0x81, 0x83,
  0x10, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x02, 0x40, 0x21,
  0x82, 0x02, 0x60, 0x0C, 0x01, 0x98, 0x10, 0x31, 0x00, 0xD0, 0x02, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x20, 0x09, 0x80, 0x83, 0xF8,
  0x0F, 0x01, 0x86, 0x10, 0x09, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x02, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x34, 0x02, 0x90, 0x64, 0x7C,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x02, 0x0F, 0xE0, 0xE0, 0x00, 0xC0, 0x24, 0x80, 0x00, 0x00, 0x00, 0x09,
  0x29, 0x25, 0x00, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x00, 0x3E, 0x30, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x40, 0x01, 0xFF, 0x00, 0x18,
  0x03, 0x00, 0x80, 0x02, 0x04, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00,
  0x24, 0x03, 0xC0, 0x90, 0x30, 0x81, 0x81, 0x02, 0x06, 0x04, 0x08, 0x18,
  0x20, 0x20, 0x60, 0x80, 0x81, 0x82, 0x02, 0x06, 0x08, 0x08, 0x18, 0x20,
  0x20, 0x60, 0x80, 0x81, 0x82, 0x06, 0x0A, 0x04, 0x18, 0x28, 0x1F, 0x9F,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08,
  0x40, 0x04, 0x10, 0x02, 0x08, 0x02, 0x04, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x7F, 0xF0, 0x20, 0x08, 0x20, 0x04, 0x10, 0x01, 0x08, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0xFD,
  0x04, 0x07, 0x20, 0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x14, 0x00, 0xA0, 0x19, 0xFF, 0x08, 0x06, 0x40, 0x0A, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00,
  0x9F, 0xF8, 0x01, 0xF8, 0x0C, 0x0C, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xFE,
  0x01, 0x03, 0x82, 0x00, 0xC4, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x90, 0x02, 0x20, 0x18, 0x7F, 0x80, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F,
  0xF8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFF, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x01, 0xFC, 0x03, 0x01, 0xC2, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x12, 0x00, 0x08, 0x80,
  0x04, 0x30, 0x02, 0x07, 0xFE, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x9F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0xCF, 0x00, 0x80, 0x0C, 0x00, 0xA0,
  0x09, 0x00, 0x88, 0x0C, 0x40, 0xC2, 0x04, 0x10, 0x40, 0x84, 0x04, 0x40,
  0x26, 0x01, 0x70, 0x0A, 0x40, 0x63, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04,
  0x04, 0x20, 0x11, 0x00, 0x88, 0x02, 0x40, 0x0A, 0x00, 0x50, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xD0, 0x00, 0x3A, 0x00, 0x0B, 0x40, 0x01, 0x64, 0x00,
  0x2C, 0x80, 0x09, 0x90, 0x01, 0x31, 0x00, 0x26, 0x20, 0x08, 0xC2, 0x01,
  0x18, 0x40, 0x43, 0x08, 0x08, 0x60, 0x81, 0x0C, 0x10, 0x41, 0x82, 0x08,
  0x30, 0x21, 0x06, 0x04, 0x40, 0xC0, 0x48, 0x18, 0x0A, 0x03, 0x01, 0x40,
  0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0D, 0x00,
  0x1A, 0x00, 0x32, 0x00, 0x64, 0x00, 0xC4, 0x01, 0x84, 0x03, 0x08, 0x06,
  0x08, 0x0C, 0x10, 0x18, 0x10, 0x30, 0x10, 0x60, 0x20, 0xC0, 0x21, 0x80,
  0x43, 0x00, 0x46, 0x00, 0x4C, 0x00, 0x98, 0x00, 0xB0, 0x01, 0x60, 0x01,
  0xC0, 0x01, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x20, 0x80, 0x04, 0x20,
  0x01, 0x10, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x20,
  0x01, 0x04, 0x00, 0x80, 0x80, 0x40, 0x1F, 0xE0, 0xFA, 0x08, 0x1C, 0x80,
  0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0xCF, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x03, 0xF0, 0x03, 0x03,
  0x01, 0x00, 0x20, 0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x24, 0x00, 0x0A,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x02, 0x20, 0x01, 0x04, 0x00, 0x80, 0x80, 0x40,
  0x1F, 0xE0, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0xFE, 0x04, 0x0E, 0x20, 0x09, 0x00, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x8F,
  0xF8, 0x41, 0x02, 0x04, 0x10, 0x30, 0x80, 0x84, 0x02, 0x20, 0x11, 0x00,
  0x48, 0x02, 0x40, 0x0A, 0x00, 0x50, 0x01, 0x0F, 0xC3, 0x03, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x80, 0x6F, 0xF8, 0xFF, 0xFC, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x14, 0x00, 0x48, 0x01, 0x8C, 0x06, 0x0F, 0xF0, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x02, 0x20, 0x04,
  0x20, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x10,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x28,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x20, 0x44,
  0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x10, 0x82,
  0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10, 0x08, 0x81,
  0x10, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x09, 0x00, 0xA0, 0x05, 0x00,
  0xA0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x40, 0x04,
  0x80, 0x08, 0x80, 0x21, 0x00, 0x41, 0x01, 0x01, 0x04, 0x02, 0x08, 0x02,
  0x20, 0x04, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x08, 0x00, 0x10, 0x00, 0x50,
  0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x10, 0x40, 0x40, 0x40, 0x80, 0x82,
  0x00, 0x88, 0x01, 0x10, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00, 0x14, 0x00,
  0x90, 0x02, 0x20, 0x10, 0x80, 0x41, 0x01, 0x04, 0x08, 0x08, 0x20, 0x21,
  0x00, 0x44, 0x01, 0x20, 0x02, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x7F, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0xFC, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x01, 0x00, 0x03, 0x00, 0x0A, 0x00,
  0x12, 0x00, 0x44, 0x01, 0x04, 0x02, 0x08, 0x08, 0x08, 0x10, 0x10, 0x40,
  0x20, 0x80, 0x22, 0x00, 0x44, 0x00, 0x50, 0x00, 0xC0, 0xFF, 0xF8, 0xC0,
  0x82, 0x04, 0x0C, 0x0F, 0x03, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x03, 0xF1, 0xC1, 0x20, 0x14, 0x01, 0x40, 0x18, 0x03,
  0x80, 0x34, 0x05, 0x40, 0x53, 0xF9, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0xE0, 0xB0, 0xC7, 0x01, 0x30, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x05, 0x00, 0x28, 0x01, 0x40, 0x0B, 0x00, 0x94, 0x08, 0x9F, 0x80, 0x07,
  0xC3, 0x04, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x03, 0xFC,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x21,
  0xE1, 0x10, 0xC9, 0x01, 0x50, 0x06, 0x80, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0D,
  0x00, 0xA4, 0x0D, 0x1F, 0x88, 0x0F, 0x01, 0x0C, 0x20, 0x24, 0x02, 0x40,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x11, 0xFE, 0x07, 0xC2, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x7C, 0xF0, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x00, 0x0F, 0x80, 0x82, 0x48, 0x0A, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0D, 0x00, 0x68, 0x05, 0x20, 0x68, 0xFC, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x40, 0x61, 0xFC, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x78, 0xB0, 0xD8,
  0x0F, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x70, 0x01,
  0x55, 0x55, 0x55, 0x55, 0x08, 0xC0, 0x00, 0x00, 0x01, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x5C,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0xA0,
  0x48, 0x32, 0x08, 0x84, 0x22, 0x09, 0x02, 0xA0, 0xA8, 0x31, 0x08, 0x42,
  0x08, 0x81, 0x20, 0x48, 0x0A, 0x01, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0x80,
  0x0E, 0x07, 0x0B, 0x19, 0x84, 0xC0, 0x90, 0x28, 0x06, 0x02, 0x80, 0x40,
  0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04,
  0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x0F, 0x16, 0x1B,
  0x01, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0F, 0x80,
  0x82, 0x08, 0x08, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x48, 0x02,
  0x20, 0x20, 0xFE, 0x00, 0x0F, 0x04, 0x86, 0x28, 0x09, 0x80, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x28,
  0x01, 0x40, 0x0B, 0x00, 0x58, 0x04, 0xA0, 0x44, 0xFC, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x0F,
  0x00, 0x86, 0x48, 0x0A, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x68,
  0x05, 0x20, 0x48, 0xFC, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0F, 0xB0, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x0F, 0x86, 0x0D, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x4F,
  0xF0, 0x10, 0x10, 0x10, 0x10, 0x1F, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1A, 0x05, 0x3F, 0x20, 0x80,
  0x14, 0x01, 0x40, 0x14, 0x02, 0x20, 0x22, 0x02, 0x20, 0x41, 0x04, 0x10,
  0x41, 0x08, 0x08, 0x80, 0x88, 0x09, 0x00, 0x50, 0x05, 0x00, 0x60, 0x02,
  0x00, 0xC0, 0x20, 0x14, 0x05, 0x01, 0x40, 0x50, 0x24, 0x05, 0x02, 0x20,
  0x50, 0x22, 0x08, 0x82, 0x20, 0x88, 0x42, 0x08, 0x84, 0x11, 0x08, 0x41,
  0x10, 0x44, 0x11, 0x04, 0x80, 0x90, 0x48, 0x0A, 0x02, 0x80, 0xA0, 0x28,
  0x0A, 0x03, 0x00, 0x40, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x34, 0x04, 0x20,
  0x42, 0x08, 0x10, 0x80, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x09,
  0x01, 0x08, 0x10, 0x82, 0x04, 0x40, 0x44, 0x02, 0x80, 0x10, 0xC0, 0x1A,
  0x00, 0x90, 0x04, 0x40, 0x42, 0x02, 0x10, 0x10, 0x41, 0x02, 0x08, 0x10,
  0x40, 0x44, 0x02, 0x20, 0x11, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0xFF,
  0xC0, 0x01, 0x83, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x83, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xC0, 0x18, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0E, 0x06, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x0F, 0x00,
  0x7C, 0x0C, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_Thin33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 24, 7, 3, -24 },
  { 4, 6, 9, 10, 2, -24 },
  { 11, 17, 24, 19, 1, -24 },
  { 62, 12, 27, 17, 2, -25 },
  { 103, 20, 24, 24, 2, -24 },
  { 163, 17, 24, 19, 2, -24 },
  { 214, 1, 9, 6, 2, -24 },
  { 216, 6, 29, 9, 1, -24 },
  { 238, 6, 29, 9, 1, -24 },
  { 260, 12, 11, 16, 2, -25 },
  { 277, 14, 15, 17, 1, -19 },
  { 304, 3, 8, 6, 1, -4 },
  { 307, 8, 1, 10, 1, -9 },
  { 308, 1, 2, 7, 3, -2 },
  { 309, 9, 24, 11, 1, -24 },
  { 336, 13, 24, 17, 2, -24 },
  { 375, 7, 24, 17, 3, -24 },
  { 396, 12, 24, 17, 2, -24 },
  { 432, 13, 24, 17, 1, -24 },
  { 471, 15, 24, 17, 1, -24 },
  { 516, 13, 24, 17, 2, -24 },
  { 555, 13, 24, 17, 2, -24 },
  { 594, 13, 24, 17, 2, -24 },
  { 633, 13, 24, 17, 2, -24 },
  { 672, 13, 24, 17, 2, -24 },
  { 711, 1, 18, 7, 3, -18 },
  { 714, 3, 22, 7, 1, -18 },
  { 723, 13, 14, 17, 2, -19 },
  { 746, 14, 7, 17, 1, -15 },
  { 759, 13, 14, 17, 2, -19 },
  { 782, 10, 24, 12, 1, -24 },
  { 812, 22, 26, 26, 2, -23 },
  { 884, 17, 24, 17, 0, -24 },
  { 935, 13, 24, 18, 3, -24 },
  { 974, 15, 24, 18, 2, -24 },
  { 1019, 15, 24, 20, 3, -24 },
  { 1064, 11, 24, 16, 3, -24 },
  { 1097, 11, 24, 15, 3, -24 },
  { 1130, 17, 24, 21, 2, -24 },
  { 1181, 15, 24, 21, 3, -24 },
  { 1226, 5, 24, 9, 2, -24 },
  { 1241, 7, 30, 7, -3, -24 },
  { 1268, 13, 24, 16, 3, -24 },
  { 1307, 11, 24, 15, 3, -24 },
  { 1340, 19, 24, 25, 3, -24 },
  { 1397, 15, 24, 21, 3, -24 },
  { 1442, 18, 24, 22, 2, -24 },
  { 1496, 12, 24, 17, 3, -24 },
  { 1532, 18, 30, 22, 2, -24 },
  { 1600, 13, 24, 17, 3, -24 },
  { 1639, 12, 24, 16, 2, -24 },
  { 1675, 14, 24, 15, 0, -24 },
  { 1717, 15, 24, 21, 3, -24 },
  { 1762, 16, 24, 16, 0, -24 },
  { 1810, 24, 24, 26, 1, -24 },
  { 1882, 15, 24, 15, 0, -24 },
  { 1927, 14, 24, 14, 0, -24 },
  { 1969, 14, 24, 16, 1, -24 },
  { 2011, 6, 29, 10, 3, -24 },
  { 2033, 9, 24, 11, 1, -24 },
  { 2060, 6, 29, 10, 1, -24 },
  { 2082, 15, 14, 17, 1, -24 },
  { 2109, 13, 1, 13, 0, 3 },
  { 2111, 6, 5, 8, 1, -25 },
  { 2115, 12, 18, 15, 1, -18 },
  { 2142, 13, 25, 17, 3, -25 },
  { 2183, 11, 18, 14, 2, -18 },
  { 2208, 13, 25, 17, 2, -25 },
  { 2249, 12, 18, 16, 2, -18 },
  { 2276, 10, 25, 8, 0, -25 },
  { 2308, 13, 26, 17, 2, -18 },
  { 2351, 11, 25, 17, 3, -25 },
  { 2386, 2, 24, 6, 2, -24 },
  { 2392, 5, 32, 6, -1, -24 },
  { 2412, 10, 25, 13, 3, -25 },
  { 2444, 1, 25, 6, 3, -25 },
  { 2448, 20, 18, 25, 3, -18 },
  { 2493, 11, 18, 17, 3, -18 },
  { 2518, 13, 18, 17, 2, -18 },
  { 2548, 13, 26, 17, 3, -18 },
  { 2591, 13, 26, 17, 2, -18 },
  { 2634, 8, 18, 11, 3, -18 },
  { 2652, 11, 18, 13, 1, -18 },
  { 2677, 8, 22, 9, 0, -22 },
  { 2699, 11, 17, 17, 3, -17 },
  { 2723, 12, 17, 13, 0, -17 },
  { 2749, 20, 17, 21, 0, -17 },
  { 2792, 12, 17, 14, 1, -17 },
  { 2818, 13, 25, 13, 0, -17 },
  { 2859, 10, 17, 13, 1, -17 },
  { 2881, 9, 29, 11, 1, -24 },
  { 2914, 1, 33, 16, 7, -25 },
  { 2919, 9, 29, 11, 1, -24 },
  { 2952, 13, 3, 17, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_Thin33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_THIN33PT7B_H_
