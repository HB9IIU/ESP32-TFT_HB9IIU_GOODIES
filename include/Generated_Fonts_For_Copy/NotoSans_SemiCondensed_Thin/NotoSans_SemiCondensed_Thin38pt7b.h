#ifndef _NOTOSANS_SEMICONDENSED_THIN38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin38pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x55, 0x55, 0x55, 0x55, 0x00, 0x3C, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x01, 0x81, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00,
  0x10, 0x10, 0x01, 0x02, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x20, 0x20,
  0x7F, 0xFF, 0xF0, 0x20, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04,
  0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x08, 0x0F, 0xFF,
  0xFC, 0x04, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08,
  0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x00,
  0x01, 0x00, 0x04, 0x00, 0x7C, 0x06, 0x4E, 0x61, 0x01, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x40, 0x61, 0x00, 0xC4,
  0x00, 0xD0, 0x00, 0xE0, 0x01, 0x60, 0x04, 0x40, 0x10, 0x80, 0x41, 0x01,
  0x04, 0x04, 0x10, 0x10, 0x40, 0x41, 0x01, 0x04, 0x04, 0x28, 0x11, 0x9F,
  0xF8, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x6C, 0x00,
  0x81, 0x84, 0x01, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x41, 0x00, 0x80, 0x82, 0x01, 0x01, 0x08, 0x02,
  0x02, 0x10, 0x04, 0x04, 0x43, 0x88, 0x08, 0x8C, 0x98, 0x13, 0x20, 0x90,
  0x64, 0xC1, 0x30, 0x89, 0x01, 0x36, 0x22, 0x02, 0x10, 0x44, 0x04, 0x01,
  0x08, 0x08, 0x02, 0x10, 0x10, 0x08, 0x20, 0x20, 0x10, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x02, 0x08, 0x10, 0x04,
  0x30, 0x20, 0x07, 0xC0, 0x01, 0x80, 0x01, 0xDC, 0x00, 0x20, 0x40, 0x08,
  0x08, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x10, 0x03, 0x02, 0x00, 0x20, 0x80, 0x02, 0x20, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x02, 0x40, 0x01, 0x84, 0x00, 0x60, 0x40, 0x28, 0x04, 0x0A, 0x00,
  0xC1, 0x40, 0x0C, 0x28, 0x00, 0x89, 0x00, 0x09, 0x20, 0x00, 0xC4, 0x00,
  0x18, 0x40, 0x03, 0x88, 0x01, 0x90, 0xC0, 0x61, 0x0F, 0xF0, 0x10, 0xFF,
  0xC0, 0x04, 0x21, 0x04, 0x20, 0x86, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x06, 0x08, 0x20, 0x41,
  0x82, 0x04, 0xC0, 0x40, 0x80, 0x81, 0x81, 0x02, 0x02, 0x04, 0x08, 0x18,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x20, 0x41, 0x82, 0x08, 0x10, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x03, 0x88, 0x71, 0xEE, 0x00, 0xC0, 0x03, 0x00, 0x12,
  0x00, 0x84, 0x04, 0x08, 0x30, 0x30, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x32, 0x22, 0x24, 0x44, 0x80, 0xFF, 0x80, 0xF0,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x1D, 0xC0, 0x40, 0x41, 0x00, 0x42, 0x00, 0xC8,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x01, 0x30, 0x02, 0x20,
  0x08, 0x60, 0x10, 0x60, 0x40, 0x7F, 0x00, 0x06, 0x1C, 0x4B, 0x1C, 0x30,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x03, 0x00, 0x3B, 0xC1, 0x80,
  0x42, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0x00, 0x7B, 0xC1, 0x80, 0x44, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x03, 0xF8, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x12, 0x00, 0x43, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01,
  0x08, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08, 0x08, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x20, 0x60, 0x08, 0x10, 0x02, 0x08, 0x00, 0x83,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xF8, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0xFF, 0x04, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x09, 0x80, 0x61, 0xFF, 0x80, 0x00, 0x20, 0x07,
  0xB8, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x0C, 0x08, 0xE3, 0x12, 0x01, 0x28,
  0x01, 0x60, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x20, 0x04, 0x60, 0x18, 0x60, 0x60,
  0x7F, 0x80, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x00, 0x1D, 0xE0, 0xC0, 0x61, 0x00,
  0x64, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0xC0, 0x18,
  0x80, 0x20, 0xC1, 0x80, 0xC6, 0x00, 0x70, 0x03, 0xB8, 0x0C, 0x18, 0x20,
  0x08, 0x80, 0x09, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x40, 0x04, 0xC0, 0x18, 0xC0, 0x60, 0x7F, 0x00, 0x03, 0x00,
  0x39, 0xC0, 0xC0, 0x43, 0x00, 0x44, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x68, 0x00,
  0xD0, 0x02, 0x90, 0x09, 0x1C, 0xE2, 0x04, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x03, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x33, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x32, 0x22, 0x24, 0x44, 0x80, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x04,
  0x0F, 0x72, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x01, 0x80,
  0x30, 0x00, 0x10, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x06, 0x40, 0x1F, 0xC0, 0x90, 0x18, 0x10, 0x24, 0x0C,
  0x04, 0x0A, 0x02, 0x01, 0x02, 0x81, 0x80, 0x40, 0x60, 0x40, 0x10, 0x18,
  0x10, 0x04, 0x06, 0x04, 0x01, 0x02, 0x81, 0x00, 0xC0, 0xA0, 0x40, 0x30,
  0x28, 0x10, 0x0C, 0x0A, 0x04, 0x03, 0x02, 0x80, 0x81, 0x41, 0x10, 0x10,
  0x98, 0x84, 0x03, 0xC1, 0xC1, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x70, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x08, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x10, 0x02, 0x02, 0x00,
  0x40, 0x40, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0F, 0xFF, 0x02,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x06, 0x00, 0x00, 0x80,
  0xFF, 0xE1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x01, 0x8F, 0xFC,
  0x10, 0x0E, 0x20, 0x02, 0x40, 0x02, 0x80, 0x05, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00,
  0x63, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x7B, 0xF0, 0x60, 0x08, 0x30, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x08, 0x07, 0xFE, 0xFF, 0xC0, 0x40, 0x18, 0x20, 0x02,
  0x10, 0x00, 0x88, 0x00, 0x24, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x14, 0x00, 0x12, 0x00, 0x19, 0x00, 0x08, 0x80, 0x18, 0x40,
  0x38, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x1F, 0x7C, 0x02, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x20, 0x00, 0x13,
  0x00, 0x01, 0x10, 0x00, 0x10, 0xC0, 0x01, 0x06, 0x00, 0x30, 0x1F, 0xFC,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x8F, 0xC0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x8C,
  0x70, 0x80, 0x05, 0x00, 0x12, 0x00, 0x44, 0x01, 0x08, 0x06, 0x10, 0x18,
  0x20, 0x60, 0x40, 0x80, 0x82, 0x01, 0x08, 0x02, 0x20, 0x04, 0xC0, 0x0B,
  0x80, 0x1C, 0x80, 0x31, 0x80, 0x41, 0x00, 0x81, 0x01, 0x03, 0x02, 0x02,
  0x04, 0x02, 0x08, 0x06, 0x10, 0x04, 0x20, 0x04, 0x40, 0x08, 0x80, 0x09,
  0x00, 0x0A, 0x00, 0x18, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0x70, 0x00, 0x05, 0xA0, 0x00, 0x26, 0x80,
  0x00, 0x9B, 0x00, 0x02, 0x64, 0x00, 0x11, 0x90, 0x00, 0x46, 0x20, 0x01,
  0x18, 0x80, 0x08, 0x62, 0x00, 0x21, 0x84, 0x01, 0x86, 0x10, 0x04, 0x18,
  0x60, 0x10, 0x60, 0x80, 0x81, 0x82, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10,
  0x40, 0x60, 0x41, 0x01, 0x80, 0x8C, 0x06, 0x02, 0x20, 0x18, 0x08, 0x80,
  0x60, 0x14, 0x01, 0x80, 0x50, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xA0, 0x01, 0x90, 0x01,
  0x90, 0x01, 0x88, 0x01, 0x8C, 0x01, 0x84, 0x01, 0x82, 0x01, 0x82, 0x01,
  0x81, 0x01, 0x81, 0x81, 0x80, 0x81, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21,
  0x80, 0x31, 0x80, 0x11, 0x80, 0x09, 0x80, 0x09, 0x80, 0x05, 0x80, 0x05,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x00, 0x20, 0x00, 0x1E, 0x70, 0x01,
  0x00, 0x60, 0x10, 0x01, 0x81, 0x00, 0x06, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x24, 0x00,
  0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x10, 0x00, 0x40,
  0x40, 0x06, 0x01, 0x80, 0x60, 0x07, 0xFC, 0x00, 0xFF, 0x84, 0x03, 0x20,
  0x05, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x40, 0x33, 0xFF, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x1E, 0x70, 0x01, 0x00, 0x60,
  0x10, 0x01, 0x81, 0x00, 0x06, 0x10, 0x00, 0x10, 0x80, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20,
  0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x10, 0x00, 0x60, 0x40, 0x06,
  0x01, 0x80, 0x60, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0xFF, 0x81,
  0x00, 0xC2, 0x00, 0x44, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x03, 0x10, 0x18,
  0x3F, 0xC0, 0x40, 0x80, 0x80, 0x81, 0x01, 0x02, 0x01, 0x04, 0x03, 0x08,
  0x02, 0x10, 0x06, 0x20, 0x04, 0x40, 0x04, 0x80, 0x09, 0x00, 0x0A, 0x00,
  0x18, 0x01, 0x80, 0x1C, 0xF0, 0xC0, 0x13, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x12, 0x00, 0x47, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x80, 0x04, 0x20, 0x03,
  0x06, 0x01, 0x80, 0x7F, 0x80, 0x80, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x61, 0x80, 0x08,
  0x10, 0x01, 0x02, 0x00, 0x60, 0x40, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x08, 0x00, 0x41, 0x00,
  0x08, 0x20, 0x01, 0x08, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x48, 0x00,
  0x05, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x06, 0x00, 0x24, 0x00, 0xA0, 0x02,
  0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x20, 0x09, 0x00, 0x42, 0x00,
  0x90, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x10, 0x10, 0x80,
  0x81, 0x01, 0x08, 0x08, 0x10, 0x20, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x08,
  0x20, 0x41, 0x00, 0x82, 0x04, 0x10, 0x08, 0x40, 0x61, 0x00, 0x84, 0x02,
  0x10, 0x04, 0x40, 0x22, 0x00, 0x44, 0x02, 0x20, 0x04, 0x80, 0x32, 0x00,
  0x48, 0x01, 0x20, 0x02, 0x80, 0x14, 0x00, 0x28, 0x01, 0x40, 0x03, 0x00,
  0x14, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x10,
  0x01, 0x0C, 0x00, 0x82, 0x00, 0x81, 0x80, 0x40, 0x40, 0x40, 0x10, 0x20,
  0x08, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x58, 0x00, 0x28, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x05, 0x00, 0x02, 0x40, 0x02, 0x20, 0x03, 0x08, 0x01,
  0x04, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x20, 0x40, 0x10, 0x40, 0x04,
  0x60, 0x02, 0x20, 0x00, 0xB0, 0x00, 0x60, 0x80, 0x01, 0xA0, 0x00, 0x90,
  0x00, 0x84, 0x00, 0x42, 0x00, 0x40, 0x80, 0x20, 0x40, 0x20, 0x10, 0x10,
  0x08, 0x18, 0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x22, 0x00, 0x12,
  0x00, 0x05, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0xFF, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x48, 0x00, 0x64, 0x00, 0x21, 0x00, 0x30, 0x80, 0x10, 0x20, 0x10, 0x10,
  0x08, 0x0C, 0x08, 0x02, 0x04, 0x01, 0x84, 0x00, 0x42, 0x00, 0x32, 0x00,
  0x0B, 0x00, 0x06, 0xFF, 0xFE, 0x81, 0x06, 0x0C, 0x10, 0x30, 0x3F, 0xC6,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0xFF, 0x30, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x40, 0x53, 0xF9, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x1F, 0xC2, 0x40,
  0x65, 0x00, 0x4C, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x02, 0xC0, 0x05, 0x80, 0x1A, 0x80, 0x24, 0x80, 0x88, 0xFE, 0x00, 0x07,
  0xF8, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x06, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x1F, 0xC4, 0x40, 0x49, 0x00, 0x54, 0x00, 0x68, 0x00, 0xD0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xE0, 0x03, 0x40, 0x06, 0x80, 0x0C, 0x80, 0x29, 0x80,
  0x90, 0xFE, 0x20, 0x0F, 0xE0, 0x40, 0x42, 0x00, 0x98, 0x02, 0x40, 0x05,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80,
  0x43, 0xFE, 0x03, 0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x1F, 0xF0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xE2, 0x20, 0x34, 0x80, 0x2A,
  0x00, 0x34, 0x00, 0x68, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x01, 0xA0, 0x03,
  0x40, 0x0A, 0x40, 0x14, 0x40, 0x48, 0x7F, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x23, 0x00, 0x81, 0xFE,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x7F, 0x24, 0x05, 0x40, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0xF0, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0xBC, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x03, 0x80, 0x68, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x60, 0x84,
  0x08, 0x80, 0x94, 0x0A, 0x60, 0xC2, 0x0C, 0x10, 0x81, 0x08, 0x08, 0x80,
  0x48, 0x04, 0x80, 0x28, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xF8, 0x9F,
  0xC3, 0xF9, 0x60, 0x48, 0x1A, 0x80, 0xA0, 0x16, 0x00, 0xC0, 0x1C, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x8F, 0xE4, 0x80,
  0xA8, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x0F, 0xF0, 0x20, 0x30, 0x80, 0x32,
  0x00, 0x24, 0x00, 0x28, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x50, 0x00, 0xA0, 0x03,
  0x40, 0x04, 0x40, 0x18, 0x40, 0x60, 0x7F, 0x00, 0x8F, 0xE1, 0x20, 0x32,
  0x80, 0x25, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x01,
  0x60, 0x02, 0xC0, 0x05, 0x40, 0x12, 0x40, 0x44, 0x7F, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0xE2, 0x20, 0x24, 0x80, 0x2A, 0x00, 0x34, 0x00,
  0x68, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xA0, 0x03, 0x40, 0x0A, 0x40,
  0x14, 0xC0, 0x48, 0x7F, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x8F, 0xC8,
  0x28, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1F, 0xF1, 0x00,
  0x90, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xB0, 0x0C, 0xFF, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x07,
  0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x1F, 0x80, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1A, 0x01, 0x58, 0x1A, 0x7F, 0x10, 0x80, 0x05, 0x00, 0x14,
  0x00, 0x90, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01, 0x04, 0x04, 0x10, 0x20,
  0x40, 0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20,
  0x02, 0x80, 0x0A, 0x00, 0x30, 0x00, 0x40, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xA0, 0x0A, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24,
  0x04, 0x81, 0x08, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x62, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x20, 0x14,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0xC0, 0x0D, 0x00, 0x62, 0x01, 0x0C, 0x08, 0x10, 0x20, 0x21,
  0x00, 0x8C, 0x01, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x20, 0x0C,
  0x80, 0x21, 0x01, 0x06, 0x04, 0x08, 0x20, 0x11, 0x80, 0x44, 0x00, 0xA0,
  0x03, 0xC0, 0x06, 0x80, 0x09, 0x00, 0x13, 0x00, 0x42, 0x00, 0x84, 0x01,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00,
  0x44, 0x00, 0x88, 0x01, 0x10, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0F, 0xFF, 0x01, 0xC1, 0x80, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0xE0, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0xC1, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x40, 0xE0, 0x00, 0x3E, 0x01, 0xC1, 0x82, 0x80,
  0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Thin38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 27, 8, 3, -27 },
  { 8, 6, 10, 12, 3, -27 },
  { 16, 20, 27, 21, 1, -27 },
  { 84, 14, 31, 19, 2, -29 },
  { 139, 23, 28, 27, 2, -28 },
  { 220, 19, 28, 22, 2, -28 },
  { 287, 1, 10, 6, 3, -27 },
  { 289, 6, 33, 10, 2, -27 },
  { 314, 7, 33, 10, 1, -27 },
  { 343, 14, 13, 18, 2, -29 },
  { 366, 16, 17, 19, 2, -22 },
  { 400, 4, 9, 7, 1, -4 },
  { 405, 9, 1, 11, 1, -11 },
  { 407, 2, 2, 8, 3, -2 },
  { 408, 11, 27, 12, 1, -27 },
  { 446, 15, 28, 19, 2, -28 },
  { 499, 7, 27, 19, 4, -27 },
  { 523, 15, 28, 19, 2, -28 },
  { 576, 15, 28, 19, 2, -28 },
  { 629, 18, 27, 19, 1, -27 },
  { 690, 15, 27, 19, 2, -27 },
  { 741, 15, 28, 19, 2, -28 },
  { 794, 15, 27, 19, 2, -27 },
  { 845, 15, 28, 19, 2, -28 },
  { 898, 15, 28, 19, 2, -28 },
  { 951, 2, 20, 8, 3, -20 },
  { 956, 4, 25, 8, 1, -20 },
  { 969, 16, 17, 19, 2, -22 },
  { 1003, 16, 9, 19, 2, -18 },
  { 1021, 16, 17, 19, 2, -22 },
  { 1055, 11, 28, 14, 1, -28 },
  { 1094, 26, 31, 30, 2, -27 },
  { 1195, 19, 27, 19, 0, -27 },
  { 1260, 15, 27, 21, 4, -27 },
  { 1311, 18, 28, 21, 2, -28 },
  { 1374, 17, 27, 23, 4, -27 },
  { 1432, 12, 27, 19, 4, -27 },
  { 1473, 12, 27, 17, 4, -27 },
  { 1514, 20, 28, 25, 2, -28 },
  { 1584, 16, 27, 24, 4, -27 },
  { 1638, 6, 27, 10, 2, -27 },
  { 1659, 8, 34, 8, -3, -27 },
  { 1693, 15, 27, 19, 4, -27 },
  { 1744, 12, 27, 17, 4, -27 },
  { 1785, 22, 27, 29, 4, -27 },
  { 1860, 16, 27, 24, 4, -27 },
  { 1914, 21, 28, 25, 2, -28 },
  { 1988, 13, 27, 19, 4, -27 },
  { 2032, 21, 34, 25, 2, -28 },
  { 2122, 15, 27, 20, 4, -27 },
  { 2173, 15, 28, 19, 2, -28 },
  { 2226, 17, 27, 17, 0, -27 },
  { 2284, 18, 27, 24, 3, -27 },
  { 2345, 19, 27, 19, 0, -27 },
  { 2410, 28, 27, 30, 1, -27 },
  { 2505, 17, 27, 17, 0, -27 },
  { 2563, 17, 27, 17, 0, -27 },
  { 2621, 16, 27, 18, 1, -27 },
  { 2675, 8, 33, 12, 3, -27 },
  { 2708, 11, 27, 12, 1, -27 },
  { 2746, 8, 33, 12, 1, -27 },
  { 2779, 17, 15, 19, 1, -27 },
  { 2811, 15, 1, 15, 0, 3 },
  { 2813, 6, 6, 9, 2, -29 },
  { 2818, 12, 20, 17, 2, -20 },
  { 2848, 15, 29, 20, 3, -29 },
  { 2903, 13, 20, 16, 2, -20 },
  { 2936, 15, 29, 20, 2, -29 },
  { 2991, 14, 20, 18, 2, -20 },
  { 3026, 11, 29, 10, 0, -29 },
  { 3066, 15, 29, 20, 2, -20 },
  { 3121, 13, 29, 20, 3, -29 },
  { 3169, 2, 27, 7, 3, -27 },
  { 3176, 6, 36, 7, -1, -27 },
  { 3203, 12, 29, 15, 3, -29 },
  { 3247, 1, 29, 7, 3, -29 },
  { 3251, 23, 20, 29, 3, -20 },
  { 3309, 13, 20, 20, 3, -20 },
  { 3342, 15, 20, 19, 2, -20 },
  { 3380, 15, 29, 20, 3, -20 },
  { 3435, 15, 29, 20, 2, -20 },
  { 3490, 9, 20, 13, 3, -20 },
  { 3513, 13, 20, 15, 1, -20 },
  { 3546, 9, 25, 11, 1, -25 },
  { 3575, 13, 20, 20, 3, -20 },
  { 3608, 14, 20, 14, 0, -20 },
  { 3643, 22, 20, 24, 1, -20 },
  { 3698, 14, 20, 16, 1, -20 },
  { 3733, 15, 29, 15, 0, -20 },
  { 3788, 12, 20, 15, 1, -20 },
  { 3818, 10, 33, 13, 1, -27 },
  { 3860, 1, 38, 18, 9, -29 },
  { 3865, 10, 33, 13, 2, -27 },
  { 3907, 16, 3, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Thin38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_THIN38PT7B_H_
