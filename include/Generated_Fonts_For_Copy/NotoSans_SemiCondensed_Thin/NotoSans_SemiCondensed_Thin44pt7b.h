#ifndef _NOTOSANS_SEMICONDENSED_THIN44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin44pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0xBC, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x00, 0x40, 0x20, 0x00,
  0x80, 0x80, 0x01, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10,
  0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x60, 0x00, 0x80, 0x80, 0x7F, 0xFF,
  0xFC, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x30,
  0x00, 0x40, 0x40, 0x01, 0x80, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00,
  0x08, 0x04, 0x00, 0x10, 0x08, 0x0F, 0xFF, 0xFF, 0x80, 0xC0, 0x40, 0x01,
  0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10,
  0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x01, 0xFE, 0x03, 0x91, 0xE3, 0x08,
  0x23, 0x04, 0x01, 0x02, 0x01, 0x81, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x30,
  0x20, 0x08, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00, 0x19, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x2E, 0x00, 0x11, 0x80, 0x08, 0x20, 0x04,
  0x08, 0x02, 0x06, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x20, 0x08, 0x10, 0x04, 0x13, 0x82, 0x30, 0x7F, 0xF0, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x04, 0x02, 0x30,
  0x01, 0x00, 0x83, 0x00, 0x20, 0x30, 0x20, 0x08, 0x04, 0x06, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x10, 0x08, 0x08, 0x06, 0x01, 0x02, 0x00, 0xC0, 0x20,
  0x40, 0x18, 0x04, 0x10, 0x03, 0x00, 0x82, 0x00, 0x60, 0x10, 0xC0, 0x0C,
  0x02, 0x10, 0x00, 0x80, 0x46, 0x3E, 0x10, 0x08, 0x8C, 0x22, 0x02, 0x33,
  0x06, 0x60, 0x44, 0x40, 0x44, 0x18, 0x88, 0x08, 0x66, 0x23, 0x01, 0x87,
  0x04, 0x60, 0x10, 0x01, 0x08, 0x02, 0x00, 0x21, 0x00, 0x40, 0x08, 0x20,
  0x08, 0x01, 0x04, 0x01, 0x00, 0x40, 0x80, 0x20, 0x08, 0x18, 0x04, 0x02,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x20, 0x18, 0x04, 0x04, 0x02, 0x00, 0xC0,
  0x80, 0xC0, 0x08, 0x20, 0x10, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0E, 0x30,
  0x00, 0x30, 0x10, 0x00, 0x40, 0x30, 0x01, 0x80, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x18, 0x02, 0x00, 0x10, 0x0C, 0x00,
  0x20, 0x10, 0x00, 0x20, 0x40, 0x00, 0x61, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x30, 0xC0, 0x00, 0xC0,
  0xC0, 0x13, 0x00, 0xC0, 0x24, 0x00, 0x80, 0x88, 0x00, 0x81, 0x30, 0x00,
  0x82, 0x40, 0x01, 0x88, 0x80, 0x01, 0x91, 0x00, 0x01, 0xC1, 0x00, 0x01,
  0x82, 0x00, 0x07, 0x06, 0x00, 0x19, 0x04, 0x00, 0x63, 0x06, 0x01, 0x83,
  0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x04, 0x06, 0x03, 0xC0, 0x80, 0x81, 0x81, 0x03,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18,
  0x20, 0x83, 0x04, 0x10, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xE0, 0x83, 0x1C, 0x9C, 0x03, 0xE0, 0x01, 0x80, 0x01,
  0x40, 0x02, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x08, 0x10, 0x0C, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0F, 0xFF, 0xFC,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x24,
  0x96, 0x92, 0x92, 0x00, 0xFF, 0xFF, 0xF0, 0x5D, 0x80, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0x1C, 0x04, 0x03, 0x04, 0x00, 0x82, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x0D, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50,
  0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0xC0, 0x01, 0x20, 0x00, 0x90, 0x00, 0x8C, 0x00, 0x42,
  0x00, 0x41, 0x80, 0x60, 0x60, 0x60, 0x0F, 0xE0, 0x01, 0x83, 0x43, 0x23,
  0x16, 0x0E, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0xE0, 0x0E, 0x1C, 0x1C,
  0x01, 0x08, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0xFF, 0xFF, 0x07, 0xE0, 0x0E, 0x1C, 0x18, 0x01, 0x98, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x1F,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x13, 0x00, 0x30, 0x7F, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x1E, 0x00, 0x00, 0xB0,
  0x00, 0x09, 0x80, 0x00, 0xCC, 0x00, 0x04, 0x60, 0x00, 0x43, 0x00, 0x02,
  0x18, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x04, 0x00,
  0xC0, 0x40, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x82, 0x00, 0x0C, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x3F,
  0xFE, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x7C, 0x03, 0xE3, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x48, 0x00,
  0x46, 0x00, 0xC1, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xC1, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x3F, 0xC2, 0x60,
  0x31, 0x60, 0x04, 0xE0, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0xD0, 0x00, 0x48, 0x00, 0x22, 0x00, 0x31, 0x80, 0x30, 0x60, 0x30, 0x0F,
  0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x03,
  0xF0, 0x03, 0x87, 0x01, 0x80, 0x20, 0xC0, 0x04, 0x20, 0x01, 0x18, 0x00,
  0x66, 0x00, 0x09, 0x00, 0x02, 0x60, 0x00, 0x88, 0x00, 0x62, 0x00, 0x10,
  0x40, 0x08, 0x18, 0x06, 0x01, 0x86, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x07,
  0x38, 0x03, 0x03, 0x01, 0x00, 0x20, 0x80, 0x04, 0x60, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x09,
  0x00, 0x02, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0x80, 0x60, 0x1F, 0xE0, 0x03,
  0xE0, 0x07, 0x1C, 0x04, 0x01, 0x04, 0x00, 0x46, 0x00, 0x32, 0x00, 0x09,
  0x00, 0x05, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x03, 0x20, 0x02, 0x98,
  0x03, 0x47, 0x06, 0x20, 0xFC, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x05, 0xD8, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x22, 0x26, 0x64, 0x44, 0x88, 0x80, 0x00, 0x00, 0x40, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x07,
  0x87, 0x20, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x08,
  0x80, 0x1F, 0xE0, 0x26, 0x01, 0x80, 0x80, 0x90, 0x0C, 0x02, 0x03, 0x40,
  0x20, 0x08, 0x05, 0x01, 0x80, 0x20, 0x14, 0x04, 0x00, 0x80, 0x70, 0x10,
  0x02, 0x01, 0xC0, 0xC0, 0x08, 0x07, 0x03, 0x00, 0x60, 0x1C, 0x0C, 0x01,
  0x80, 0x70, 0x30, 0x06, 0x03, 0xC0, 0xC0, 0x18, 0x0B, 0x01, 0x00, 0x60,
  0x24, 0x04, 0x02, 0x80, 0x90, 0x18, 0x0A, 0x04, 0x40, 0x30, 0xCC, 0x31,
  0x80, 0x7E, 0x1F, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00, 0x12,
  0x00, 0x00, 0x4C, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x80,
  0x00, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x40, 0x02,
  0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x10, 0x08, 0x00, 0x20,
  0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x42, 0x00, 0x01, 0x90, 0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x40, 0xFF, 0xF8, 0x20, 0x01, 0x88, 0x00, 0x32, 0x00,
  0x04, 0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00,
  0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x06, 0x20, 0x07, 0x0F,
  0xFF, 0x02, 0x00, 0x38, 0x80, 0x03, 0x20, 0x00, 0x68, 0x00, 0x0A, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x02, 0x20, 0x07, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x1E, 0x0F, 0x07, 0x00, 0x20, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x1F, 0xFC, 0xFF, 0xF8,
  0x08, 0x00, 0xE0, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00,
  0x04, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x10, 0x80, 0x06, 0x08, 0x03,
  0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0x81, 0xE0, 0x30, 0x00, 0xC3, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x44, 0x00, 0x01, 0x18, 0x00, 0x04, 0x30, 0x00,
  0x10, 0x38, 0x00, 0xC0, 0x3F, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x3F, 0x80,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0xFC, 0x70, 0x80, 0x01, 0xA0, 0x00, 0xC8, 0x00, 0x62, 0x00, 0x30,
  0x80, 0x08, 0x20, 0x04, 0x08, 0x02, 0x02, 0x01, 0x80, 0x80, 0xC0, 0x20,
  0x60, 0x08, 0x30, 0x02, 0x08, 0x00, 0x84, 0x00, 0x23, 0x00, 0x09, 0xA0,
  0x02, 0xCC, 0x00, 0xA1, 0x00, 0x30, 0x20, 0x08, 0x0C, 0x02, 0x01, 0x00,
  0x80, 0x60, 0x20, 0x0C, 0x08, 0x01, 0x02, 0x00, 0x60, 0x80, 0x0C, 0x20,
  0x01, 0x08, 0x00, 0x62, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00,
  0x0C, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x80,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x16, 0x80, 0x00,
  0x0D, 0xB0, 0x00, 0x02, 0x64, 0x00, 0x00, 0x99, 0x00, 0x00, 0x66, 0x20,
  0x00, 0x11, 0x88, 0x00, 0x04, 0x63, 0x00, 0x03, 0x18, 0x40, 0x00, 0x86,
  0x10, 0x00, 0x21, 0x86, 0x00, 0x10, 0x60, 0x80, 0x04, 0x18, 0x20, 0x03,
  0x06, 0x04, 0x00, 0x81, 0x81, 0x00, 0x20, 0x60, 0x60, 0x18, 0x18, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x80, 0x60, 0x10, 0x20, 0x18,
  0x04, 0x18, 0x06, 0x00, 0x84, 0x01, 0x80, 0x21, 0x00, 0x60, 0x0C, 0xC0,
  0x18, 0x01, 0x20, 0x06, 0x00, 0x48, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x80, 0x00,
  0xD8, 0x00, 0x19, 0x00, 0x03, 0x30, 0x00, 0x62, 0x00, 0x0C, 0x20, 0x01,
  0x84, 0x00, 0x30, 0x40, 0x06, 0x0C, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x03,
  0x01, 0x00, 0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x20, 0x30, 0x06, 0x06,
  0x00, 0x40, 0xC0, 0x04, 0x18, 0x00, 0xC3, 0x00, 0x08, 0x60, 0x01, 0x8C,
  0x00, 0x11, 0x80, 0x01, 0x30, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x7E, 0x00, 0x03, 0xC3,
  0x80, 0x06, 0x00, 0x60, 0x08, 0x00, 0x30, 0x10, 0x00, 0x18, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x40, 0x00, 0x06, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x20, 0x00, 0x08, 0x30, 0x00, 0x08, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x80, 0x1C, 0x80,
  0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x18, 0xFF, 0xF0, 0xFE, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xC3, 0xC0, 0x06, 0x00, 0x60, 0x08, 0x00, 0x30, 0x10, 0x00, 0x18,
  0x20, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x40, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04,
  0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x18, 0x00, 0x10,
  0x0C, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0xFF, 0xF0, 0x20, 0x07, 0x08, 0x00,
  0x62, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x20,
  0x01, 0x88, 0x00, 0xC2, 0x01, 0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x06,
  0x02, 0x00, 0x80, 0x80, 0x30, 0x20, 0x04, 0x08, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x04, 0x20, 0x01, 0x88, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01, 0x20,
  0x00, 0x68, 0x00, 0x0C, 0x01, 0xF8, 0x07, 0x07, 0xC6, 0x00, 0x44, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x13, 0x00, 0x30, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x04,
  0x30, 0x00, 0x81, 0xC0, 0x30, 0x07, 0xFE, 0x00, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x24, 0x00, 0x01, 0x90, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00,
  0xC2, 0x00, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x01, 0x00,
  0x80, 0x04, 0x02, 0x00, 0x10, 0x08, 0x00, 0x80, 0x30, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x06, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x20,
  0x00, 0xC0, 0x80, 0x01, 0x02, 0x00, 0x04, 0x10, 0x00, 0x18, 0x40, 0x00,
  0x21, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x20, 0x00, 0x04, 0x80, 0x00, 0x16,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x70, 0x00, 0x48, 0x00,
  0x28, 0x00, 0x64, 0x00, 0x34, 0x00, 0x33, 0x00, 0x12, 0x00, 0x10, 0x80,
  0x09, 0x80, 0x08, 0x40, 0x04, 0x40, 0x0C, 0x20, 0x06, 0x20, 0x04, 0x18,
  0x02, 0x10, 0x02, 0x04, 0x01, 0x0C, 0x01, 0x02, 0x00, 0x82, 0x01, 0x81,
  0x00, 0xC1, 0x00, 0x80, 0x40, 0x40, 0x80, 0x40, 0x20, 0x20, 0x60, 0x20,
  0x10, 0x10, 0x10, 0x30, 0x08, 0x18, 0x08, 0x10, 0x02, 0x08, 0x04, 0x08,
  0x01, 0x04, 0x03, 0x04, 0x00, 0x82, 0x00, 0x86, 0x00, 0x41, 0x00, 0x42,
  0x00, 0x11, 0x00, 0x21, 0x00, 0x08, 0x80, 0x18, 0x80, 0x04, 0x40, 0x04,
  0xC0, 0x02, 0x20, 0x02, 0x40, 0x00, 0xB0, 0x01, 0x20, 0x00, 0x50, 0x00,
  0x90, 0x00, 0x28, 0x00, 0x38, 0x00, 0x14, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x06, 0x00, 0x60, 0x00, 0x66, 0x00, 0x08, 0x40,
  0x02, 0x0C, 0x00, 0xC0, 0x80, 0x10, 0x18, 0x06, 0x01, 0x00, 0x80, 0x30,
  0x30, 0x02, 0x04, 0x00, 0x61, 0x80, 0x04, 0x20, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xB0, 0x00, 0x12,
  0x00, 0x04, 0x60, 0x00, 0x84, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x00,
  0x80, 0x60, 0x10, 0x08, 0x01, 0x02, 0x00, 0x30, 0x40, 0x02, 0x10, 0x00,
  0x66, 0x00, 0x04, 0x80, 0x00, 0xF0, 0x00, 0x08, 0xC0, 0x00, 0x68, 0x00,
  0x09, 0x80, 0x03, 0x10, 0x00, 0x43, 0x00, 0x08, 0x20, 0x02, 0x04, 0x00,
  0x40, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0xC0, 0x10, 0x10, 0x01, 0x06,
  0x00, 0x20, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x0C, 0x80, 0x00, 0xA0,
  0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC,
  0x00, 0x40, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x11, 0x00,
  0x06, 0x20, 0x00, 0x82, 0x00, 0x30, 0x40, 0x04, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x08, 0x01, 0x01, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x22,
  0x00, 0x04, 0xC0, 0x00, 0x50, 0x00, 0x0C, 0xFF, 0xFF, 0x80, 0x81, 0x81,
  0x81, 0x81, 0x01, 0x01, 0x80, 0x03, 0x80, 0x3F, 0xE0, 0x80, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x0F, 0xF0, 0xE0, 0x26, 0x00, 0x58, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xA8, 0x03, 0x58, 0x0C,
  0x9F, 0xE1, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0xE0, 0x23,
  0xDE, 0x12, 0x01, 0x8A, 0x00, 0x66, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x02,
  0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50,
  0x00, 0x2C, 0x00, 0x26, 0x00, 0x12, 0x80, 0x11, 0x20, 0x30, 0x8F, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0xBC, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x83, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0xF0, 0x41, 0xEE, 0x21, 0x00, 0xD1,
  0x00, 0x29, 0x00, 0x0C, 0x80, 0x06, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x16, 0x00, 0x19,
  0x00, 0x0C, 0x40, 0x0A, 0x30, 0x09, 0x07, 0xF8, 0x80, 0x00, 0xC0, 0x03,
  0x9C, 0x03, 0x01, 0x02, 0x00, 0x43, 0x00, 0x21, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x01, 0xA0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x0F, 0xFC,
  0x00, 0xF0, 0x1E, 0xC1, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xFF, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x03, 0xDE,
  0x46, 0x01, 0xA2, 0x00, 0x72, 0x00, 0x19, 0x00, 0x0D, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x6C, 0x00, 0x32, 0x00, 0x18, 0x80, 0x14, 0x60, 0x32, 0x0F, 0xF1, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x60, 0x06, 0x1F, 0xFE, 0x00, 0x70, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x03, 0x82, 0x3D, 0xC4, 0x80, 0x4A, 0x00, 0x58,
  0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x5F, 0x00, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06,
  0x09, 0xF1, 0x80, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x01, 0xA0, 0x0C,
  0x80, 0x22, 0x01, 0x08, 0x08, 0x20, 0x60, 0x83, 0x02, 0x08, 0x08, 0x40,
  0x23, 0x00, 0x94, 0x02, 0xC8, 0x0A, 0x20, 0x30, 0x40, 0x81, 0x82, 0x02,
  0x08, 0x04, 0x20, 0x18, 0x80, 0x22, 0x00, 0xC8, 0x01, 0x20, 0x02, 0x80,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x1C, 0x27, 0xB8, 0x3F,
  0xCB, 0x03, 0x10, 0x1A, 0x80, 0x68, 0x02, 0xC0, 0x0E, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x01, 0x81, 0x1C, 0xE2, 0x40, 0x35, 0x00, 0x2C, 0x00, 0x78, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0xE0, 0x01,
  0xEF, 0x00, 0x80, 0x60, 0x40, 0x0C, 0x20, 0x01, 0x88, 0x00, 0x24, 0x00,
  0x09, 0x00, 0x03, 0x40, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x34, 0x00, 0x08, 0x80, 0x02, 0x30, 0x01, 0x04, 0x00, 0xC0, 0xC0,
  0x60, 0x1F, 0xE0, 0x01, 0xC0, 0x47, 0xBC, 0x26, 0x03, 0x14, 0x00, 0xCE,
  0x00, 0x26, 0x00, 0x1B, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x40, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x4E, 0x00, 0x25,
  0x00, 0x22, 0x60, 0x61, 0x1F, 0xE0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xDC, 0x42, 0x01, 0xA2, 0x00,
  0x52, 0x00, 0x19, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x32, 0x00,
  0x39, 0x80, 0x14, 0x60, 0x32, 0x0F, 0xF1, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x03, 0x23, 0xFB, 0x02, 0x80, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x07,
  0x80, 0x7B, 0xF6, 0x00, 0x90, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x2C, 0x03, 0x1F, 0xF8, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x0F, 0xFC, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x0F, 0xC0, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x05, 0x60, 0x09,
  0x30, 0x19, 0x1F, 0xE1, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x4C, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x10, 0xC0, 0x10, 0x20, 0x08, 0x10, 0x04, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x81, 0x00, 0x20, 0x80, 0x10, 0x40,
  0x08, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x28, 0x00, 0x14,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x2C,
  0x00, 0xC0, 0x09, 0x00, 0x58, 0x02, 0x40, 0x12, 0x01, 0x90, 0x04, 0x80,
  0x46, 0x03, 0x20, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x03, 0x08, 0x08,
  0x40, 0x83, 0x04, 0x18, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x86, 0x04,
  0x30, 0x21, 0x00, 0x88, 0x0C, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x4C,
  0x02, 0x40, 0x12, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x07, 0x00,
  0x28, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0xC0, 0x03, 0x60, 0x06,
  0x20, 0x04, 0x10, 0x0C, 0x18, 0x08, 0x08, 0x10, 0x04, 0x30, 0x06, 0x20,
  0x02, 0x60, 0x03, 0x40, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40,
  0x06, 0x20, 0x04, 0x30, 0x08, 0x10, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x04,
  0x20, 0x06, 0x40, 0x02, 0xC0, 0x01, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00,
  0x44, 0x00, 0x62, 0x00, 0x21, 0x00, 0x10, 0x40, 0x18, 0x20, 0x08, 0x10,
  0x04, 0x04, 0x06, 0x02, 0x02, 0x01, 0x01, 0x00, 0x41, 0x80, 0x20, 0x80,
  0x10, 0x40, 0x04, 0x60, 0x02, 0x20, 0x01, 0x10, 0x00, 0x58, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x18, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x03, 0x80, 0xE0,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x81, 0xC0,
  0x00, 0x3F, 0x80, 0x70, 0x38, 0x38, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Thin44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 31, 9, 4, -31 },
  { 9, 8, 11, 14, 3, -31 },
  { 20, 23, 31, 25, 1, -31 },
  { 110, 17, 36, 22, 2, -33 },
  { 187, 27, 32, 31, 2, -32 },
  { 295, 23, 32, 26, 2, -32 },
  { 387, 1, 11, 7, 3, -31 },
  { 389, 8, 38, 11, 2, -31 },
  { 427, 7, 38, 11, 2, -31 },
  { 461, 16, 15, 21, 2, -33 },
  { 491, 18, 21, 22, 2, -26 },
  { 539, 3, 11, 8, 2, -5 },
  { 544, 10, 2, 13, 2, -13 },
  { 547, 3, 3, 9, 3, -3 },
  { 549, 13, 31, 14, 1, -31 },
  { 600, 17, 32, 22, 3, -32 },
  { 668, 9, 31, 22, 4, -31 },
  { 703, 17, 32, 22, 2, -32 },
  { 771, 17, 32, 22, 2, -32 },
  { 839, 21, 32, 22, 1, -32 },
  { 923, 17, 31, 22, 3, -31 },
  { 989, 17, 32, 22, 3, -32 },
  { 1057, 18, 31, 22, 2, -31 },
  { 1127, 18, 32, 22, 2, -32 },
  { 1199, 17, 32, 22, 2, -32 },
  { 1267, 3, 23, 9, 3, -23 },
  { 1276, 4, 29, 9, 2, -23 },
  { 1291, 18, 19, 22, 2, -25 },
  { 1334, 18, 11, 22, 2, -21 },
  { 1359, 18, 19, 22, 2, -25 },
  { 1402, 13, 32, 16, 1, -32 },
  { 1454, 30, 35, 34, 2, -31 },
  { 1586, 22, 31, 22, 0, -31 },
  { 1672, 18, 31, 24, 4, -31 },
  { 1742, 20, 32, 24, 3, -32 },
  { 1822, 20, 31, 27, 4, -31 },
  { 1900, 15, 31, 21, 4, -31 },
  { 1959, 15, 31, 19, 4, -31 },
  { 2018, 22, 32, 28, 3, -32 },
  { 2106, 19, 31, 28, 4, -31 },
  { 2180, 7, 31, 11, 2, -31 },
  { 2208, 8, 39, 9, -3, -31 },
  { 2247, 18, 31, 22, 4, -31 },
  { 2317, 15, 31, 20, 4, -31 },
  { 2376, 26, 31, 34, 4, -31 },
  { 2477, 19, 31, 28, 4, -31 },
  { 2551, 24, 32, 29, 3, -32 },
  { 2647, 16, 31, 22, 4, -31 },
  { 2709, 24, 39, 29, 3, -32 },
  { 2826, 18, 31, 23, 4, -31 },
  { 2896, 17, 32, 21, 2, -32 },
  { 2964, 19, 31, 19, 0, -31 },
  { 3038, 20, 31, 28, 4, -31 },
  { 3116, 22, 31, 22, 0, -31 },
  { 3202, 33, 31, 35, 1, -31 },
  { 3330, 19, 31, 20, 0, -31 },
  { 3404, 19, 31, 19, 0, -31 },
  { 3478, 19, 31, 21, 1, -31 },
  { 3552, 8, 38, 14, 4, -31 },
  { 3590, 13, 31, 14, 1, -31 },
  { 3641, 9, 38, 14, 1, -31 },
  { 3684, 19, 18, 22, 2, -32 },
  { 3727, 17, 1, 17, 0, 4 },
  { 3730, 7, 7, 11, 2, -34 },
  { 3737, 15, 24, 20, 2, -24 },
  { 3782, 17, 33, 23, 4, -33 },
  { 3853, 15, 24, 18, 2, -24 },
  { 3898, 17, 33, 23, 2, -33 },
  { 3969, 17, 24, 21, 2, -24 },
  { 4020, 13, 34, 11, 0, -34 },
  { 4076, 17, 35, 23, 2, -24 },
  { 4151, 15, 33, 23, 4, -33 },
  { 4213, 3, 32, 9, 3, -32 },
  { 4225, 7, 43, 9, -1, -32 },
  { 4263, 14, 33, 18, 4, -33 },
  { 4321, 1, 33, 8, 4, -33 },
  { 4326, 26, 24, 34, 4, -24 },
  { 4404, 15, 24, 23, 4, -24 },
  { 4449, 18, 24, 23, 2, -24 },
  { 4503, 17, 34, 23, 4, -24 },
  { 4576, 17, 34, 23, 2, -24 },
  { 4649, 10, 24, 15, 4, -24 },
  { 4679, 14, 24, 18, 2, -24 },
  { 4721, 10, 29, 12, 1, -29 },
  { 4758, 16, 23, 23, 3, -23 },
  { 4804, 17, 23, 17, 0, -23 },
  { 4853, 26, 23, 27, 1, -23 },
  { 4928, 16, 23, 18, 1, -23 },
  { 4974, 17, 34, 17, 0, -23 },
  { 5047, 13, 23, 17, 2, -23 },
  { 5085, 11, 38, 15, 2, -31 },
  { 5138, 1, 45, 21, 10, -34 },
  { 5144, 11, 38, 15, 2, -31 },
  { 5197, 18, 3, 22, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Thin44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_THIN44PT7B_H_
