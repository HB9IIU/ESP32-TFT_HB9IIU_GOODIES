#ifndef _NOTOSANS_SEMICONDENSED_THIN7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xD0, 0x6F, 0x6F, 0xA0, 0xF9, 0x3E, 0xD7, 0x3E, 0x55, 0x00,
  0x66, 0x4B, 0xF0, 0xC0, 0x6A, 0x90, 0xFC, 0xEC, 0x5D, 0x00, 0xC0, 0xC0,
  0x00, 0x56, 0x80, 0xF6, 0xDE, 0xF8, 0xE4, 0xAE, 0xE5, 0x1E, 0x2E, 0xF2,
  0xF1, 0x9E, 0x73, 0xDE, 0xE4, 0xA4, 0xF5, 0x5E, 0xF7, 0x96, 0x80, 0x98,
  0x71, 0x80, 0xE0, 0xC7, 0x00, 0xD6, 0x00, 0x7D, 0x77, 0xBA, 0x38, 0x44,
  0xEA, 0x90, 0xFF, 0xC0, 0x78, 0x88, 0x70, 0xF6, 0xDE, 0xEE, 0xC0, 0xEE,
  0x80, 0x78, 0xA9, 0x70, 0xB7, 0xDA, 0xF8, 0x55, 0x70, 0xEA, 0xC0, 0xAA,
  0xC0, 0x9B, 0xBB, 0xD0, 0xB6, 0xFA, 0x79, 0x99, 0x70, 0xFE, 0x80, 0x79,
  0x99, 0x53, 0xFF, 0xC0, 0xF1, 0x1E, 0xE9, 0x24, 0xB6, 0xDE, 0xB6, 0xA4,
  0xAD, 0x6A, 0xA5, 0x00, 0xA9, 0x5A, 0xB5, 0x24, 0xE5, 0x2E, 0xFC, 0xA5,
  0x40, 0xD5, 0x70, 0x4E, 0x80, 0xE0, 0x80, 0xE7, 0xF0, 0xBF, 0xC0, 0x72,
  0x70, 0x2E, 0xDE, 0x77, 0x70, 0xFA, 0x80, 0x76, 0xF2, 0x80, 0xBF, 0xC0,
  0x78, 0x7E, 0xBA, 0xC0, 0xF8, 0xBD, 0xDD, 0xFF, 0x76, 0xF0, 0xFF, 0xA0,
  0x76, 0xF2, 0x40, 0xF0, 0xF1, 0xF0, 0xBA, 0xC0, 0xFF, 0xB7, 0x20, 0xBB,
  0xF5, 0xA9, 0x50, 0xB7, 0x25, 0x00, 0xD7, 0x57, 0x50, 0xFE, 0xD5, 0x70,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 5, 4, 0, -5 },
  { 8, 5, 5, 5, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 1, 6, 2, 0, -5 },
  { 19, 3, 2, 3, 0, -5 },
  { 20, 3, 3, 4, 0, -4 },
  { 22, 1, 2, 1, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 1, 0, -1 },
  { 25, 2, 5, 2, 0, -5 },
  { 27, 3, 5, 4, 0, -5 },
  { 29, 1, 5, 4, 1, -5 },
  { 30, 3, 5, 4, 0, -5 },
  { 32, 3, 5, 4, 0, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 3, 5, 4, 0, -5 },
  { 40, 3, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 0, -5 },
  { 44, 3, 5, 4, 0, -5 },
  { 46, 1, 4, 1, 0, -4 },
  { 47, 1, 5, 1, 0, -4 },
  { 48, 3, 3, 4, 0, -4 },
  { 50, 3, 1, 4, 0, -3 },
  { 51, 3, 3, 4, 0, -4 },
  { 53, 2, 5, 3, 0, -5 },
  { 55, 5, 6, 5, 0, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 2, 5, 4, 1, -5 },
  { 64, 4, 5, 4, 0, -5 },
  { 67, 3, 5, 4, 1, -5 },
  { 69, 2, 5, 3, 1, -5 },
  { 71, 2, 5, 3, 1, -5 },
  { 73, 4, 5, 5, 0, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 1, 5, 2, 0, -5 },
  { 79, 2, 6, 2, -1, -5 },
  { 81, 2, 5, 3, 1, -5 },
  { 83, 2, 5, 3, 1, -5 },
  { 85, 4, 5, 5, 1, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 4, 5, 5, 0, -5 },
  { 93, 2, 5, 4, 1, -5 },
  { 95, 4, 6, 5, 0, -5 },
  { 98, 2, 5, 4, 1, -5 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 3, 5, 4, 1, -5 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 5, 5, 6, 0, -5 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 3, 5, 3, 0, -5 },
  { 118, 1, 6, 2, 1, -5 },
  { 119, 2, 5, 2, 0, -5 },
  { 121, 2, 6, 2, 0, -5 },
  { 123, 3, 3, 4, 0, -5 },
  { 125, 3, 1, 3, 0, 0 },
  { 126, 1, 1, 2, 0, -5 },
  { 127, 3, 4, 3, 0, -4 },
  { 129, 2, 5, 4, 1, -5 },
  { 131, 3, 4, 3, 0, -4 },
  { 133, 3, 5, 4, 0, -5 },
  { 135, 3, 4, 3, 0, -4 },
  { 137, 2, 5, 2, 0, -5 },
  { 139, 3, 6, 4, 0, -4 },
  { 142, 2, 5, 4, 1, -5 },
  { 144, 1, 5, 1, 0, -5 },
  { 145, 1, 7, 1, 0, -5 },
  { 146, 2, 5, 3, 1, -5 },
  { 148, 1, 5, 1, 0, -5 },
  { 149, 4, 4, 5, 1, -4 },
  { 151, 2, 4, 4, 1, -4 },
  { 152, 3, 4, 4, 0, -4 },
  { 154, 2, 6, 4, 1, -4 },
  { 156, 3, 6, 4, 0, -4 },
  { 159, 1, 4, 2, 1, -4 },
  { 160, 3, 4, 3, 0, -4 },
  { 162, 2, 5, 2, 0, -5 },
  { 164, 2, 4, 4, 1, -4 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 4, 4, 4, 0, -4 },
  { 169, 3, 4, 3, 0, -4 },
  { 171, 3, 6, 3, 0, -4 },
  { 174, 2, 4, 3, 0, -4 },
  { 175, 2, 6, 2, 0, -5 },
  { 177, 1, 7, 3, 1, -5 },
  { 178, 2, 6, 2, 0, -5 },
  { 180, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Thin7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_THIN7PT7B_H_
