#ifndef _NOTOSANS_SEMICONDENSED_THIN21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0x99, 0x99, 0x90, 0x08, 0x41, 0x10, 0x22, 0x04, 0x47,
  0xFE, 0x11, 0x04, 0x20, 0x88, 0x11, 0x1F, 0xFC, 0x44, 0x08, 0x82, 0x10,
  0x42, 0x08, 0x80, 0x10, 0x3E, 0x50, 0x90, 0x90, 0x90, 0x90, 0x70, 0x08,
  0x16, 0x11, 0x11, 0x11, 0x11, 0x92, 0x7C, 0x10, 0x70, 0x44, 0x42, 0x22,
  0x21, 0x11, 0x08, 0x90, 0x44, 0x82, 0x29, 0xD1, 0x51, 0x72, 0x88, 0x28,
  0x41, 0x42, 0x12, 0x10, 0x88, 0x88, 0x44, 0x41, 0xC0, 0x3C, 0x04, 0x41,
  0x08, 0x21, 0x02, 0x20, 0x48, 0x06, 0x01, 0x40, 0x44, 0x30, 0x8A, 0x09,
  0x40, 0xA8, 0x09, 0x02, 0x9F, 0x88, 0xF8, 0x32, 0x44, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x44, 0x23, 0x89, 0x12, 0x49, 0x24, 0x92, 0x4A, 0x50, 0x10,
  0x10, 0x91, 0x76, 0x18, 0x24, 0x66, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x6A, 0x80, 0xF8, 0x80, 0x04, 0x10, 0x42,
  0x08, 0x21, 0x04, 0x10, 0x82, 0x10, 0x41, 0x08, 0x00, 0x3E, 0x42, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C,
  0x13, 0xD1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x10, 0x7C, 0x82, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFF, 0x7E,
  0x81, 0x01, 0x01, 0x01, 0x02, 0x04, 0x3C, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0xFE, 0x01, 0x00, 0xC0, 0x50, 0x14, 0x09, 0x02, 0x41, 0x10, 0x84,
  0x21, 0x10, 0x4F, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x10, 0x7F, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x7E, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFE,
  0x1F, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0xF9, 0x82, 0x81, 0x40, 0x60,
  0x30, 0x14, 0x12, 0x08, 0xF8, 0xFF, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x3E, 0x41, 0x81, 0x81,
  0x41, 0x42, 0x34, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E, 0x3C,
  0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x01, 0x01, 0x01, 0x02,
  0x02, 0xFC, 0x80, 0x20, 0x40, 0x00, 0x1A, 0xA0, 0x01, 0x83, 0x06, 0x0C,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x00,
  0xF8, 0x10, 0x41, 0x04, 0x20, 0x84, 0x21, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xE0, 0x60, 0x42, 0x00, 0x90, 0x01, 0x43, 0x86, 0x11, 0x18, 0x84,
  0x62, 0x11, 0x88, 0x46, 0x21, 0x18, 0x84, 0x62, 0x31, 0x87, 0x39, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x04, 0x01, 0x80, 0x28, 0x05, 0x01,
  0x20, 0x22, 0x04, 0x41, 0x08, 0x3F, 0x84, 0x11, 0x02, 0x20, 0x24, 0x05,
  0x00, 0xA0, 0x08, 0xFE, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFE, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xFE, 0x1F, 0xC8, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0xFC, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0xCF, 0xC0, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x7F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x7F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x00,
  0x0F, 0xE6, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1E, 0x80,
  0x30, 0x06, 0x00, 0xA0, 0x14, 0x02, 0x40, 0x47, 0xF8, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0xE9, 0x24, 0x92, 0x49, 0x24, 0xB8, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xB8, 0x81, 0x82, 0x84, 0x88,
  0x90, 0x90, 0xA0, 0xD0, 0x90, 0x88, 0x84, 0x84, 0x82, 0x81, 0x81, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0x80, 0x80, 0x18, 0x01, 0xC0, 0x3C, 0x03, 0xA0, 0x5A, 0x05, 0xA0, 0x59,
  0x09, 0x90, 0x98, 0x89, 0x89, 0x18, 0x91, 0x86, 0x18, 0x61, 0x82, 0x10,
  0x80, 0xC0, 0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x11, 0x84, 0xC2, 0x60,
  0xB0, 0x58, 0x1C, 0x06, 0x02, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x40,
  0x22, 0x04, 0x1F, 0x80, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84,
  0xF8, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x82, 0x04, 0x40, 0x24,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14,
  0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84, 0xF8, 0x88, 0x84, 0x82,
  0x82, 0x81, 0x81, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x40, 0x20, 0x1C, 0x02,
  0x01, 0x01, 0x01, 0x01, 0x01, 0xFE, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0A, 0x04, 0xFC, 0x80, 0x60, 0x14, 0x05, 0x02, 0x40, 0x88, 0x22,
  0x10, 0x84, 0x11, 0x04, 0x81, 0x20, 0x48, 0x0C, 0x03, 0x00, 0x40, 0x80,
  0x81, 0x40, 0x81, 0x41, 0x81, 0x41, 0x42, 0x41, 0x42, 0x22, 0x42, 0x22,
  0x42, 0x22, 0x24, 0x22, 0x24, 0x14, 0x24, 0x14, 0x24, 0x14, 0x18, 0x14,
  0x18, 0x08, 0x18, 0x08, 0x10, 0x40, 0xA0, 0x88, 0x44, 0x41, 0x20, 0xA0,
  0x20, 0x10, 0x14, 0x09, 0x08, 0x84, 0x24, 0x12, 0x06, 0x02, 0x80, 0xC0,
  0x50, 0x48, 0x22, 0x21, 0x10, 0x50, 0x28, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x8F, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x40, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F,
  0x08, 0x0A, 0x05, 0x04, 0x42, 0x22, 0x09, 0x05, 0x01, 0xFF, 0x88, 0x80,
  0x7C, 0x04, 0x08, 0x10, 0x2F, 0xE0, 0xC1, 0x83, 0x0D, 0xE8, 0x80, 0x80,
  0x80, 0x80, 0x90, 0xEC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x80, 0xF8,
  0x01, 0x01, 0x01, 0x01, 0x09, 0x37, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x3F, 0x3E, 0x42, 0x81, 0x81, 0x81, 0xFE, 0x80, 0x80,
  0x80, 0x40, 0x3F, 0x1C, 0x82, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x7E, 0x81, 0x02, 0x04, 0x09, 0x1D,
  0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x8F, 0xFE, 0x10,
  0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2E, 0x81, 0x02, 0x04,
  0x08, 0x10, 0xA2, 0x48, 0xA1, 0x43, 0x84, 0x88, 0x91, 0x21, 0x43, 0xFF,
  0xFF, 0xF9, 0xF8, 0x61, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18,
  0x21, 0x82, 0x18, 0x21, 0x82, 0x10, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x08, 0x3E, 0x20, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x20, 0x8F, 0x80, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01,
  0x01, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x7D, 0x02, 0x04, 0x06,
  0x03, 0x01, 0x01, 0x02, 0x07, 0xF0, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x1C, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0D,
  0xE8, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18, 0x10,
  0x82, 0x0C, 0x10, 0x51, 0x44, 0x8A, 0x24, 0x51, 0x12, 0x48, 0xA2, 0x85,
  0x14, 0x28, 0x60, 0x82, 0x04, 0x10, 0x41, 0x42, 0x22, 0x14, 0x18, 0x08,
  0x14, 0x24, 0x22, 0x42, 0xC1, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24,
  0x24, 0x18, 0x18, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFC, 0x10, 0x82,
  0x10, 0x82, 0x10, 0x42, 0x0F, 0xC0, 0x19, 0x08, 0x42, 0x10, 0x84, 0x46,
  0x08, 0x42, 0x10, 0x84, 0x20, 0xC0, 0xFF, 0xFF, 0xF8, 0xC1, 0x08, 0x42,
  0x10, 0x84, 0x10, 0xC4, 0x42, 0x10, 0x84, 0x27, 0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 15, 4, 2, -15 },
  { 3, 4, 5, 7, 1, -15 },
  { 6, 11, 15, 12, 0, -15 },
  { 27, 8, 17, 11, 1, -16 },
  { 44, 13, 15, 15, 1, -15 },
  { 69, 11, 15, 12, 1, -15 },
  { 90, 1, 5, 4, 1, -15 },
  { 91, 4, 18, 5, 1, -15 },
  { 100, 3, 18, 5, 1, -15 },
  { 107, 8, 7, 10, 1, -16 },
  { 114, 9, 9, 11, 1, -12 },
  { 125, 2, 5, 4, 1, -2 },
  { 127, 5, 1, 6, 1, -6 },
  { 128, 1, 1, 4, 2, -1 },
  { 129, 6, 15, 7, 0, -15 },
  { 141, 8, 15, 11, 1, -15 },
  { 156, 4, 15, 11, 2, -15 },
  { 164, 8, 15, 11, 1, -15 },
  { 179, 8, 15, 11, 1, -15 },
  { 194, 10, 15, 11, 0, -15 },
  { 213, 8, 15, 11, 1, -15 },
  { 228, 9, 15, 11, 1, -15 },
  { 245, 8, 15, 11, 1, -15 },
  { 260, 8, 15, 11, 1, -15 },
  { 275, 8, 15, 11, 1, -15 },
  { 290, 1, 11, 4, 2, -11 },
  { 292, 2, 14, 4, 1, -11 },
  { 296, 9, 9, 11, 1, -12 },
  { 307, 9, 5, 11, 1, -10 },
  { 313, 9, 9, 11, 1, -12 },
  { 324, 6, 15, 8, 1, -15 },
  { 336, 14, 17, 16, 1, -15 },
  { 366, 11, 15, 11, 0, -15 },
  { 387, 8, 15, 11, 2, -15 },
  { 402, 10, 15, 11, 1, -15 },
  { 421, 10, 15, 13, 2, -15 },
  { 440, 7, 15, 10, 2, -15 },
  { 454, 7, 15, 9, 2, -15 },
  { 468, 11, 15, 14, 1, -15 },
  { 489, 9, 15, 13, 2, -15 },
  { 506, 3, 15, 5, 1, -15 },
  { 512, 5, 19, 5, -2, -15 },
  { 524, 8, 15, 10, 2, -15 },
  { 539, 7, 15, 9, 2, -15 },
  { 553, 12, 15, 16, 2, -15 },
  { 576, 9, 15, 13, 2, -15 },
  { 593, 12, 15, 14, 1, -15 },
  { 616, 8, 15, 11, 2, -15 },
  { 631, 12, 19, 14, 1, -15 },
  { 660, 8, 15, 11, 2, -15 },
  { 675, 8, 15, 10, 1, -15 },
  { 690, 9, 15, 9, 0, -15 },
  { 707, 9, 15, 13, 2, -15 },
  { 724, 10, 15, 10, 0, -15 },
  { 743, 16, 15, 17, 0, -15 },
  { 773, 9, 15, 9, 0, -15 },
  { 790, 9, 15, 9, 0, -15 },
  { 807, 8, 15, 10, 1, -15 },
  { 822, 4, 18, 7, 2, -15 },
  { 831, 6, 15, 7, 0, -15 },
  { 843, 4, 18, 7, 1, -15 },
  { 852, 9, 8, 11, 1, -15 },
  { 861, 8, 1, 8, 0, 2 },
  { 862, 3, 3, 5, 1, -16 },
  { 864, 7, 11, 10, 1, -11 },
  { 874, 8, 16, 11, 2, -16 },
  { 890, 7, 11, 9, 1, -11 },
  { 900, 8, 16, 11, 1, -16 },
  { 916, 8, 11, 10, 1, -11 },
  { 927, 6, 16, 5, 0, -16 },
  { 939, 8, 16, 11, 1, -11 },
  { 955, 7, 16, 11, 2, -16 },
  { 969, 1, 15, 4, 2, -15 },
  { 971, 4, 20, 4, -1, -15 },
  { 981, 7, 16, 9, 2, -16 },
  { 995, 1, 16, 4, 2, -16 },
  { 997, 12, 11, 16, 2, -11 },
  { 1014, 7, 11, 11, 2, -11 },
  { 1024, 9, 11, 11, 1, -11 },
  { 1037, 8, 16, 11, 2, -11 },
  { 1053, 8, 16, 11, 1, -11 },
  { 1069, 5, 11, 7, 2, -11 },
  { 1076, 7, 11, 8, 1, -11 },
  { 1086, 5, 14, 6, 0, -14 },
  { 1095, 7, 11, 11, 2, -11 },
  { 1105, 8, 11, 8, 0, -11 },
  { 1116, 13, 11, 13, 0, -11 },
  { 1134, 8, 11, 9, 0, -11 },
  { 1145, 8, 16, 8, 0, -11 },
  { 1161, 6, 11, 8, 1, -11 },
  { 1170, 5, 18, 7, 1, -15 },
  { 1182, 1, 21, 10, 4, -16 },
  { 1185, 5, 18, 7, 1, -15 },
  { 1197, 9, 1, 11, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Thin21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_THIN21PT7B_H_
