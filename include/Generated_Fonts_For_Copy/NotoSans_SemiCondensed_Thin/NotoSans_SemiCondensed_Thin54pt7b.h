#ifndef _NOTOSANS_SEMICONDENSED_THIN54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin54pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xA4, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x07, 0xF8, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x18, 0x02, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x10, 0x02, 0x00, 0x01, 0x00, 0x60, 0x00, 0x10,
  0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x08,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x20, 0x0F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x02, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x20,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xE0, 0x0F,
  0x4F, 0xE1, 0x84, 0x0C, 0x30, 0x40, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x0C,
  0x04, 0x00, 0x80, 0x40, 0x08, 0x04, 0x00, 0x80, 0x40, 0x08, 0x04, 0x00,
  0xC0, 0x40, 0x0C, 0x04, 0x00, 0x60, 0x40, 0x03, 0x04, 0x00, 0x18, 0x40,
  0x00, 0xE4, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x04,
  0x70, 0x00, 0x41, 0x80, 0x04, 0x0C, 0x00, 0x40, 0x60, 0x04, 0x03, 0x00,
  0x40, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x40, 0x30, 0x04, 0x02, 0x00, 0x40, 0x68, 0x04, 0x1C,
  0xF8, 0x47, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x0C, 0x60, 0x00, 0x60, 0x0C,
  0x18, 0x00, 0x20, 0x0C, 0x06, 0x00, 0x30, 0x04, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x0C, 0x00,
  0x80, 0x08, 0x04, 0x00, 0x40, 0x04, 0x06, 0x00, 0x20, 0x02, 0x02, 0x00,
  0x10, 0x01, 0x03, 0x00, 0x08, 0x00, 0x81, 0x00, 0x04, 0x00, 0x41, 0x80,
  0x02, 0x00, 0x20, 0x80, 0x01, 0x00, 0x30, 0xC0, 0xC0, 0xC0, 0x18, 0x61,
  0xF8, 0x60, 0x0C, 0x21, 0x86, 0x10, 0x04, 0x31, 0x81, 0x88, 0x02, 0x10,
  0x80, 0x46, 0x03, 0x18, 0xC0, 0x31, 0x83, 0x08, 0x40, 0x08, 0x63, 0x0C,
  0x20, 0x04, 0x1F, 0x04, 0x10, 0x02, 0x00, 0x06, 0x18, 0x01, 0x00, 0x02,
  0x0C, 0x00, 0x80, 0x03, 0x06, 0x00, 0x60, 0x01, 0x03, 0x00, 0x30, 0x01,
  0x81, 0x80, 0x18, 0x00, 0x80, 0xC0, 0x08, 0x00, 0xC0, 0x60, 0x04, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x60, 0x08, 0x01, 0x00, 0x30, 0x04, 0x01, 0x80,
  0x10, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x40, 0x08, 0x00, 0x60, 0x60,
  0x0C, 0x00, 0x18, 0x60, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x80, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x18, 0x00, 0x20, 0x03,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x08, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x13, 0x00, 0x30, 0x02, 0x40, 0x03, 0x00,
  0xD8, 0x00, 0x20, 0x1B, 0x00, 0x06, 0x02, 0x40, 0x00, 0x60, 0xC8, 0x00,
  0x06, 0x11, 0x00, 0x00, 0x66, 0x20, 0x00, 0x06, 0x84, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x6C, 0x30, 0x00,
  0x18, 0xC3, 0x00, 0x0C, 0x08, 0x38, 0x07, 0x00, 0x81, 0xFF, 0x80, 0x18,
  0x06, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x02,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x10,
  0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x08, 0x06, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x20, 0x10, 0x0F, 0x82, 0x07,
  0x1C, 0x47, 0x00, 0x7F, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x19, 0x00,
  0x02, 0x10, 0x00, 0x83, 0x00, 0x30, 0x20, 0x0C, 0x02, 0x03, 0x00, 0x60,
  0x20, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x18, 0x84, 0x63, 0x18, 0x84, 0x62, 0x11, 0x88, 0x00, 0xFF, 0xF0, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x38,
  0x03, 0x00, 0x60, 0x10, 0x01, 0x81, 0x80, 0x04, 0x18, 0x00, 0x30, 0x80,
  0x00, 0x84, 0x00, 0x06, 0x60, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04,
  0x80, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0x20,
  0x00, 0x09, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x21, 0x80, 0x01,
  0x04, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x81, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xB0, 0xE6, 0x30, 0xCC, 0x1F,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x00, 0xF0,
  0x70, 0x0C, 0x00, 0xE0, 0xC0, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3E, 0x1E, 0x03, 0x80, 0x0C, 0x18,
  0x00, 0x18, 0x40, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0xE3, 0xE0, 0x0E, 0x01,
  0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03,
  0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x40, 0x80, 0x00, 0x30, 0x20, 0x00,
  0x18, 0x08, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x20,
  0x00, 0x40, 0x08, 0x00, 0x30, 0x02, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x40, 0x00, 0x80, 0x30,
  0x00, 0x20, 0x08, 0x00, 0x08, 0x06, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x27, 0xFC, 0x03, 0xF8, 0x78, 0x08,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xCC, 0x00,
  0x1C, 0x78, 0x03, 0x80, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0x83, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x07, 0x00, 0x43, 0xFF, 0x06, 0x30, 0x06, 0x33, 0x00, 0x19, 0xA0,
  0x00, 0x6F, 0x00, 0x01, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00,
  0x00, 0xA0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x20, 0x00, 0x19,
  0x80, 0x00, 0x84, 0x00, 0x0C, 0x30, 0x00, 0x40, 0xC0, 0x04, 0x03, 0x80,
  0xC0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3C, 0x7C, 0x03, 0x00, 0x30, 0x20, 0x00, 0xC3,
  0x00, 0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x02, 0x60, 0x00,
  0x13, 0x00, 0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x18,
  0x00, 0x30, 0x60, 0x03, 0x01, 0x80, 0x30, 0x03, 0x07, 0x00, 0x0E, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xB8, 0x00, 0x70, 0x70, 0x06, 0x00, 0xC0, 0x60,
  0x03, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x32, 0x00, 0x00, 0xB0, 0x00, 0x07,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x41,
  0x80, 0x0E, 0x06, 0x01, 0xC0, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0x03, 0xFC,
  0x00, 0x78, 0x70, 0x06, 0x00, 0xE0, 0x60, 0x01, 0x82, 0x00, 0x04, 0x30,
  0x00, 0x31, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x34, 0x00, 0x00,
  0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xD0, 0x00, 0x0E,
  0xC0, 0x00, 0xF3, 0x00, 0x0D, 0x8C, 0x00, 0xCC, 0x38, 0x3C, 0x60, 0x7F,
  0x82, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x20,
  0x0E, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x5F, 0xA0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x11, 0xCE, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0x8C, 0x63,
  0x10, 0x8C, 0x42, 0x31, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xF8, 0xF0, 0x80, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x00, 0x62, 0x00, 0x1F, 0xF8, 0x02, 0x60, 0x03, 0x00, 0x80, 0x26, 0x00,
  0x60, 0x08, 0x03, 0x40, 0x0C, 0x00, 0x80, 0x3C, 0x01, 0x80, 0x08, 0x01,
  0xC0, 0x10, 0x00, 0x80, 0x1C, 0x03, 0x00, 0x08, 0x01, 0xC0, 0x30, 0x00,
  0x80, 0x18, 0x02, 0x00, 0x18, 0x01, 0x80, 0x20, 0x01, 0x80, 0x18, 0x02,
  0x00, 0x18, 0x01, 0x80, 0x20, 0x01, 0x80, 0x18, 0x02, 0x00, 0x18, 0x03,
  0x80, 0x20, 0x01, 0x80, 0x38, 0x02, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x03,
  0x80, 0x2C, 0x03, 0x00, 0x28, 0x06, 0xC0, 0x10, 0x06, 0x80, 0x44, 0x01,
  0x80, 0xCC, 0x0C, 0x40, 0x0E, 0x38, 0x63, 0x86, 0x00, 0x3E, 0x03, 0xE0,
  0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x40, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x32, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x08, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x30, 0x02, 0x00, 0x04, 0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x18, 0x00, 0x80, 0x03, 0x00, 0x3F, 0xFF, 0xE0, 0x04,
  0x00, 0x04, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x04, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x30, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x24, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x08, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x08, 0x00, 0x1C, 0x20, 0x00,
  0x18, 0x80, 0x00, 0x32, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x06,
  0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x18, 0x80, 0x00,
  0xC2, 0x00, 0x0E, 0x0F, 0xFF, 0xE0, 0x20, 0x07, 0xE0, 0x80, 0x00, 0xE2,
  0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68,
  0x00, 0x03, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2, 0x00, 0x3E, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x30, 0x00, 0x40,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x18, 0x00, 0xFF, 0xF8, 0x00, 0x02, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x20, 0x00, 0xE0, 0x10, 0x00, 0x1C, 0x08, 0x00, 0x03, 0x04, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x31, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x40,
  0x00, 0x01, 0x20, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x0C, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x08,
  0x00, 0x1C, 0x04, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0F, 0xFF, 0xFA, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0xA0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0xFC,
  0x00, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x01,
  0xC0, 0x00, 0x10, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x20, 0xE7, 0xF0, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0xC8, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2, 0x00, 0x06, 0x08,
  0x00, 0x30, 0x20, 0x01, 0x80, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x01,
  0x80, 0x20, 0x0C, 0x00, 0x80, 0x60, 0x02, 0x03, 0x00, 0x08, 0x18, 0x00,
  0x20, 0xC0, 0x00, 0x87, 0x00, 0x02, 0x1C, 0x00, 0x08, 0xD0, 0x00, 0x26,
  0x60, 0x00, 0xB0, 0xC0, 0x02, 0x81, 0x00, 0x0C, 0x06, 0x00, 0x20, 0x0C,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00,
  0x80, 0x06, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x00, 0x60, 0x80,
  0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x06, 0x20, 0x00, 0x08, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x68, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFC, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1D, 0x00,
  0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0xB2, 0x00, 0x00, 0x03, 0x64, 0x00,
  0x00, 0x06, 0xCC, 0x00, 0x00, 0x09, 0x88, 0x00, 0x00, 0x33, 0x18, 0x00,
  0x00, 0x46, 0x30, 0x00, 0x00, 0x8C, 0x20, 0x00, 0x03, 0x18, 0x60, 0x00,
  0x04, 0x30, 0x40, 0x00, 0x18, 0x60, 0x80, 0x00, 0x30, 0xC1, 0x80, 0x00,
  0x41, 0x81, 0x00, 0x01, 0x83, 0x03, 0x00, 0x02, 0x06, 0x06, 0x00, 0x04,
  0x0C, 0x04, 0x00, 0x18, 0x18, 0x0C, 0x00, 0x20, 0x30, 0x08, 0x00, 0xC0,
  0x60, 0x10, 0x01, 0x80, 0xC0, 0x30, 0x02, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x20, 0x0C, 0x00, 0x80, 0xC0, 0x18,
  0x01, 0x81, 0x00, 0x30, 0x03, 0x02, 0x00, 0x60, 0x02, 0x0C, 0x00, 0xC0,
  0x06, 0x10, 0x01, 0x80, 0x04, 0x60, 0x03, 0x00, 0x08, 0xC0, 0x06, 0x00,
  0x19, 0x00, 0x0C, 0x00, 0x16, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xA0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x90, 0x00,
  0x03, 0x98, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x86, 0x00,
  0x03, 0x82, 0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x03, 0x81, 0x80,
  0x03, 0x80, 0xC0, 0x03, 0x80, 0x40, 0x03, 0x80, 0x60, 0x03, 0x80, 0x20,
  0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x03, 0x80, 0x08, 0x03, 0x80, 0x0C,
  0x03, 0x80, 0x04, 0x03, 0x80, 0x06, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01,
  0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00,
  0x63, 0x80, 0x00, 0x23, 0x80, 0x00, 0x33, 0x80, 0x00, 0x13, 0x80, 0x00,
  0x1B, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x80, 0x07, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00,
  0x06, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x18,
  0x80, 0x0F, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x20, 0x01, 0xC1, 0x00, 0x03, 0x88, 0x00,
  0x04, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x06, 0x80, 0x00, 0x34,
  0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00,
  0x1A, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00, 0x06, 0x20,
  0x00, 0x61, 0x00, 0x0E, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x02, 0x00, 0x40,
  0x10, 0x03, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20, 0x01, 0x81, 0x00,
  0x0C, 0x08, 0x00, 0x30, 0x40, 0x00, 0x82, 0x00, 0x06, 0x10, 0x00, 0x10,
  0x80, 0x00, 0xC4, 0x00, 0x02, 0x20, 0x00, 0x19, 0x00, 0x00, 0x68, 0x00,
  0x03, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x00, 0x3C, 0x1F,
  0x87, 0x00, 0x08, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC8, 0x00, 0x1C, 0x70, 0x03, 0xC1, 0xFF,
  0xF8, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x08, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x08, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x08, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x08,
  0x01, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x08, 0x00, 0x30, 0x01, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x40, 0x00, 0x1C, 0x00, 0x03, 0x60, 0x00, 0x3C,
  0x00, 0x02, 0x20, 0x00, 0x34, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x06,
  0x20, 0x00, 0x26, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x04, 0x10, 0x00,
  0x62, 0x00, 0x04, 0x10, 0x00, 0x42, 0x00, 0x0C, 0x10, 0x00, 0x43, 0x00,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x08, 0x08, 0x00, 0xC1, 0x00, 0x08, 0x08,
  0x00, 0x81, 0x00, 0x18, 0x08, 0x00, 0x81, 0x80, 0x18, 0x0C, 0x00, 0x81,
  0x80, 0x10, 0x04, 0x01, 0x80, 0x80, 0x30, 0x04, 0x01, 0x80, 0x80, 0x30,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x02, 0x03,
  0x00, 0x40, 0x60, 0x02, 0x03, 0x00, 0x40, 0x60, 0x02, 0x02, 0x00, 0x60,
  0x60, 0x03, 0x02, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00, 0x20, 0xC0, 0x01,
  0x06, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x30, 0x80, 0x01, 0x84, 0x00,
  0x30, 0x80, 0x00, 0x8C, 0x00, 0x11, 0x80, 0x00, 0x8C, 0x00, 0x11, 0x80,
  0x00, 0x88, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x00, 0x58,
  0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x02, 0x30, 0x00, 0x06, 0x10, 0x00,
  0x04, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x04, 0x00,
  0x30, 0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00,
  0xC0, 0x01, 0x80, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x43, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x81, 0x80, 0x01, 0x80,
  0x80, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x20, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x10, 0x18, 0x00, 0x18, 0x10, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x22, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x08,
  0x08, 0x00, 0x30, 0x18, 0x00, 0x40, 0x10, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x20, 0x0C, 0x00, 0x60, 0x10, 0x00, 0x40, 0x60, 0x00, 0xC0, 0xC0, 0x00,
  0x81, 0x00, 0x01, 0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x06,
  0x40, 0x00, 0x05, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x20, 0x00,
  0x06, 0x60, 0x00, 0x08, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x40, 0x80, 0x01,
  0x81, 0x80, 0x02, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x02, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x10, 0x00,
  0x18, 0x60, 0x00, 0x10, 0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x03, 0x01, 0xFC, 0x01, 0xF1, 0xE0, 0x60, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0xFF, 0xC0, 0xF8, 0x18, 0x70, 0x03, 0x38, 0x00, 0x66, 0x00, 0x0D, 0x80,
  0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x40, 0x01, 0xEC, 0x00, 0x2C, 0x80, 0x09, 0x9C, 0x06, 0x30, 0xFF,
  0x86, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x0F, 0xE0, 0x61, 0xE3, 0xC3, 0x30, 0x03, 0x1B, 0x00, 0x0C, 0xD0, 0x00,
  0x27, 0x80, 0x01, 0xB8, 0x00, 0x05, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x05,
  0xC0, 0x00, 0x6F, 0x00, 0x02, 0x68, 0x00, 0x33, 0x20, 0x03, 0x18, 0xC0,
  0x70, 0xC3, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xF8, 0xF0,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x03, 0xFF,
  0x80, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x1F,
  0xC0, 0x83, 0xC3, 0x84, 0x30, 0x06, 0x23, 0x00, 0x19, 0x30, 0x00, 0x69,
  0x00, 0x01, 0x58, 0x00, 0x0E, 0x80, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x0E, 0xC0,
  0x00, 0x52, 0x00, 0x02, 0x98, 0x00, 0x24, 0x60, 0x03, 0x21, 0xC0, 0x71,
  0x03, 0xFE, 0x08, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x78, 0xF0, 0x0C,
  0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0x43, 0x00, 0x06, 0x60, 0x00, 0x26,
  0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x20, 0x70, 0x0E, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0xFE, 0x07,
  0x04, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFE, 0x1F, 0xFC, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x01, 0xFE, 0x08, 0x3C, 0x78, 0x43, 0x00, 0x22, 0x30, 0x00,
  0xB3, 0x00, 0x03, 0x90, 0x00, 0x1D, 0x80, 0x00, 0xE8, 0x00, 0x03, 0x40,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xA0, 0x00, 0x0D,
  0x00, 0x00, 0xEC, 0x00, 0x07, 0x20, 0x00, 0x79, 0x80, 0x02, 0xC6, 0x00,
  0x26, 0x1C, 0x06, 0x30, 0x3F, 0xE1, 0x80, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x8C, 0x00, 0x38, 0x3E,
  0x0F, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x1F, 0xC1,
  0x8F, 0x0E, 0x33, 0x00, 0x66, 0xC0, 0x06, 0xD0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x20, 0xDF, 0x80, 0x00, 0x01, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x03, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x03, 0x37, 0x9F, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x0C, 0x30,
  0x06, 0x0C, 0x01, 0x03, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x18,
  0x03, 0x04, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0xD8, 0x03, 0x63, 0x00,
  0xD0, 0x40, 0x38, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x40, 0xC0, 0x18, 0x30,
  0x02, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x02, 0x30, 0x00, 0xCC, 0x00,
  0x13, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC1, 0xF8, 0x03, 0xF0, 0x63, 0x87, 0x07, 0x9E, 0x33, 0x00, 0x86, 0x01,
  0x9B, 0x00, 0x66, 0x00, 0x6F, 0x00, 0x1A, 0x00, 0x17, 0x00, 0x07, 0x00,
  0x0F, 0x80, 0x03, 0x00, 0x07, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x20, 0x00, 0x38, 0x00, 0x10,
  0x00, 0x1C, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x07, 0x00, 0x02,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x20, 0x00, 0x38, 0x00, 0x10, 0x00, 0x1C, 0x00,
  0x08, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x07, 0x00, 0x02, 0x00, 0x03, 0x80,
  0x01, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x20, 0x00, 0x38, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x08,
  0xC1, 0xFC, 0x18, 0x70, 0xE3, 0x30, 0x06, 0x6C, 0x00, 0x6D, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x01, 0xFE, 0x00,
  0x1E, 0x3E, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0x80,
  0x00, 0xC6, 0x00, 0x01, 0x10, 0x00, 0x06, 0x40, 0x00, 0x1B, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x04, 0x30, 0x00, 0x30, 0x40, 0x01, 0x81, 0x80, 0x0C, 0x03,
  0x80, 0x60, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x81, 0xFC, 0x08, 0x78,
  0xF0, 0x8C, 0x01, 0x89, 0x00, 0x0C, 0xB0, 0x00, 0x4E, 0x00, 0x06, 0xC0,
  0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xA0, 0x00, 0x4B, 0x00,
  0x0C, 0x98, 0x01, 0x88, 0xE0, 0x70, 0x87, 0xFC, 0x08, 0x0C, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x08, 0x3C, 0x78, 0x43, 0x00,
  0x62, 0x30, 0x01, 0xB3, 0x00, 0x07, 0x90, 0x00, 0x1D, 0x80, 0x00, 0xE8,
  0x00, 0x03, 0x40, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xA0, 0x00, 0x0D, 0x00, 0x00, 0xEC, 0x00, 0x07, 0x20, 0x00, 0x79, 0x80,
  0x02, 0xC6, 0x00, 0x26, 0x1C, 0x06, 0x30, 0x7F, 0xE1, 0x80, 0x70, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x83, 0xF8, 0xF7, 0x98,
  0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x03, 0xFC, 0x03, 0xC7, 0xE3, 0x80, 0x08, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x68, 0x00, 0x33, 0x80, 0x18, 0x3F, 0xFC, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xF8, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x07, 0xF0, 0x04,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x07, 0x40, 0x00,
  0xAC, 0x00, 0x34, 0xC0, 0x0C, 0x8C, 0x07, 0x10, 0xFF, 0x82, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x36, 0x00, 0x02, 0x60,
  0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x04, 0x10, 0x00, 0xC1,
  0x80, 0x08, 0x18, 0x00, 0x80, 0x80, 0x18, 0x0C, 0x01, 0x00, 0xC0, 0x10,
  0x04, 0x03, 0x00, 0x60, 0x20, 0x06, 0x02, 0x00, 0x20, 0x60, 0x02, 0x04,
  0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x09,
  0x80, 0x00, 0x90, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x02, 0x40, 0x01,
  0xC0, 0x02, 0x40, 0x03, 0x40, 0x06, 0x60, 0x02, 0x40, 0x06, 0x60, 0x02,
  0x40, 0x04, 0x20, 0x06, 0x60, 0x04, 0x20, 0x06, 0x20, 0x0C, 0x30, 0x04,
  0x20, 0x0C, 0x30, 0x04, 0x30, 0x08, 0x10, 0x0C, 0x30, 0x08, 0x10, 0x08,
  0x10, 0x18, 0x18, 0x08, 0x10, 0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x18,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x30, 0x0C, 0x10, 0x0C, 0x30, 0x04, 0x30,
  0x0C, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x36, 0x00, 0x06, 0x30,
  0x00, 0x41, 0x00, 0x0C, 0x18, 0x00, 0x80, 0x80, 0x18, 0x0C, 0x03, 0x00,
  0x60, 0x20, 0x02, 0x06, 0x00, 0x30, 0x40, 0x01, 0x8C, 0x00, 0x09, 0x80,
  0x00, 0xD0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xD0,
  0x00, 0x19, 0x80, 0x01, 0x0C, 0x00, 0x30, 0x40, 0x06, 0x06, 0x00, 0x60,
  0x30, 0x0C, 0x01, 0x00, 0x80, 0x18, 0x18, 0x00, 0x83, 0x00, 0x0C, 0x20,
  0x00, 0x66, 0x00, 0x02, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x1A, 0x00, 0x00,
  0x98, 0x00, 0x04, 0xC0, 0x00, 0x62, 0x00, 0x02, 0x18, 0x00, 0x10, 0xC0,
  0x01, 0x82, 0x00, 0x08, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x02, 0x00, 0x20,
  0x18, 0x01, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x80, 0x18, 0x04, 0x00, 0xC0,
  0x60, 0x02, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x02, 0x08, 0x00,
  0x18, 0x40, 0x00, 0xC6, 0x00, 0x02, 0x20, 0x00, 0x19, 0x00, 0x00, 0xD8,
  0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x8C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x04, 0x01, 0xF0, 0x1C, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x3C, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x38, 0x0F, 0x80,
  0x20, 0x00, 0x1F, 0xE0, 0x02, 0xE0, 0xF0, 0x0F, 0x00, 0x78, 0x74, 0x00,
  0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 39, 11, 4, -39 },
  { 16, 9, 14, 17, 4, -39 },
  { 32, 28, 39, 31, 1, -39 },
  { 169, 20, 44, 27, 3, -41 },
  { 279, 33, 40, 38, 3, -39 },
  { 444, 27, 40, 32, 3, -39 },
  { 579, 1, 14, 9, 4, -39 },
  { 581, 10, 48, 14, 2, -39 },
  { 641, 10, 48, 14, 2, -39 },
  { 701, 19, 19, 26, 3, -41 },
  { 747, 23, 24, 27, 2, -31 },
  { 816, 5, 13, 10, 2, -6 },
  { 825, 12, 1, 16, 2, -15 },
  { 827, 3, 3, 11, 4, -3 },
  { 829, 16, 39, 18, 1, -39 },
  { 907, 21, 39, 27, 3, -39 },
  { 1010, 11, 39, 27, 5, -39 },
  { 1064, 21, 39, 27, 3, -39 },
  { 1167, 22, 40, 27, 2, -39 },
  { 1277, 26, 39, 27, 1, -39 },
  { 1404, 21, 40, 27, 3, -39 },
  { 1509, 21, 40, 27, 3, -39 },
  { 1614, 21, 39, 27, 3, -39 },
  { 1717, 21, 40, 27, 3, -39 },
  { 1822, 21, 40, 27, 3, -39 },
  { 1927, 3, 29, 11, 4, -29 },
  { 1938, 5, 36, 11, 2, -29 },
  { 1961, 23, 23, 27, 2, -31 },
  { 2028, 23, 12, 27, 2, -25 },
  { 2063, 23, 23, 27, 2, -31 },
  { 2130, 16, 39, 19, 2, -39 },
  { 2208, 36, 43, 42, 3, -38 },
  { 2402, 27, 39, 27, 0, -39 },
  { 2534, 22, 39, 29, 5, -39 },
  { 2642, 25, 40, 29, 3, -39 },
  { 2767, 25, 39, 33, 5, -39 },
  { 2889, 18, 39, 26, 5, -39 },
  { 2977, 18, 39, 24, 5, -39 },
  { 3065, 28, 40, 35, 3, -39 },
  { 3205, 24, 39, 34, 5, -39 },
  { 3322, 8, 39, 14, 3, -39 },
  { 3361, 11, 48, 12, -4, -39 },
  { 3427, 22, 39, 27, 5, -39 },
  { 3535, 18, 39, 24, 5, -39 },
  { 3623, 31, 39, 42, 5, -39 },
  { 3775, 24, 39, 34, 5, -39 },
  { 3892, 30, 40, 36, 3, -39 },
  { 4042, 20, 39, 27, 5, -39 },
  { 4140, 30, 48, 36, 3, -39 },
  { 4320, 21, 39, 28, 5, -39 },
  { 4423, 21, 40, 26, 3, -39 },
  { 4528, 24, 39, 24, 0, -39 },
  { 4645, 24, 40, 34, 5, -39 },
  { 4765, 27, 39, 27, 0, -39 },
  { 4897, 40, 39, 43, 1, -39 },
  { 5092, 24, 39, 24, 0, -39 },
  { 5209, 23, 39, 23, 0, -39 },
  { 5322, 22, 39, 26, 2, -39 },
  { 5430, 10, 48, 17, 5, -39 },
  { 5490, 16, 39, 18, 1, -39 },
  { 5568, 10, 48, 17, 2, -39 },
  { 5628, 23, 22, 27, 2, -39 },
  { 5692, 21, 1, 21, 0, 5 },
  { 5695, 9, 8, 13, 2, -41 },
  { 5704, 19, 30, 25, 2, -29 },
  { 5776, 21, 42, 28, 4, -41 },
  { 5887, 18, 30, 22, 3, -29 },
  { 5955, 21, 42, 28, 3, -41 },
  { 6066, 20, 30, 26, 3, -29 },
  { 6141, 15, 41, 14, 1, -41 },
  { 6218, 21, 42, 28, 3, -29 },
  { 6329, 19, 41, 28, 4, -41 },
  { 6427, 3, 39, 11, 4, -39 },
  { 6442, 9, 52, 11, -2, -39 },
  { 6501, 18, 41, 22, 4, -41 },
  { 6594, 1, 41, 10, 5, -41 },
  { 6600, 33, 29, 41, 4, -29 },
  { 6720, 19, 29, 28, 4, -29 },
  { 6789, 22, 30, 28, 3, -29 },
  { 6872, 20, 42, 28, 5, -29 },
  { 6977, 21, 42, 28, 3, -29 },
  { 7088, 12, 29, 18, 5, -29 },
  { 7132, 18, 30, 22, 2, -29 },
  { 7200, 13, 37, 15, 1, -36 },
  { 7261, 19, 30, 28, 4, -29 },
  { 7333, 20, 29, 21, 0, -29 },
  { 7406, 32, 28, 34, 1, -28 },
  { 7518, 20, 29, 23, 1, -29 },
  { 7591, 21, 42, 21, 0, -29 },
  { 7702, 17, 29, 21, 2, -29 },
  { 7764, 14, 48, 18, 2, -39 },
  { 7848, 2, 54, 26, 12, -41 },
  { 7862, 14, 48, 18, 2, -39 },
  { 7946, 23, 4, 27, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Thin54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_THIN54PT7B_H_
