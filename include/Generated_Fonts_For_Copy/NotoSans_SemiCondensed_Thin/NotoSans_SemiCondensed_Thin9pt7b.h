#ifndef _NOTOSANS_SEMICONDENSED_THIN9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x53, 0xD5, 0xF5, 0x30, 0x6B, 0xA4, 0x33, 0xE2, 0x42,
  0xAB, 0x2B, 0x74, 0xD4, 0xC0, 0x22, 0x94, 0xCA, 0xCB, 0xE0, 0xC0, 0x6A,
  0xA4, 0xD5, 0x5C, 0x2D, 0x60, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x29, 0x29,
  0x00, 0x56, 0xDB, 0x78, 0xD5, 0x50, 0x61, 0x11, 0x24, 0xF0, 0x69, 0x16,
  0x11, 0xF0, 0x22, 0x59, 0x71, 0xF3, 0x93, 0xC0, 0x72, 0x7B, 0x78, 0xF1,
  0x22, 0x24, 0x69, 0x96, 0x99, 0x70, 0x69, 0x99, 0x71, 0x60, 0x88, 0x8C,
  0x3C, 0x61, 0xFF, 0xE1, 0x2C, 0xC4, 0x94, 0x10, 0x7D, 0x26, 0xAD, 0x5B,
  0xE8, 0x0E, 0x00, 0x63, 0x14, 0xE9, 0x44, 0xF7, 0xDB, 0xC0, 0x78, 0x88,
  0x88, 0xF0, 0xF9, 0x99, 0x9E, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x78,
  0x8A, 0x99, 0xF0, 0x99, 0xF9, 0x99, 0xD5, 0x70, 0x55, 0x56, 0xBA, 0x6B,
  0x40, 0x92, 0x49, 0xC0, 0x8C, 0x67, 0xBD, 0xD4, 0x99, 0xDB, 0xB9, 0x69,
  0x99, 0x99, 0xF0, 0xF6, 0xE9, 0x00, 0x69, 0x99, 0x99, 0xD2, 0x10, 0xF6,
  0xEB, 0x40, 0x78, 0x86, 0x11, 0xF0, 0xF4, 0x44, 0x44, 0x99, 0x99, 0x9F,
  0x99, 0x55, 0x62, 0x93, 0x25, 0xAB, 0x64, 0x49, 0x00, 0x96, 0x26, 0x99,
  0x96, 0x64, 0x44, 0xF2, 0x24, 0x4F, 0xEA, 0xAC, 0x91, 0x22, 0x40, 0xD5,
  0x5C, 0x65, 0x90, 0xF0, 0x90, 0x65, 0xDE, 0x93, 0xDB, 0x78, 0x72, 0x46,
  0x11, 0x79, 0x99, 0x70, 0x79, 0x78, 0x70, 0x6B, 0x24, 0x90, 0x79, 0x99,
  0x71, 0x70, 0x93, 0xDB, 0x68, 0xBE, 0xBF, 0x80, 0x92, 0xE9, 0xA8, 0xFE,
  0xDD, 0x6B, 0x5A, 0x80, 0xF6, 0xDA, 0x79, 0x99, 0x70, 0xF6, 0xDF, 0x20,
  0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x71, 0x1E, 0xBA, 0xB0, 0xB6, 0xDE,
  0xB6, 0xA4, 0xAD, 0x6E, 0x94, 0x80, 0x96, 0x46, 0x90, 0xB6, 0xA4, 0xB0,
  0x65, 0x2E, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Thin9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 0, -7 },
  { 11, 6, 7, 6, 0, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 2, 0, -6 },
  { 23, 2, 7, 2, 0, -6 },
  { 25, 2, 7, 2, 0, -6 },
  { 27, 4, 3, 4, 0, -7 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 3, 0, -3 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 3, 7, 5, 1, -7 },
  { 40, 2, 6, 5, 1, -6 },
  { 42, 4, 7, 5, 0, -7 },
  { 46, 4, 7, 5, 0, -7 },
  { 50, 4, 6, 5, 0, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 3, 7, 5, 1, -7 },
  { 59, 4, 6, 5, 0, -6 },
  { 62, 4, 7, 5, 0, -7 },
  { 66, 4, 7, 5, 0, -7 },
  { 70, 1, 5, 2, 0, -5 },
  { 71, 1, 6, 2, 0, -5 },
  { 72, 4, 4, 5, 0, -5 },
  { 74, 4, 2, 5, 0, -4 },
  { 75, 4, 4, 5, 0, -5 },
  { 77, 3, 7, 3, 0, -7 },
  { 80, 7, 7, 7, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 4, 7, 5, 1, -7 },
  { 98, 4, 6, 6, 1, -6 },
  { 101, 3, 6, 4, 1, -6 },
  { 104, 3, 6, 4, 1, -6 },
  { 107, 4, 7, 6, 1, -7 },
  { 111, 4, 6, 6, 1, -6 },
  { 114, 2, 6, 2, 0, -6 },
  { 116, 2, 8, 2, -1, -6 },
  { 118, 3, 6, 4, 1, -6 },
  { 121, 3, 6, 4, 1, -6 },
  { 124, 5, 6, 7, 1, -6 },
  { 128, 4, 6, 6, 1, -6 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 3, 6, 5, 1, -6 },
  { 138, 4, 9, 6, 1, -7 },
  { 143, 3, 6, 5, 1, -6 },
  { 146, 4, 7, 4, 0, -7 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 4, 6, 6, 1, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 7, 6, 7, 0, -6 },
  { 165, 4, 6, 4, 0, -6 },
  { 168, 4, 6, 4, 0, -6 },
  { 171, 4, 6, 4, 0, -6 },
  { 174, 2, 7, 3, 1, -6 },
  { 176, 3, 6, 3, 0, -6 },
  { 179, 2, 7, 3, 0, -6 },
  { 181, 4, 3, 5, 0, -6 },
  { 183, 4, 1, 4, 0, 0 },
  { 184, 2, 2, 2, 0, -7 },
  { 185, 3, 5, 4, 0, -5 },
  { 187, 3, 7, 5, 1, -7 },
  { 190, 3, 5, 4, 0, -5 },
  { 192, 4, 7, 5, 0, -7 },
  { 196, 4, 5, 4, 0, -5 },
  { 199, 3, 7, 2, 0, -7 },
  { 202, 4, 7, 5, 0, -5 },
  { 206, 3, 7, 5, 1, -7 },
  { 209, 1, 7, 2, 0, -7 },
  { 210, 1, 9, 2, 0, -7 },
  { 212, 3, 7, 4, 1, -7 },
  { 215, 1, 7, 2, 0, -7 },
  { 216, 5, 5, 7, 1, -5 },
  { 220, 3, 5, 5, 1, -5 },
  { 222, 4, 5, 5, 0, -5 },
  { 225, 3, 7, 5, 1, -5 },
  { 228, 4, 7, 5, 0, -5 },
  { 232, 2, 5, 3, 1, -5 },
  { 234, 3, 5, 4, 0, -5 },
  { 236, 2, 6, 3, 0, -6 },
  { 238, 3, 5, 5, 1, -5 },
  { 240, 3, 5, 3, 0, -5 },
  { 242, 5, 5, 6, 0, -5 },
  { 246, 4, 5, 4, 0, -5 },
  { 249, 3, 7, 3, 0, -5 },
  { 252, 3, 5, 3, 0, -5 },
  { 254, 3, 7, 3, 0, -6 },
  { 257, 1, 9, 4, 2, -7 },
  { 259, 3, 7, 3, 0, -6 },
  { 262, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Thin9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_THIN9PT7B_H_
