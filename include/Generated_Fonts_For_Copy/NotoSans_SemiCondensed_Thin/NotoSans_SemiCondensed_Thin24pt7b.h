#ifndef _NOTOSANS_SEMICONDENSED_THIN24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x80, 0x99, 0x99, 0x99, 0x08, 0x40, 0x84, 0x08, 0x40,
  0x88, 0x10, 0x8F, 0xFF, 0x10, 0x81, 0x08, 0x10, 0x81, 0x10, 0x11, 0x0E,
  0xFE, 0x21, 0x02, 0x10, 0x21, 0x02, 0x20, 0x22, 0x00, 0x08, 0x1F, 0x92,
  0x31, 0x08, 0x84, 0x42, 0x20, 0x90, 0x38, 0x06, 0x02, 0xC1, 0x10, 0x88,
  0x44, 0x22, 0x11, 0xC9, 0x0F, 0x02, 0x00, 0x78, 0x10, 0x88, 0x42, 0x10,
  0x84, 0x22, 0x08, 0x44, 0x10, 0x90, 0x21, 0x26, 0x42, 0x92, 0x45, 0x42,
  0xD2, 0x84, 0x49, 0x08, 0x12, 0x10, 0x44, 0x20, 0x88, 0x42, 0x10, 0x84,
  0x22, 0x10, 0x3C, 0x1E, 0x01, 0x08, 0x08, 0x40, 0x41, 0x02, 0x10, 0x10,
  0x80, 0x48, 0x01, 0x80, 0x34, 0x02, 0x20, 0x90, 0x85, 0x02, 0x28, 0x0A,
  0x40, 0x32, 0x01, 0x88, 0x14, 0x3F, 0x18, 0xFC, 0x12, 0x24, 0x44, 0x88,
  0x88, 0x88, 0x88, 0x84, 0x44, 0x22, 0x10, 0x84, 0x42, 0x21, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x22, 0x44, 0x80, 0x08, 0x04, 0x22, 0x2F, 0x60, 0xC0,
  0xA0, 0x48, 0x42, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x56, 0xA0, 0xF8, 0x80, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x80,
  0x1F, 0x08, 0x24, 0x09, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x40, 0x50, 0x24, 0x08, 0x84, 0x1E, 0x00, 0x19, 0x53,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7E, 0x10, 0x40,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xC0, 0x7F, 0x20, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x18, 0x3E, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0xFF, 0x00, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04,
  0x80, 0x48, 0x08, 0x81, 0x08, 0x10, 0x82, 0x08, 0x40, 0x84, 0x08, 0xFF,
  0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0xFC, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x06, 0xFC, 0x00, 0x0F, 0x8C, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0xE2,
  0xC4, 0xC0, 0xB0, 0x18, 0x06, 0x01, 0x40, 0x50, 0x14, 0x04, 0x82, 0x1F,
  0x00, 0xFF, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x00, 0x3F,
  0x10, 0x24, 0x09, 0x02, 0x40, 0x90, 0x22, 0x10, 0x78, 0x12, 0x08, 0x44,
  0x0A, 0x01, 0x80, 0x60, 0x18, 0x05, 0x02, 0x3F, 0x00, 0x3E, 0x10, 0x48,
  0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x03, 0x40, 0xCC, 0xD0, 0xC4, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x7C, 0x00, 0xC0, 0x08, 0x50, 0x00, 0x05,
  0x6A, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x10, 0x18, 0x18, 0x18, 0x08, 0x00,
  0xFC, 0x08, 0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x40, 0x81, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x07, 0xF0, 0x08, 0x0C, 0x10, 0x02, 0x20, 0x02, 0x40,
  0x01, 0x41, 0xF1, 0x42, 0x11, 0x84, 0x11, 0x84, 0x11, 0x88, 0x11, 0x88,
  0x21, 0x84, 0x21, 0x84, 0x21, 0x82, 0xD2, 0x41, 0x0C, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x05, 0x00, 0x90, 0x09,
  0x00, 0x88, 0x10, 0x81, 0x08, 0x10, 0x82, 0x04, 0x3F, 0xC2, 0x04, 0x40,
  0x24, 0x02, 0x40, 0x28, 0x01, 0x80, 0x10, 0xFF, 0x20, 0x28, 0x0A, 0x01,
  0x80, 0x60, 0x28, 0x0B, 0xFC, 0x83, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x02, 0xFF, 0x00, 0x0F, 0xE2, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xE0, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xA0, 0x14, 0x0C, 0xFE, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x0F, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x81, 0xF4, 0x00, 0x60, 0x02, 0x80, 0x14, 0x00,
  0xA0, 0x04, 0x80, 0x22, 0x01, 0x0F, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0xF2, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x1F, 0x00, 0x80, 0xE0, 0x48, 0x22, 0x08, 0x84,
  0x22, 0x09, 0x02, 0xC0, 0xD0, 0x22, 0x08, 0x42, 0x10, 0x82, 0x20, 0x48,
  0x12, 0x02, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x07, 0x00,
  0x3C, 0x00, 0xE8, 0x03, 0xA0, 0x16, 0x80, 0x59, 0x01, 0x64, 0x09, 0x88,
  0x26, 0x21, 0x18, 0x84, 0x61, 0x11, 0x84, 0x86, 0x12, 0x18, 0x28, 0x60,
  0xC1, 0x81, 0x04, 0x80, 0x38, 0x06, 0x80, 0xD0, 0x19, 0x03, 0x20, 0x62,
  0x0C, 0x41, 0x84, 0x30, 0x46, 0x08, 0xC0, 0x98, 0x13, 0x01, 0x60, 0x1C,
  0x03, 0x80, 0x20, 0x0F, 0xE0, 0xC0, 0x42, 0x01, 0x10, 0x02, 0x40, 0x0A,
  0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x02,
  0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0xFE, 0x40, 0xA0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x83, 0x7E, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0xC0, 0x42, 0x01, 0x10, 0x02,
  0x40, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x50, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x04, 0x86, 0x3F, 0x08, 0x42, 0x08, 0x82, 0x20, 0x48,
  0x0A, 0x02, 0x80, 0x40, 0x3F, 0xA0, 0x20, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x60, 0x0E, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0x00,
  0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x0A, 0x02, 0x3F, 0x80,
  0x80, 0x18, 0x02, 0x40, 0x24, 0x02, 0x40, 0x42, 0x04, 0x20, 0x42, 0x08,
  0x10, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x50, 0x30, 0x28, 0x14, 0x14,
  0x12, 0x0A, 0x09, 0x08, 0x84, 0x84, 0x42, 0x22, 0x22, 0x11, 0x11, 0x09,
  0x04, 0x84, 0x82, 0x41, 0x41, 0x40, 0xA0, 0xA0, 0x60, 0x30, 0x30, 0x10,
  0x08, 0x08, 0x00, 0x40, 0x48, 0x08, 0x82, 0x10, 0x81, 0x10, 0x14, 0x02,
  0x80, 0x20, 0x04, 0x01, 0x40, 0x28, 0x08, 0x82, 0x10, 0x41, 0x10, 0x22,
  0x02, 0x80, 0x60, 0x80, 0x50, 0x14, 0x08, 0x82, 0x21, 0x08, 0x41, 0x10,
  0x48, 0x0A, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x00, 0xFF, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0xFC,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F,
  0x80, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x80, 0x81, 0x02, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0xF0, 0x04, 0x02, 0x81, 0x20, 0x44, 0x21, 0x08, 0x44, 0x09,
  0x02, 0x80, 0x60, 0x10, 0xFF, 0x80, 0x84, 0x30, 0x3E, 0x41, 0x01, 0x01,
  0x01, 0x01, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x05, 0xF3, 0x05, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xC1, 0x5F, 0x00, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x20, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x47, 0x92, 0x15, 0x03, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x05, 0x03, 0x40, 0xCF, 0xD0, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C,
  0x07, 0xFF, 0x00, 0x80, 0x40, 0x10, 0x08, 0x03, 0xF8, 0x1E, 0x40, 0x81,
  0x02, 0x1F, 0x88, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x1E, 0x48, 0x54, 0x0D, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x14, 0x0D, 0x03, 0x3F, 0x40, 0x10, 0x04, 0x01, 0x00, 0x90, 0x43,
  0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC1, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x8F, 0xFF, 0x80, 0x10, 0x00,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x82, 0x82, 0x84, 0x88, 0x90, 0xA0, 0xB0, 0xC8, 0x88,
  0x84, 0x84, 0x82, 0x81, 0xFF, 0xFF, 0xC0, 0xBC, 0x7B, 0x0A, 0x18, 0x10,
  0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04,
  0x18, 0x10, 0x60, 0x41, 0x81, 0x04, 0xBE, 0xC1, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x08, 0x64, 0x09, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x09, 0x02, 0x3F, 0x00,
  0x9E, 0x70, 0xB0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x38, 0x2B, 0xE4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1E, 0x48,
  0x54, 0x0D, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x0D,
  0x05, 0x3E, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0xBF, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3E, 0x40, 0x80, 0x80,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x20, 0x82, 0x3F,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x07, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0xC0,
  0x50, 0x28, 0x24, 0x11, 0x08, 0x88, 0x44, 0x12, 0x0A, 0x05, 0x01, 0x00,
  0x80, 0x81, 0x03, 0x02, 0x09, 0x06, 0x12, 0x14, 0x24, 0x28, 0x44, 0x49,
  0x09, 0x12, 0x12, 0x24, 0x24, 0x48, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x80,
  0x81, 0x00, 0x81, 0x81, 0x42, 0x24, 0x24, 0x18, 0x10, 0x18, 0x24, 0x24,
  0x42, 0x81, 0x81, 0x80, 0xC0, 0x50, 0x28, 0x24, 0x11, 0x08, 0x88, 0x44,
  0x12, 0x0A, 0x05, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x30,
  0x00, 0xFE, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x0F,
  0xE0, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x04, 0x0C, 0xFF, 0xFF, 0xFF, 0xE0, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x20, 0x44, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0xC0,
  0x30, 0x33, 0x10, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_Thin24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 4, 6, 7, 2, -17 },
  { 7, 12, 17, 14, 1, -17 },
  { 33, 9, 19, 12, 1, -18 },
  { 55, 15, 17, 17, 1, -17 },
  { 87, 13, 17, 14, 1, -17 },
  { 115, 1, 6, 4, 2, -17 },
  { 116, 4, 21, 6, 1, -17 },
  { 127, 4, 21, 6, 1, -17 },
  { 138, 9, 8, 11, 1, -18 },
  { 147, 10, 11, 12, 1, -14 },
  { 161, 2, 6, 4, 1, -3 },
  { 163, 5, 1, 7, 1, -7 },
  { 164, 1, 1, 5, 2, -1 },
  { 165, 7, 17, 8, 0, -17 },
  { 180, 10, 17, 12, 1, -17 },
  { 202, 5, 17, 12, 2, -17 },
  { 213, 10, 17, 12, 1, -17 },
  { 235, 10, 17, 12, 1, -17 },
  { 257, 12, 17, 12, 0, -17 },
  { 283, 9, 17, 12, 2, -17 },
  { 303, 10, 17, 12, 1, -17 },
  { 325, 10, 17, 12, 1, -17 },
  { 347, 10, 17, 12, 1, -17 },
  { 369, 10, 17, 12, 1, -17 },
  { 391, 1, 13, 5, 2, -13 },
  { 393, 2, 16, 5, 1, -13 },
  { 397, 10, 11, 12, 1, -14 },
  { 411, 10, 5, 12, 1, -11 },
  { 418, 10, 11, 12, 1, -14 },
  { 432, 7, 17, 9, 1, -17 },
  { 447, 16, 19, 19, 1, -17 },
  { 485, 12, 17, 12, 0, -17 },
  { 511, 10, 17, 13, 2, -17 },
  { 533, 11, 17, 13, 1, -17 },
  { 557, 11, 17, 15, 2, -17 },
  { 581, 8, 17, 12, 2, -17 },
  { 598, 8, 17, 11, 2, -17 },
  { 615, 13, 17, 16, 1, -17 },
  { 643, 11, 17, 15, 2, -17 },
  { 667, 4, 17, 6, 1, -17 },
  { 676, 5, 21, 5, -2, -17 },
  { 690, 10, 17, 12, 2, -17 },
  { 712, 8, 17, 11, 2, -17 },
  { 729, 14, 17, 18, 2, -17 },
  { 759, 11, 17, 15, 2, -17 },
  { 783, 14, 17, 16, 1, -17 },
  { 813, 9, 17, 12, 2, -17 },
  { 833, 14, 21, 16, 1, -17 },
  { 870, 10, 17, 12, 2, -17 },
  { 892, 9, 17, 12, 1, -17 },
  { 912, 11, 17, 11, 0, -17 },
  { 936, 11, 17, 15, 2, -17 },
  { 960, 12, 17, 12, 0, -17 },
  { 986, 17, 17, 19, 1, -17 },
  { 1023, 11, 17, 11, 0, -17 },
  { 1047, 10, 17, 10, 0, -17 },
  { 1069, 10, 17, 12, 1, -17 },
  { 1091, 5, 21, 7, 2, -17 },
  { 1105, 7, 17, 8, 0, -17 },
  { 1120, 4, 21, 7, 1, -17 },
  { 1131, 10, 10, 12, 1, -17 },
  { 1144, 9, 1, 9, 0, 2 },
  { 1146, 4, 3, 6, 1, -18 },
  { 1148, 8, 13, 11, 1, -13 },
  { 1161, 9, 18, 13, 2, -18 },
  { 1182, 8, 13, 10, 1, -13 },
  { 1195, 10, 18, 13, 1, -18 },
  { 1218, 9, 13, 12, 1, -13 },
  { 1233, 7, 18, 6, 0, -18 },
  { 1249, 10, 19, 13, 1, -13 },
  { 1273, 8, 18, 12, 2, -18 },
  { 1291, 1, 17, 5, 2, -17 },
  { 1294, 4, 23, 5, -1, -17 },
  { 1306, 8, 18, 10, 2, -18 },
  { 1324, 1, 18, 5, 2, -18 },
  { 1327, 14, 13, 18, 2, -13 },
  { 1350, 8, 13, 12, 2, -13 },
  { 1363, 10, 13, 12, 1, -13 },
  { 1380, 9, 19, 13, 2, -13 },
  { 1402, 10, 19, 13, 1, -13 },
  { 1426, 6, 13, 8, 2, -13 },
  { 1436, 8, 13, 10, 1, -13 },
  { 1449, 6, 16, 7, 0, -16 },
  { 1461, 8, 13, 12, 2, -13 },
  { 1474, 9, 13, 9, 0, -13 },
  { 1489, 15, 13, 15, 0, -13 },
  { 1514, 8, 13, 10, 1, -13 },
  { 1527, 9, 19, 9, 0, -13 },
  { 1549, 7, 13, 9, 1, -13 },
  { 1561, 6, 21, 8, 1, -17 },
  { 1577, 1, 24, 11, 5, -18 },
  { 1580, 6, 21, 8, 1, -17 },
  { 1596, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Thin24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_THIN24PT7B_H_
