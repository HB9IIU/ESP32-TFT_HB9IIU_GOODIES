#ifndef _NOTOSANS_SEMICONDENSED_THIN60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin60pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x40, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x80, 0x08,
  0x00, 0x01, 0x00, 0x10, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x80, 0x18, 0x01, 0x80, 0x00, 0x20, 0x02, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x80, 0x08, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x01, 0x00, 0x00, 0x20,
  0x02, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x04, 0x00, 0x40, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0xF6, 0x3E, 0x07, 0x0C, 0x0E, 0x18, 0x18, 0x00,
  0x20, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x83,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xCF, 0x00, 0x01, 0x87, 0x00, 0x03, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x02, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x73, 0x80, 0xC1, 0x83, 0xF9, 0xBE, 0x00, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xE0,
  0x00, 0x18, 0x01, 0xC3, 0x00, 0x01, 0x80, 0x30, 0x18, 0x00, 0x10, 0x03,
  0x00, 0x80, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x06, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x06,
  0x0C, 0x00, 0x0C, 0x00, 0x61, 0x83, 0xF0, 0x40, 0x04, 0x18, 0x61, 0xC4,
  0x00, 0x41, 0x0C, 0x0C, 0x60, 0x0C, 0x30, 0x80, 0x66, 0x00, 0xC2, 0x18,
  0x02, 0x30, 0x08, 0x61, 0x00, 0x33, 0x01, 0x84, 0x30, 0x03, 0x1C, 0x30,
  0xC3, 0x00, 0x30, 0xFE, 0x08, 0x30, 0x01, 0x00, 0x01, 0x83, 0x00, 0x10,
  0x00, 0x10, 0x20, 0x01, 0x00, 0x03, 0x02, 0x00, 0x10, 0x00, 0x20, 0x20,
  0x01, 0x00, 0x06, 0x02, 0x00, 0x10, 0x00, 0x60, 0x20, 0x01, 0x00, 0x0C,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x18, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x01, 0x80, 0x20, 0x06, 0x00, 0x18, 0x06, 0x00, 0x40,
  0x00, 0xC0, 0x40, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x80, 0x00, 0x3F, 0x80,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x20, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x18, 0xC0, 0x04, 0x00,
  0x23, 0x00, 0x0C, 0x00, 0x46, 0x00, 0x0C, 0x01, 0x88, 0x00, 0x0C, 0x03,
  0x30, 0x00, 0x0C, 0x04, 0x60, 0x00, 0x0C, 0x18, 0xC0, 0x00, 0x08, 0x21,
  0x80, 0x00, 0x18, 0xC3, 0x00, 0x00, 0x19, 0x06, 0x00, 0x00, 0x1E, 0x0C,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x78, 0x18, 0x00, 0x00, 0xD0, 0x10,
  0x00, 0x07, 0x30, 0x30, 0x00, 0x1C, 0x30, 0x38, 0x00, 0x60, 0x30, 0x3C,
  0x03, 0x80, 0x30, 0x1F, 0xFC, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x20, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00,
  0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x20, 0x04, 0x01, 0xF0, 0x10, 0x1C, 0xF0, 0x43, 0xC0,
  0x79, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xA0, 0x00, 0x0C,
  0xC0, 0x00, 0x21, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0xC6,
  0x31, 0x88, 0xC6, 0x31, 0x18, 0xC4, 0x23, 0x00, 0xFF, 0xFC, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x81, 0xC0, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x18, 0x18, 0x00, 0x08, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x20, 0x1C, 0x06, 0x81, 0x90, 0xE2, 0x38,
  0x4C, 0x0B, 0x01, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x03, 0xFF, 0x00, 0x1E, 0x07, 0x80, 0xE0, 0x03,
  0x83, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x3C,
  0x03, 0x81, 0xE0, 0x01, 0x87, 0x00, 0x01, 0x88, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x71, 0xF0, 0x03, 0x80, 0x7F, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x01, 0xFF, 0xFC, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0xC1, 0xF0, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x01, 0xE0, 0x30, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x83,
  0xFF, 0x02, 0x1F, 0x07, 0x04, 0x70, 0x03, 0x89, 0x80, 0x01, 0x96, 0x00,
  0x03, 0x28, 0x00, 0x03, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x84,
  0x00, 0x06, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x81, 0xE0, 0x0E, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20,
  0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x01, 0xC3, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE7, 0x80, 0x03, 0x81, 0xC0, 0x06,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x10, 0x20, 0x00, 0x18, 0x60, 0x00, 0x08, 0x40,
  0x00, 0x0C, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x40, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x1A, 0x30, 0x00, 0x32, 0x1C,
  0x00, 0x62, 0x0F, 0x01, 0xC2, 0x03, 0xFF, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x20, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x18, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0x86, 0x18,
  0x61, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x04, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x3C, 0x07, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x00, 0x61, 0x80, 0x03, 0xFF, 0x80,
  0x10, 0xC0, 0x03, 0x80, 0xC0, 0x0C, 0x40, 0x03, 0x00, 0x20, 0x06, 0x60,
  0x03, 0x00, 0x10, 0x03, 0x30, 0x03, 0x00, 0x08, 0x00, 0x90, 0x01, 0x00,
  0x04, 0x00, 0x48, 0x01, 0x80, 0x02, 0x00, 0x2C, 0x00, 0xC0, 0x03, 0x00,
  0x1E, 0x00, 0x40, 0x01, 0x80, 0x0F, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x80,
  0x30, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x01, 0x60, 0x0C, 0x00,
  0x18, 0x00, 0xB0, 0x06, 0x00, 0x0C, 0x00, 0x58, 0x03, 0x00, 0x06, 0x00,
  0x2C, 0x01, 0x80, 0x03, 0x00, 0x36, 0x00, 0xC0, 0x03, 0x80, 0x1B, 0x00,
  0x20, 0x01, 0x40, 0x08, 0x80, 0x18, 0x00, 0xA0, 0x0C, 0x40, 0x0C, 0x00,
  0xD0, 0x04, 0x30, 0x03, 0x00, 0xCC, 0x06, 0x18, 0x00, 0xE1, 0xC3, 0x0E,
  0x04, 0x00, 0x3F, 0xC0, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x80, 0x60, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18, 0x02,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x80, 0x06, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0xE0, 0x80, 0x00, 0x38, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x60, 0x80, 0x07, 0xC0, 0xFF, 0xFE, 0x00, 0x80, 0x03,
  0xE0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x38, 0x80, 0x00, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x7C, 0x03,
  0x80, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x1F,
  0x00, 0x38, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x02, 0x00, 0x07, 0x80, 0x40, 0x00, 0x3C, 0x08, 0x00,
  0x01, 0xC1, 0x00, 0x00, 0x1C, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x32, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x32, 0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x18, 0x20, 0x00, 0x06, 0x04, 0x00, 0x03, 0x80,
  0x80, 0x01, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xE8, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x06, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0xFF, 0x8F, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x3F, 0xE0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x6C, 0x1C, 0xFF, 0x80, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x60, 0x80, 0x00, 0xE0, 0x80, 0x00, 0xC0, 0x80, 0x01, 0x80, 0x80,
  0x03, 0x00, 0x80, 0x06, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x80,
  0x38, 0x00, 0x80, 0x30, 0x00, 0x80, 0x60, 0x00, 0x80, 0xC0, 0x00, 0x81,
  0x80, 0x00, 0x83, 0x00, 0x00, 0x87, 0x00, 0x00, 0x8F, 0x00, 0x00, 0x8D,
  0x80, 0x00, 0x98, 0xC0, 0x00, 0xB0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x80, 0x30, 0x00, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x80,
  0x0C, 0x00, 0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80,
  0x01, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x07, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xD0, 0x00, 0x00,
  0x00, 0xFB, 0x00, 0x00, 0x00, 0x37, 0x60, 0x00, 0x00, 0x06, 0xE4, 0x00,
  0x00, 0x00, 0x9C, 0xC0, 0x00, 0x00, 0x33, 0x98, 0x00, 0x00, 0x06, 0x71,
  0x80, 0x00, 0x00, 0x8E, 0x30, 0x00, 0x00, 0x31, 0xC2, 0x00, 0x00, 0x06,
  0x38, 0x60, 0x00, 0x00, 0x87, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x80, 0x00,
  0x04, 0x1C, 0x18, 0x00, 0x01, 0x83, 0x83, 0x00, 0x00, 0x30, 0x70, 0x20,
  0x00, 0x04, 0x0E, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x40, 0x00, 0x30, 0x38,
  0x0C, 0x00, 0x04, 0x07, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x10, 0x00, 0x20,
  0x1C, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x01, 0x80, 0x70, 0x04, 0x00,
  0x20, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x01,
  0x80, 0x20, 0x07, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x02, 0x01, 0x80, 0x1C,
  0x00, 0x60, 0x60, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x70, 0x00, 0x81, 0x00,
  0x0E, 0x00, 0x18, 0x60, 0x01, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0x00, 0x31,
  0x00, 0x07, 0x00, 0x06, 0x60, 0x00, 0xE0, 0x00, 0x4C, 0x00, 0x1C, 0x00,
  0x0D, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0x20, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x81, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00,
  0xE0, 0x08, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80,
  0x02, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x10, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x00, 0x8E, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x08, 0x00, 0x3C, 0x20, 0x00, 0x38,
  0x80, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80,
  0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x62, 0x00,
  0x03, 0x08, 0x00, 0x78, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x0F, 0x04, 0x00, 0x03, 0x08,
  0x00, 0x03, 0x10, 0x00, 0x02, 0x20, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00,
  0x00, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x0C, 0x80, 0x00,
  0x19, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x0C,
  0x10, 0x00, 0x70, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x18, 0x02, 0x00, 0x30, 0x04, 0x00, 0x30, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x60, 0x20, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80, 0x00, 0xC1, 0x00,
  0x01, 0x82, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00,
  0x06, 0x20, 0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0D, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xE0, 0x0F, 0x00, 0xF8, 0x38, 0x00,
  0x10, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x80,
  0x00, 0x71, 0xE0, 0x03, 0x80, 0xFF, 0xFE, 0x00, 0x0B, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x08, 0x06, 0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x20, 0x06, 0x00, 0x01, 0x00, 0x10, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x10, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80, 0x30, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x0A, 0x00, 0x00, 0x66, 0x00, 0x00, 0x50, 0x00, 0x03, 0x10, 0x00, 0x06,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x36, 0x00, 0x00, 0x86, 0x00, 0x01, 0xB0,
  0x00, 0x0C, 0x30, 0x00, 0x08, 0x80, 0x00, 0x60, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x30, 0x00, 0x10, 0x30, 0x00, 0x30, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x30, 0x00, 0x60,
  0x30, 0x00, 0xC1, 0x80, 0x02, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x20, 0x20, 0x01, 0x80, 0x20, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x01, 0x00, 0x30, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x60, 0x08, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x08,
  0x06, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x03, 0x01,
  0x00, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x18, 0x10, 0x00, 0x40, 0xC0,
  0x00, 0x40, 0x80, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x20, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x00, 0xC2, 0x00, 0x02, 0x18, 0x00, 0x02,
  0x10, 0x00, 0x18, 0x80, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x13, 0x00, 0x00, 0x12, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x10, 0x02, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x80, 0x60, 0x00, 0x30, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x02, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x03, 0xFE, 0x01, 0xF8, 0x78, 0x38, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x1F, 0xF0, 0x1F, 0xF3, 0x0F, 0x00, 0x31, 0x80,
  0x03, 0x30, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x40, 0x01, 0xB6, 0x00, 0x33, 0x38, 0x0E, 0x31, 0xFF, 0xC3,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x7F, 0xC0, 0x41, 0xE1,
  0xE0, 0x8E, 0x00, 0x61, 0x30, 0x00, 0x62, 0x40, 0x00, 0x65, 0x80, 0x00,
  0x4A, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x70, 0x00, 0x06, 0xA0, 0x00,
  0x19, 0x60, 0x00, 0x32, 0x60, 0x00, 0xC4, 0x60, 0x03, 0x08, 0x70, 0x1C,
  0x10, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0x07,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x30, 0x1F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0xFF, 0x83, 0x03, 0xC1, 0xC3, 0x06, 0x00, 0x63, 0x0C, 0x00, 0x33,
  0x18, 0x00, 0x1B, 0x10, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x20, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x20, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x30, 0x00, 0x0B,
  0x18, 0x00, 0x13, 0x0C, 0x00, 0x33, 0x07, 0x00, 0xE3, 0x01, 0xFF, 0x83,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x87, 0x80, 0x1C, 0x01, 0x80,
  0x60, 0x01, 0x81, 0x80, 0x01, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x58, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x01, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x01, 0xFF, 0xE1, 0xFF, 0xF0,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x82, 0x07, 0x83, 0xC4, 0x18, 0x01,
  0xC8, 0x60, 0x00, 0xD1, 0x80, 0x00, 0xA6, 0x00, 0x01, 0xCC, 0x00, 0x01,
  0x90, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0x40, 0x00, 0x1C, 0xC0, 0x00, 0x28, 0x80, 0x00,
  0xD1, 0x80, 0x01, 0x21, 0x80, 0x0E, 0x41, 0xC0, 0x70, 0x80, 0xFF, 0xC1,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x61, 0x80, 0x01, 0x83, 0xE0,
  0x1E, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x07, 0xFC, 0x18, 0xF0, 0x78, 0xCE,
  0x00, 0xE6, 0xC0, 0x03, 0x34, 0x00, 0x0D, 0x60, 0x00, 0x2A, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x6F, 0x64, 0x00, 0x00, 0x00, 0x06,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x01, 0x80, 0xF0, 0x18, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x32, 0x18, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x36, 0x00, 0x04, 0xC0, 0x01, 0x98, 0x00, 0x63, 0x00,
  0x18, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0xC0, 0x18, 0x10, 0x03, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x78,
  0x01, 0x9B, 0x00, 0x32, 0x30, 0x06, 0xC3, 0x00, 0xB0, 0x60, 0x1C, 0x06,
  0x03, 0x00, 0x40, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x01,
  0x86, 0x00, 0x10, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00,
  0x6C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0xFC, 0x00, 0xFE, 0x08, 0x70,
  0xF0, 0x38, 0x38, 0x8C, 0x03, 0x86, 0x00, 0xC9, 0x80, 0x18, 0xC0, 0x06,
  0xB0, 0x00, 0xD8, 0x00, 0x6A, 0x00, 0x05, 0x00, 0x03, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x81, 0xFF, 0x04, 0x3C, 0x1E, 0x23,
  0x80, 0x39, 0x30, 0x00, 0xC9, 0x00, 0x03, 0x50, 0x00, 0x0A, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x03, 0xC1, 0xE0,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x30,
  0x03, 0x80, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x80, 0xFF, 0x01,
  0x07, 0x87, 0x82, 0x18, 0x01, 0x84, 0x60, 0x01, 0x89, 0x80, 0x01, 0x96,
  0x00, 0x01, 0x28, 0x00, 0x03, 0x50, 0x00, 0x02, 0xE0, 0x00, 0x05, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x02, 0xE0, 0x00, 0x0D, 0x40, 0x00, 0x1B,
  0xC0, 0x00, 0x66, 0x80, 0x00, 0xCD, 0x80, 0x03, 0x19, 0x80, 0x0C, 0x31,
  0xC0, 0x70, 0x61, 0xFF, 0xC0, 0xC0, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x82, 0x07, 0x87, 0x84, 0x18, 0x01, 0x88, 0x60, 0x01, 0x91, 0x80, 0x01,
  0xA6, 0x00, 0x01, 0x4C, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xD0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x29, 0x80, 0x00, 0xD1, 0x80, 0x03, 0x21, 0x80, 0x0C,
  0x41, 0xC0, 0x70, 0x81, 0xFF, 0xC1, 0x00, 0x3C, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x81,
  0xFE, 0x1E, 0x78, 0xC0, 0x26, 0x00, 0x90, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x80, 0xF8, 0x7E,
  0x18, 0x00, 0x23, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x6C, 0x00, 0x0C, 0xF8, 0x03,
  0x81, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x1C,
  0x10, 0x3F, 0xC0, 0x18, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x80, 0x00, 0xB6, 0x00, 0x0D, 0x98, 0x00, 0xCC, 0x70,
  0x1C, 0x61, 0xFF, 0x83, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x33, 0x00, 0x00, 0x62, 0x00, 0x00, 0x84, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x60, 0x00, 0x80, 0x40, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x08, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x80, 0x04, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x08, 0x00, 0x10, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x80, 0x00, 0x43, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00, 0x01, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x01, 0xA0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x0F, 0x00,
  0x04, 0xC0, 0x01, 0x20, 0x00, 0x98, 0x00, 0x26, 0x00, 0x31, 0x00, 0x0C,
  0xC0, 0x06, 0x30, 0x01, 0x88, 0x00, 0x86, 0x00, 0x21, 0x00, 0x10, 0x40,
  0x0C, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x20, 0x40, 0x10,
  0x30, 0x0C, 0x08, 0x02, 0x02, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x81, 0x80, 0x60, 0x40, 0x10, 0x30,
  0x0C, 0x18, 0x02, 0x04, 0x00, 0x83, 0x00, 0x61, 0x80, 0x10, 0x40, 0x0C,
  0x30, 0x03, 0x08, 0x00, 0x84, 0x00, 0x63, 0x00, 0x18, 0x80, 0x04, 0x60,
  0x03, 0x30, 0x00, 0xC8, 0x00, 0x66, 0x00, 0x19, 0x00, 0x04, 0x80, 0x01,
  0x60, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80,
  0x02, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x03, 0x01,
  0x80, 0x02, 0x02, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x30, 0x00, 0x18, 0x20, 0x00,
  0x30, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x06, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x04, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x10, 0x00, 0x60,
  0x20, 0x00, 0xC0, 0x60, 0x01, 0x00, 0x40, 0x06, 0x00, 0x80, 0x0C, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x04,
  0x06, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x10, 0x60, 0x00, 0x20,
  0xC0, 0x00, 0x61, 0x00, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x90,
  0x00, 0x01, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x08, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0xE8,
  0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Thin60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 43, 13, 5, -43 },
  { 18, 10, 16, 19, 4, -43 },
  { 38, 31, 43, 34, 1, -43 },
  { 205, 23, 49, 30, 3, -46 },
  { 346, 36, 44, 43, 3, -43 },
  { 544, 31, 45, 35, 3, -44 },
  { 719, 2, 16, 10, 4, -43 },
  { 723, 10, 52, 15, 3, -43 },
  { 788, 11, 52, 15, 2, -43 },
  { 860, 22, 21, 28, 3, -46 },
  { 918, 25, 28, 30, 3, -35 },
  { 1006, 5, 15, 11, 2, -7 },
  { 1016, 14, 1, 18, 2, -17 },
  { 1018, 3, 3, 12, 5, -3 },
  { 1020, 18, 43, 19, 1, -43 },
  { 1117, 24, 45, 30, 3, -44 },
  { 1252, 11, 43, 30, 6, -43 },
  { 1312, 23, 43, 30, 3, -43 },
  { 1436, 23, 44, 30, 3, -43 },
  { 1563, 29, 43, 30, 1, -43 },
  { 1719, 23, 44, 30, 4, -43 },
  { 1846, 23, 44, 30, 4, -43 },
  { 1973, 24, 43, 30, 3, -43 },
  { 2102, 24, 44, 30, 3, -43 },
  { 2234, 24, 44, 30, 3, -43 },
  { 2366, 3, 32, 12, 5, -32 },
  { 2378, 6, 40, 12, 2, -32 },
  { 2408, 25, 26, 30, 3, -35 },
  { 2490, 25, 14, 30, 3, -28 },
  { 2534, 25, 26, 30, 3, -35 },
  { 2616, 18, 43, 21, 2, -43 },
  { 2713, 41, 49, 47, 3, -43 },
  { 2965, 30, 43, 30, 0, -43 },
  { 3127, 24, 43, 33, 6, -43 },
  { 3256, 27, 44, 32, 4, -43 },
  { 3405, 27, 43, 37, 6, -43 },
  { 3551, 20, 43, 29, 6, -43 },
  { 3659, 20, 43, 26, 6, -43 },
  { 3767, 31, 45, 39, 4, -44 },
  { 3942, 26, 43, 38, 6, -43 },
  { 4082, 9, 43, 16, 3, -43 },
  { 4131, 12, 53, 13, -5, -43 },
  { 4211, 24, 43, 30, 6, -43 },
  { 4340, 20, 43, 27, 6, -43 },
  { 4448, 35, 43, 46, 6, -43 },
  { 4637, 26, 43, 38, 6, -43 },
  { 4777, 32, 45, 40, 4, -44 },
  { 4957, 22, 43, 30, 6, -43 },
  { 5076, 32, 54, 40, 4, -44 },
  { 5292, 23, 43, 31, 6, -43 },
  { 5416, 23, 44, 29, 3, -43 },
  { 5543, 26, 43, 27, 0, -43 },
  { 5683, 28, 44, 38, 5, -43 },
  { 5837, 29, 43, 29, 0, -43 },
  { 5993, 45, 43, 47, 1, -43 },
  { 6235, 27, 43, 27, 0, -43 },
  { 6381, 26, 43, 26, 0, -43 },
  { 6521, 25, 43, 29, 2, -43 },
  { 6656, 12, 52, 19, 5, -43 },
  { 6734, 18, 43, 19, 1, -43 },
  { 6831, 11, 52, 19, 2, -43 },
  { 6903, 26, 24, 30, 2, -43 },
  { 6981, 24, 2, 23, 0, 5 },
  { 6987, 10, 10, 14, 2, -46 },
  { 7000, 20, 33, 27, 3, -32 },
  { 7083, 23, 47, 32, 5, -46 },
  { 7219, 20, 33, 25, 3, -32 },
  { 7302, 24, 47, 32, 3, -46 },
  { 7443, 23, 33, 29, 3, -32 },
  { 7538, 17, 46, 15, 1, -46 },
  { 7636, 23, 46, 31, 3, -32 },
  { 7769, 21, 46, 31, 5, -46 },
  { 7890, 4, 43, 12, 4, -43 },
  { 7912, 10, 57, 12, -2, -43 },
  { 7984, 19, 46, 24, 5, -46 },
  { 8094, 2, 46, 12, 5, -46 },
  { 8106, 36, 32, 46, 5, -32 },
  { 8250, 21, 32, 31, 5, -32 },
  { 8334, 24, 33, 31, 3, -32 },
  { 8433, 23, 46, 31, 5, -32 },
  { 8566, 23, 46, 31, 3, -32 },
  { 8699, 14, 32, 20, 5, -32 },
  { 8755, 20, 33, 24, 2, -32 },
  { 8838, 14, 40, 17, 1, -39 },
  { 8908, 21, 33, 31, 5, -32 },
  { 8995, 23, 32, 23, 0, -32 },
  { 9087, 35, 32, 37, 1, -32 },
  { 9227, 23, 32, 25, 1, -32 },
  { 9319, 23, 47, 23, 0, -32 },
  { 9455, 19, 32, 23, 2, -32 },
  { 9531, 16, 52, 20, 2, -43 },
  { 9635, 2, 61, 29, 13, -46 },
  { 9651, 16, 52, 20, 2, -43 },
  { 9755, 25, 5, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_Thin60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_THIN60PT7B_H_
