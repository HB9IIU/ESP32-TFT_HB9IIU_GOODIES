#ifndef _NOTOSANS_SEMICONDENSED_THIN15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x5B, 0x24, 0x24, 0x24,
  0xFF, 0x24, 0x24, 0x48, 0x7D, 0x29, 0x4A, 0x38, 0xA5, 0x29, 0x7C, 0x40,
  0x62, 0x49, 0x25, 0x12, 0x89, 0xB4, 0xE5, 0xD2, 0x29, 0x24, 0x92, 0x48,
  0xE0, 0x30, 0x92, 0x22, 0x45, 0x0C, 0x24, 0xC5, 0x85, 0x0B, 0xE8, 0xF0,
  0x5A, 0xAA, 0xAA, 0x40, 0xA5, 0x55, 0x56, 0x80, 0x25, 0x5C, 0xA8, 0x80,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xF0, 0xE0, 0x80, 0x08, 0x84, 0x22,
  0x10, 0x88, 0x42, 0x20, 0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x27,
  0x80, 0x2E, 0x92, 0x49, 0x24, 0x80, 0xF0, 0x20, 0x82, 0x08, 0x21, 0x08,
  0x41, 0x0F, 0xC0, 0xF0, 0x20, 0x41, 0x09, 0xC0, 0x81, 0x04, 0x1F, 0x80,
  0x04, 0x18, 0x50, 0xA2, 0x44, 0x91, 0x42, 0x7E, 0x08, 0x10, 0x7A, 0x08,
  0x20, 0xF0, 0x20, 0x41, 0x04, 0x1F, 0x80, 0x39, 0x08, 0x20, 0xB3, 0x28,
  0x61, 0x86, 0x17, 0x80, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20, 0x84,
  0x00, 0x7A, 0x18, 0x61, 0x49, 0xC8, 0xA1, 0x86, 0x17, 0x80, 0x72, 0x28,
  0x61, 0x86, 0x37, 0x41, 0x08, 0x2F, 0x00, 0x81, 0x83, 0xC0, 0x04, 0x66,
  0x20, 0x60, 0x60, 0x40, 0xFC, 0x0F, 0xC0, 0x81, 0x81, 0x81, 0x19, 0x88,
  0x00, 0xF0, 0x42, 0x10, 0x88, 0x84, 0x00, 0x08, 0x1E, 0x08, 0x64, 0x0A,
  0x31, 0x92, 0x68, 0x9A, 0x26, 0x89, 0x96, 0x62, 0x68, 0x01, 0xF8, 0x10,
  0x10, 0x18, 0x28, 0x24, 0x24, 0x7C, 0x42, 0x42, 0x82, 0x81, 0xFA, 0x18,
  0x61, 0x87, 0xE8, 0x61, 0x86, 0x1F, 0x80, 0x3E, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x80, 0xF8, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0B, 0xE0, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x3E, 0xFC, 0x21,
  0x08, 0x7E, 0x10, 0x84, 0x20, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x8E, 0x81,
  0x81, 0x81, 0x41, 0x3F, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83,
  0x06, 0x08, 0xEA, 0xAA, 0xAC, 0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x86,
  0x28, 0xA4, 0xA3, 0x89, 0x24, 0x8A, 0x18, 0x40, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3E, 0x80, 0xC0, 0x70, 0x78, 0x3A, 0x1D, 0x16, 0x4B, 0x25,
  0x94, 0xC6, 0x62, 0x20, 0x83, 0x07, 0x0D, 0x19, 0x32, 0x62, 0xC5, 0x87,
  0x0E, 0x08, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0xFA, 0x18, 0x61, 0x86, 0x2F, 0x20, 0x82, 0x08, 0x00, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x04, 0x04, 0x02,
  0xFA, 0x18, 0x61, 0x86, 0x2F, 0x22, 0x8A, 0x18, 0x40, 0x7A, 0x08, 0x20,
  0x81, 0xC0, 0x81, 0x04, 0x1F, 0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x05, 0xF0, 0x83, 0x06, 0x0A, 0x14, 0x48, 0x89, 0x14, 0x28, 0x20, 0x40,
  0x84, 0x18, 0x42, 0x46, 0x24, 0x62, 0x4A, 0x24, 0x94, 0x29, 0x42, 0x94,
  0x31, 0x41, 0x08, 0x10, 0x80, 0x82, 0x89, 0x11, 0x43, 0x02, 0x0C, 0x14,
  0x44, 0x8A, 0x08, 0x83, 0x09, 0x12, 0x42, 0x86, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x83, 0xF8, 0xF2,
  0x49, 0x24, 0x92, 0x4E, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0xE4,
  0x92, 0x49, 0x24, 0x9E, 0x20, 0xC5, 0x12, 0x8A, 0x10, 0xFC, 0x90, 0xF0,
  0x42, 0x7C, 0xC6, 0x3F, 0x82, 0x08, 0x3E, 0x86, 0x18, 0x61, 0x86, 0x1F,
  0x80, 0x7C, 0x21, 0x08, 0x42, 0x0F, 0x04, 0x10, 0x5F, 0x86, 0x18, 0x61,
  0x86, 0x17, 0xC0, 0x7C, 0x63, 0xF8, 0x42, 0x0F, 0x7A, 0x11, 0xC4, 0x21,
  0x08, 0x42, 0x10, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x10, 0xBC,
  0x82, 0x08, 0x3E, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x9F, 0xE0, 0x41,
  0x55, 0x55, 0x58, 0x84, 0x21, 0x19, 0x53, 0x14, 0x94, 0xA2, 0xFF, 0xE0,
  0xF7, 0xC4, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0xFA, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x5E, 0xFA, 0x18, 0x61,
  0x86, 0x18, 0x7E, 0x82, 0x08, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x5F,
  0x04, 0x10, 0x40, 0xF8, 0x88, 0x88, 0x88, 0xF8, 0x84, 0x31, 0x1F, 0x44,
  0xF4, 0x44, 0x44, 0x47, 0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x86, 0x24, 0x92,
  0x50, 0xC3, 0x08, 0x88, 0xC4, 0x53, 0x2A, 0x95, 0x52, 0x98, 0x8C, 0x44,
  0x85, 0x22, 0x84, 0x10, 0xA4, 0xA1, 0x86, 0x14, 0x92, 0x48, 0xC3, 0x08,
  0x20, 0x82, 0x30, 0xF1, 0x22, 0x44, 0x8F, 0x29, 0x24, 0xA2, 0x49, 0x26,
  0xFF, 0xFE, 0x84, 0x44, 0x44, 0x32, 0x44, 0x44, 0xC0, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Thin15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 8, 11, 8, 0, -11 },
  { 16, 5, 12, 8, 1, -11 },
  { 24, 9, 11, 11, 1, -11 },
  { 37, 7, 11, 9, 1, -11 },
  { 47, 1, 4, 3, 1, -11 },
  { 48, 2, 13, 4, 1, -11 },
  { 52, 2, 13, 4, 1, -11 },
  { 56, 5, 5, 7, 1, -11 },
  { 60, 6, 7, 8, 1, -9 },
  { 66, 1, 4, 3, 1, -2 },
  { 67, 3, 1, 5, 1, -5 },
  { 68, 1, 1, 3, 1, -1 },
  { 69, 5, 11, 5, 0, -11 },
  { 76, 6, 11, 8, 1, -11 },
  { 85, 3, 11, 8, 1, -11 },
  { 90, 6, 11, 8, 1, -11 },
  { 99, 6, 11, 8, 1, -11 },
  { 108, 7, 11, 8, 0, -11 },
  { 118, 6, 11, 8, 1, -11 },
  { 127, 6, 11, 8, 1, -11 },
  { 136, 6, 11, 8, 1, -11 },
  { 145, 6, 11, 8, 1, -11 },
  { 154, 6, 11, 8, 1, -11 },
  { 163, 1, 8, 3, 1, -8 },
  { 164, 1, 10, 3, 1, -8 },
  { 166, 6, 7, 8, 1, -9 },
  { 172, 6, 3, 8, 1, -7 },
  { 175, 6, 7, 8, 1, -9 },
  { 181, 5, 11, 5, 0, -11 },
  { 188, 10, 12, 12, 1, -11 },
  { 203, 8, 11, 8, 0, -11 },
  { 214, 6, 11, 8, 1, -11 },
  { 223, 7, 11, 8, 1, -11 },
  { 233, 7, 11, 9, 1, -11 },
  { 243, 5, 11, 7, 1, -11 },
  { 250, 5, 11, 7, 1, -11 },
  { 257, 8, 11, 10, 1, -11 },
  { 268, 7, 11, 9, 1, -11 },
  { 278, 2, 11, 4, 1, -11 },
  { 281, 3, 14, 3, -1, -11 },
  { 287, 6, 11, 7, 1, -11 },
  { 296, 5, 11, 7, 1, -11 },
  { 303, 9, 11, 12, 1, -11 },
  { 316, 7, 11, 9, 1, -11 },
  { 326, 8, 11, 10, 1, -11 },
  { 337, 6, 11, 8, 1, -11 },
  { 346, 8, 14, 10, 1, -11 },
  { 360, 6, 11, 8, 1, -11 },
  { 369, 6, 11, 7, 1, -11 },
  { 378, 7, 11, 7, 0, -11 },
  { 388, 7, 11, 9, 1, -11 },
  { 398, 7, 11, 7, 0, -11 },
  { 408, 12, 11, 12, 0, -11 },
  { 425, 7, 11, 7, 0, -11 },
  { 435, 7, 11, 7, 0, -11 },
  { 445, 7, 11, 7, 0, -11 },
  { 455, 3, 13, 5, 1, -11 },
  { 460, 5, 11, 5, 0, -11 },
  { 467, 3, 13, 5, 0, -11 },
  { 472, 6, 6, 8, 1, -11 },
  { 477, 6, 1, 6, 0, 1 },
  { 478, 2, 2, 4, 1, -11 },
  { 479, 5, 8, 7, 1, -8 },
  { 484, 6, 11, 8, 1, -11 },
  { 493, 5, 8, 6, 1, -8 },
  { 498, 6, 11, 8, 1, -11 },
  { 507, 5, 8, 7, 1, -8 },
  { 512, 5, 11, 4, 0, -11 },
  { 519, 6, 12, 8, 1, -8 },
  { 528, 6, 11, 8, 1, -11 },
  { 537, 1, 11, 3, 1, -11 },
  { 539, 2, 15, 3, 0, -11 },
  { 543, 5, 11, 6, 1, -11 },
  { 550, 1, 11, 3, 1, -11 },
  { 552, 9, 8, 11, 1, -8 },
  { 561, 6, 8, 8, 1, -8 },
  { 567, 6, 8, 8, 1, -8 },
  { 573, 6, 11, 8, 1, -8 },
  { 582, 6, 11, 8, 1, -8 },
  { 591, 4, 8, 5, 1, -8 },
  { 595, 4, 8, 6, 1, -8 },
  { 599, 4, 10, 4, 0, -10 },
  { 604, 5, 8, 8, 1, -8 },
  { 609, 6, 8, 6, 0, -8 },
  { 615, 9, 8, 9, 0, -8 },
  { 624, 6, 8, 6, 0, -8 },
  { 630, 6, 12, 6, 0, -8 },
  { 639, 4, 8, 6, 1, -8 },
  { 643, 3, 13, 5, 1, -11 },
  { 648, 1, 15, 7, 3, -11 },
  { 650, 4, 13, 5, 1, -11 },
  { 657, 6, 1, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Thin15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_THIN15PT7B_H_
