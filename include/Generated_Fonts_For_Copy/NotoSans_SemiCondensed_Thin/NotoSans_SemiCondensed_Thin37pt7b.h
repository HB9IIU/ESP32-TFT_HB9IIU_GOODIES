#ifndef _NOTOSANS_SEMICONDENSED_THIN37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFA, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x01, 0x01, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81,
  0x00, 0x10, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x20, 0x7F, 0xFF,
  0xE0, 0x40, 0x80, 0x08, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x10,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x1F, 0x7F, 0xF8, 0x20, 0x20,
  0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80,
  0x10, 0x10, 0x02, 0x06, 0x00, 0x02, 0x00, 0x08, 0x00, 0xFE, 0x0C, 0x86,
  0x42, 0x03, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20,
  0x10, 0x80, 0x32, 0x00, 0x68, 0x00, 0x70, 0x00, 0xB0, 0x02, 0x30, 0x08,
  0x60, 0x20, 0x80, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x02,
  0x0A, 0x08, 0x4F, 0xFE, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x1C, 0x00,
  0x00, 0x88, 0x03, 0x04, 0x10, 0x08, 0x10, 0x40, 0x20, 0x80, 0x81, 0x02,
  0x02, 0x04, 0x08, 0x08, 0x20, 0x20, 0x20, 0x80, 0x80, 0x84, 0x02, 0x02,
  0x10, 0x08, 0x08, 0x80, 0x20, 0x22, 0x3C, 0x80, 0x91, 0x09, 0x04, 0x48,
  0x24, 0x12, 0x20, 0x48, 0x88, 0x81, 0x1C, 0x44, 0x04, 0x01, 0x10, 0x10,
  0x08, 0x40, 0x40, 0x21, 0x01, 0x00, 0x84, 0x04, 0x04, 0x10, 0x10, 0x10,
  0x20, 0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x10, 0x04, 0x20, 0xC0, 0x1F,
  0x00, 0x03, 0x80, 0x01, 0x8C, 0x00, 0x40, 0x40, 0x08, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x01, 0x04,
  0x00, 0x21, 0x00, 0x02, 0xC0, 0x00, 0x30, 0x00, 0x1A, 0x00, 0x04, 0x60,
  0x01, 0x04, 0x02, 0x40, 0x40, 0x50, 0x04, 0x0A, 0x00, 0x42, 0x40, 0x04,
  0x48, 0x00, 0xD1, 0x00, 0x0A, 0x20, 0x00, 0x86, 0x00, 0x28, 0x40, 0x0C,
  0x84, 0x02, 0x18, 0x7F, 0x81, 0x80, 0xFF, 0x80, 0x0C, 0x21, 0x0C, 0x20,
  0x84, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x81, 0xC0, 0x40, 0xC0, 0x81,
  0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x18, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x08, 0x20, 0xB9, 0x38, 0x3E, 0x00,
  0x60, 0x05, 0x00, 0x44, 0x06, 0x10, 0x20, 0x42, 0x02, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x32, 0x22, 0x24, 0x44, 0x80, 0xFF,
  0x80, 0xF0, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x00, 0x03,
  0x80, 0x10, 0x40, 0x40, 0x41, 0x00, 0x42, 0x00, 0x88, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x12, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x10, 0x04, 0x20, 0x10, 0x30, 0x60,
  0x3F, 0x00, 0x03, 0x0D, 0x19, 0x21, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x0F, 0x80, 0xC1, 0x84, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0xC1, 0x8C, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0xC0, 0x7F, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0A,
  0x00, 0xC7, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x05,
  0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01,
  0x04, 0x01, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x40, 0x10, 0x20, 0x08, 0x20, 0x04, 0x20, 0x02, 0x1F, 0xFF, 0xF0, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x3F, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x3E, 0x03, 0x83,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C, 0xC0,
  0x30, 0xFF, 0x80, 0x00, 0xF0, 0x0E, 0x10, 0x30, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x3F, 0x09, 0x81, 0x94, 0x01, 0x30, 0x01, 0x60, 0x02, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x10, 0x02,
  0x20, 0x08, 0x20, 0x30, 0x3F, 0x80, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x07, 0xC0, 0x30, 0x60, 0x80,
  0x62, 0x00, 0x44, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08,
  0x40, 0x10, 0xC0, 0x40, 0x43, 0x00, 0x78, 0x00, 0xF8, 0x06, 0x08, 0x10,
  0x0C, 0x40, 0x08, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x20, 0x02, 0x40, 0x08, 0x60, 0x30, 0x7F, 0x80, 0x07, 0x80,
  0x61, 0x82, 0x01, 0x10, 0x06, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x36, 0x01,
  0x4C, 0x19, 0x0F, 0x84, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x03, 0x07, 0xF8, 0x00, 0xB8, 0x00,
  0x00, 0x00, 0x0F, 0x23, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x32,
  0x22, 0x24, 0x44, 0x80, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x40, 0x00, 0x1E, 0x1C, 0x30, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x06, 0x01, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x10, 0x80, 0x00, 0x04, 0xC0, 0x3E, 0x02, 0x40, 0x20,
  0x81, 0x20, 0x20, 0x40, 0x60, 0x20, 0x20, 0x30, 0x20, 0x10, 0x18, 0x10,
  0x08, 0x0C, 0x08, 0x04, 0x06, 0x04, 0x02, 0x03, 0x02, 0x01, 0x01, 0x81,
  0x00, 0x80, 0xC0, 0x80, 0x40, 0xA0, 0x40, 0x60, 0x50, 0x30, 0x30, 0x64,
  0x0C, 0x24, 0x22, 0x03, 0xC1, 0xE1, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x14, 0x00,
  0x02, 0x80, 0x00, 0x50, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x10, 0x10, 0x02, 0x02, 0x00,
  0x40, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x7F, 0xF0, 0x10, 0x01, 0x02,
  0x00, 0x20, 0x40, 0x04, 0x10, 0x00, 0xC2, 0x00, 0x08, 0x40, 0x01, 0x10,
  0x00, 0x32, 0x00, 0x02, 0xC0, 0x00, 0x50, 0x00, 0x0C, 0xFF, 0xF1, 0x00,
  0x12, 0x00, 0x14, 0x00, 0x28, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x07, 0x8F, 0xFF, 0x10, 0x01, 0x20,
  0x01, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x40, 0x06, 0x80, 0x19, 0xFF, 0xC0, 0x00, 0x7C,
  0x01, 0xC1, 0xC1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x40, 0x7F, 0xC0, 0xFF, 0xE0, 0x40, 0x0C,
  0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x28, 0x00, 0x14, 0x00, 0x12, 0x00, 0x19, 0x00, 0x18, 0x80,
  0x30, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F,
  0xFF, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFA, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x38, 0x18,
  0x00, 0x84, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x08, 0x80, 0x01, 0x08, 0x00, 0x20, 0xC0, 0x04, 0x07, 0xFF, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x23, 0xF0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x06, 0xFC, 0x80,
  0x07, 0x00, 0x12, 0x00, 0x44, 0x01, 0x88, 0x06, 0x10, 0x08, 0x20, 0x20,
  0x40, 0x80, 0x82, 0x01, 0x0C, 0x02, 0x30, 0x04, 0xE0, 0x09, 0x60, 0x14,
  0x40, 0x30, 0x40, 0x40, 0x80, 0x80, 0x81, 0x00, 0x82, 0x01, 0x04, 0x01,
  0x08, 0x01, 0x10, 0x02, 0x20, 0x02, 0x40, 0x06, 0x80, 0x05, 0x00, 0x04,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x07, 0xFF, 0xC0, 0xC0, 0x00, 0x0E, 0x80, 0x00,
  0x3A, 0x00, 0x01, 0x68, 0x00, 0x05, 0x90, 0x00, 0x16, 0x40, 0x00, 0x99,
  0x00, 0x02, 0x62, 0x00, 0x09, 0x88, 0x00, 0x46, 0x10, 0x01, 0x18, 0x40,
  0x08, 0x61, 0x00, 0x21, 0x82, 0x00, 0x86, 0x08, 0x04, 0x18, 0x20, 0x10,
  0x60, 0x40, 0x41, 0x81, 0x02, 0x06, 0x02, 0x08, 0x18, 0x08, 0x60, 0x60,
  0x21, 0x01, 0x80, 0x44, 0x06, 0x01, 0x20, 0x18, 0x04, 0x80, 0x60, 0x0A,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x10, 0xC0, 0x00, 0xF0, 0x00, 0x68,
  0x00, 0x32, 0x00, 0x19, 0x00, 0x0C, 0x40, 0x06, 0x20, 0x03, 0x08, 0x01,
  0x82, 0x00, 0xC1, 0x00, 0x60, 0x40, 0x30, 0x20, 0x18, 0x08, 0x0C, 0x06,
  0x06, 0x01, 0x03, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x08, 0x60, 0x06, 0x30,
  0x01, 0x18, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x70, 0x60, 0x0C, 0x01, 0x81, 0x00,
  0x0C, 0x30, 0x00, 0x42, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00,
  0x61, 0x00, 0x04, 0x18, 0x00, 0x80, 0xC0, 0x30, 0x03, 0xFE, 0x00, 0xFF,
  0xE2, 0x00, 0xC8, 0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x03, 0x8F,
  0xE0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x70, 0x60, 0x0C, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x61, 0x00, 0x04, 0x18, 0x00, 0x80,
  0xC0, 0x30, 0x03, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0xFF, 0xE1, 0x00, 0x22,
  0x00, 0x24, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x88, 0x02, 0x1F, 0xF8, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x41, 0x00, 0x82, 0x00, 0x84, 0x01, 0x88, 0x01, 0x10,
  0x01, 0x20, 0x02, 0x40, 0x02, 0x80, 0x05, 0x00, 0x04, 0x07, 0xE0, 0x60,
  0x72, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x0A, 0x00, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x09,
  0x00, 0x04, 0x40, 0x04, 0x18, 0x04, 0x07, 0xFC, 0x00, 0x80, 0x00, 0x50,
  0x00, 0x14, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00,
  0x10, 0x40, 0x04, 0x10, 0x02, 0x04, 0x00, 0x80, 0x80, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x03, 0x01, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x05, 0x00, 0x28, 0x00, 0xA0, 0x05, 0x00, 0x24, 0x00, 0xA0,
  0x04, 0x80, 0x14, 0x00, 0x88, 0x04, 0x40, 0x11, 0x00, 0x88, 0x04, 0x20,
  0x11, 0x00, 0x84, 0x02, 0x20, 0x10, 0x40, 0x82, 0x02, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x02, 0x10, 0x10, 0xC0, 0x42,
  0x02, 0x10, 0x08, 0x40, 0x42, 0x01, 0x08, 0x08, 0x40, 0x12, 0x00, 0x98,
  0x02, 0x40, 0x12, 0x00, 0x48, 0x02, 0x40, 0x09, 0x00, 0x48, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x20, 0x02, 0x10, 0x04, 0x10, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x04, 0x10, 0x04, 0x10, 0x02, 0x20, 0x02, 0x60, 0x01, 0x40, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x06, 0x20, 0x04, 0x10,
  0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x60, 0x02,
  0x40, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04,
  0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x30,
  0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0xFE, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x7F, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40,
  0x10, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0xFF, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x40, 0x01,
  0x20, 0x02, 0x20, 0x02, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x08, 0x08, 0x18,
  0x0C, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0xC0, 0x01, 0xFF,
  0xFE, 0xC0, 0x81, 0x02, 0x04, 0x10, 0x0F, 0x87, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x7F, 0x38, 0x14, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x40, 0x53, 0xF1,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x87, 0xC2, 0x60, 0xCA, 0x01, 0xB8, 0x02, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x0A, 0x80, 0x6B, 0x03, 0x23,
  0xF8, 0x03, 0xE0, 0xC1, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x07, 0xC4, 0x60,
  0xD2, 0x01, 0x58, 0x03, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50,
  0x01, 0x40, 0x0C, 0x80, 0x33, 0x01, 0x43, 0xF9, 0x07, 0xC0, 0x60, 0x83,
  0x01, 0x08, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x83, 0xFC, 0x03, 0xE0, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x7F, 0x91, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x07, 0xC4,
  0x60, 0xD2, 0x01, 0xD8, 0x03, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x50, 0x01, 0x40, 0x0C, 0x80, 0x33, 0x03, 0x43, 0xF9, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x98, 0x0C, 0x1F,
  0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x87, 0xC4, 0xC3, 0x28, 0x05, 0x80, 0x3C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0xB8,
  0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x08, 0x30, 0x80, 0x00, 0x00, 0x02,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0x38, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28, 0x06,
  0x80, 0x48, 0x08, 0x81, 0x08, 0x20, 0x86, 0x08, 0x40, 0x88, 0x09, 0xC0,
  0xA4, 0x0E, 0x20, 0xC2, 0x08, 0x10, 0x80, 0x88, 0x08, 0x80, 0x48, 0x06,
  0x80, 0x28, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x8F, 0x81, 0xE2, 0x41, 0x18,
  0x6A, 0x02, 0x80, 0xF0, 0x0A, 0x01, 0xC0, 0x10, 0x06, 0x00, 0x40, 0x18,
  0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01,
  0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00,
  0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60,
  0x04, 0x01, 0x87, 0xC4, 0xC1, 0x28, 0x05, 0x80, 0x3C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x07,
  0xC0, 0x30, 0x60, 0xC0, 0x23, 0x00, 0x64, 0x00, 0x48, 0x00, 0xA0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x01, 0x20, 0x02, 0x40, 0x04, 0x40, 0x10, 0x40, 0x40, 0x7F,
  0x00, 0x87, 0xC2, 0x60, 0xCA, 0x01, 0xA8, 0x02, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x0A, 0x80, 0x69, 0x03, 0x23, 0xF8,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x07, 0xC4, 0x60, 0x92, 0x01, 0x58, 0x03, 0x40,
  0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x0D, 0x80, 0x73,
  0x03, 0x47, 0xF1, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x8F, 0xCC, 0x28, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x0F, 0xC3, 0x03, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x80, 0x27, 0xFC,
  0x20, 0x20, 0x20, 0x20, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1A, 0x01, 0x58, 0x12, 0x7F, 0x10, 0x80, 0x06, 0x00,
  0x14, 0x00, 0x90, 0x02, 0x40, 0x08, 0x80, 0x42, 0x01, 0x08, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x80, 0x20, 0x06, 0x00,
  0x80, 0x28, 0x03, 0x00, 0xA0, 0x14, 0x02, 0x40, 0x50, 0x09, 0x01, 0x20,
  0x44, 0x04, 0x81, 0x10, 0x22, 0x04, 0x20, 0x88, 0x10, 0x82, 0x10, 0x82,
  0x10, 0x42, 0x08, 0x41, 0x08, 0x11, 0x02, 0x20, 0x4C, 0x09, 0x01, 0x20,
  0x24, 0x04, 0x80, 0x90, 0x0A, 0x01, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x20, 0x80, 0x09, 0x00, 0x66, 0x01, 0x08, 0x08, 0x10, 0x20,
  0x41, 0x00, 0x88, 0x01, 0x20, 0x05, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x40,
  0x0C, 0x80, 0x23, 0x01, 0x04, 0x04, 0x08, 0x20, 0x21, 0x80, 0x44, 0x01,
  0xA0, 0x03, 0x80, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02, 0x20, 0x08, 0x80,
  0x22, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x80, 0x82, 0x02, 0x08, 0x08,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x30, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0F, 0xFF, 0x03,
  0xC1, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x03, 0x80, 0x30, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x07, 0x06, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xC1, 0x80, 0x38, 0x01, 0xCE, 0x06,
  0x03, 0xB0, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 6, 9, 11, 3, -26 },
  { 15, 19, 26, 21, 1, -26 },
  { 77, 14, 30, 19, 2, -28 },
  { 130, 22, 27, 26, 2, -27 },
  { 205, 19, 27, 22, 2, -27 },
  { 270, 1, 9, 6, 3, -26 },
  { 272, 6, 32, 10, 2, -26 },
  { 296, 7, 32, 10, 1, -26 },
  { 324, 13, 13, 18, 2, -28 },
  { 346, 15, 17, 19, 2, -22 },
  { 378, 4, 9, 7, 1, -4 },
  { 383, 9, 1, 11, 1, -11 },
  { 385, 2, 2, 8, 3, -2 },
  { 386, 10, 26, 12, 1, -26 },
  { 419, 15, 27, 19, 2, -27 },
  { 470, 8, 26, 19, 3, -26 },
  { 496, 14, 27, 19, 2, -27 },
  { 544, 14, 27, 19, 2, -27 },
  { 592, 17, 27, 19, 1, -27 },
  { 650, 15, 26, 19, 2, -26 },
  { 699, 15, 27, 19, 2, -27 },
  { 750, 15, 26, 19, 2, -26 },
  { 799, 15, 27, 19, 2, -27 },
  { 850, 14, 27, 19, 2, -27 },
  { 898, 2, 20, 8, 3, -20 },
  { 903, 4, 25, 8, 1, -20 },
  { 916, 15, 16, 19, 2, -21 },
  { 946, 15, 8, 19, 2, -17 },
  { 961, 15, 16, 19, 2, -21 },
  { 991, 11, 27, 13, 1, -27 },
  { 1029, 25, 30, 29, 2, -26 },
  { 1123, 19, 26, 19, 0, -26 },
  { 1185, 15, 26, 20, 3, -26 },
  { 1234, 17, 27, 20, 2, -27 },
  { 1292, 17, 26, 23, 3, -26 },
  { 1348, 13, 26, 18, 3, -26 },
  { 1391, 13, 26, 16, 3, -26 },
  { 1434, 19, 27, 24, 2, -27 },
  { 1499, 17, 26, 23, 3, -26 },
  { 1555, 6, 26, 10, 2, -26 },
  { 1575, 8, 32, 8, -3, -26 },
  { 1607, 15, 26, 18, 3, -26 },
  { 1656, 13, 26, 17, 3, -26 },
  { 1699, 22, 26, 28, 3, -26 },
  { 1771, 17, 26, 23, 3, -26 },
  { 1827, 20, 27, 25, 2, -27 },
  { 1895, 14, 26, 19, 3, -26 },
  { 1941, 20, 33, 25, 2, -27 },
  { 2024, 15, 26, 19, 3, -26 },
  { 2073, 14, 27, 18, 2, -27 },
  { 2121, 16, 26, 16, 0, -26 },
  { 2173, 17, 26, 23, 3, -26 },
  { 2229, 18, 26, 18, 0, -26 },
  { 2288, 27, 26, 29, 1, -26 },
  { 2376, 16, 26, 16, 0, -26 },
  { 2428, 16, 26, 16, 0, -26 },
  { 2480, 16, 26, 18, 1, -26 },
  { 2532, 7, 32, 11, 3, -26 },
  { 2560, 10, 26, 12, 1, -26 },
  { 2593, 7, 32, 11, 1, -26 },
  { 2621, 16, 15, 19, 1, -27 },
  { 2651, 15, 1, 14, 0, 3 },
  { 2653, 6, 6, 9, 1, -28 },
  { 2658, 12, 20, 17, 2, -20 },
  { 2688, 14, 28, 19, 3, -28 },
  { 2737, 12, 20, 15, 2, -20 },
  { 2767, 14, 28, 19, 2, -28 },
  { 2816, 14, 20, 18, 2, -20 },
  { 2851, 11, 28, 9, 0, -28 },
  { 2890, 14, 29, 19, 2, -20 },
  { 2941, 13, 28, 19, 3, -28 },
  { 2987, 2, 27, 7, 3, -27 },
  { 2994, 6, 36, 7, -1, -27 },
  { 3021, 12, 28, 15, 3, -28 },
  { 3063, 1, 28, 7, 3, -28 },
  { 3067, 22, 20, 28, 3, -20 },
  { 3122, 13, 20, 19, 3, -20 },
  { 3155, 15, 20, 19, 2, -20 },
  { 3193, 14, 29, 19, 3, -20 },
  { 3244, 14, 29, 19, 2, -20 },
  { 3295, 9, 20, 12, 3, -20 },
  { 3318, 12, 20, 15, 1, -20 },
  { 3348, 8, 24, 10, 1, -24 },
  { 3372, 13, 20, 19, 3, -20 },
  { 3405, 14, 20, 14, 0, -20 },
  { 3440, 22, 20, 23, 1, -20 },
  { 3495, 14, 20, 16, 1, -20 },
  { 3530, 14, 29, 14, 0, -20 },
  { 3581, 12, 20, 14, 1, -20 },
  { 3611, 10, 32, 13, 1, -26 },
  { 3651, 1, 37, 18, 8, -28 },
  { 3656, 9, 32, 13, 2, -26 },
  { 3692, 15, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_Thin37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_THIN37PT7B_H_
