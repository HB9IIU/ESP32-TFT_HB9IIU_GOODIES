#ifndef _NOTOSANS_SEMICONDENSED_THIN13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFC, 0x24, 0x49, 0xF9, 0x22, 0x9F, 0xCA, 0x24, 0x48,
  0x27, 0xA9, 0x4A, 0x38, 0xA5, 0x2F, 0x88, 0xE4, 0xA8, 0xA8, 0xAE, 0xB9,
  0x59, 0x29, 0x29, 0x46, 0xF2, 0x49, 0x18, 0x62, 0x58, 0xE2, 0xF4, 0xE0,
  0x6A, 0xAA, 0xA4, 0xC8, 0x92, 0x49, 0x2B, 0x00, 0x22, 0xF6, 0x90, 0x21,
  0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80, 0x11, 0x22, 0x24, 0x48, 0x80, 0xF4,
  0x63, 0x18, 0xC6, 0x31, 0x70, 0x74, 0x92, 0x49, 0x20, 0xF0, 0x42, 0x21,
  0x11, 0x10, 0xF8, 0xF0, 0x42, 0x27, 0x04, 0x21, 0xF0, 0x08, 0x62, 0x8A,
  0x4A, 0x2F, 0xC2, 0x08, 0xF4, 0x21, 0x60, 0x84, 0x21, 0xF0, 0x74, 0x21,
  0xE8, 0xC6, 0x31, 0x70, 0xF8, 0x44, 0x22, 0x10, 0x88, 0x40, 0xFC, 0x62,
  0xA7, 0x46, 0x31, 0xF0, 0xF4, 0x63, 0x19, 0xB4, 0x22, 0xE0, 0x82, 0x40,
  0x06, 0x80, 0x3A, 0x20, 0xC1, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00,
  0xF1, 0x11, 0x24, 0x40, 0x40, 0x7E, 0x81, 0x99, 0xA5, 0xA5, 0xA5, 0xA5,
  0x9A, 0x80, 0x7C, 0x10, 0x60, 0xA1, 0x44, 0x8E, 0x91, 0x42, 0x82, 0xFC,
  0x63, 0x1F, 0xC6, 0x31, 0xF8, 0x7E, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7C,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0xF8, 0xFC, 0x21, 0x0F, 0x42, 0x10,
  0xF8, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x80, 0x7E, 0x08, 0x20, 0x9E, 0x18,
  0x61, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xEA, 0xAA, 0xC0,
  0x24, 0x92, 0x49, 0x27, 0x80, 0x8C, 0xA9, 0x8A, 0x52, 0x51, 0x88, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xF8, 0x81, 0x81, 0xC3, 0xC3, 0xA5, 0xA5, 0x99,
  0x99, 0x91, 0x87, 0x1C, 0x69, 0x96, 0x58, 0xE3, 0x84, 0x7D, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x7C, 0xFC, 0x63, 0x1F, 0x42, 0x10, 0x80, 0x7D,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x74, 0x10, 0x30, 0xFC, 0x63, 0x1F,
  0x4A, 0x51, 0x88, 0xF4, 0x21, 0x07, 0x04, 0x21, 0xF0, 0xFC, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x86,
  0x14, 0x52, 0x48, 0xA3, 0x04, 0x10, 0x88, 0x63, 0x14, 0xC5, 0x2A, 0x52,
  0x94, 0xA3, 0x28, 0x84, 0x21, 0x00, 0x8D, 0x23, 0x0C, 0x20, 0xC4, 0x92,
  0x84, 0x85, 0x24, 0x94, 0x20, 0x82, 0x08, 0x20, 0x7C, 0x20, 0x84, 0x20,
  0x84, 0x10, 0xFC, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x84, 0x44, 0x22, 0x21,
  0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x30, 0xA4, 0x91, 0x84, 0xF8, 0xB0,
  0xF1, 0x17, 0x99, 0xF0, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8F, 0x80, 0x78,
  0x88, 0x88, 0xF0, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8F, 0xC0, 0x74, 0x63,
  0xF8, 0x43, 0xE0, 0x34, 0x4E, 0x44, 0x44, 0x44, 0x7C, 0x63, 0x18, 0xC7,
  0xE1, 0x0F, 0x80, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x40, 0xBF, 0x80,
  0x45, 0x55, 0x57, 0x88, 0x89, 0xAC, 0xCA, 0x99, 0xFF, 0xC0, 0xFF, 0x89,
  0x89, 0x89, 0x89, 0x89, 0x89, 0xF4, 0x63, 0x18, 0xC6, 0x20, 0x74, 0x63,
  0x18, 0xC7, 0xC0, 0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x00, 0x7C, 0x63,
  0x18, 0xC7, 0xE1, 0x08, 0x40, 0xF2, 0x49, 0x20, 0x7C, 0x10, 0x60, 0x87,
  0xE0, 0x4B, 0xA4, 0x92, 0x60, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0x8C, 0x64,
  0xA5, 0x30, 0x80, 0x89, 0x89, 0x99, 0x56, 0x66, 0x26, 0x22, 0x8A, 0x8C,
  0x43, 0x2A, 0x20, 0x8C, 0x52, 0xA5, 0x10, 0x84, 0x26, 0x00, 0x78, 0x84,
  0x44, 0x23, 0xE0, 0x32, 0x22, 0x4C, 0x42, 0x22, 0x30, 0xFF, 0xF8, 0xC9,
  0x24, 0x52, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Thin13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -9 },
  { 4, 7, 9, 7, 0, -9 },
  { 12, 5, 11, 7, 1, -10 },
  { 19, 8, 9, 9, 1, -9 },
  { 28, 6, 9, 8, 1, -9 },
  { 35, 1, 3, 2, 1, -9 },
  { 36, 2, 11, 3, 1, -9 },
  { 39, 3, 11, 3, 0, -9 },
  { 44, 4, 5, 6, 1, -10 },
  { 47, 5, 6, 7, 1, -8 },
  { 51, 2, 3, 2, 0, -1 },
  { 52, 3, 1, 4, 0, -4 },
  { 53, 1, 1, 3, 1, -1 },
  { 54, 4, 9, 4, 0, -9 },
  { 59, 5, 9, 7, 1, -9 },
  { 65, 3, 9, 7, 1, -9 },
  { 69, 5, 9, 7, 1, -9 },
  { 75, 5, 9, 7, 1, -9 },
  { 81, 6, 9, 7, 0, -9 },
  { 88, 5, 9, 7, 1, -9 },
  { 94, 5, 9, 7, 1, -9 },
  { 100, 5, 9, 7, 1, -9 },
  { 106, 5, 9, 7, 1, -9 },
  { 112, 5, 9, 7, 1, -9 },
  { 118, 1, 7, 3, 1, -7 },
  { 119, 2, 9, 3, 0, -7 },
  { 122, 5, 5, 7, 1, -7 },
  { 126, 5, 3, 7, 1, -6 },
  { 128, 5, 5, 7, 1, -7 },
  { 132, 4, 9, 5, 0, -9 },
  { 137, 8, 10, 10, 1, -9 },
  { 147, 7, 9, 7, 0, -9 },
  { 155, 5, 9, 7, 1, -9 },
  { 161, 6, 9, 7, 1, -9 },
  { 168, 6, 9, 8, 1, -9 },
  { 175, 5, 9, 6, 1, -9 },
  { 181, 5, 9, 6, 1, -9 },
  { 187, 6, 9, 8, 1, -9 },
  { 194, 6, 9, 8, 1, -9 },
  { 201, 2, 9, 3, 1, -9 },
  { 204, 3, 11, 3, -1, -9 },
  { 209, 5, 9, 6, 1, -9 },
  { 215, 5, 9, 6, 1, -9 },
  { 221, 8, 9, 10, 1, -9 },
  { 230, 6, 9, 8, 1, -9 },
  { 237, 7, 9, 9, 1, -9 },
  { 245, 5, 9, 7, 1, -9 },
  { 251, 7, 11, 9, 1, -9 },
  { 261, 5, 9, 7, 1, -9 },
  { 267, 5, 9, 6, 1, -9 },
  { 273, 6, 9, 6, 0, -9 },
  { 280, 6, 9, 8, 1, -9 },
  { 287, 6, 9, 6, 0, -9 },
  { 294, 10, 9, 10, 0, -9 },
  { 306, 6, 9, 6, 0, -9 },
  { 313, 6, 9, 6, 0, -9 },
  { 320, 6, 9, 6, 0, -9 },
  { 327, 3, 11, 4, 1, -9 },
  { 332, 4, 9, 4, 0, -9 },
  { 337, 3, 11, 4, 0, -9 },
  { 342, 6, 5, 7, 0, -9 },
  { 346, 5, 1, 5, 0, 1 },
  { 347, 2, 2, 3, 1, -10 },
  { 348, 4, 7, 6, 1, -7 },
  { 352, 5, 10, 7, 1, -10 },
  { 359, 4, 7, 5, 1, -7 },
  { 363, 5, 10, 7, 1, -10 },
  { 370, 5, 7, 6, 1, -7 },
  { 375, 4, 10, 3, 0, -10 },
  { 380, 5, 10, 7, 1, -7 },
  { 387, 5, 10, 7, 1, -10 },
  { 394, 1, 9, 3, 1, -9 },
  { 396, 2, 12, 3, 0, -9 },
  { 399, 4, 10, 5, 1, -10 },
  { 404, 1, 10, 3, 1, -10 },
  { 406, 8, 7, 10, 1, -7 },
  { 413, 5, 7, 7, 1, -7 },
  { 418, 5, 7, 7, 1, -7 },
  { 423, 5, 10, 7, 1, -7 },
  { 430, 5, 10, 7, 1, -7 },
  { 437, 3, 7, 4, 1, -7 },
  { 440, 5, 7, 5, 0, -7 },
  { 445, 3, 9, 4, 0, -9 },
  { 449, 5, 7, 7, 1, -7 },
  { 454, 5, 7, 5, 0, -7 },
  { 459, 8, 7, 8, 0, -7 },
  { 466, 5, 7, 5, 0, -7 },
  { 471, 5, 10, 5, 0, -7 },
  { 478, 5, 7, 5, 0, -7 },
  { 483, 4, 11, 4, 0, -9 },
  { 489, 1, 13, 6, 3, -10 },
  { 491, 3, 11, 4, 1, -9 },
  { 496, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_Thin13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_THIN13PT7B_H_
