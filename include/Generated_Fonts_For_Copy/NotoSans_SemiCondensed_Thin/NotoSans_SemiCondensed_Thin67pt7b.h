#ifndef _NOTOSANS_SEMICONDENSED_THIN67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin67pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00, 0x6F,
  0xF7, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x00, 0x60, 0x01, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x20, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x08, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x20,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xF0, 0xC0, 0xF0,
  0x70, 0x30, 0x08, 0x38, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0xE0, 0x00,
  0x03, 0x1E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x02, 0x00, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0xC4, 0x00, 0xC0, 0xE1, 0xE0, 0x30,
  0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x1C, 0x38,
  0x00, 0x02, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0x80, 0x03, 0x01, 0x80, 0x00, 0x80, 0x03, 0x01, 0x80,
  0x00, 0x80, 0x03, 0x01, 0x00, 0x00, 0x80, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x02, 0x00, 0x00, 0xC0, 0x03, 0x06, 0x07, 0xE0, 0xC0, 0x03, 0x04,
  0x1C, 0x38, 0xC0, 0x02, 0x0C, 0x38, 0x18, 0xC0, 0x06, 0x0C, 0x30, 0x0C,
  0x60, 0x06, 0x18, 0x60, 0x06, 0x60, 0x04, 0x18, 0x60, 0x06, 0x30, 0x0C,
  0x30, 0x40, 0x06, 0x30, 0x18, 0x30, 0xC0, 0x02, 0x1C, 0x38, 0x60, 0xC0,
  0x03, 0x0F, 0xE0, 0x60, 0xC0, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0x80, 0x03, 0x00, 0x01, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x80, 0x03,
  0x00, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x21, 0xC0, 0x0C, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x1C,
  0x00, 0x63, 0x00, 0x01, 0x80, 0x0C, 0x60, 0x00, 0x18, 0x01, 0x0C, 0x00,
  0x01, 0x80, 0x61, 0x00, 0x00, 0x18, 0x0C, 0x20, 0x00, 0x01, 0x83, 0x0C,
  0x00, 0x00, 0x38, 0x61, 0x80, 0x00, 0x03, 0x18, 0x10, 0x00, 0x00, 0x33,
  0x02, 0x00, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x66, 0x03, 0x80,
  0x00, 0x18, 0x60, 0x38, 0x00, 0x0E, 0x06, 0x03, 0x80, 0x03, 0x80, 0x60,
  0x3C, 0x03, 0xC0, 0x0E, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xE0,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x10, 0x02, 0xF0, 0x10, 0x1F, 0x1E, 0x10,
  0xF8, 0x03, 0xD3, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x83, 0x00, 0x01, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x60, 0x1C, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0x62, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x64, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x04, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x07, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x1A, 0x01, 0x90, 0x38, 0x83, 0x84, 0x38,
  0x23, 0x01, 0x70, 0x0F, 0x00, 0x50, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x0F, 0x00, 0xF0, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xF8, 0x03, 0xE0, 0x1F,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x01, 0x00, 0x06, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0xA0, 0x00, 0x2F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x3C, 0x02, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x07,
  0xC0, 0x1E, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x70, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x7F, 0xE0, 0x30, 0x7C, 0x3E, 0x0C, 0x70, 0x01,
  0xC3, 0x38, 0x00, 0x18, 0xDC, 0x00, 0x03, 0x36, 0x00, 0x00, 0xCF, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x03, 0x80, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07,
  0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x70, 0x00, 0x78, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x70, 0x78, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x81, 0xC0,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x79, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x03,
  0x63, 0x00, 0x00, 0xCC, 0x70, 0x00, 0x39, 0x07, 0x00, 0x0E, 0x20, 0x78,
  0x0F, 0x04, 0x03, 0xFF, 0x81, 0x80, 0x02, 0x80, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x80, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFE, 0x18, 0xF3, 0xCF, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x31, 0x86,
  0x18, 0x43, 0x0C, 0x20, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xFF, 0xC0, 0xFC, 0x1F, 0x0C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x3F, 0xE0,
  0x01, 0x86, 0x00, 0x07, 0xFF, 0xC0, 0x04, 0x60, 0x00, 0x70, 0x06, 0x00,
  0x33, 0x00, 0x06, 0x00, 0x30, 0x01, 0x98, 0x00, 0x60, 0x01, 0x80, 0x0D,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x6C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x60,
  0x03, 0x00, 0x03, 0x00, 0x0B, 0x00, 0x18, 0x00, 0x18, 0x00, 0x78, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x40, 0x06, 0x00, 0x06,
  0x00, 0x0A, 0x00, 0x30, 0x00, 0x30, 0x00, 0xD0, 0x01, 0x80, 0x01, 0x80,
  0x06, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x30, 0x03, 0x00, 0x07, 0x80, 0x19, 0x80, 0x0C, 0x00, 0x2C, 0x00, 0xCC,
  0x00, 0x60, 0x03, 0x20, 0x0C, 0x60, 0x01, 0x80, 0x31, 0x80, 0xE1, 0x80,
  0x07, 0x07, 0x06, 0x0E, 0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x60, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x3C, 0x18,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x78, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x40, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x03, 0xE0,
  0x06, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xE3, 0xFF, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x64, 0x0F, 0x3F, 0xE0, 0x38, 0x00,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07,
  0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x87,
  0x80, 0x00, 0x31, 0xB8, 0x00, 0x06, 0x73, 0x00, 0x00, 0xDC, 0x30, 0x00,
  0x1B, 0x07, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xDD, 0x80, 0x00, 0x00, 0x01,
  0xBB, 0x00, 0x00, 0x00, 0x02, 0xF6, 0x00, 0x00, 0x00, 0x0D, 0xE6, 0x00,
  0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00, 0x00, 0x67, 0x88, 0x00, 0x00, 0x00,
  0xCF, 0x18, 0x00, 0x00, 0x01, 0x9E, 0x30, 0x00, 0x00, 0x06, 0x3C, 0x30,
  0x00, 0x00, 0x0C, 0x78, 0x60, 0x00, 0x00, 0x10, 0xF0, 0xC0, 0x00, 0x00,
  0x61, 0xE0, 0xC0, 0x00, 0x00, 0xC3, 0xC1, 0x80, 0x00, 0x03, 0x07, 0x81,
  0x00, 0x00, 0x06, 0x0F, 0x03, 0x00, 0x00, 0x0C, 0x1E, 0x06, 0x00, 0x00,
  0x30, 0x3C, 0x06, 0x00, 0x00, 0x60, 0x78, 0x0C, 0x00, 0x00, 0xC0, 0xF0,
  0x18, 0x00, 0x03, 0x01, 0xE0, 0x18, 0x00, 0x06, 0x03, 0xC0, 0x30, 0x00,
  0x08, 0x07, 0x80, 0x60, 0x00, 0x30, 0x0F, 0x00, 0x60, 0x00, 0x60, 0x1E,
  0x00, 0xC0, 0x01, 0x80, 0x3C, 0x00, 0x80, 0x03, 0x00, 0x78, 0x01, 0x80,
  0x06, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x30, 0x03,
  0xC0, 0x06, 0x00, 0x40, 0x07, 0x80, 0x0C, 0x01, 0x80, 0x0F, 0x00, 0x0C,
  0x03, 0x00, 0x1E, 0x00, 0x18, 0x0C, 0x00, 0x3C, 0x00, 0x10, 0x18, 0x00,
  0x78, 0x00, 0x30, 0x30, 0x00, 0xF0, 0x00, 0x60, 0xC0, 0x01, 0xE0, 0x00,
  0x61, 0x80, 0x03, 0xC0, 0x00, 0xC2, 0x00, 0x07, 0x80, 0x01, 0x8C, 0x00,
  0x0F, 0x00, 0x01, 0x98, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00,
  0x02, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x60, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x03,
  0xC6, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0xF0,
  0x60, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x3C, 0x0C,
  0x00, 0x00, 0xF0, 0x18, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x0F, 0x00, 0xC0,
  0x00, 0x3C, 0x01, 0x80, 0x00, 0xF0, 0x06, 0x00, 0x03, 0xC0, 0x0C, 0x00,
  0x0F, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x30, 0x03, 0xC0, 0x00, 0x60, 0x0F, 0x00, 0x01, 0x80, 0x3C, 0x00,
  0x03, 0x00, 0xF0, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x18, 0x0F, 0x00, 0x00,
  0x30, 0x3C, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x06,
  0x0F, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x18, 0xF0, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0x06, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0x7C, 0x18, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x70, 0x60, 0x01, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x80, 0xC0, 0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x03, 0xF8, 0x1C, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC3, 0xF0, 0x03, 0xE0,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06,
  0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x81, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10, 0x30, 0x00,
  0x10, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x04, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x02, 0x01, 0x80,
  0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x20,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x01,
  0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x08, 0x06, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x03, 0x00, 0x00, 0x81, 0x80, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x40, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x02, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x26, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x01, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10,
  0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0x01, 0xE0, 0x07, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xD0, 0x3C,
  0x00, 0x43, 0x80, 0x01, 0x18, 0x00, 0x04, 0xC0, 0x00, 0x16, 0x00, 0x00,
  0x58, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x58, 0x00,
  0x0D, 0x60, 0x00, 0x64, 0xC0, 0x03, 0x11, 0xC0, 0x38, 0x43, 0xFF, 0x81,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x01, 0xFE, 0x00, 0xC0, 0xFF, 0xF0,
  0x18, 0x70, 0x07, 0x03, 0x18, 0x00, 0x30, 0x66, 0x00, 0x03, 0x0D, 0x80,
  0x00, 0x31, 0xB0, 0x00, 0x06, 0x34, 0x00, 0x00, 0x67, 0x80, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x06, 0x78, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x31, 0xB0,
  0x00, 0x06, 0x36, 0x00, 0x01, 0x86, 0x60, 0x00, 0x70, 0xC7, 0x00, 0x1C,
  0x18, 0x78, 0x0E, 0x03, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x3C, 0x00, 0xC1, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x10, 0x3C, 0x03, 0xC0,
  0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x01, 0xFE, 0x03, 0x01, 0xFF, 0xE0,
  0xC1, 0xE0, 0x0E, 0x30, 0xE0, 0x01, 0xCC, 0x70, 0x00, 0x33, 0x18, 0x00,
  0x06, 0xCC, 0x00, 0x00, 0xB3, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xD0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x0F, 0x60, 0x00, 0x03, 0xCC, 0x00, 0x01, 0xB3, 0x80,
  0x00, 0x6C, 0x70, 0x00, 0x33, 0x0E, 0x00, 0x18, 0xC1, 0xE0, 0x3C, 0x30,
  0x1F, 0xFC, 0x0C, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x90, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x03, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x3C, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x30, 0x78,
  0x03, 0x8C, 0x38, 0x00, 0x33, 0x1C, 0x00, 0x04, 0xC6, 0x00, 0x01, 0xB3,
  0x00, 0x00, 0x3C, 0xC0, 0x00, 0x0F, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x74, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x03, 0xD8, 0x00, 0x00, 0xB3, 0x00, 0x00, 0x6C, 0x60, 0x00, 0x13,
  0x1C, 0x00, 0x0C, 0xC3, 0x80, 0x0E, 0x30, 0x78, 0x0F, 0x0C, 0x07, 0xFF,
  0x03, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x1E, 0x00, 0x0E, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x3F, 0x80, 0x83, 0xFF, 0xE1, 0x0E, 0x00, 0xE2, 0x30, 0x00, 0xE4,
  0xC0, 0x00, 0xCB, 0x00, 0x00, 0xD4, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0xCF, 0xE3, 0xF0, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x74, 0x00, 0x07, 0x20, 0x00, 0x31,
  0x00, 0x03, 0x08, 0x00, 0x30, 0x40, 0x03, 0x02, 0x00, 0x38, 0x10, 0x01,
  0x80, 0x80, 0x18, 0x04, 0x01, 0x80, 0x20, 0x18, 0x01, 0x00, 0xC0, 0x08,
  0x0C, 0x00, 0x40, 0xC0, 0x02, 0x0E, 0x00, 0x10, 0xF0, 0x00, 0x84, 0xC0,
  0x04, 0x67, 0x00, 0x26, 0x18, 0x01, 0x60, 0x60, 0x0E, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x30, 0x10, 0x01, 0x80, 0x80, 0x06, 0x04, 0x00, 0x30,
  0x20, 0x00, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00, 0x62, 0x00,
  0x01, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x8E, 0x01, 0xC1, 0xC0, 0x38, 0x9C, 0x00,
  0xC3, 0x80, 0x1C, 0x90, 0x00, 0x63, 0x00, 0x0E, 0xB0, 0x00, 0x36, 0x00,
  0x06, 0xA0, 0x00, 0x3C, 0x00, 0x06, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x7F, 0x81, 0x07, 0xFF,
  0xC2, 0x1C, 0x01, 0xC4, 0x60, 0x01, 0xC9, 0x80, 0x01, 0xD6, 0x00, 0x01,
  0xA8, 0x00, 0x03, 0x50, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x01,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x20,
  0x7F, 0xF8, 0x08, 0x70, 0x07, 0x82, 0x38, 0x00, 0x70, 0x9C, 0x00, 0x0C,
  0x26, 0x00, 0x01, 0x8B, 0x00, 0x00, 0x32, 0x80, 0x00, 0x0C, 0xE0, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x28, 0x00, 0x00, 0x8B, 0x00, 0x00,
  0x62, 0x60, 0x00, 0x30, 0x9C, 0x00, 0x1C, 0x23, 0x80, 0x0E, 0x08, 0x78,
  0x0F, 0x02, 0x07, 0xFF, 0x00, 0x80, 0x1E, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFC, 0x10, 0x3C, 0x03, 0x84, 0x1C, 0x00, 0x31, 0x0E, 0x00,
  0x06, 0x43, 0x00, 0x00, 0xD1, 0x80, 0x00, 0x14, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x51, 0x80,
  0x00, 0x34, 0x70, 0x00, 0x19, 0x0C, 0x00, 0x0E, 0x41, 0xC0, 0x07, 0x10,
  0x3C, 0x07, 0x84, 0x03, 0xFF, 0x81, 0x00, 0x1F, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0xFD,
  0x07, 0xFE, 0x1C, 0x04, 0x60, 0x09, 0x80, 0x16, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x87,
  0x00, 0x1E, 0x70, 0x00, 0x26, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x80, 0x00, 0x36, 0x00, 0x07, 0x3E,
  0x00, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0xFF, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x81, 0x01, 0xFF,
  0x00, 0x78, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x0F, 0x60, 0x00, 0x0B, 0x70, 0x00, 0x1B, 0x30,
  0x00, 0x33, 0x18, 0x00, 0xE3, 0x0E, 0x03, 0xC3, 0x07, 0xFF, 0x03, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0x40, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00, 0xC0,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x02,
  0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0xC0, 0x00,
  0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0x90, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x02, 0x40, 0x00, 0x1C, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x60, 0x00, 0x34, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x04, 0x30, 0x00,
  0x66, 0x00, 0x0C, 0x30, 0x00, 0x62, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00,
  0x0C, 0x10, 0x00, 0x43, 0x00, 0x08, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x18,
  0x00, 0xC1, 0x00, 0x18, 0x18, 0x00, 0x81, 0x80, 0x18, 0x08, 0x01, 0x81,
  0x80, 0x10, 0x0C, 0x01, 0x80, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x06, 0x03,
  0x00, 0x40, 0x60, 0x06, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x02, 0x06, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03,
  0x04, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x10, 0x80, 0x01, 0x88, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80,
  0x00, 0x98, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x09, 0x00, 0x00, 0xD0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x08, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x06,
  0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x03, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x02, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x80, 0x60, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x60, 0x00, 0x02, 0x18, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x01, 0x78, 0x3C, 0x00,
  0x3E, 0x00, 0x78, 0x06, 0x80, 0x01, 0xF7, 0xC8, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Thin67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 48, 14, 5, -48 },
  { 25, 11, 17, 21, 5, -48 },
  { 49, 34, 48, 38, 2, -48 },
  { 253, 26, 55, 34, 3, -51 },
  { 432, 40, 50, 48, 4, -49 },
  { 682, 35, 50, 39, 3, -49 },
  { 901, 2, 17, 11, 5, -48 },
  { 906, 12, 59, 17, 3, -48 },
  { 995, 12, 59, 17, 2, -48 },
  { 1084, 24, 23, 32, 4, -51 },
  { 1153, 28, 31, 34, 3, -39 },
  { 1262, 5, 16, 12, 3, -7 },
  { 1272, 16, 2, 20, 2, -19 },
  { 1276, 4, 4, 14, 5, -4 },
  { 1278, 20, 48, 22, 1, -48 },
  { 1398, 26, 50, 34, 4, -49 },
  { 1561, 13, 48, 34, 6, -48 },
  { 1639, 26, 49, 34, 3, -49 },
  { 1799, 26, 50, 34, 3, -49 },
  { 1962, 32, 48, 34, 1, -48 },
  { 2154, 26, 49, 34, 4, -48 },
  { 2314, 26, 50, 34, 4, -49 },
  { 2477, 26, 48, 34, 4, -48 },
  { 2633, 26, 50, 34, 4, -49 },
  { 2796, 27, 50, 34, 3, -49 },
  { 2965, 4, 36, 14, 5, -36 },
  { 2983, 6, 45, 14, 3, -36 },
  { 3017, 28, 29, 34, 3, -39 },
  { 3119, 28, 15, 34, 3, -31 },
  { 3172, 28, 29, 34, 3, -39 },
  { 3274, 20, 49, 24, 2, -49 },
  { 3397, 45, 55, 52, 4, -48 },
  { 3707, 34, 48, 34, 0, -48 },
  { 3911, 27, 48, 37, 6, -48 },
  { 4073, 30, 50, 36, 4, -49 },
  { 4261, 31, 48, 41, 6, -48 },
  { 4447, 23, 48, 33, 6, -48 },
  { 4585, 23, 48, 30, 6, -48 },
  { 4723, 35, 50, 43, 4, -49 },
  { 4942, 30, 48, 42, 6, -48 },
  { 5122, 10, 48, 17, 4, -48 },
  { 5182, 13, 60, 14, -5, -48 },
  { 5280, 27, 48, 33, 6, -48 },
  { 5442, 23, 48, 30, 6, -48 },
  { 5580, 39, 48, 52, 6, -48 },
  { 5814, 30, 48, 42, 6, -48 },
  { 5994, 37, 50, 45, 4, -49 },
  { 6226, 25, 48, 34, 6, -48 },
  { 6376, 37, 60, 45, 4, -49 },
  { 6654, 27, 48, 34, 6, -48 },
  { 6816, 26, 50, 33, 3, -49 },
  { 6979, 29, 48, 30, 0, -48 },
  { 7153, 30, 49, 42, 6, -48 },
  { 7337, 33, 48, 33, 0, -48 },
  { 7535, 49, 48, 53, 2, -48 },
  { 7829, 30, 48, 30, 0, -48 },
  { 8009, 29, 48, 29, 0, -48 },
  { 8183, 28, 48, 33, 2, -48 },
  { 8351, 13, 59, 21, 6, -48 },
  { 8447, 20, 48, 22, 1, -48 },
  { 8567, 13, 59, 21, 2, -48 },
  { 8663, 29, 27, 34, 2, -48 },
  { 8761, 26, 2, 26, 0, 6 },
  { 8768, 10, 10, 16, 3, -51 },
  { 8781, 22, 37, 31, 3, -36 },
  { 8883, 27, 52, 35, 5, -51 },
  { 9059, 22, 37, 28, 4, -36 },
  { 9161, 26, 52, 35, 4, -51 },
  { 9330, 25, 37, 32, 4, -36 },
  { 9446, 19, 51, 17, 1, -51 },
  { 9568, 26, 52, 35, 4, -36 },
  { 9737, 23, 51, 34, 6, -51 },
  { 9884, 3, 48, 13, 5, -48 },
  { 9902, 10, 64, 13, -2, -48 },
  { 9982, 21, 51, 27, 6, -51 },
  { 10116, 1, 51, 13, 6, -51 },
  { 10123, 40, 36, 51, 6, -36 },
  { 10303, 23, 36, 34, 6, -36 },
  { 10407, 27, 37, 34, 4, -36 },
  { 10532, 26, 52, 35, 6, -36 },
  { 10701, 26, 52, 35, 3, -36 },
  { 10870, 15, 36, 22, 6, -36 },
  { 10938, 21, 37, 27, 3, -36 },
  { 11036, 16, 45, 19, 1, -44 },
  { 11126, 24, 36, 34, 5, -35 },
  { 11234, 25, 35, 25, 0, -35 },
  { 11344, 40, 35, 42, 1, -35 },
  { 11519, 24, 35, 28, 2, -35 },
  { 11624, 26, 51, 26, 0, -35 },
  { 11790, 21, 35, 26, 2, -35 },
  { 11882, 18, 59, 23, 2, -48 },
  { 12015, 2, 68, 32, 15, -51 },
  { 12032, 17, 59, 23, 3, -48 },
  { 12158, 28, 6, 34, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_Thin67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_THIN67PT7B_H_
