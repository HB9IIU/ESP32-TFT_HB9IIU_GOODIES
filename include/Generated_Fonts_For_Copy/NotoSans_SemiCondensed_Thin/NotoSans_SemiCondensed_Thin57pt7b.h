#ifndef _NOTOSANS_SEMICONDENSED_THIN57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin57pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB0, 0x00, 0x00, 0x37, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x28, 0x08,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x20, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x10, 0x02, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x40, 0x08, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x80, 0x18, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x08, 0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x10,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x01, 0x80, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x80, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0x23, 0xE0,
  0x60, 0x81, 0xC3, 0x02, 0x00, 0x18, 0x08, 0x00, 0x40, 0x20, 0x03, 0x00,
  0x80, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80,
  0x0C, 0x02, 0x00, 0x30, 0x08, 0x00, 0x60, 0x20, 0x01, 0x80, 0x80, 0x03,
  0x82, 0x00, 0x07, 0x08, 0x00, 0x07, 0x20, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x23, 0x80, 0x00, 0x87, 0x00, 0x02, 0x06,
  0x00, 0x08, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x80, 0x60, 0x02, 0x00, 0x80,
  0x08, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x08,
  0x02, 0x00, 0x20, 0x18, 0x00, 0x80, 0xC0, 0x02, 0x07, 0x30, 0x08, 0x38,
  0xFE, 0x27, 0x80, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x03, 0x0C, 0x00,
  0x04, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x20, 0x06, 0x01,
  0x80, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x08, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x01, 0x80, 0x40,
  0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0x06, 0x02, 0x00, 0x0C, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0x18, 0x10, 0x00, 0x30, 0x03, 0x06, 0x00, 0x06, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0x0C, 0x30, 0x7C, 0x18, 0x01, 0x86, 0x18, 0xC1,
  0x00, 0x20, 0x86, 0x0C, 0x20, 0x04, 0x31, 0x80, 0xC6, 0x01, 0x84, 0x20,
  0x08, 0x40, 0x21, 0x8C, 0x01, 0x8C, 0x0C, 0x21, 0x80, 0x30, 0xC3, 0x0C,
  0x20, 0x02, 0x0F, 0xC1, 0x04, 0x00, 0x40, 0x00, 0x60, 0x80, 0x08, 0x00,
  0x08, 0x10, 0x01, 0x00, 0x03, 0x02, 0x00, 0x20, 0x00, 0x40, 0x40, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x80, 0x02, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x20,
  0x02, 0x00, 0x18, 0x04, 0x00, 0x40, 0x06, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0x20, 0x08, 0x00,
  0x80, 0x06, 0x01, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x04, 0x00, 0x0C, 0x18,
  0x01, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x40, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x02,
  0x30, 0x03, 0x00, 0x33, 0x00, 0x08, 0x01, 0x90, 0x00, 0x60, 0x09, 0x80,
  0x01, 0x80, 0xCC, 0x00, 0x06, 0x06, 0x60, 0x00, 0x18, 0x22, 0x00, 0x00,
  0x63, 0x10, 0x00, 0x01, 0x10, 0xC0, 0x00, 0x0D, 0x86, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x0B, 0x06, 0x00, 0x00, 0xC8, 0x18,
  0x00, 0x1C, 0x20, 0x60, 0x01, 0x81, 0x81, 0xC0, 0x38, 0x06, 0x07, 0xFF,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0,
  0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x70, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x02, 0x00, 0x80, 0x3E, 0x04,
  0x0F, 0x3C, 0x23, 0xC0, 0x1D, 0x70, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00,
  0x0D, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x10, 0x00, 0x40, 0xC0, 0x06, 0x03,
  0x00, 0x60, 0x08, 0x06, 0x00, 0x20, 0x10, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23, 0x10, 0x8C, 0x00, 0xFF, 0xF8, 0x7D,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x07, 0x00, 0x18,
  0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x03, 0x02, 0x00, 0x02, 0x0C, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x90, 0x00, 0x01,
  0x60, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x24, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x04, 0x20, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x80, 0x00,
  0x81, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x07, 0x01, 0xF0, 0x3B,
  0x06, 0x30, 0xC3, 0x38, 0x36, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFE, 0x00, 0x7C,
  0x1C, 0x03, 0x80, 0x1C, 0x18, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x00, 0x7C, 0x1E, 0x07, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x0E,
  0x3C, 0x00, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x02, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x7F, 0xF8, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x08, 0x00, 0x18, 0x3C, 0x01, 0xC0, 0x3F, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x20, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x7F,
  0x00, 0x87, 0xEF, 0x81, 0x1C, 0x01, 0x82, 0x60, 0x01, 0x85, 0x80, 0x01,
  0x9E, 0x00, 0x01, 0x38, 0x00, 0x03, 0x70, 0x00, 0x02, 0xE0, 0x00, 0x04,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x08, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x41, 0x80, 0x01, 0x81, 0x80,
  0x02, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x70, 0x01, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0x07, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00,
  0x01, 0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04, 0x60, 0x00,
  0x08, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x21, 0x00, 0x00, 0x43, 0x00, 0x01,
  0x86, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x01, 0xC0,
  0x07, 0x0E, 0x00, 0x03, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0x30, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x10, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x58, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x06, 0x00, 0x1C, 0x07, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x03, 0xFE, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x1C, 0x04, 0x00, 0x18, 0x30,
  0x00, 0x21, 0x80, 0x00, 0xC4, 0x00, 0x01, 0x10, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x34, 0x00, 0x01, 0xD8, 0x00, 0x05, 0x20, 0x00, 0x34, 0xC0, 0x01,
  0x91, 0x80, 0x0C, 0x43, 0x80, 0xE3, 0x03, 0xFE, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x08,
  0x07, 0x80, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x7D, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xC0, 0x18, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0xC6, 0x23, 0x18, 0xC4, 0x63, 0x10, 0x8C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x78, 0x3C, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x0F,
  0xE0, 0x02, 0x20, 0x00, 0xF3, 0xE0, 0x09, 0x80, 0x0E, 0x01, 0x80, 0x36,
  0x00, 0x60, 0x06, 0x00, 0xD8, 0x01, 0x00, 0x18, 0x03, 0x40, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x20, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x06, 0x00, 0x70,
  0x04, 0x00, 0x10, 0x01, 0xC0, 0x10, 0x00, 0x40, 0x07, 0x00, 0x40, 0x01,
  0x00, 0x1C, 0x03, 0x00, 0x04, 0x00, 0x70, 0x0C, 0x00, 0x10, 0x01, 0xC0,
  0x30, 0x00, 0x40, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x01, 0x00, 0x0C,
  0x00, 0xF0, 0x04, 0x00, 0x30, 0x02, 0xC0, 0x18, 0x00, 0xC0, 0x0B, 0x00,
  0x60, 0x05, 0x80, 0x64, 0x00, 0xC0, 0x32, 0x03, 0x10, 0x01, 0x81, 0x8C,
  0x18, 0x60, 0x03, 0xFC, 0x1F, 0xC1, 0x80, 0x03, 0xC0, 0x3C, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x20, 0x02, 0x00, 0x03, 0x00, 0x18, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x30, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x18, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0x86, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x98, 0x00, 0x01, 0x30, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x0F, 0x07, 0xFF, 0xF0, 0x0C, 0x00,
  0x7C, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x16, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98,
  0x00, 0x07, 0x30, 0x00, 0x18, 0x60, 0x07, 0xE0, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0x01, 0xF0, 0x0E, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x04, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0C, 0x00,
  0x1E, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x1E, 0x03, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x1E,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xBF, 0x82, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0xFF, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xCF, 0xF8, 0x7E, 0x00, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x01,
  0x86, 0x00, 0x03, 0x1E, 0x00, 0x06, 0x6C, 0x00, 0x0D, 0x8C, 0x00, 0x1B,
  0x0C, 0x00, 0x3C, 0x18, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x10, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x01, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x30, 0x00, 0x02, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7D, 0x00, 0x00, 0x00, 0x2E, 0xC0, 0x00, 0x00, 0x37,
  0x60, 0x00, 0x00, 0x13, 0x90, 0x00, 0x00, 0x09, 0xCC, 0x00, 0x00, 0x0C,
  0xE6, 0x00, 0x00, 0x04, 0x71, 0x00, 0x00, 0x06, 0x38, 0xC0, 0x00, 0x03,
  0x1C, 0x20, 0x00, 0x01, 0x0E, 0x18, 0x00, 0x01, 0x87, 0x0C, 0x00, 0x00,
  0xC3, 0x82, 0x00, 0x00, 0x41, 0xC1, 0x80, 0x00, 0x60, 0xE0, 0xC0, 0x00,
  0x20, 0x70, 0x20, 0x00, 0x30, 0x38, 0x18, 0x00, 0x18, 0x1C, 0x04, 0x00,
  0x08, 0x0E, 0x02, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x06, 0x03, 0x80, 0x40,
  0x02, 0x01, 0xC0, 0x30, 0x03, 0x00, 0xE0, 0x18, 0x01, 0x00, 0x70, 0x04,
  0x01, 0x80, 0x38, 0x03, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x40, 0x0E, 0x00,
  0x40, 0x60, 0x07, 0x00, 0x30, 0x30, 0x03, 0x80, 0x08, 0x10, 0x01, 0xC0,
  0x06, 0x18, 0x00, 0xE0, 0x03, 0x08, 0x00, 0x70, 0x00, 0x84, 0x00, 0x38,
  0x00, 0x66, 0x00, 0x1C, 0x00, 0x32, 0x00, 0x0E, 0x00, 0x0B, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x20, 0x00, 0x03, 0x98,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x38,
  0x20, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0x20, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x06, 0x00,
  0x38, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x20, 0x07, 0x00, 0x18,
  0x03, 0x80, 0x04, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00,
  0x60, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x04, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x04, 0x70,
  0x00, 0x03, 0x38, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x60, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x30, 0x00,
  0xE1, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x58,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x0C,
  0x60, 0x03, 0xC3, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x0C, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x13, 0x00, 0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x11,
  0x80, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x08, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x00,
  0xC3, 0x00, 0x00, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x01, 0xFF, 0xC0,
  0x1E, 0x03, 0xE1, 0xC0, 0x01, 0x8E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x0E, 0x3C, 0x00, 0xF0, 0x7F,
  0xFF, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x26, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x1E, 0x01, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x10, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x20, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x10, 0x00, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x68, 0x00, 0x01, 0x80, 0x00, 0x09, 0x00, 0x00, 0x38, 0x00, 0x01, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x66, 0x00, 0x00, 0xA0, 0x00, 0x0C, 0x40, 0x00,
  0x34, 0x00, 0x01, 0x08, 0x00, 0x06, 0xC0, 0x00, 0x21, 0x80, 0x00, 0x98,
  0x00, 0x0C, 0x30, 0x00, 0x11, 0x00, 0x01, 0x82, 0x00, 0x06, 0x20, 0x00,
  0x20, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x81,
  0x80, 0x02, 0x08, 0x00, 0x30, 0x10, 0x00, 0xC1, 0x00, 0x04, 0x02, 0x00,
  0x18, 0x30, 0x01, 0x80, 0x60, 0x02, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x40,
  0x40, 0x06, 0x00, 0x80, 0x18, 0x08, 0x00, 0x80, 0x10, 0x03, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x40, 0x30, 0x06, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0,
  0x04, 0x03, 0x00, 0x40, 0x10, 0x00, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x18,
  0x08, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x10, 0x18, 0x00, 0x20, 0x60,
  0x02, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x20, 0x00, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x10, 0x40,
  0x00, 0x21, 0x80, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x00,
  0xC4, 0x00, 0x04, 0x40, 0x00, 0x09, 0x80, 0x00, 0x88, 0x00, 0x01, 0x30,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00,
  0x28, 0x00, 0x00, 0x50, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xA0,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x01, 0x84, 0x00, 0x00, 0x83, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x40, 0x60, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x08, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x61, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x20,
  0x00, 0x10, 0x18, 0x00, 0x18, 0x04, 0x00, 0x08, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x81, 0x00, 0x00, 0x61, 0x80, 0x00, 0x11, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10, 0x08, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x18, 0x03, 0x00, 0x04, 0x01, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x80, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x20, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0x40, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x08, 0x00, 0x01, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x40, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x10, 0x00, 0x60, 0x18, 0x00, 0x30, 0x08, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x00, 0xF0, 0x01, 0xFF, 0xC0, 0xF0, 0x0C, 0x10, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x0F, 0xF8,
  0x1F, 0xC3, 0x1E, 0x00, 0x67, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xB6, 0x00, 0x66, 0x60, 0x18, 0xC7,
  0xFE, 0x18, 0x08, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x78, 0x02, 0x0F, 0xFC, 0x08, 0xE0, 0x1C, 0x26, 0x00, 0x38,
  0x90, 0x00, 0x62, 0xC0, 0x00, 0xCA, 0x00, 0x01, 0x30, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x13, 0x80, 0x00,
  0xCA, 0x00, 0x03, 0x2C, 0x00, 0x18, 0x98, 0x00, 0xC2, 0x38, 0x0E, 0x08,
  0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x0E, 0x00,
  0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x7F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x38, 0x04, 0x0F, 0xFC, 0x10,
  0x70, 0x1C, 0x43, 0x00, 0x19, 0x18, 0x00, 0x34, 0xC0, 0x00, 0x53, 0x00,
  0x01, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0x60, 0x00, 0x0C, 0x80, 0x00, 0x53, 0x00, 0x01, 0x46, 0x00, 0x09, 0x1C,
  0x00, 0x64, 0x1C, 0x07, 0x10, 0x3F, 0xF0, 0x40, 0x04, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xF8, 0x01, 0xC0, 0x60, 0x18, 0x01, 0x81, 0x80, 0x06, 0x08,
  0x00, 0x18, 0xC0, 0x00, 0xC4, 0x00, 0x02, 0x60, 0x00, 0x1A, 0x00, 0x00,
  0xD0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x01, 0x03, 0x80, 0x38, 0x07, 0xFF, 0x00, 0x05, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0x01, 0x81, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x10, 0x70, 0x0C, 0x43, 0x00,
  0x19, 0x18, 0x00, 0x34, 0xC0, 0x00, 0x53, 0x00, 0x01, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x1C, 0x80,
  0x00, 0x53, 0x00, 0x03, 0x46, 0x00, 0x09, 0x0C, 0x00, 0x64, 0x1C, 0x07,
  0x10, 0x3F, 0xF0, 0x40, 0x1A, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x31, 0x00, 0x01, 0x87, 0x80, 0x1C,
  0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x70, 0x08, 0x3F, 0xF0, 0x8E, 0x03, 0x89, 0x80, 0x0C, 0xB0, 0x00,
  0x4A, 0x00, 0x06, 0xE0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0xFF, 0xA0, 0x00, 0x00, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x03, 0x81,
  0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x67, 0xE1, 0xE0,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x68, 0x00, 0x32, 0x00, 0x18,
  0x80, 0x04, 0x20, 0x03, 0x08, 0x01, 0x82, 0x00, 0xC0, 0x80, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x02, 0x06, 0x00, 0x83, 0x00, 0x21, 0x80, 0x08, 0x70,
  0x02, 0x26, 0x00, 0x98, 0x80, 0x2C, 0x30, 0x0E, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x30, 0x20, 0x04, 0x08, 0x01, 0x82, 0x00, 0x30, 0x80, 0x04, 0x20,
  0x01, 0x88, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x28, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x21,
  0xFF, 0x01, 0xFF, 0x08, 0xC0, 0x60, 0xE0, 0x72, 0x60, 0x0C, 0x60, 0x0C,
  0xB0, 0x01, 0x30, 0x01, 0xA8, 0x00, 0x68, 0x00, 0x2C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x78, 0x08, 0x3F, 0xF0,
  0x8E, 0x03, 0x89, 0x80, 0x0C, 0x90, 0x00, 0x6A, 0x00, 0x06, 0xE0, 0x00,
  0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x03,
  0x81, 0x80, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x06,
  0x00, 0xE0, 0x38, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x78, 0x02,
  0x0F, 0xFC, 0x08, 0x60, 0x1C, 0x23, 0x00, 0x38, 0x98, 0x00, 0x62, 0xC0,
  0x00, 0xCA, 0x00, 0x01, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0xB0, 0x00, 0x06, 0xE0, 0x00, 0x1A, 0x80, 0x00, 0xCB, 0x00, 0x03, 0x24,
  0x00, 0x18, 0x9C, 0x00, 0xC2, 0x38, 0x0E, 0x08, 0x3F, 0xE0, 0x20, 0x08,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xFC, 0x10, 0x70, 0x1C, 0x43, 0x00, 0x19, 0x18, 0x00, 0x34,
  0xC0, 0x00, 0x52, 0x00, 0x01, 0x58, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x1C, 0x80, 0x00, 0x53, 0x00, 0x03,
  0x46, 0x00, 0x19, 0x1C, 0x00, 0xC4, 0x38, 0x06, 0x10, 0x3F, 0xF0, 0x40,
  0x0C, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x64, 0x3F, 0xE3, 0x81, 0x30, 0x0B, 0x00, 0x50, 0x02, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x70, 0x07, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x68, 0x00, 0x19, 0xE0,
  0x0E, 0x0F, 0xFF, 0x80, 0x07, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0xFF, 0xFC, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x04, 0x0F,
  0xF0, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00,
  0x34, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x05, 0x20, 0x00, 0xD3, 0x00,
  0x19, 0x1C, 0x07, 0x10, 0xFF, 0xC1, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x0D,
  0x00, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x04, 0x20, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x02, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60, 0x60, 0x01,
  0x00, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x40, 0x18, 0x01, 0x80, 0x40, 0x02, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x30,
  0x20, 0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x06, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x23, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x05, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x09, 0x00, 0x07, 0x80,
  0x06, 0x60, 0x01, 0xA0, 0x01, 0x98, 0x00, 0x48, 0x00, 0x42, 0x00, 0x13,
  0x00, 0x10, 0x80, 0x0C, 0xC0, 0x0C, 0x30, 0x02, 0x10, 0x03, 0x0C, 0x00,
  0x84, 0x00, 0x81, 0x00, 0x61, 0x80, 0x20, 0x40, 0x18, 0x20, 0x18, 0x18,
  0x04, 0x08, 0x06, 0x06, 0x03, 0x03, 0x01, 0x00, 0x80, 0xC0, 0xC0, 0x40,
  0x20, 0x20, 0x10, 0x30, 0x0C, 0x08, 0x04, 0x0C, 0x03, 0x06, 0x01, 0x82,
  0x00, 0x41, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x60, 0x06, 0x30, 0x03,
  0x18, 0x00, 0x8C, 0x00, 0xC4, 0x00, 0x22, 0x00, 0x11, 0x00, 0x0C, 0x80,
  0x04, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x58, 0x00, 0x68, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x60, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x08,
  0x30, 0x00, 0xC0, 0x80, 0x0C, 0x06, 0x00, 0x40, 0x18, 0x06, 0x00, 0x40,
  0x60, 0x03, 0x03, 0x00, 0x08, 0x30, 0x00, 0x61, 0x00, 0x01, 0x98, 0x00,
  0x05, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x58,
  0x00, 0x06, 0x60, 0x00, 0x61, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x30, 0x01,
  0x01, 0x80, 0x18, 0x06, 0x01, 0x80, 0x10, 0x08, 0x00, 0xC0, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00, 0x01, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x26, 0x00, 0x00, 0x88, 0x00, 0x06, 0x30, 0x00,
  0x10, 0xC0, 0x00, 0x41, 0x00, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x20,
  0x20, 0x01, 0x80, 0xC0, 0x04, 0x03, 0x00, 0x10, 0x04, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x60, 0x08, 0x00, 0x80, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x04,
  0x00, 0x10, 0x30, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00, 0x02, 0x18, 0x00,
  0x0C, 0x40, 0x00, 0x33, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0xFC,
  0x03, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x7C, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x3E, 0x00, 0x3C, 0x01, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x03, 0x80, 0x3E, 0x01, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x81, 0xE0, 0x0C, 0x00, 0xF0, 0x68,
  0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Thin57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 41, 12, 5, -41 },
  { 17, 10, 15, 18, 4, -41 },
  { 36, 30, 41, 32, 1, -41 },
  { 190, 22, 46, 29, 3, -43 },
  { 317, 35, 42, 41, 3, -41 },
  { 501, 29, 42, 33, 3, -41 },
  { 654, 2, 15, 10, 4, -41 },
  { 658, 10, 50, 15, 3, -41 },
  { 721, 10, 50, 15, 2, -41 },
  { 784, 21, 20, 27, 3, -43 },
  { 837, 23, 26, 29, 3, -33 },
  { 912, 5, 13, 10, 2, -6 },
  { 921, 13, 1, 17, 2, -16 },
  { 923, 3, 3, 12, 4, -3 },
  { 925, 17, 41, 18, 1, -41 },
  { 1013, 23, 42, 29, 3, -41 },
  { 1134, 12, 41, 29, 5, -41 },
  { 1196, 22, 41, 29, 3, -41 },
  { 1309, 22, 42, 29, 3, -41 },
  { 1425, 27, 41, 29, 1, -41 },
  { 1564, 22, 42, 29, 4, -41 },
  { 1680, 23, 42, 29, 3, -41 },
  { 1801, 23, 41, 29, 3, -41 },
  { 1919, 23, 42, 29, 3, -41 },
  { 2040, 22, 42, 29, 3, -41 },
  { 2156, 3, 30, 12, 4, -30 },
  { 2168, 5, 37, 12, 2, -30 },
  { 2192, 23, 25, 29, 3, -33 },
  { 2264, 23, 14, 29, 3, -27 },
  { 2305, 23, 25, 29, 3, -33 },
  { 2377, 17, 41, 20, 2, -41 },
  { 2465, 38, 46, 44, 3, -40 },
  { 2684, 29, 41, 29, 0, -41 },
  { 2833, 23, 41, 31, 5, -41 },
  { 2951, 26, 42, 31, 3, -41 },
  { 3088, 26, 41, 35, 5, -41 },
  { 3222, 20, 41, 28, 5, -41 },
  { 3325, 20, 41, 25, 5, -41 },
  { 3428, 30, 42, 37, 3, -41 },
  { 3586, 25, 41, 36, 5, -41 },
  { 3715, 9, 41, 15, 3, -41 },
  { 3762, 12, 51, 12, -5, -41 },
  { 3839, 23, 41, 28, 5, -41 },
  { 3957, 19, 41, 25, 5, -41 },
  { 4055, 33, 41, 44, 5, -41 },
  { 4225, 25, 41, 36, 5, -41 },
  { 4354, 31, 42, 38, 3, -41 },
  { 4517, 21, 41, 29, 5, -41 },
  { 4625, 31, 51, 38, 3, -41 },
  { 4823, 23, 41, 29, 5, -41 },
  { 4941, 22, 42, 28, 3, -41 },
  { 5057, 25, 41, 25, 0, -41 },
  { 5186, 26, 42, 36, 5, -41 },
  { 5323, 28, 41, 28, 0, -41 },
  { 5467, 43, 41, 45, 1, -41 },
  { 5688, 25, 41, 25, 0, -41 },
  { 5817, 25, 41, 25, 0, -41 },
  { 5946, 24, 41, 28, 2, -41 },
  { 6069, 11, 50, 18, 5, -41 },
  { 6138, 17, 41, 18, 1, -41 },
  { 6226, 11, 50, 18, 2, -41 },
  { 6295, 25, 23, 29, 2, -41 },
  { 6367, 22, 2, 22, 0, 5 },
  { 6373, 9, 9, 14, 2, -44 },
  { 6384, 19, 32, 26, 3, -31 },
  { 6460, 22, 44, 30, 5, -43 },
  { 6581, 19, 32, 24, 3, -31 },
  { 6657, 22, 44, 30, 3, -43 },
  { 6778, 21, 32, 27, 3, -31 },
  { 6862, 16, 44, 14, 1, -44 },
  { 6950, 22, 45, 30, 3, -31 },
  { 7074, 20, 43, 29, 5, -43 },
  { 7182, 3, 41, 11, 4, -41 },
  { 7198, 9, 55, 11, -2, -41 },
  { 7260, 18, 43, 23, 5, -43 },
  { 7357, 1, 43, 11, 5, -43 },
  { 7363, 34, 31, 43, 5, -31 },
  { 7495, 20, 31, 29, 5, -31 },
  { 7573, 23, 32, 29, 3, -31 },
  { 7665, 22, 44, 30, 5, -31 },
  { 7786, 22, 44, 30, 3, -31 },
  { 7907, 13, 31, 19, 5, -31 },
  { 7958, 19, 32, 23, 2, -31 },
  { 8034, 14, 39, 16, 1, -38 },
  { 8103, 20, 31, 29, 4, -30 },
  { 8181, 22, 30, 22, 0, -30 },
  { 8264, 34, 30, 35, 1, -30 },
  { 8392, 21, 30, 24, 1, -30 },
  { 8471, 22, 44, 22, 0, -30 },
  { 8592, 18, 30, 22, 2, -30 },
  { 8660, 15, 50, 19, 2, -41 },
  { 8754, 1, 57, 27, 13, -43 },
  { 8762, 15, 50, 19, 2, -41 },
  { 8856, 23, 5, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_Thin57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_THIN57PT7B_H_
