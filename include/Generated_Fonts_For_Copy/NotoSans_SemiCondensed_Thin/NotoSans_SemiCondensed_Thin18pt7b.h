#ifndef _NOTOSANS_SEMICONDENSED_THIN18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC8, 0xB6, 0xDA, 0x09, 0x02, 0x41, 0x10, 0x44, 0x7F, 0xC4,
  0x41, 0x20, 0x48, 0xFF, 0x88, 0x82, 0x20, 0x88, 0x24, 0x00, 0x10, 0xFA,
  0x44, 0x89, 0x12, 0x14, 0x18, 0x1C, 0x24, 0x48, 0x91, 0x5F, 0x04, 0x00,
  0x70, 0x92, 0x22, 0x24, 0x45, 0x08, 0xA1, 0x19, 0xA5, 0x4B, 0xD1, 0x0A,
  0x21, 0x44, 0x48, 0x89, 0x12, 0x1C, 0x38, 0x22, 0x11, 0x08, 0x84, 0x41,
  0xC0, 0xC1, 0x91, 0x84, 0xC2, 0xA0, 0xD0, 0x67, 0xC8, 0xF8, 0x29, 0x49,
  0x24, 0x92, 0x48, 0x91, 0x91, 0x22, 0x49, 0x24, 0x94, 0xA4, 0x10, 0x49,
  0x5E, 0x31, 0x24, 0x40, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10,
  0xF0, 0xF0, 0x80, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10,
  0x80, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x23,
  0xC0, 0x2E, 0x92, 0x49, 0x24, 0x92, 0x79, 0x08, 0x08, 0x10, 0x20, 0x81,
  0x04, 0x10, 0x40, 0x82, 0x0F, 0xE0, 0x79, 0x08, 0x08, 0x10, 0x20, 0x8E,
  0x02, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0x02, 0x03, 0x02, 0x81, 0x41, 0x20,
  0x90, 0x88, 0x84, 0x42, 0x7F, 0xC0, 0x80, 0x40, 0x20, 0x7C, 0x82, 0x04,
  0x08, 0x1F, 0x01, 0x01, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0x3E, 0x81, 0x04,
  0x08, 0x17, 0xB0, 0xC1, 0x83, 0x06, 0x0A, 0x13, 0xC0, 0xFE, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x00, 0x7D, 0x06, 0x0C,
  0x14, 0x45, 0x0E, 0x22, 0x83, 0x06, 0x0C, 0x17, 0xC0, 0x79, 0x0A, 0x0C,
  0x18, 0x30, 0x60, 0xBF, 0x02, 0x04, 0x10, 0x2F, 0x80, 0xC0, 0x40, 0xC0,
  0xF0, 0x06, 0x31, 0x84, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0xC0, 0x60, 0x30, 0x10, 0xC6, 0x30, 0x00, 0xF0, 0x42, 0x10, 0x88, 0x88,
  0x42, 0x00, 0x04, 0x00, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x01, 0x87, 0x98,
  0x89, 0x90, 0x99, 0x09, 0x91, 0x19, 0x11, 0x8E, 0xE8, 0x00, 0x40, 0x02,
  0x08, 0x1F, 0x00, 0x08, 0x04, 0x05, 0x02, 0x81, 0x21, 0x10, 0x88, 0x7E,
  0x41, 0x20, 0x90, 0x50, 0x18, 0x08, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBF,
  0x41, 0x83, 0x06, 0x0C, 0x1F, 0xC0, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0xF8, 0x84, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0xFE, 0x08, 0x20, 0x82,
  0x0F, 0xA0, 0x82, 0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xA0,
  0x82, 0x08, 0x20, 0x80, 0x1F, 0x90, 0x10, 0x10, 0x08, 0x04, 0x02, 0x1D,
  0x01, 0x80, 0xC0, 0x50, 0x28, 0x13, 0xF8, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x49,
  0x2E, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x83, 0x0A, 0x24, 0x8A, 0x18,
  0x28, 0x48, 0x91, 0x12, 0x24, 0x28, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x60, 0x18, 0x0F, 0x03, 0xC0, 0xE8,
  0x5A, 0x16, 0x89, 0x92, 0x64, 0x99, 0x46, 0x31, 0x88, 0x40, 0x81, 0x81,
  0xC1, 0xC1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x81, 0x3F,
  0x10, 0x24, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14,
  0x09, 0x02, 0x3F, 0x00, 0xFA, 0x18, 0x61, 0x86, 0x18, 0xB4, 0x82, 0x08,
  0x20, 0x80, 0x3F, 0x10, 0x24, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x09, 0x02, 0x3D, 0x00, 0x80, 0x20, 0x04, 0xF9, 0x0A,
  0x14, 0x18, 0x50, 0xBA, 0x48, 0x89, 0x12, 0x14, 0x28, 0x20, 0x7F, 0x02,
  0x04, 0x08, 0x08, 0x0E, 0x02, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C,
  0x80, 0xC0, 0x60, 0x48, 0x24, 0x12, 0x10, 0x88, 0x44, 0x24, 0x0A, 0x05,
  0x03, 0x00, 0x80, 0x81, 0x06, 0x0C, 0x14, 0x30, 0x90, 0xC2, 0x44, 0x89,
  0x12, 0x22, 0x49, 0x09, 0x24, 0x24, 0x50, 0xA1, 0x41, 0x86, 0x06, 0x08,
  0x10, 0x20, 0x81, 0x42, 0x42, 0x24, 0x14, 0x18, 0x08, 0x18, 0x24, 0x24,
  0x42, 0x42, 0x81, 0x81, 0x82, 0x42, 0x42, 0x24, 0x24, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFE, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x81, 0x04, 0x0F, 0xE0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x27, 0x81, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0xE4, 0x92, 0x49, 0x24,
  0x92, 0x4F, 0x10, 0x50, 0xA2, 0x24, 0x50, 0x60, 0x80, 0xFE, 0x91, 0x80,
  0x78, 0x10, 0x41, 0x1D, 0x98, 0x61, 0x87, 0xF0, 0x81, 0x02, 0x04, 0x0B,
  0xD8, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x37, 0x80, 0x3D, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x81, 0xF0, 0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x2F, 0xC0, 0x38, 0x8A, 0x0C, 0x1F, 0xF0, 0x20,
  0x40, 0x80, 0xF8, 0x19, 0x08, 0x4F, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x10, 0x3F,
  0x80, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x40, 0x9F, 0xF8, 0x20, 0x12, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x82,
  0x08, 0x20, 0x86, 0x28, 0xA4, 0xA3, 0x49, 0x22, 0x86, 0x10, 0xFF, 0xFC,
  0xB9, 0xD8, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84,
  0x30, 0x84, 0xBD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x38,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xF8, 0xF9, 0x0A, 0x14, 0x18,
  0x30, 0x60, 0xC2, 0x85, 0xF2, 0x04, 0x08, 0x10, 0x00, 0x3A, 0x8E, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x10, 0x20, 0x40, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x7A, 0x08, 0x20, 0x40, 0xC0, 0x81, 0x07, 0xE0, 0x42,
  0x3E, 0x84, 0x21, 0x08, 0x42, 0x10, 0x70, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x86, 0xF4, 0x83, 0x06, 0x12, 0x24, 0x49, 0x0A, 0x14, 0x30,
  0x20, 0x84, 0x28, 0x85, 0x29, 0x25, 0x24, 0x94, 0x62, 0x8C, 0x61, 0x8C,
  0x20, 0x80, 0x82, 0x84, 0x91, 0x41, 0x02, 0x0A, 0x12, 0x45, 0x04, 0x83,
  0x05, 0x0A, 0x24, 0x44, 0x8A, 0x14, 0x10, 0x20, 0x41, 0x02, 0x1C, 0x00,
  0xF8, 0x42, 0x22, 0x11, 0x08, 0x87, 0xC0, 0x34, 0x44, 0x44, 0x44, 0xC4,
  0x44, 0x44, 0x43, 0xFF, 0xFF, 0xC0, 0xC2, 0x22, 0x22, 0x22, 0x32, 0x22,
  0x22, 0x2C, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_Thin18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 13, 4, 1, -13 },
  { 3, 3, 5, 6, 1, -13 },
  { 5, 10, 13, 10, 0, -13 },
  { 22, 7, 15, 9, 1, -14 },
  { 36, 11, 13, 13, 1, -13 },
  { 54, 9, 13, 11, 1, -13 },
  { 69, 1, 5, 3, 1, -13 },
  { 70, 3, 16, 5, 1, -13 },
  { 76, 3, 16, 5, 1, -13 },
  { 82, 6, 7, 9, 1, -14 },
  { 88, 7, 9, 9, 1, -11 },
  { 96, 1, 4, 3, 1, -2 },
  { 97, 4, 1, 5, 1, -5 },
  { 98, 1, 1, 4, 1, -1 },
  { 99, 6, 13, 6, 0, -13 },
  { 109, 7, 13, 9, 1, -13 },
  { 121, 3, 13, 9, 2, -13 },
  { 126, 7, 13, 9, 1, -13 },
  { 138, 7, 13, 9, 1, -13 },
  { 150, 9, 13, 9, 0, -13 },
  { 165, 7, 13, 9, 1, -13 },
  { 177, 7, 13, 9, 1, -13 },
  { 189, 7, 13, 9, 1, -13 },
  { 201, 7, 13, 9, 1, -13 },
  { 213, 7, 13, 9, 1, -13 },
  { 225, 1, 10, 4, 1, -10 },
  { 227, 1, 12, 4, 1, -10 },
  { 229, 7, 7, 9, 1, -10 },
  { 236, 7, 4, 9, 1, -8 },
  { 240, 7, 7, 9, 1, -10 },
  { 247, 5, 13, 6, 1, -13 },
  { 256, 12, 15, 14, 1, -13 },
  { 279, 9, 13, 9, 0, -13 },
  { 294, 7, 13, 10, 2, -13 },
  { 306, 8, 13, 10, 1, -13 },
  { 319, 8, 13, 11, 2, -13 },
  { 332, 6, 13, 9, 2, -13 },
  { 342, 6, 13, 8, 2, -13 },
  { 352, 9, 13, 12, 1, -13 },
  { 367, 8, 13, 11, 2, -13 },
  { 380, 3, 13, 5, 1, -13 },
  { 385, 3, 16, 4, -1, -13 },
  { 391, 7, 13, 9, 2, -13 },
  { 403, 6, 13, 8, 2, -13 },
  { 413, 10, 13, 14, 2, -13 },
  { 430, 8, 13, 11, 2, -13 },
  { 443, 10, 13, 12, 1, -13 },
  { 460, 6, 13, 9, 2, -13 },
  { 470, 10, 16, 12, 1, -13 },
  { 490, 7, 13, 9, 2, -13 },
  { 502, 7, 13, 9, 1, -13 },
  { 514, 8, 13, 8, 0, -13 },
  { 527, 8, 13, 11, 2, -13 },
  { 540, 9, 13, 9, 0, -13 },
  { 555, 14, 13, 14, 0, -13 },
  { 578, 8, 13, 8, 0, -13 },
  { 591, 8, 13, 8, 0, -13 },
  { 604, 7, 13, 9, 1, -13 },
  { 616, 3, 16, 6, 2, -13 },
  { 622, 6, 13, 6, 0, -13 },
  { 632, 3, 16, 6, 1, -13 },
  { 638, 7, 7, 9, 1, -13 },
  { 645, 7, 1, 7, 0, 1 },
  { 646, 3, 3, 4, 1, -14 },
  { 648, 6, 10, 8, 1, -10 },
  { 656, 7, 14, 9, 1, -14 },
  { 669, 6, 10, 7, 1, -10 },
  { 677, 7, 14, 9, 1, -14 },
  { 690, 7, 10, 9, 1, -10 },
  { 699, 5, 14, 5, 0, -14 },
  { 708, 7, 14, 9, 1, -10 },
  { 721, 7, 14, 9, 1, -14 },
  { 734, 1, 13, 4, 1, -13 },
  { 736, 3, 17, 4, -1, -13 },
  { 743, 6, 14, 7, 1, -14 },
  { 754, 1, 14, 3, 1, -14 },
  { 756, 11, 10, 14, 1, -10 },
  { 770, 7, 10, 9, 1, -10 },
  { 779, 7, 10, 9, 1, -10 },
  { 788, 7, 14, 9, 2, -10 },
  { 801, 7, 14, 9, 1, -10 },
  { 814, 4, 10, 6, 2, -10 },
  { 819, 6, 10, 7, 1, -10 },
  { 827, 5, 12, 5, 0, -12 },
  { 835, 7, 10, 9, 1, -10 },
  { 844, 7, 10, 7, 0, -10 },
  { 853, 11, 9, 11, 0, -9 },
  { 866, 7, 10, 8, 0, -10 },
  { 875, 7, 14, 7, 0, -10 },
  { 888, 5, 10, 7, 1, -10 },
  { 895, 4, 16, 6, 1, -13 },
  { 903, 1, 18, 9, 4, -14 },
  { 906, 4, 16, 6, 1, -13 },
  { 914, 7, 1, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Thin18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_THIN18PT7B_H_
