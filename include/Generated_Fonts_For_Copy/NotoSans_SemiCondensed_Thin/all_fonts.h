#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_Thin
// Headers: 67

#include "NotoSans_SemiCondensed_Thin6pt7b.h"
#include "NotoSans_SemiCondensed_Thin7pt7b.h"
#include "NotoSans_SemiCondensed_Thin8pt7b.h"
#include "NotoSans_SemiCondensed_Thin9pt7b.h"
#include "NotoSans_SemiCondensed_Thin10pt7b.h"
#include "NotoSans_SemiCondensed_Thin11pt7b.h"
#include "NotoSans_SemiCondensed_Thin12pt7b.h"
#include "NotoSans_SemiCondensed_Thin13pt7b.h"
#include "NotoSans_SemiCondensed_Thin14pt7b.h"
#include "NotoSans_SemiCondensed_Thin15pt7b.h"
#include "NotoSans_SemiCondensed_Thin16pt7b.h"
#include "NotoSans_SemiCondensed_Thin17pt7b.h"
#include "NotoSans_SemiCondensed_Thin18pt7b.h"
#include "NotoSans_SemiCondensed_Thin19pt7b.h"
#include "NotoSans_SemiCondensed_Thin20pt7b.h"
#include "NotoSans_SemiCondensed_Thin21pt7b.h"
#include "NotoSans_SemiCondensed_Thin22pt7b.h"
#include "NotoSans_SemiCondensed_Thin23pt7b.h"
#include "NotoSans_SemiCondensed_Thin24pt7b.h"
#include "NotoSans_SemiCondensed_Thin25pt7b.h"
#include "NotoSans_SemiCondensed_Thin26pt7b.h"
#include "NotoSans_SemiCondensed_Thin27pt7b.h"
#include "NotoSans_SemiCondensed_Thin28pt7b.h"
#include "NotoSans_SemiCondensed_Thin29pt7b.h"
#include "NotoSans_SemiCondensed_Thin30pt7b.h"
#include "NotoSans_SemiCondensed_Thin31pt7b.h"
#include "NotoSans_SemiCondensed_Thin32pt7b.h"
#include "NotoSans_SemiCondensed_Thin33pt7b.h"
#include "NotoSans_SemiCondensed_Thin34pt7b.h"
#include "NotoSans_SemiCondensed_Thin35pt7b.h"
#include "NotoSans_SemiCondensed_Thin36pt7b.h"
#include "NotoSans_SemiCondensed_Thin37pt7b.h"
#include "NotoSans_SemiCondensed_Thin38pt7b.h"
#include "NotoSans_SemiCondensed_Thin39pt7b.h"
#include "NotoSans_SemiCondensed_Thin40pt7b.h"
#include "NotoSans_SemiCondensed_Thin41pt7b.h"
#include "NotoSans_SemiCondensed_Thin42pt7b.h"
#include "NotoSans_SemiCondensed_Thin43pt7b.h"
#include "NotoSans_SemiCondensed_Thin44pt7b.h"
#include "NotoSans_SemiCondensed_Thin45pt7b.h"
#include "NotoSans_SemiCondensed_Thin46pt7b.h"
#include "NotoSans_SemiCondensed_Thin47pt7b.h"
#include "NotoSans_SemiCondensed_Thin48pt7b.h"
#include "NotoSans_SemiCondensed_Thin49pt7b.h"
#include "NotoSans_SemiCondensed_Thin50pt7b.h"
#include "NotoSans_SemiCondensed_Thin51pt7b.h"
#include "NotoSans_SemiCondensed_Thin52pt7b.h"
#include "NotoSans_SemiCondensed_Thin53pt7b.h"
#include "NotoSans_SemiCondensed_Thin54pt7b.h"
#include "NotoSans_SemiCondensed_Thin55pt7b.h"
#include "NotoSans_SemiCondensed_Thin56pt7b.h"
#include "NotoSans_SemiCondensed_Thin57pt7b.h"
#include "NotoSans_SemiCondensed_Thin58pt7b.h"
#include "NotoSans_SemiCondensed_Thin59pt7b.h"
#include "NotoSans_SemiCondensed_Thin60pt7b.h"
#include "NotoSans_SemiCondensed_Thin61pt7b.h"
#include "NotoSans_SemiCondensed_Thin62pt7b.h"
#include "NotoSans_SemiCondensed_Thin63pt7b.h"
#include "NotoSans_SemiCondensed_Thin64pt7b.h"
#include "NotoSans_SemiCondensed_Thin65pt7b.h"
#include "NotoSans_SemiCondensed_Thin66pt7b.h"
#include "NotoSans_SemiCondensed_Thin67pt7b.h"
#include "NotoSans_SemiCondensed_Thin68pt7b.h"
#include "NotoSans_SemiCondensed_Thin69pt7b.h"
#include "NotoSans_SemiCondensed_Thin70pt7b.h"
#include "NotoSans_SemiCondensed_Thin71pt7b.h"
#include "NotoSans_SemiCondensed_Thin72pt7b.h"
