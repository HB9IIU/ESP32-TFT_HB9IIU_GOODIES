#ifndef _NOTOSANS_SEMICONDENSED_THIN6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_THIN6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Thin.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Thin6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x7B, 0xD0, 0x59, 0x3C, 0xED, 0x37, 0xEA, 0xF0, 0x80,
  0xF8, 0xF8, 0x7C, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xF6, 0xF0, 0xF0,
  0xE5, 0x70, 0xEC, 0xF0, 0x4B, 0x90, 0xD8, 0xF0, 0xDA, 0xF0, 0xE9, 0x20,
  0xEA, 0xF0, 0xF5, 0xB0, 0xA0, 0xB0, 0xEC, 0xFC, 0xF8, 0xD8, 0xFF, 0xF8,
  0x60, 0x57, 0xD0, 0xFF, 0xF2, 0x70, 0xFF, 0xEB, 0xFA, 0xF2, 0xF0, 0xFF,
  0xF0, 0xF8, 0xEB, 0xAB, 0xB7, 0xF0, 0xFF, 0xF9, 0x9F, 0xFA, 0xF9, 0x9D,
  0x20, 0xFB, 0xF8, 0xF0, 0xE9, 0x20, 0xFF, 0xB7, 0x20, 0xAF, 0x74, 0xA0,
  0xAB, 0x50, 0xB9, 0x20, 0xE9, 0x70, 0xF8, 0xA5, 0xF8, 0x54, 0xC0, 0x80,
  0x7C, 0x9A, 0xDE, 0xEC, 0x2E, 0xDE, 0xFB, 0x00, 0x6A, 0x80, 0xF6, 0xF0,
  0x9A, 0xDA, 0xF0, 0xF8, 0xAF, 0xC0, 0xF8, 0xFB, 0xB0, 0xF6, 0x80, 0xF7,
  0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0xEB, 0xB7, 0x80, 0xF8, 0xD5,
  0xA0, 0xDC, 0xF6, 0xDC, 0xEA, 0xC0, 0xFC, 0xD5, 0xC0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Thin6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 2, 3, 3, 0, -5 },
  { 15, 3, 3, 3, 0, -4 },
  { 17, 1, 2, 1, 0, -1 },
  { 18, 2, 1, 2, 0, -2 },
  { 19, 1, 1, 1, 0, -1 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 3, 4, 3, 0, -4 },
  { 23, 1, 4, 3, 1, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 1, 3, 1, 0, -3 },
  { 41, 1, 4, 1, 0, -3 },
  { 42, 3, 2, 3, 0, -3 },
  { 43, 3, 2, 3, 0, -3 },
  { 44, 3, 2, 3, 0, -3 },
  { 45, 2, 4, 2, 0, -4 },
  { 46, 4, 5, 5, 0, -4 },
  { 49, 3, 4, 3, 0, -4 },
  { 51, 2, 4, 3, 1, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 2, 4, 3, 1, -4 },
  { 56, 2, 4, 3, 1, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 1, 4, 2, 0, -4 },
  { 61, 1, 5, 1, 0, -4 },
  { 62, 2, 4, 3, 1, -4 },
  { 63, 2, 4, 3, 1, -4 },
  { 64, 3, 4, 5, 1, -4 },
  { 66, 2, 4, 4, 1, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 2, 4, 3, 1, -4 },
  { 70, 4, 5, 4, 0, -4 },
  { 73, 2, 4, 3, 1, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 2, 4, 4, 1, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 5, 4, 5, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 1, 5, 2, 1, -4 },
  { 91, 2, 4, 2, 0, -4 },
  { 92, 1, 5, 2, 0, -4 },
  { 93, 3, 2, 3, 0, -4 },
  { 94, 2, 1, 2, 0, 0 },
  { 95, 1, 1, 1, 0, -5 },
  { 96, 2, 3, 3, 0, -3 },
  { 97, 3, 5, 3, 0, -5 },
  { 99, 2, 3, 2, 0, -3 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 3, 3, 3, 0, -3 },
  { 104, 2, 5, 2, 0, -5 },
  { 106, 3, 4, 3, 0, -3 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 1, 4, 1, 0, -4 },
  { 111, 1, 5, 1, 0, -4 },
  { 112, 2, 5, 2, 0, -5 },
  { 114, 1, 5, 1, 0, -5 },
  { 115, 4, 3, 5, 0, -3 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 3, 3, 3, 0, -3 },
  { 121, 3, 4, 3, 0, -3 },
  { 123, 3, 4, 3, 0, -3 },
  { 125, 2, 3, 2, 0, -3 },
  { 126, 2, 3, 2, 0, -3 },
  { 127, 2, 4, 2, 0, -4 },
  { 128, 3, 3, 3, 0, -3 },
  { 130, 2, 3, 2, 0, -3 },
  { 131, 4, 3, 4, 0, -3 },
  { 133, 2, 3, 3, 0, -3 },
  { 134, 2, 4, 2, 0, -3 },
  { 135, 2, 3, 2, 0, -3 },
  { 136, 2, 5, 2, 0, -4 },
  { 138, 1, 6, 3, 1, -5 },
  { 139, 2, 5, 2, 0, -4 },
  { 141, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Thin6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Thin6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Thin6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_THIN6PT7B_H_
