#ifndef _ROBOTOMONO_THINITALIC6PT7B_H_
#define _ROBOTOMONO_THINITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x67, 0x6C, 0x2D, 0x1A, 0x80, 0xF5, 0xF0, 0x6A, 0xF0,
  0xC0, 0x6A, 0xA0, 0xFC, 0xF0, 0x2B, 0xA0, 0x80, 0xC0, 0x80, 0x25, 0x60,
  0x77, 0xF0, 0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xF7, 0x76, 0xF0,
  0xDA, 0x6E, 0xF0, 0xFF, 0x00, 0x10, 0x7C, 0x7C, 0x5C, 0xDA, 0xFE, 0xAC,
  0x4F, 0xD0, 0xFE, 0xF0, 0xF2, 0x70, 0xF6, 0xF0, 0xFE, 0x70, 0x7E, 0x40,
  0xF2, 0xF0, 0xBE, 0xD0, 0x69, 0x70, 0x24, 0xF0, 0x7C, 0xAA, 0x52, 0x70,
  0xAF, 0xD0, 0xBE, 0xD0, 0xF6, 0xF0, 0x77, 0x40, 0xF6, 0xF2, 0x77, 0xD0,
  0xE8, 0xF0, 0xF2, 0x40, 0xB6, 0xF0, 0xBA, 0x40, 0xB7, 0x60, 0x74, 0x4A,
  0xF2, 0x40, 0x69, 0x70, 0xEA, 0xA0, 0xF0, 0x55, 0xA0, 0xB0, 0xE0, 0x00,
  0xEF, 0x80, 0x4A, 0xDE, 0xF3, 0x80, 0x2E, 0xDE, 0xFB, 0x80, 0x3A, 0x48,
  0xF6, 0xF0, 0x53, 0xDA, 0x45, 0x70, 0x64, 0xAC, 0x4A, 0xEA, 0x44, 0xAE,
  0xFF, 0x80, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xEF,
  0x80, 0xEB, 0xB7, 0x80, 0xE8, 0xDA, 0xA0, 0x6A, 0x80, 0xA9, 0x60, 0x6B,
  0x80, 0x5A, 0xA0, 0xF8, 0x44, 0x95, 0x80, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 1, 2, 4, 2, -5 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 1, -5 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 2, 2, 4, 1, -4 },
  { 17, 3, 4, 4, 0, -4 },
  { 19, 1, 1, 4, 1, 0 },
  { 20, 2, 1, 4, 1, -2 },
  { 21, 1, 1, 4, 1, -1 },
  { 22, 3, 4, 4, 0, -4 },
  { 24, 3, 4, 4, 0, -4 },
  { 26, 1, 4, 4, 1, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 2, 4, 4, 1, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 2, 4, 4, 1, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 2, 4, 4, 1, -4 },
  { 40, 1, 3, 4, 1, -3 },
  { 41, 1, 4, 4, 1, -3 },
  { 42, 3, 2, 4, 0, -3 },
  { 43, 3, 2, 4, 0, -3 },
  { 44, 3, 2, 4, 0, -3 },
  { 45, 2, 4, 4, 1, -4 },
  { 46, 4, 4, 4, 0, -4 },
  { 48, 3, 4, 4, 0, -4 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 3, 4, 4, 0, -4 },
  { 54, 3, 4, 4, 0, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 5, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 3, 4, 4, 1, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 1, -4 },
  { 92, 3, 4, 4, 1, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 3, 4, 4, 1, -4 },
  { 98, 3, 4, 4, 0, -4 },
  { 100, 2, 6, 4, 1, -5 },
  { 102, 1, 4, 4, 1, -4 },
  { 103, 2, 6, 4, 1, -5 },
  { 105, 2, 2, 4, 1, -4 },
  { 106, 3, 1, 4, 0, 0 },
  { 107, 1, 1, 4, 2, -5 },
  { 108, 3, 3, 4, 0, -3 },
  { 110, 3, 5, 4, 0, -5 },
  { 112, 3, 3, 4, 0, -3 },
  { 114, 3, 5, 4, 0, -5 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 3, 5, 4, 1, -5 },
  { 120, 3, 4, 4, 0, -3 },
  { 122, 3, 5, 4, 0, -5 },
  { 124, 3, 4, 4, 0, -4 },
  { 126, 3, 5, 4, 0, -4 },
  { 128, 3, 5, 4, 0, -5 },
  { 130, 3, 5, 4, 0, -5 },
  { 132, 3, 3, 4, 0, -3 },
  { 134, 3, 3, 4, 0, -3 },
  { 136, 3, 3, 4, 0, -3 },
  { 138, 3, 4, 4, 0, -3 },
  { 140, 3, 4, 4, 0, -3 },
  { 142, 2, 3, 4, 1, -3 },
  { 143, 3, 3, 4, 0, -3 },
  { 145, 2, 4, 4, 1, -4 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 2, 3, 4, 1, -3 },
  { 149, 4, 3, 4, 0, -3 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 3, 4, 4, 0, -3 },
  { 155, 3, 3, 4, 0, -3 },
  { 157, 2, 6, 4, 1, -5 },
  { 159, 1, 5, 4, 1, -4 },
  { 160, 3, 6, 4, 0, -5 },
  { 163, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_ThinItalic6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic6pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_THINITALIC6PT7B_H_
