#ifndef _ROBOTOMONO_THINITALIC14PT7B_H_
#define _ROBOTOMONO_THINITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x68, 0x20, 0xFC, 0x09, 0x0A, 0x12, 0x7F, 0x14, 0x24, 0x24,
  0xFA, 0x48, 0x48, 0x08, 0x69, 0x0A, 0x14, 0x04, 0x06, 0x02, 0x85, 0x09,
  0x61, 0x00, 0xE1, 0x4A, 0xA5, 0x45, 0x05, 0x8C, 0xA9, 0x92, 0x38, 0x39,
  0x14, 0x94, 0x21, 0x49, 0x63, 0x8B, 0xD0, 0xE0, 0x18, 0x88, 0x84, 0x22,
  0x10, 0x84, 0x21, 0x04, 0x20, 0x21, 0x11, 0x11, 0x11, 0x11, 0x12, 0x2C,
  0x10, 0x8F, 0xC8, 0xD8, 0x10, 0x20, 0x47, 0xF2, 0x04, 0x08, 0x00, 0xE0,
  0xF0, 0x80, 0x04, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0x3D,
  0x14, 0x63, 0x96, 0x9C, 0x61, 0x89, 0xC0, 0x3D, 0x12, 0x22, 0x22, 0x24,
  0x3C, 0x85, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0xF8, 0x1E, 0x45, 0x08,
  0x11, 0xC0, 0x80, 0xC1, 0x84, 0xF0, 0x02, 0x08, 0x28, 0xA2, 0x48, 0x91,
  0x5F, 0x04, 0x10, 0x3E, 0x41, 0x02, 0x86, 0xC0, 0x81, 0x42, 0x84, 0xF0,
  0x1C, 0x84, 0x2E, 0xC6, 0x18, 0x61, 0x89, 0xC0, 0xFC, 0x10, 0x84, 0x10,
  0x82, 0x10, 0x82, 0x00, 0x3C, 0x85, 0x0A, 0x13, 0xC8, 0xA1, 0x42, 0x85,
  0xF0, 0x3D, 0x18, 0x61, 0x86, 0x17, 0xC1, 0x09, 0xC0, 0x40, 0x08, 0x20,
  0x00, 0x24, 0x80, 0x0D, 0xC8, 0x18, 0x1C, 0xFC, 0x0F, 0xC0, 0x60, 0x60,
  0x4E, 0xC0, 0x7C, 0x42, 0x11, 0x11, 0x00, 0x02, 0x00, 0x1E, 0x21, 0x4D,
  0x55, 0xA5, 0xA5, 0xA9, 0xBE, 0x80, 0x7C, 0x04, 0x18, 0x50, 0xA2, 0x44,
  0x9F, 0xA1, 0x43, 0x04, 0x7C, 0x85, 0x0A, 0x2F, 0x90, 0xA1, 0x42, 0x85,
  0xF0, 0x3C, 0x86, 0x0C, 0x08, 0x10, 0x20, 0x42, 0x84, 0xF0, 0x78, 0x89,
  0x0C, 0x18, 0x30, 0x61, 0x42, 0x89, 0xE0, 0x7E, 0x81, 0x02, 0x0F, 0xD0,
  0x20, 0x40, 0x81, 0xF0, 0x7E, 0x81, 0x02, 0x0F, 0xD0, 0x20, 0x40, 0x81,
  0x00, 0x3C, 0x86, 0x0C, 0x08, 0x13, 0xA1, 0x42, 0x84, 0xF0, 0x21, 0x21,
  0x41, 0x41, 0x7D, 0x42, 0x42, 0x42, 0x82, 0x82, 0x7E, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x21, 0xF0, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x42,
  0x89, 0xE0, 0x43, 0x44, 0x48, 0x50, 0xA0, 0x50, 0x90, 0x88, 0x88, 0x84,
  0x42, 0x10, 0x84, 0x42, 0x10, 0x87, 0xC0, 0x42, 0x86, 0x9D, 0x5A, 0xB2,
  0xA9, 0x42, 0x85, 0x08, 0x21, 0x21, 0x51, 0x51, 0x49, 0x4A, 0x4A, 0x46,
  0x86, 0x82, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x88, 0xE0, 0x7C,
  0x85, 0x0A, 0x14, 0x6F, 0x20, 0x40, 0x81, 0x00, 0x3C, 0x86, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0x84, 0xF0, 0x20, 0x40, 0x7C, 0x85, 0x0A, 0x18, 0x4F,
  0x22, 0x44, 0x89, 0x08, 0x3C, 0x85, 0x0A, 0x03, 0x01, 0x01, 0x42, 0x84,
  0xF0, 0xFC, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x00, 0x42, 0x86, 0x0C,
  0x18, 0x30, 0xA1, 0x42, 0x88, 0xE0, 0x86, 0x18, 0xA2, 0x8A, 0x49, 0x28,
  0x41, 0x00, 0x93, 0x46, 0x96, 0xAD, 0x53, 0x26, 0x48, 0x91, 0x20, 0x21,
  0x21, 0x12, 0x14, 0x08, 0x08, 0x14, 0x24, 0x42, 0x82, 0x86, 0x18, 0xA4,
  0x51, 0x84, 0x10, 0x41, 0x00, 0x3F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20,
  0x20, 0x40, 0xFC, 0x32, 0x24, 0x44, 0x44, 0x48, 0x88, 0xC0, 0xAA, 0x95,
  0x54, 0x31, 0x11, 0x11, 0x22, 0x22, 0x22, 0xC0, 0x21, 0x94, 0xA8, 0x84,
  0xFC, 0xC0, 0x39, 0x18, 0x41, 0x7E, 0x18, 0xBD, 0x41, 0x04, 0x1E, 0x46,
  0x18, 0x61, 0x86, 0x2F, 0x00, 0x39, 0x18, 0x60, 0x82, 0x08, 0x5E, 0x02,
  0x04, 0x09, 0xD4, 0x50, 0xA1, 0x42, 0x85, 0x11, 0xE0, 0x39, 0x18, 0x7F,
  0x82, 0x08, 0x1E, 0x1C, 0x82, 0x2E, 0x41, 0x04, 0x10, 0x41, 0x08, 0x00,
  0x39, 0x18, 0x61, 0x86, 0x18, 0x9E, 0x0A, 0x2F, 0x00, 0x41, 0x04, 0x16,
  0xE6, 0x18, 0x61, 0x86, 0x18, 0x40, 0x08, 0x18, 0x21, 0x08, 0x42, 0x27,
  0xC0, 0x04, 0x01, 0x81, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0xE0, 0x40,
  0x81, 0x02, 0x14, 0x4B, 0x28, 0x30, 0x91, 0x12, 0x30, 0x38, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x3E, 0x36, 0x49, 0x89, 0x89, 0x91, 0x91, 0x92, 0x92,
  0x1B, 0x98, 0x61, 0x86, 0x18, 0x61, 0x39, 0x18, 0x61, 0x86, 0x18, 0x7E,
  0x1C, 0x45, 0x0A, 0x14, 0x28, 0x51, 0x3C, 0x81, 0x02, 0x00, 0x39, 0x18,
  0x61, 0x86, 0x18, 0x9E, 0x08, 0x20, 0x80, 0x1D, 0x84, 0x20, 0x82, 0x08,
  0x20, 0x39, 0x14, 0x50, 0x38, 0x18, 0x7E, 0x27, 0xC8, 0x84, 0x21, 0x08,
  0x70, 0x46, 0x18, 0x61, 0x86, 0x2F, 0x80, 0x83, 0x09, 0x22, 0x45, 0x04,
  0x08, 0x00, 0x93, 0x66, 0xD5, 0xAC, 0x91, 0x22, 0x00, 0x23, 0x14, 0x18,
  0x18, 0x28, 0x44, 0xC2, 0x41, 0x42, 0x22, 0x24, 0x28, 0x28, 0x10, 0x10,
  0x20, 0xC0, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x0C, 0x41, 0x08,
  0x20, 0x84, 0x30, 0x41, 0x04, 0x10, 0x40, 0xC0, 0x55, 0x5A, 0xAA, 0x20,
  0x40, 0x82, 0x10, 0x40, 0x83, 0x10, 0x42, 0x08, 0x23, 0x00, 0x71, 0x8E,
};

const GFXglyph RobotoMono_ThinItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 2, 3, 8, 4, -11 },
  { 5, 8, 10, 8, 0, -10 },
  { 15, 7, 12, 8, 1, -11 },
  { 26, 7, 10, 8, 1, -10 },
  { 35, 6, 10, 8, 1, -10 },
  { 43, 1, 3, 8, 4, -11 },
  { 44, 5, 14, 8, 2, -11 },
  { 53, 4, 14, 8, 1, -11 },
  { 60, 6, 5, 8, 2, -10 },
  { 64, 7, 7, 8, 1, -8 },
  { 71, 1, 3, 8, 2, -1 },
  { 72, 4, 1, 8, 2, -5 },
  { 73, 1, 1, 8, 3, -1 },
  { 74, 6, 11, 8, 1, -10 },
  { 83, 6, 10, 8, 1, -10 },
  { 91, 4, 10, 8, 2, -10 },
  { 96, 7, 10, 8, 0, -10 },
  { 105, 7, 10, 8, 0, -10 },
  { 114, 7, 10, 8, 0, -10 },
  { 123, 7, 10, 8, 1, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 2, -10 },
  { 148, 7, 10, 8, 1, -10 },
  { 157, 6, 10, 8, 1, -10 },
  { 165, 2, 7, 8, 4, -7 },
  { 167, 3, 9, 8, 3, -7 },
  { 171, 6, 5, 8, 1, -7 },
  { 175, 6, 3, 8, 1, -6 },
  { 178, 6, 5, 8, 1, -7 },
  { 182, 5, 10, 8, 2, -10 },
  { 189, 8, 10, 8, 0, -10 },
  { 199, 7, 10, 8, 0, -10 },
  { 208, 7, 10, 8, 1, -10 },
  { 217, 7, 10, 8, 1, -10 },
  { 226, 7, 10, 8, 1, -10 },
  { 235, 7, 10, 8, 1, -10 },
  { 244, 7, 10, 8, 1, -10 },
  { 253, 7, 10, 8, 1, -10 },
  { 262, 8, 10, 8, 0, -10 },
  { 272, 7, 10, 8, 1, -10 },
  { 281, 7, 10, 8, 1, -10 },
  { 290, 8, 10, 8, 1, -10 },
  { 300, 5, 10, 8, 1, -10 },
  { 307, 7, 10, 8, 1, -10 },
  { 316, 8, 10, 8, 0, -10 },
  { 326, 7, 10, 8, 1, -10 },
  { 335, 7, 10, 8, 1, -10 },
  { 344, 7, 12, 8, 1, -10 },
  { 355, 7, 10, 8, 1, -10 },
  { 364, 7, 10, 8, 1, -10 },
  { 373, 6, 10, 8, 2, -10 },
  { 381, 7, 10, 8, 1, -10 },
  { 390, 6, 10, 8, 2, -10 },
  { 398, 7, 10, 8, 2, -10 },
  { 407, 8, 10, 8, 0, -10 },
  { 417, 6, 10, 8, 2, -10 },
  { 425, 8, 10, 8, 0, -10 },
  { 435, 4, 13, 8, 2, -11 },
  { 442, 2, 11, 8, 3, -10 },
  { 445, 4, 13, 8, 2, -11 },
  { 452, 5, 6, 8, 2, -10 },
  { 456, 6, 1, 8, 0, 0 },
  { 457, 2, 1, 8, 4, -10 },
  { 458, 6, 8, 8, 1, -8 },
  { 464, 6, 11, 8, 1, -11 },
  { 473, 6, 8, 8, 1, -8 },
  { 479, 7, 11, 8, 1, -11 },
  { 489, 6, 8, 8, 1, -8 },
  { 495, 6, 11, 8, 2, -11 },
  { 504, 6, 11, 8, 1, -8 },
  { 513, 6, 11, 8, 1, -11 },
  { 522, 5, 10, 8, 1, -10 },
  { 529, 6, 13, 8, 0, -10 },
  { 539, 7, 11, 8, 1, -11 },
  { 549, 5, 11, 8, 1, -11 },
  { 556, 8, 8, 8, 0, -8 },
  { 564, 6, 8, 8, 1, -8 },
  { 570, 6, 8, 8, 1, -8 },
  { 576, 7, 11, 8, 0, -8 },
  { 586, 6, 11, 8, 1, -8 },
  { 595, 6, 8, 8, 2, -8 },
  { 601, 6, 8, 8, 1, -8 },
  { 607, 5, 9, 8, 2, -9 },
  { 613, 6, 7, 8, 1, -7 },
  { 619, 7, 7, 8, 1, -7 },
  { 626, 7, 7, 8, 1, -7 },
  { 633, 8, 7, 8, 0, -7 },
  { 640, 8, 10, 8, 0, -7 },
  { 650, 7, 7, 8, 0, -7 },
  { 657, 6, 14, 8, 2, -11 },
  { 668, 2, 12, 8, 3, -10 },
  { 671, 6, 14, 8, 1, -11 },
  { 682, 8, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_ThinItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic14pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_THINITALIC14PT7B_H_
