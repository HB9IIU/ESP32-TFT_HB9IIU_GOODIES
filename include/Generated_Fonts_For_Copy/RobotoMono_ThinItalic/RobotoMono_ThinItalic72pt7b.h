#ifndef _ROBOTOMONO_THINITALIC72PT7B_H_
#define _ROBOTOMONO_THINITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x00,
  0x18, 0x19, 0xC0, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC0, 0xCC,
  0x06, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC0, 0xC4, 0x06, 0x60, 0x33, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x81, 0x80, 0x04, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x10,
  0x01, 0xC1, 0x80, 0x02, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x18, 0x03, 0x80, 0x80, 0x03, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x06,
  0x00, 0x18, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x08, 0x00, 0xE0, 0x30,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x03, 0x80, 0x03, 0x01, 0xC0,
  0x60, 0x00, 0x70, 0xF0, 0x18, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x00, 0x3E,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xFC, 0x00, 0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x30,
  0x1E, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x18, 0x00,
  0x60, 0x30, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x07, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x18, 0x0E, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x30, 0x00, 0x60, 0x60, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0xC0, 0x03, 0x03, 0x00, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x0C, 0x30,
  0x00, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x30, 0x01, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x00, 0x61, 0x80,
  0x01, 0x80, 0x0C, 0x60, 0x00, 0x30, 0x03, 0x1C, 0x00, 0x03, 0x00, 0x63,
  0x00, 0x00, 0x30, 0x1C, 0x60, 0x00, 0x06, 0x03, 0x18, 0x00, 0x00, 0x60,
  0xE3, 0x00, 0x00, 0x06, 0x18, 0x60, 0x00, 0x00, 0xC7, 0x0C, 0x00, 0x00,
  0x0C, 0xC1, 0x80, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x00, 0x1E, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xF8, 0x0C, 0x00, 0x00, 0x3B, 0x00,
  0xC0, 0x00, 0x0E, 0x30, 0x1C, 0x00, 0x07, 0x07, 0x01, 0xE0, 0x03, 0xC0,
  0x60, 0x0F, 0x03, 0xE0, 0x06, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0x18, 0x8C, 0x63, 0x18, 0xC4, 0x63, 0x18, 0xC4, 0x63, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x7F, 0x80, 0x30, 0x0F, 0xCF, 0xC0, 0xC1, 0xF8,
  0x07, 0xC3, 0x1F, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x30, 0x61, 0x86, 0x1C, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1E, 0x18,
  0x00, 0x00, 0x1D, 0x0C, 0x00, 0x00, 0x1C, 0x8C, 0x00, 0x00, 0x1C, 0xC6,
  0x00, 0x00, 0x18, 0x63, 0x00, 0x00, 0x18, 0x31, 0x80, 0x00, 0x18, 0x19,
  0x80, 0x00, 0x38, 0x0C, 0xC0, 0x00, 0x38, 0x06, 0x60, 0x00, 0x38, 0x03,
  0x30, 0x00, 0x38, 0x01, 0x18, 0x00, 0x30, 0x01, 0x8C, 0x00, 0x30, 0x00,
  0xCC, 0x00, 0x30, 0x00, 0x66, 0x00, 0x70, 0x00, 0x33, 0x00, 0x70, 0x00,
  0x19, 0x80, 0x70, 0x00, 0x18, 0xC0, 0x70, 0x00, 0x0C, 0x40, 0x70, 0x00,
  0x06, 0x20, 0x60, 0x00, 0x03, 0x30, 0x60, 0x00, 0x01, 0x18, 0xE0, 0x00,
  0x01, 0x8C, 0xE0, 0x00, 0x00, 0xC6, 0xE0, 0x00, 0x00, 0x63, 0xE0, 0x00,
  0x00, 0x61, 0xE0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xF3, 0x01, 0xE0, 0xC1,
  0xE0, 0x23, 0xE0, 0x19, 0xC0, 0x06, 0x40, 0x01, 0xA0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x1C, 0x10, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x08,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x04, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x83, 0xFE, 0x00, 0x00, 0x23, 0xFF,
  0xF0, 0x00, 0x0D, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x3F, 0xF8, 0x00,
  0xC1, 0xF0, 0x7C, 0x01, 0x0F, 0x00, 0x1C, 0x06, 0x38, 0x00, 0x1C, 0x0D,
  0xC0, 0x00, 0x1C, 0x17, 0x00, 0x00, 0x18, 0x78, 0x00, 0x00, 0x18, 0xF0,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x03, 0x43, 0x00, 0x00, 0x0D, 0x87,
  0x00, 0x00, 0x33, 0x06, 0x00, 0x00, 0xC6, 0x06, 0x00, 0x07, 0x18, 0x07,
  0x00, 0x3C, 0x30, 0x07, 0xC7, 0xE0, 0x60, 0x07, 0xFF, 0x01, 0x80, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x03, 0xC1,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x78, 0x38,
  0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x03, 0xC0, 0x1E,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x7E, 0x00, 0x30, 0x1C, 0x00, 0xFF, 0x80, 0x18, 0x0C, 0x00, 0xE0,
  0x70, 0x0C, 0x0E, 0x00, 0xC0, 0x18, 0x06, 0x06, 0x00, 0xC0, 0x0C, 0x03,
  0x07, 0x00, 0xC0, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x02, 0x00, 0xC3, 0x80,
  0x60, 0x03, 0x00, 0x61, 0x80, 0x60, 0x01, 0x80, 0x30, 0xC0, 0x30, 0x00,
  0x80, 0x18, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x60, 0x18, 0x00, 0x60, 0x04,
  0x70, 0x18, 0x00, 0x30, 0x06, 0x30, 0x0C, 0x00, 0x10, 0x03, 0x18, 0x06,
  0x00, 0x18, 0x01, 0x8C, 0x06, 0x00, 0x0C, 0x00, 0xCC, 0x03, 0x00, 0x06,
  0x00, 0x46, 0x01, 0x80, 0x06, 0x00, 0x63, 0x00, 0xC0, 0x03, 0x00, 0x31,
  0x80, 0x40, 0x01, 0x80, 0x18, 0xC0, 0x60, 0x01, 0x80, 0x18, 0x60, 0x30,
  0x00, 0xC0, 0x0C, 0x20, 0x18, 0x00, 0xE0, 0x06, 0x10, 0x0C, 0x00, 0x70,
  0x06, 0x08, 0x06, 0x00, 0x78, 0x03, 0x04, 0x03, 0x00, 0x6C, 0x03, 0x03,
  0x01, 0x80, 0x66, 0x01, 0x81, 0x80, 0x40, 0x73, 0x01, 0x80, 0xC0, 0x30,
  0x70, 0xC3, 0x80, 0x60, 0x0F, 0xF0, 0x7F, 0x80, 0x30, 0x03, 0xE0, 0x1F,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x60,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0xE0, 0x10, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x1E, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00,
  0x40, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF8, 0x60, 0x00, 0x3F,
  0xFF, 0x84, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x10, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x00, 0x06, 0x1F,
  0x00, 0x00, 0x00, 0x04, 0x31, 0x80, 0x00, 0x00, 0x0C, 0x61, 0xC0, 0x00,
  0x00, 0x0D, 0xC0, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x0F,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x06,
  0xC0, 0x16, 0x00, 0x00, 0x1D, 0x80, 0x66, 0x00, 0x00, 0x33, 0x00, 0xCC,
  0x00, 0x00, 0xEC, 0x01, 0x98, 0x00, 0x01, 0x98, 0x03, 0x30, 0x00, 0x06,
  0x30, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x30,
  0xC0, 0x00, 0xE1, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x07,
  0x0C, 0x01, 0x82, 0x00, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x30, 0x30, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x18, 0x18, 0x01, 0x80, 0x80, 0x30, 0x30, 0x03,
  0x03, 0x00, 0x60, 0x20, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x01,
  0x80, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0x18, 0x02, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x60, 0x06, 0x00, 0x80, 0x19, 0xC0, 0x0C, 0x03, 0x00, 0x33,
  0x00, 0x18, 0x06, 0x00, 0x2C, 0x00, 0x60, 0x0C, 0x00, 0x58, 0x00, 0xC0,
  0x18, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x02, 0x80, 0x00, 0x00, 0x20, 0x0D, 0x80, 0x00, 0x00, 0xC0, 0x1B, 0x00,
  0x00, 0x01, 0x80, 0x33, 0x00, 0x00, 0x03, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x00, 0xC4, 0x00, 0x00, 0x0C, 0x01, 0x0C, 0x00, 0x00, 0x10, 0x06, 0x18,
  0x00, 0x00, 0x60, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0x18, 0x30, 0x00, 0x01,
  0x80, 0x30, 0x60, 0x00, 0x03, 0x00, 0x60, 0x60, 0x00, 0x06, 0x00, 0x80,
  0xC0, 0x00, 0x08, 0x03, 0x00, 0x80, 0x00, 0x30, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x00, 0x30, 0x06, 0x00, 0x10, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x01, 0x00, 0x20, 0x00, 0x40,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x08, 0x00, 0x02,
  0x00, 0x80, 0x30, 0x00, 0x06, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0xC0, 0x00, 0x08, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x18, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x04, 0x00, 0x00, 0x30, 0x40, 0x18, 0x00, 0x00, 0x61, 0x80,
  0x30, 0x00, 0x00, 0x43, 0x00, 0x60, 0x00, 0x00, 0xC6, 0x00, 0xC0, 0x00,
  0x01, 0x8C, 0x01, 0x80, 0x00, 0x01, 0x18, 0x02, 0x00, 0x00, 0x03, 0x20,
  0x0C, 0x00, 0x00, 0x06, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x80, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE8, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x30, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x00, 0xB0, 0x00, 0x18, 0x00, 0x0D, 0x80, 0x01, 0xC0, 0x00, 0x6C, 0x00,
  0x0E, 0x00, 0x02, 0x60, 0x00, 0x50, 0x00, 0x33, 0x00, 0x06, 0x80, 0x01,
  0x98, 0x00, 0x36, 0x00, 0x08, 0xC0, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x19,
  0x80, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x21, 0x80, 0x0C, 0x60, 0x03, 0x0C,
  0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x0C, 0x18, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x06, 0x00,
  0xC1, 0x80, 0x10, 0x30, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x0C,
  0x0C, 0x03, 0x03, 0x00, 0x40, 0x60, 0x18, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x04, 0x01, 0x81, 0x80, 0x60,
  0x60, 0x0C, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x10, 0x60,
  0x06, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x8E,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x04, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x04, 0x07, 0x80, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x00, 0xD0, 0x60, 0x00, 0x01,
  0xB0, 0x60, 0x00, 0x07, 0x30, 0x30, 0x00, 0x0E, 0x30, 0x38, 0x00, 0x3C,
  0x30, 0x1F, 0x03, 0xF0, 0x30, 0x07, 0xFF, 0x80, 0x30, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x3E, 0x00, 0x03, 0x01, 0xFF, 0xC0, 0x03, 0x07, 0xC1,
  0xE0, 0x03, 0x1E, 0x00, 0x70, 0x03, 0x38, 0x00, 0x18, 0x03, 0x60, 0x00,
  0x0C, 0x02, 0xC0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x01, 0xC0, 0x6C, 0x00, 0x03, 0x80, 0x6E, 0x00, 0x07,
  0x00, 0xC7, 0x00, 0x1E, 0x00, 0xC1, 0xE0, 0x78, 0x00, 0xC0, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07,
  0xC0, 0x18, 0x00, 0x0F, 0xFF, 0x03, 0x00, 0x03, 0xE0, 0xF0, 0x60, 0x01,
  0xE0, 0x03, 0x0C, 0x00, 0x70, 0x00, 0x31, 0x80, 0x1C, 0x00, 0x03, 0x60,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x30, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x30, 0x00,
  0x03, 0xE0, 0x07, 0x00, 0x00, 0xE8, 0x00, 0x70, 0x00, 0x3B, 0x00, 0x07,
  0x00, 0x1C, 0x60, 0x00, 0x78, 0x1F, 0x0C, 0x00, 0x03, 0xFF, 0x81, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x30,
  0x00, 0x7C, 0x1E, 0x0C, 0x00, 0x78, 0x00, 0xC3, 0x00, 0x38, 0x00, 0x18,
  0xC0, 0x1C, 0x00, 0x03, 0x30, 0x0E, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x78, 0x03,
  0x00, 0x00, 0x3E, 0x00, 0x60, 0x00, 0x1D, 0x80, 0x1C, 0x00, 0x0E, 0xC0,
  0x03, 0x80, 0x0F, 0x30, 0x00, 0x78, 0x1F, 0x0C, 0x00, 0x07, 0xFF, 0x03,
  0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x03, 0x00, 0xFF,
  0xE0, 0x03, 0x03, 0xE0, 0x78, 0x03, 0x0F, 0x00, 0x1C, 0x02, 0x1C, 0x00,
  0x0C, 0x06, 0x38, 0x00, 0x06, 0x06, 0x60, 0x00, 0x06, 0x06, 0xC0, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x03, 0x05, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x7D, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x04, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x03, 0x3B, 0x00, 0x00, 0x01,
  0x9C, 0xE0, 0x00, 0x00, 0x6E, 0x18, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x63,
  0xFF, 0x01, 0xFF, 0x80, 0x11, 0xE0, 0xE0, 0xF0, 0x70, 0x0C, 0xE0, 0x18,
  0xF0, 0x0E, 0x03, 0x60, 0x03, 0x70, 0x01, 0x80, 0xF0, 0x00, 0xD8, 0x00,
  0x60, 0x38, 0x00, 0x3C, 0x00, 0x08, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x81, 0x00, 0x00, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x04, 0x00, 0x03, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x81, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x40, 0x00, 0x30, 0x00, 0x18, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0x00,
  0xFF, 0xE0, 0x03, 0x03, 0xE0, 0x78, 0x03, 0x0F, 0x00, 0x1C, 0x02, 0x1C,
  0x00, 0x0C, 0x06, 0x30, 0x00, 0x06, 0x06, 0x60, 0x00, 0x06, 0x06, 0xC0,
  0x00, 0x03, 0x07, 0x80, 0x00, 0x03, 0x05, 0x00, 0x00, 0x03, 0x0F, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x0F, 0xFF, 0x00,
  0x01, 0x87, 0xC0, 0xF0, 0x00, 0x31, 0xC0, 0x07, 0x00, 0x06, 0x70, 0x00,
  0x30, 0x00, 0x98, 0x00, 0x07, 0x00, 0x36, 0x00, 0x00, 0x60, 0x07, 0x80,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x18, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x0C, 0xE0, 0x00, 0x70, 0x01, 0x8E, 0x00, 0x3C, 0x00, 0x30, 0xF8, 0x3E,
  0x00, 0x06, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x03, 0x00, 0x1F, 0x07, 0x83,
  0x00, 0x78, 0x01, 0xE3, 0x00, 0xE0, 0x00, 0x63, 0x01, 0xC0, 0x00, 0x32,
  0x03, 0x80, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xE0,
  0x30, 0x00, 0x03, 0xE0, 0x18, 0x00, 0x07, 0x40, 0x1C, 0x00, 0x0E, 0x40,
  0x0E, 0x00, 0x3C, 0xC0, 0x07, 0x81, 0xF0, 0xC0, 0x01, 0xFF, 0xC0, 0xC0,
  0x00, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x0C, 0x01, 0xFF, 0xF0, 0x30, 0x1F, 0x80, 0x80,
  0xC1, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x0E, 0xC0, 0x30, 0x00, 0x1C,
  0xC0, 0x38, 0x00, 0x70, 0xC0, 0x1F, 0x07, 0xE0, 0x80, 0x07, 0xFF, 0x81,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x06, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00,
  0x03, 0x00, 0x01, 0xB0, 0x00, 0x38, 0x00, 0x0D, 0x80, 0x01, 0xC0, 0x00,
  0xCC, 0x00, 0x1A, 0x00, 0x06, 0x60, 0x00, 0xD0, 0x00, 0x33, 0x00, 0x04,
  0x80, 0x03, 0x18, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x18, 0x03, 0x83, 0x00,
  0x60, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C,
  0x06, 0x01, 0x81, 0x80, 0x60, 0x30, 0x08, 0x0C, 0x07, 0x00, 0x80, 0xC0,
  0x20, 0x30, 0x06, 0x06, 0x01, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x01, 0x90, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x01, 0x60, 0x00, 0x6C, 0x00,
  0x0B, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0xE0,
  0x38, 0x00, 0x00, 0xC6, 0x00, 0x70, 0x00, 0x06, 0x30, 0x00, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x80, 0x03, 0x18, 0x00,
  0x07, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x01, 0xC3, 0x00, 0x00, 0x0F, 0xBE,
  0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ThinItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 11, 51, 42, 15, -51 },
  { 72, 13, 15, 42, 18, -54 },
  { 97, 42, 51, 42, 1, -51 },
  { 365, 34, 65, 42, 5, -58 },
  { 642, 35, 53, 42, 4, -52 },
  { 874, 35, 53, 42, 3, -52 },
  { 1106, 5, 15, 42, 21, -54 },
  { 1116, 21, 73, 42, 13, -57 },
  { 1308, 21, 74, 42, 7, -57 },
  { 1503, 30, 28, 42, 10, -51 },
  { 1608, 35, 37, 42, 4, -42 },
  { 1770, 7, 15, 42, 9, -6 },
  { 1784, 25, 2, 42, 8, -24 },
  { 1791, 4, 4, 42, 17, -4 },
  { 1793, 32, 55, 42, 6, -51 },
  { 2013, 33, 53, 42, 5, -52 },
  { 2232, 18, 51, 42, 11, -51 },
  { 2347, 33, 52, 42, 2, -52 },
  { 2562, 35, 53, 42, 2, -52 },
  { 2794, 35, 51, 42, 2, -51 },
  { 3018, 35, 52, 42, 6, -51 },
  { 3246, 31, 53, 42, 4, -52 },
  { 3452, 32, 51, 42, 9, -51 },
  { 3656, 36, 53, 42, 4, -52 },
  { 3895, 31, 53, 42, 7, -52 },
  { 4101, 9, 35, 42, 19, -35 },
  { 4141, 14, 44, 42, 14, -35 },
  { 4218, 32, 29, 42, 6, -38 },
  { 4334, 33, 17, 42, 5, -32 },
  { 4405, 33, 29, 42, 4, -38 },
  { 4525, 26, 52, 42, 12, -52 },
  { 4694, 41, 53, 42, 1, -52 },
  { 4966, 35, 51, 42, 0, -51 },
  { 5190, 35, 51, 42, 4, -51 },
  { 5414, 35, 53, 42, 5, -52 },
  { 5646, 37, 51, 42, 3, -51 },
  { 5882, 37, 51, 42, 4, -51 },
  { 6118, 37, 51, 42, 4, -51 },
  { 6354, 36, 53, 42, 4, -52 },
  { 6593, 39, 51, 42, 2, -51 },
  { 6842, 36, 51, 42, 4, -51 },
  { 7072, 36, 52, 42, 3, -51 },
  { 7306, 40, 51, 42, 4, -51 },
  { 7561, 28, 51, 42, 5, -51 },
  { 7740, 39, 51, 42, 3, -51 },
  { 7989, 39, 51, 42, 2, -51 },
  { 8238, 34, 53, 42, 5, -52 },
  { 8464, 37, 51, 42, 5, -51 },
  { 8700, 36, 61, 42, 4, -52 },
  { 8975, 35, 51, 42, 4, -51 },
  { 9199, 36, 53, 42, 4, -52 },
  { 9438, 35, 51, 42, 9, -51 },
  { 9662, 36, 52, 42, 5, -51 },
  { 9896, 35, 51, 42, 8, -51 },
  { 10120, 37, 51, 42, 8, -51 },
  { 10356, 42, 51, 42, 1, -51 },
  { 10624, 35, 51, 42, 8, -51 },
  { 10848, 37, 51, 42, 2, -51 },
  { 11084, 21, 70, 42, 11, -59 },
  { 11268, 13, 55, 42, 15, -51 },
  { 11358, 20, 70, 42, 11, -59 },
  { 11533, 25, 28, 42, 9, -51 },
  { 11621, 29, 2, 42, 3, 0 },
  { 11629, 7, 9, 42, 22, -53 },
  { 11637, 32, 40, 42, 4, -39 },
  { 11797, 32, 55, 42, 4, -54 },
  { 12017, 31, 40, 42, 5, -39 },
  { 12172, 35, 55, 42, 5, -54 },
  { 12413, 32, 40, 42, 5, -39 },
  { 12573, 34, 55, 42, 10, -55 },
  { 12807, 34, 54, 42, 3, -39 },
  { 13037, 32, 54, 42, 4, -54 },
  { 13253, 29, 51, 42, 4, -51 },
  { 13438, 33, 67, 42, 0, -52 },
  { 13715, 34, 54, 42, 5, -54 },
  { 13945, 29, 54, 42, 4, -54 },
  { 14141, 42, 39, 42, -1, -39 },
  { 14346, 32, 39, 42, 4, -39 },
  { 14502, 33, 40, 42, 4, -39 },
  { 14667, 35, 54, 42, 1, -39 },
  { 14904, 32, 54, 42, 5, -39 },
  { 15120, 30, 39, 42, 10, -39 },
  { 15267, 32, 40, 42, 5, -39 },
  { 15427, 27, 49, 42, 9, -48 },
  { 15593, 32, 39, 42, 6, -38 },
  { 15749, 33, 38, 42, 7, -38 },
  { 15906, 37, 38, 42, 6, -38 },
  { 16082, 38, 38, 42, 2, -38 },
  { 16263, 43, 53, 42, -1, -38 },
  { 16548, 37, 38, 42, 1, -38 },
  { 16724, 28, 71, 42, 11, -56 },
  { 16973, 12, 61, 42, 15, -51 },
  { 17065, 28, 72, 42, 6, -56 },
  { 17317, 38, 11, 42, 2, -27 },
};

const GFXfont RobotoMono_ThinItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic72pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_THINITALIC72PT7B_H_
