#ifndef _ROBOTOMONO_THINITALIC36PT7B_H_
#define _ROBOTOMONO_THINITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42,
  0x10, 0x00, 0x00, 0x00, 0x86, 0x00, 0x42, 0x89, 0x12, 0x24, 0x50, 0xA2,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0x40,
  0x02, 0x04, 0x00, 0x10, 0x20, 0x01, 0x01, 0x00, 0x08, 0x10, 0x0F, 0xFF,
  0xF8, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x10, 0x20, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x30, 0x20,
  0x3F, 0xFF, 0xF0, 0x08, 0x10, 0x00, 0x80, 0x80, 0x04, 0x08, 0x00, 0x20,
  0x40, 0x02, 0x02, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x01, 0xF0, 0x01, 0x83, 0x01, 0x80, 0x40,
  0x40, 0x08, 0x20, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x82, 0x00, 0x40, 0xC0,
  0x60, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x0E, 0x00, 0x0C, 0x40, 0x02, 0x08, 0x01, 0x02, 0x04, 0x40, 0x83,
  0x20, 0x20, 0x88, 0x08, 0x42, 0x04, 0x20, 0x81, 0x08, 0x20, 0x84, 0x04,
  0x62, 0x00, 0xE1, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x60, 0x04,
  0x7C, 0x02, 0x10, 0x81, 0x08, 0x20, 0x42, 0x04, 0x21, 0x02, 0x10, 0x40,
  0x8C, 0x10, 0x22, 0x04, 0x09, 0x01, 0x04, 0x00, 0x43, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x84, 0x00, 0x81, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x20, 0x08, 0x10, 0x04, 0x10, 0x02, 0x30, 0x00, 0xA0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x68, 0x00, 0x42, 0x00, 0x40, 0x81, 0x60, 0x40,
  0xA0, 0x10, 0xE0, 0x0C, 0x50, 0x02, 0x28, 0x00, 0xA4, 0x00, 0x72, 0x00,
  0x30, 0x80, 0x34, 0x60, 0x22, 0x0F, 0xE0, 0x80, 0x5A, 0xA8, 0x00, 0x20,
  0x0C, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0xC0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x00, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x18, 0x20, 0xCE, 0x4E, 0x03, 0xE0, 0x03, 0x00, 0x09, 0x00, 0x22,
  0x00, 0xC2, 0x03, 0x02, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x7F, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x24, 0x94,
  0xA0, 0xFF, 0xF8, 0x70, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x01, 0xF8, 0x03, 0x0C, 0x04, 0x02, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x03, 0x40, 0x05, 0x40, 0x09, 0x40, 0x31, 0x40, 0x61,
  0x80, 0xC1, 0x81, 0x01, 0x82, 0x02, 0x84, 0x02, 0x88, 0x02, 0x90, 0x02,
  0xE0, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10, 0x40, 0x30,
  0x60, 0x60, 0x1F, 0x80, 0x00, 0x81, 0xC7, 0x4C, 0x28, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x00, 0x00, 0xF8,
  0x01, 0x83, 0x01, 0x00, 0xC1, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xC1, 0x01, 0x80,
  0x41, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x13, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x50, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x11, 0x00, 0x10, 0x80, 0x10, 0x30, 0x10, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x00,
  0xA0, 0x00, 0x90, 0x00, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0xC1, 0x00,
  0x41, 0x00, 0x40, 0x80, 0x40, 0x40, 0x40, 0x20, 0x60, 0x10, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x04, 0x3F, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x03, 0xFF,
  0xC1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x3F, 0x00, 0x70,
  0x60, 0x30, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x04,
  0x00, 0x81, 0x00, 0x40, 0x20, 0x20, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x21, 0xF0, 0x26, 0x18, 0x58, 0x04, 0x70, 0x02, 0x60,
  0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x40, 0x04, 0x40, 0x0C, 0x20, 0x18, 0x30, 0x30, 0x0F,
  0xC0, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x60, 0x18,
  0x10, 0x02, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x10,
  0x00, 0x84, 0x00, 0x60, 0x80, 0x30, 0x10, 0x18, 0x03, 0xF8, 0x01, 0xEE,
  0x01, 0x80, 0x60, 0xC0, 0x08, 0x60, 0x01, 0x10, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10, 0x30,
  0x18, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x18, 0x30, 0x40, 0x21, 0x00, 0x26,
  0x00, 0x48, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x50, 0x01, 0x90, 0x05, 0x20, 0x12, 0x30, 0xC8,
  0x1E, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x07, 0x01, 0xF0, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0xC0, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x20, 0x40, 0x82, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0xC1, 0x08, 0x04, 0x80, 0x2C, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x0E, 0x1C,
  0x01, 0x80, 0x60, 0x60, 0x02, 0x04, 0x00, 0x30, 0x80, 0x81, 0x10, 0x7E,
  0x11, 0x08, 0x21, 0x21, 0x02, 0x12, 0x10, 0x41, 0x42, 0x04, 0x14, 0x20,
  0x41, 0x44, 0x04, 0x18, 0x40, 0x82, 0x84, 0x08, 0x28, 0x40, 0x82, 0x84,
  0x18, 0x48, 0x41, 0x04, 0x84, 0x30, 0xC8, 0x44, 0x98, 0x83, 0x8F, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x12, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x20, 0x80, 0x08,
  0x20, 0x04, 0x04, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x04,
  0x04, 0x01, 0x03, 0xFF, 0xC0, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0x88,
  0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x10, 0x0F,
  0xE0, 0x04, 0x0F, 0x02, 0x00, 0xC1, 0x00, 0x30, 0x80, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0x84, 0x01,
  0x83, 0xFF, 0x01, 0x00, 0xE0, 0x80, 0x18, 0x40, 0x04, 0x40, 0x01, 0x20,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x12, 0x00, 0x19,
  0x00, 0x18, 0x80, 0x30, 0x7F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x61, 0x80,
  0x60, 0x10, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x21, 0x00, 0x04, 0x80,
  0x01, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x12, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0x40, 0x80,
  0x20, 0x30, 0x30, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x02, 0x07, 0x00, 0x80,
  0x20, 0x40, 0x04, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x01,
  0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88,
  0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x44, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x82, 0x00, 0x40,
  0x80, 0x60, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFE, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xE0, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x80, 0x60,
  0x10, 0x30, 0x02, 0x08, 0x00, 0x84, 0x00, 0x11, 0x00, 0x04, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x07, 0xFA, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x84, 0x00, 0x20, 0x80, 0x18,
  0x10, 0x0C, 0x03, 0xFC, 0x00, 0x04, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x21, 0x00,
  0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x1F,
  0xFF, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82,
  0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x20, 0x0F, 0xFF,
  0xC0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x20, 0x80,
  0x08, 0x10, 0x01, 0x03, 0x00, 0x40, 0x30, 0x30, 0x03, 0xF8, 0x00, 0x08,
  0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x08, 0x01, 0x01, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00,
  0x10, 0x80, 0x01, 0x10, 0x00, 0x23, 0x00, 0x02, 0x48, 0x00, 0x38, 0x80,
  0x03, 0x04, 0x00, 0x20, 0x40, 0x02, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x04, 0x00, 0xC0, 0x40, 0x04, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x30, 0x40, 0x03, 0x0A, 0x00,
  0x50, 0xA0, 0x06, 0x0A, 0x00, 0xA0, 0xA0, 0x1A, 0x0A, 0x01, 0x20, 0x90,
  0x22, 0x11, 0x02, 0x41, 0x10, 0x44, 0x11, 0x04, 0x41, 0x10, 0x84, 0x10,
  0x88, 0x42, 0x09, 0x04, 0x20, 0xA0, 0x82, 0x0A, 0x08, 0x20, 0xC0, 0x82,
  0x04, 0x08, 0x20, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x30, 0x04, 0x00,
  0x10, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0xA0, 0x02, 0x0A, 0x00, 0x20, 0xA0,
  0x02, 0x09, 0x00, 0x21, 0x10, 0x04, 0x10, 0x80, 0x41, 0x08, 0x04, 0x10,
  0x80, 0x41, 0x04, 0x04, 0x10, 0x40, 0x82, 0x02, 0x08, 0x20, 0x20, 0x82,
  0x02, 0x08, 0x20, 0x10, 0x82, 0x01, 0x08, 0x40, 0x11, 0x04, 0x00, 0x90,
  0x40, 0x09, 0x04, 0x00, 0x50, 0x40, 0x05, 0x04, 0x00, 0x50, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x00, 0x78, 0x00, 0xC3, 0x01, 0x80, 0x41, 0x80, 0x20,
  0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x21, 0x00, 0x30, 0x40, 0x30, 0x30, 0x30, 0x07, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x80, 0xE0, 0x20, 0x02, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x01, 0x08, 0x00, 0x41, 0x00, 0x10, 0x40, 0x0C, 0x0F, 0xFE, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xE0, 0x80, 0x60, 0x10, 0x30, 0x02, 0x18, 0x00,
  0x84, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x02,
  0x30, 0x00, 0x84, 0x00, 0x41, 0x80, 0x20, 0x30, 0x30, 0x07, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x0F,
  0xF0, 0x02, 0x03, 0x80, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00,
  0x21, 0x00, 0x04, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x10,
  0x40, 0x04, 0x20, 0x02, 0x08, 0x03, 0x03, 0xFF, 0x00, 0x80, 0x80, 0x20,
  0x10, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x20, 0x40, 0x08, 0x10, 0x01,
  0x04, 0x00, 0x42, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x80, 0x00, 0xFC,
  0x00, 0xC0, 0xC0, 0x40, 0x18, 0x20, 0x02, 0x10, 0x00, 0xC4, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x44,
  0x00, 0x21, 0x00, 0x10, 0x30, 0x18, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x22, 0x00,
  0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00,
  0x11, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x20, 0x80, 0x08,
  0x10, 0x03, 0x01, 0x00, 0xC0, 0x30, 0x30, 0x03, 0xF8, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x08, 0x40, 0x04, 0x10, 0x04, 0x08, 0x02, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x40,
  0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x28, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x09, 0x04,
  0x82, 0x41, 0x20, 0x90, 0x48, 0x44, 0x22, 0x11, 0x08, 0x84, 0x42, 0x22,
  0x11, 0x08, 0x84, 0x42, 0x61, 0x10, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x04,
  0x82, 0x81, 0x40, 0xA0, 0x50, 0x30, 0x14, 0x0C, 0x05, 0x03, 0x01, 0x80,
  0x80, 0x20, 0x20, 0x08, 0x00, 0x08, 0x00, 0x18, 0x40, 0x01, 0x81, 0x00,
  0x08, 0x08, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0xC0, 0x04, 0x04, 0x00,
  0x20, 0x40, 0x00, 0x84, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00, 0x00, 0xA0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x12, 0x00, 0x01,
  0x10, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08, 0x08, 0x00, 0x80, 0x40,
  0x08, 0x01, 0x00, 0x80, 0x08, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x42, 0x00,
  0x21, 0x00, 0x20, 0x80, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x10, 0x02,
  0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xC1, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3E, 0x00, 0x80, 0x81, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10, 0x03, 0xE0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x00, 0x00, 0x80, 0x18, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x44, 0x08, 0x40, 0x84, 0x10, 0x42, 0x02, 0x20, 0x24,
  0x02, 0x40, 0x28, 0x03, 0xFF, 0xFE, 0x99, 0x12, 0x03, 0xFC, 0x04, 0x06,
  0x08, 0x02, 0x10, 0x01, 0x20, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0xFE, 0x0F, 0x02, 0x30, 0x02, 0x60, 0x02, 0x40, 0x02, 0x80, 0x02,
  0x80, 0x04, 0x80, 0x0C, 0x80, 0x14, 0x40, 0x64, 0x3F, 0x84, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x11, 0xF8, 0x16, 0x04, 0x18, 0x02, 0x10, 0x02, 0x30, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x08, 0xA0, 0x18,
  0xB0, 0x30, 0x8F, 0xC0, 0x03, 0xF0, 0x18, 0x18, 0x40, 0x11, 0x00, 0x12,
  0x00, 0x28, 0x00, 0x50, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x40, 0x10,
  0xC0, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x07, 0xF1, 0x04,
  0x05, 0x04, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x11, 0x00, 0x09,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x30, 0x40, 0x38, 0x30, 0x34, 0x0F,
  0xE4, 0x00, 0x01, 0xFC, 0x03, 0x03, 0x02, 0x00, 0x82, 0x00, 0x23, 0x00,
  0x11, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x7F, 0xFF, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x04, 0x08, 0x0C, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0xFF, 0xFC, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x82, 0x02, 0x82, 0x00, 0xC2,
  0x00, 0x61, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00,
  0x10, 0x80, 0x18, 0x20, 0x1C, 0x18, 0x1A, 0x07, 0xF2, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x41, 0x00, 0x40, 0xC0, 0x40, 0x38, 0xC0,
  0x03, 0x80, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x11, 0xFC, 0x12, 0x02, 0x14,
  0x01, 0x28, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x01, 0x10,
  0x03, 0x08, 0x03, 0x08, 0x02, 0x04, 0x06, 0x02, 0x06, 0x01, 0x04, 0x00,
  0x84, 0x00, 0x4C, 0x00, 0x4C, 0x00, 0x29, 0x00, 0x18, 0x40, 0x08, 0x20,
  0x04, 0x08, 0x04, 0x02, 0x02, 0x01, 0x81, 0x00, 0x40, 0x80, 0x10, 0x40,
  0x0C, 0x20, 0x03, 0x00, 0x07, 0xF8, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x03, 0xFF, 0xF8, 0x17, 0xE3, 0xE1, 0x82, 0xC1,
  0x30, 0x18, 0x13, 0x01, 0x01, 0x20, 0x10, 0x12, 0x02, 0x01, 0x20, 0x20,
  0x12, 0x02, 0x01, 0x40, 0x20, 0x14, 0x02, 0x02, 0x40, 0x20, 0x24, 0x04,
  0x02, 0x40, 0x40, 0x24, 0x04, 0x02, 0x80, 0x40, 0x28, 0x04, 0x04, 0x80,
  0x40, 0x48, 0x08, 0x04, 0x80, 0x80, 0x40, 0x11, 0xFC, 0x12, 0x02, 0x14,
  0x02, 0x28, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x03, 0xF8, 0x02,
  0x03, 0x02, 0x00, 0x82, 0x00, 0x22, 0x00, 0x13, 0x00, 0x09, 0x00, 0x02,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x34, 0x00, 0x12, 0x00, 0x18, 0x80, 0x08, 0x60, 0x08, 0x18, 0x18, 0x07,
  0xF0, 0x00, 0x08, 0xFC, 0x05, 0x81, 0x03, 0x00, 0x41, 0x00, 0x21, 0x80,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08,
  0x50, 0x0C, 0x2C, 0x0C, 0x11, 0xF8, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF1,
  0x0C, 0x0A, 0x10, 0x06, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x40, 0x38, 0x60, 0x68, 0x3F, 0x90,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x10, 0xFE, 0x26, 0x00, 0x50, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xF8, 0x18, 0x04, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08,
  0x40, 0x30, 0x3F, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x7F, 0xFC, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0xF8, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x08, 0x80, 0x18, 0xC0, 0x38, 0x40, 0x68, 0x3F, 0x88, 0x80, 0x00, 0xA0,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x46, 0x00, 0x21, 0x00, 0x20, 0x80, 0x20,
  0x40, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x08, 0x02, 0x0C, 0x00, 0x84,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x81,
  0x40, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x11, 0x08, 0x84, 0x42, 0x21, 0x10,
  0x88, 0x84, 0x42, 0x21, 0x10, 0x90, 0x48, 0x24, 0x0A, 0x09, 0x02, 0x82,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x0C, 0x04, 0x02, 0x00, 0x18, 0x00, 0x61,
  0x00, 0x10, 0x10, 0x06, 0x03, 0x01, 0x80, 0x20, 0x60, 0x02, 0x18, 0x00,
  0x66, 0x00, 0x04, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x80, 0x00,
  0x98, 0x00, 0x21, 0x00, 0x08, 0x10, 0x02, 0x02, 0x00, 0x80, 0x20, 0x30,
  0x06, 0x0C, 0x00, 0x43, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x20, 0x40, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x20, 0x18, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x04, 0x04, 0x00, 0x10,
  0x30, 0x00, 0x40, 0x80, 0x01, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x80,
  0x00, 0x26, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x30, 0x06, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22,
  0x10, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x07, 0x60, 0x05, 0x02, 0x00, 0xA0, 0x20,
  0x28, 0x03, 0x09, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoMono_ThinItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 7, 7, 21, 9, -27 },
  { 25, 21, 26, 21, 0, -26 },
  { 94, 18, 33, 21, 2, -29 },
  { 169, 18, 26, 21, 2, -26 },
  { 228, 17, 26, 21, 2, -26 },
  { 284, 2, 7, 21, 11, -27 },
  { 286, 11, 37, 21, 6, -29 },
  { 337, 11, 37, 21, 3, -29 },
  { 388, 15, 14, 21, 5, -26 },
  { 415, 17, 18, 21, 2, -21 },
  { 454, 3, 7, 21, 5, -3 },
  { 457, 13, 1, 21, 4, -12 },
  { 459, 2, 2, 21, 8, -2 },
  { 460, 16, 28, 21, 3, -26 },
  { 516, 16, 26, 21, 3, -26 },
  { 568, 9, 26, 21, 6, -26 },
  { 598, 17, 26, 21, 1, -26 },
  { 654, 17, 26, 21, 1, -26 },
  { 710, 17, 26, 21, 1, -26 },
  { 766, 18, 26, 21, 3, -26 },
  { 825, 16, 26, 21, 2, -26 },
  { 877, 16, 26, 21, 5, -26 },
  { 929, 18, 26, 21, 2, -26 },
  { 988, 15, 26, 21, 4, -26 },
  { 1037, 5, 17, 21, 9, -17 },
  { 1048, 7, 21, 21, 7, -17 },
  { 1067, 16, 14, 21, 3, -19 },
  { 1095, 17, 8, 21, 2, -16 },
  { 1112, 16, 14, 21, 2, -19 },
  { 1140, 13, 26, 21, 6, -26 },
  { 1183, 20, 26, 21, 1, -26 },
  { 1248, 18, 26, 21, 0, -26 },
  { 1307, 17, 26, 21, 2, -26 },
  { 1363, 18, 26, 21, 2, -26 },
  { 1422, 18, 26, 21, 2, -26 },
  { 1481, 18, 26, 21, 2, -26 },
  { 1540, 19, 26, 21, 2, -26 },
  { 1602, 18, 26, 21, 2, -26 },
  { 1661, 20, 26, 21, 1, -26 },
  { 1726, 18, 26, 21, 2, -26 },
  { 1785, 19, 26, 21, 1, -26 },
  { 1847, 20, 26, 21, 2, -26 },
  { 1912, 15, 26, 21, 2, -26 },
  { 1961, 20, 26, 21, 1, -26 },
  { 2026, 20, 26, 21, 1, -26 },
  { 2091, 17, 26, 21, 2, -26 },
  { 2147, 19, 26, 21, 2, -26 },
  { 2209, 18, 31, 21, 2, -26 },
  { 2279, 18, 26, 21, 2, -26 },
  { 2338, 18, 26, 21, 2, -26 },
  { 2397, 18, 26, 21, 4, -26 },
  { 2456, 19, 26, 21, 2, -26 },
  { 2518, 17, 26, 21, 4, -26 },
  { 2574, 18, 26, 21, 4, -26 },
  { 2633, 21, 26, 21, 1, -26 },
  { 2702, 17, 26, 21, 4, -26 },
  { 2758, 19, 26, 21, 1, -26 },
  { 2820, 10, 34, 21, 6, -29 },
  { 2863, 7, 28, 21, 7, -26 },
  { 2888, 11, 34, 21, 5, -29 },
  { 2935, 12, 14, 21, 5, -26 },
  { 2956, 15, 1, 21, 1, 0 },
  { 2958, 3, 5, 21, 11, -27 },
  { 2960, 16, 19, 21, 2, -19 },
  { 2998, 16, 27, 21, 2, -27 },
  { 3052, 15, 19, 21, 3, -19 },
  { 3088, 17, 27, 21, 3, -27 },
  { 3146, 17, 19, 21, 2, -19 },
  { 3187, 17, 27, 21, 5, -27 },
  { 3245, 17, 27, 21, 2, -19 },
  { 3303, 16, 27, 21, 2, -27 },
  { 3357, 15, 26, 21, 2, -26 },
  { 3406, 16, 34, 21, 0, -26 },
  { 3474, 17, 27, 21, 3, -27 },
  { 3532, 15, 27, 21, 2, -27 },
  { 3583, 20, 19, 21, 0, -19 },
  { 3631, 16, 19, 21, 2, -19 },
  { 3669, 17, 19, 21, 2, -19 },
  { 3710, 17, 26, 21, 1, -19 },
  { 3766, 16, 26, 21, 3, -19 },
  { 3818, 15, 19, 21, 5, -19 },
  { 3854, 16, 19, 21, 3, -19 },
  { 3892, 13, 24, 21, 5, -24 },
  { 3931, 16, 19, 21, 3, -19 },
  { 3969, 17, 19, 21, 3, -19 },
  { 4010, 18, 19, 21, 3, -19 },
  { 4053, 19, 19, 21, 1, -19 },
  { 4099, 22, 27, 21, -1, -19 },
  { 4174, 18, 19, 21, 1, -19 },
  { 4217, 13, 36, 21, 6, -28 },
  { 4276, 5, 31, 21, 8, -26 },
  { 4296, 14, 36, 21, 3, -28 },
  { 4359, 19, 6, 21, 1, -14 },
};

const GFXfont RobotoMono_ThinItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic36pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_THINITALIC36PT7B_H_
