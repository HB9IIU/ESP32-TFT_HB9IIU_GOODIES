#ifndef _ROBOTOMONO_THINITALIC58PT7B_H_
#define _ROBOTOMONO_THINITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x00,
  0x20, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xD0, 0x24, 0x09, 0x06, 0xC1, 0xB0,
  0x6C, 0x12, 0x04, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x80, 0x18,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x18, 0x01, 0x81, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x04, 0x00, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x02,
  0x00, 0x20, 0x80, 0x10, 0x03, 0x0C, 0x00, 0x80, 0x30, 0x60, 0x04, 0x01,
  0x02, 0x00, 0x20, 0x18, 0x10, 0x03, 0x01, 0x80, 0x80, 0x18, 0x08, 0x04,
  0x00, 0x80, 0xC0, 0x20, 0x0C, 0x0C, 0x01, 0x00, 0x60, 0xC0, 0x0C, 0x06,
  0x04, 0x00, 0x60, 0x60, 0x60, 0x01, 0x86, 0x06, 0x00, 0x07, 0xE0, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x1F, 0xC0, 0x00,
  0x81, 0xC3, 0x00, 0x0C, 0x18, 0x0C, 0x00, 0xC0, 0x80, 0x60, 0x04, 0x0C,
  0x01, 0x00, 0x60, 0x40, 0x08, 0x06, 0x06, 0x00, 0x40, 0x60, 0x30, 0x02,
  0x03, 0x01, 0x80, 0x10, 0x30, 0x08, 0x01, 0x83, 0x00, 0x40, 0x0C, 0x10,
  0x02, 0x00, 0x61, 0x80, 0x10, 0x02, 0x18, 0x00, 0x80, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x00, 0x80,
  0x10, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x31, 0x80, 0x30, 0x03, 0x10,
  0x01, 0x80, 0x23, 0x00, 0x08, 0x06, 0x20, 0x00, 0xC0, 0x66, 0x00, 0x06,
  0x04, 0x40, 0x00, 0x60, 0xCC, 0x00, 0x03, 0x0C, 0xC0, 0x00, 0x11, 0x8C,
  0x00, 0x01, 0xB0, 0xC0, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0xB0, 0x30, 0x00, 0x31, 0x03, 0x80, 0x0E, 0x18,
  0x0E, 0x03, 0x80, 0xC0, 0x7F, 0xE0, 0x06, 0x00, 0x70, 0x00, 0x00, 0x33,
  0x22, 0x26, 0x66, 0x44, 0xCC, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x40, 0x08, 0x03,
  0xF0, 0x18, 0x1F, 0x1E, 0x18, 0xF8, 0x03, 0xDB, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x38, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x30, 0xC6, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x1E, 0x30, 0x00, 0x06, 0xC4, 0x00, 0x01, 0x99, 0x80, 0x00,
  0xE3, 0x30, 0x00, 0x30, 0x66, 0x00, 0x0C, 0x0C, 0x80, 0x03, 0x01, 0x10,
  0x00, 0xC0, 0x26, 0x00, 0x30, 0x0C, 0xC0, 0x0C, 0x01, 0x98, 0x03, 0x00,
  0x33, 0x01, 0x80, 0x06, 0x40, 0x60, 0x00, 0x88, 0x18, 0x00, 0x13, 0x06,
  0x00, 0x06, 0x61, 0x80, 0x00, 0xCC, 0x60, 0x00, 0x11, 0x98, 0x00, 0x02,
  0x3C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x30, 0x30, 0x00, 0x04, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x03, 0x90, 0x3C, 0x21, 0xE0, 0xCF, 0x01, 0xB0, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80, 0x07,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x30, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x43, 0xF8, 0x00, 0x0C, 0xFF, 0xE0, 0x00,
  0xB8, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x3F, 0x80, 0x18, 0x7C, 0xF8, 0x06, 0x70,
  0x03, 0x01, 0x30, 0x00, 0x60, 0xD8, 0x00, 0x0C, 0x3C, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x80, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x26, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0x40, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x64, 0x00, 0x00, 0x19, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x07, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80, 0x40, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xE0,
  0x3C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x30,
  0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x01, 0x80, 0x60, 0x00, 0x40, 0x60, 0x00, 0x30, 0x60, 0x00, 0x08, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x10, 0x00, 0x00, 0x98, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x28, 0xC0, 0x00, 0x24, 0x30, 0x00, 0x66, 0x0C, 0x00, 0x63, 0x03, 0x00,
  0xE1, 0x00, 0xFF, 0xC1, 0x80, 0x0F, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x00, 0xC0, 0x3C, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x01, 0xE0,
  0x38, 0x1C, 0x00, 0xC1, 0x80, 0x03, 0x08, 0x00, 0x0C, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x01, 0x80, 0x3F,
  0x00, 0xC0, 0xC0, 0x7F, 0xC0, 0x60, 0xC0, 0x70, 0x30, 0x30, 0x40, 0x60,
  0x18, 0x18, 0x60, 0x20, 0x08, 0x0C, 0x20, 0x30, 0x04, 0x06, 0x30, 0x30,
  0x06, 0x03, 0x10, 0x18, 0x03, 0x01, 0x98, 0x18, 0x01, 0x00, 0x8C, 0x0C,
  0x00, 0x80, 0x44, 0x04, 0x00, 0xC0, 0x26, 0x06, 0x00, 0x40, 0x33, 0x03,
  0x00, 0x20, 0x19, 0x01, 0x00, 0x30, 0x0C, 0x80, 0x80, 0x18, 0x04, 0x40,
  0xC0, 0x08, 0x06, 0x60, 0x60, 0x0C, 0x03, 0x30, 0x30, 0x06, 0x01, 0x18,
  0x10, 0x07, 0x01, 0x8C, 0x08, 0x03, 0x80, 0xC6, 0x04, 0x02, 0xC0, 0xC3,
  0x03, 0x03, 0x60, 0x41, 0x81, 0x83, 0x30, 0x60, 0x40, 0x77, 0x0F, 0xE0,
  0x20, 0x1E, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x10, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0x80, 0x01, 0x80, 0x08,
  0x00, 0x30, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x40, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x10, 0x01, 0xFF, 0xF8, 0x00, 0x10, 0x01, 0xF0, 0x01, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x3C, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0E, 0x04,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x02,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x18, 0x01, 0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x70, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x3F,
  0xFC, 0x40, 0x03, 0xFF, 0xE2, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x40, 0x18, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x04, 0x03, 0x80, 0x00, 0x04, 0x07, 0x00, 0x00,
  0x04, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x0C, 0x68, 0x00, 0x00, 0x08, 0xCC, 0x00, 0x00, 0x09, 0x86, 0x00, 0x00,
  0x0B, 0x06, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x00,
  0x10, 0x01, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x20, 0x00, 0x18, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x0A, 0x01, 0x40, 0x00, 0x1E, 0x03, 0x40, 0x00, 0x36, 0x03, 0x60,
  0x00, 0x36, 0x03, 0x60, 0x00, 0x64, 0x02, 0x60, 0x00, 0x64, 0x02, 0x20,
  0x00, 0xC4, 0x02, 0x20, 0x00, 0x8C, 0x06, 0x30, 0x01, 0x8C, 0x06, 0x30,
  0x01, 0x0C, 0x06, 0x10, 0x03, 0x08, 0x04, 0x10, 0x06, 0x08, 0x04, 0x10,
  0x06, 0x18, 0x04, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x08, 0x18, 0x0C, 0x08,
  0x18, 0x10, 0x0C, 0x08, 0x10, 0x10, 0x08, 0x08, 0x30, 0x10, 0x08, 0x0C,
  0x60, 0x30, 0x08, 0x0C, 0x60, 0x30, 0x18, 0x04, 0xC0, 0x30, 0x18, 0x04,
  0x80, 0x20, 0x18, 0x05, 0x80, 0x20, 0x10, 0x07, 0x00, 0x20, 0x10, 0x07,
  0x00, 0x60, 0x10, 0x02, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x1A, 0x00,
  0x00, 0x20, 0x34, 0x00, 0x00, 0x40, 0x6C, 0x00, 0x00, 0x80, 0x88, 0x00,
  0x03, 0x01, 0x10, 0x00, 0x06, 0x02, 0x30, 0x00, 0x0C, 0x0C, 0x20, 0x00,
  0x10, 0x18, 0x60, 0x00, 0x20, 0x30, 0x40, 0x00, 0x40, 0x40, 0x80, 0x01,
  0x80, 0x81, 0x80, 0x03, 0x01, 0x01, 0x00, 0x06, 0x06, 0x02, 0x00, 0x08,
  0x0C, 0x06, 0x00, 0x10, 0x10, 0x04, 0x00, 0x20, 0x20, 0x0C, 0x00, 0xC0,
  0x40, 0x08, 0x01, 0x80, 0x80, 0x10, 0x03, 0x03, 0x00, 0x30, 0x04, 0x06,
  0x00, 0x20, 0x08, 0x08, 0x00, 0x40, 0x10, 0x10, 0x00, 0xC0, 0x60, 0x20,
  0x00, 0x80, 0xC0, 0x40, 0x01, 0x81, 0x01, 0x80, 0x01, 0x02, 0x03, 0x00,
  0x02, 0x04, 0x04, 0x00, 0x06, 0x08, 0x08, 0x00, 0x04, 0x30, 0x10, 0x00,
  0x08, 0x60, 0x60, 0x00, 0x18, 0x80, 0xC0, 0x00, 0x11, 0x01, 0x80, 0x00,
  0x32, 0x02, 0x00, 0x00, 0x2C, 0x04, 0x00, 0x00, 0x58, 0x08, 0x00, 0x00,
  0xF0, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x3C, 0x00, 0xC0,
  0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x1E, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x0E,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0C, 0x00,
  0x78, 0x00, 0x40, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0xE0, 0x04, 0x00,
  0x1C, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0x00, 0x08, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x60, 0x03,
  0x00, 0x01, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x10, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x80,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0x08, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x20, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xB0, 0x01, 0xC0, 0x02, 0xC0, 0x05, 0x00, 0x1B, 0x00, 0x14,
  0x00, 0x4C, 0x00, 0xD0, 0x01, 0x30, 0x02, 0x40, 0x0C, 0xC0, 0x19, 0x00,
  0x23, 0x00, 0x64, 0x00, 0x8C, 0x01, 0x10, 0x06, 0x30, 0x0C, 0x40, 0x10,
  0xC0, 0x31, 0x00, 0x43, 0x00, 0x84, 0x03, 0x0C, 0x06, 0x10, 0x08, 0x30,
  0x18, 0x60, 0x20, 0xC0, 0x41, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06,
  0x08, 0x0C, 0x10, 0x18, 0x20, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x84,
  0x03, 0x08, 0x06, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x62, 0x00,
  0xCC, 0x01, 0x88, 0x03, 0x30, 0x06, 0x60, 0x0C, 0x80, 0x09, 0x80, 0x36,
  0x00, 0x24, 0x00, 0xD8, 0x00, 0xB0, 0x03, 0x40, 0x02, 0xC0, 0x0F, 0x00,
  0x0A, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0A, 0x00, 0x01, 0xB0, 0x00, 0x13, 0x00,
  0x03, 0x10, 0x00, 0x61, 0x00, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x18,
  0x01, 0x80, 0x80, 0x10, 0x08, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00,
  0x40, 0xC0, 0x04, 0x08, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x63, 0x00,
  0x02, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xC6, 0x18, 0xC3, 0x18, 0x61, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x87, 0x80,
  0x0E, 0x00, 0x70, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x06, 0x07, 0x80, 0x01,
  0x83, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x60, 0x00,
  0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x84, 0x00, 0x01, 0xA1, 0x80, 0x01, 0xD8,
  0x30, 0x01, 0xC6, 0x07, 0x01, 0xE1, 0x80, 0xFF, 0xE0, 0x60, 0x07, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x81, 0xFC, 0x00, 0x61,
  0xE3, 0xC0, 0x19, 0xC0, 0x18, 0x04, 0xC0, 0x03, 0x01, 0x60, 0x00, 0x40,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x58,
  0x00, 0x30, 0x13, 0x00, 0x18, 0x0C, 0x70, 0x1C, 0x03, 0x07, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x38,
  0x03, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x08, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x98, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x1E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFC, 0x0C, 0x00, 0x78, 0x70,
  0xC0, 0x1C, 0x01, 0x8C, 0x03, 0x80, 0x0C, 0x80, 0x60, 0x00, 0x68, 0x06,
  0x00, 0x02, 0x80, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C,
  0x02, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x68, 0x01, 0x80, 0x1C, 0x80, 0x0E,
  0x07, 0x98, 0x00, 0x7F, 0xE1, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0x40, 0x00, 0x00, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x78, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0x1C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x30, 0x01, 0xE1, 0xC3, 0x00, 0x70, 0x06, 0x30, 0x0E, 0x00,
  0x33, 0x01, 0x80, 0x01, 0xA0, 0x18, 0x00, 0x0A, 0x03, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x01, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x08, 0x00, 0x0F, 0x00, 0xC0, 0x01,
  0xA0, 0x06, 0x00, 0x72, 0x00, 0x38, 0x1E, 0x20, 0x01, 0xFF, 0x86, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x04, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0xFE, 0x00, 0x40, 0xF0, 0xE0, 0x10, 0xE0, 0x0C, 0x04, 0x60,
  0x01, 0x83, 0x30, 0x00, 0x20, 0xD8, 0x00, 0x0C, 0x3C, 0x00, 0x03, 0x0A,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x1C, 0x04, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x10, 0x00, 0xE0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x02, 0x01,
  0xC0, 0x00, 0x40, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0x73, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x10, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x1F, 0x80, 0xFE,
  0x01, 0x9C, 0x38, 0x79, 0xC0, 0x6C, 0x06, 0x70, 0x18, 0x1E, 0x00, 0xF8,
  0x02, 0x07, 0x00, 0x3C, 0x00, 0xC1, 0x80, 0x0E, 0x00, 0x30, 0x60, 0x03,
  0x00, 0x0C, 0x30, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0x83, 0x00,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x00, 0x08, 0x20, 0x00, 0x80, 0x06, 0x08,
  0x00, 0x60, 0x01, 0x86, 0x00, 0x18, 0x00, 0x61, 0x80, 0x06, 0x00, 0x10,
  0x60, 0x01, 0x00, 0x04, 0x10, 0x00, 0x40, 0x01, 0x04, 0x00, 0x10, 0x00,
  0xC1, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x30, 0x00, 0x80,
  0x02, 0x08, 0x00, 0x20, 0x00, 0x82, 0x00, 0x08, 0x00, 0x20, 0x80, 0x06,
  0x00, 0x18, 0x20, 0x01, 0x80, 0x06, 0x18, 0x00, 0x60, 0x01, 0x06, 0x00,
  0x10, 0x00, 0x41, 0x00, 0x04, 0x00, 0x10, 0x40, 0x01, 0x00, 0x04, 0x10,
  0x00, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x03, 0xF8, 0x01,
  0x83, 0xC3, 0x80, 0x43, 0x80, 0x30, 0x11, 0x80, 0x06, 0x0C, 0xC0, 0x00,
  0x83, 0x40, 0x00, 0x30, 0xF0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x40, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x01, 0x80, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x81, 0xFC, 0x00, 0x18, 0xF8, 0xF0, 0x01, 0x1C, 0x01, 0x80,
  0x13, 0x00, 0x0C, 0x01, 0x60, 0x00, 0x40, 0x3C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x20, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x01,
  0x60, 0x00, 0xC0, 0x13, 0x00, 0x18, 0x03, 0x1C, 0x0F, 0x00, 0x30, 0x7F,
  0xC0, 0x03, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xC0,
  0x1E, 0x1C, 0x30, 0x1C, 0x01, 0xCC, 0x0E, 0x00, 0x32, 0x06, 0x00, 0x06,
  0x81, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x60,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x02, 0x00, 0x03, 0xC0,
  0xC0, 0x01, 0xA0, 0x18, 0x01, 0xC8, 0x03, 0x81, 0xE2, 0x00, 0x7F, 0xE1,
  0x80, 0x01, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x06, 0x01, 0xFF, 0x04, 0x0F, 0xC3, 0x04, 0x3C,
  0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x1C, 0x00, 0x70, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C,
  0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0x38, 0x00, 0x38, 0x07,
  0x80, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x08, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00,
  0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x46, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x30, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x1C, 0x30, 0x00, 0x1E, 0x0C, 0x00, 0x1B, 0x07, 0x00, 0x39,
  0x81, 0xC0, 0x70, 0x80, 0x3F, 0xF0, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x08, 0x00, 0x18, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x40, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x07, 0x80, 0x06, 0x00, 0x19, 0x00, 0x0C, 0x00, 0x32, 0x00,
  0x38, 0x00, 0x44, 0x00, 0x70, 0x01, 0x88, 0x00, 0xB0, 0x02, 0x10, 0x03,
  0x60, 0x0C, 0x20, 0x04, 0xC0, 0x18, 0x40, 0x19, 0x80, 0x20, 0xC0, 0x33,
  0x00, 0xC1, 0x80, 0x46, 0x01, 0x83, 0x01, 0x8C, 0x06, 0x06, 0x02, 0x18,
  0x0C, 0x0C, 0x0C, 0x10, 0x10, 0x18, 0x10, 0x20, 0x60, 0x30, 0x60, 0x40,
  0xC0, 0x60, 0xC0, 0x83, 0x00, 0xC1, 0x01, 0x06, 0x01, 0x86, 0x02, 0x08,
  0x03, 0x08, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x60, 0x04, 0x40, 0x19, 0x80,
  0x08, 0x80, 0x33, 0x00, 0x13, 0x00, 0x64, 0x00, 0x24, 0x00, 0xD8, 0x00,
  0x58, 0x00, 0xB0, 0x00, 0xA0, 0x01, 0x40, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x04, 0x70, 0x38, 0x00, 0x18, 0xC0, 0x38, 0x00, 0x33, 0x00, 0x18, 0x00,
  0xCC, 0x00, 0x18, 0x01, 0x98, 0x00, 0x18, 0x06, 0x20, 0x00, 0x1C, 0x38,
  0xC0, 0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_ThinItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 9, 41, 34, 12, -41 },
  { 48, 10, 12, 34, 15, -44 },
  { 63, 34, 41, 34, 1, -41 },
  { 238, 28, 53, 34, 4, -47 },
  { 424, 29, 43, 34, 3, -42 },
  { 580, 28, 43, 34, 3, -42 },
  { 731, 4, 12, 34, 17, -44 },
  { 737, 17, 59, 34, 10, -46 },
  { 863, 18, 59, 34, 5, -46 },
  { 996, 24, 22, 34, 8, -41 },
  { 1062, 27, 30, 34, 4, -34 },
  { 1164, 6, 12, 34, 7, -5 },
  { 1173, 20, 2, 34, 7, -20 },
  { 1178, 4, 3, 34, 13, -3 },
  { 1180, 26, 45, 34, 5, -41 },
  { 1327, 27, 43, 34, 4, -42 },
  { 1473, 15, 41, 34, 9, -41 },
  { 1550, 27, 42, 34, 1, -42 },
  { 1692, 29, 43, 34, 1, -42 },
  { 1848, 28, 41, 34, 2, -41 },
  { 1992, 28, 42, 34, 5, -41 },
  { 2139, 26, 43, 34, 3, -42 },
  { 2279, 26, 41, 34, 7, -41 },
  { 2413, 29, 43, 34, 3, -42 },
  { 2569, 25, 43, 34, 6, -42 },
  { 2704, 8, 28, 34, 15, -28 },
  { 2732, 11, 35, 34, 12, -28 },
  { 2781, 26, 23, 34, 5, -30 },
  { 2856, 27, 13, 34, 4, -25 },
  { 2900, 25, 22, 34, 4, -30 },
  { 2969, 21, 42, 34, 9, -42 },
  { 3080, 33, 42, 34, 1, -42 },
  { 3254, 28, 41, 34, 0, -41 },
  { 3398, 28, 41, 34, 3, -41 },
  { 3542, 28, 43, 34, 4, -42 },
  { 3693, 29, 41, 34, 3, -41 },
  { 3842, 30, 41, 34, 3, -41 },
  { 3996, 30, 41, 34, 3, -41 },
  { 4150, 29, 43, 34, 3, -42 },
  { 4306, 31, 41, 34, 2, -41 },
  { 4465, 29, 41, 34, 3, -41 },
  { 4614, 30, 42, 34, 2, -41 },
  { 4772, 32, 41, 34, 3, -41 },
  { 4936, 23, 41, 34, 4, -41 },
  { 5054, 32, 41, 34, 2, -41 },
  { 5218, 31, 41, 34, 2, -41 },
  { 5377, 27, 43, 34, 4, -42 },
  { 5523, 29, 41, 34, 4, -41 },
  { 5672, 29, 49, 34, 3, -42 },
  { 5850, 29, 41, 34, 3, -41 },
  { 5999, 29, 43, 34, 3, -42 },
  { 6155, 28, 41, 34, 7, -41 },
  { 6299, 29, 42, 34, 4, -41 },
  { 6452, 27, 41, 34, 7, -41 },
  { 6591, 30, 41, 34, 6, -41 },
  { 6745, 34, 41, 34, 1, -41 },
  { 6920, 28, 41, 34, 7, -41 },
  { 7064, 31, 41, 34, 1, -41 },
  { 7223, 17, 56, 34, 9, -47 },
  { 7342, 11, 45, 34, 12, -41 },
  { 7404, 17, 56, 34, 8, -47 },
  { 7523, 20, 22, 34, 7, -41 },
  { 7578, 24, 2, 34, 2, 0 },
  { 7584, 5, 8, 34, 18, -43 },
  { 7589, 26, 32, 34, 3, -31 },
  { 7693, 26, 45, 34, 3, -44 },
  { 7840, 25, 32, 34, 4, -31 },
  { 7940, 28, 45, 34, 4, -44 },
  { 8098, 26, 32, 34, 4, -31 },
  { 8202, 27, 44, 34, 8, -44 },
  { 8351, 28, 43, 34, 2, -31 },
  { 8502, 26, 44, 34, 3, -44 },
  { 8645, 23, 41, 34, 4, -41 },
  { 8763, 26, 53, 34, 0, -41 },
  { 8936, 27, 44, 34, 4, -44 },
  { 9085, 23, 44, 34, 4, -44 },
  { 9212, 34, 31, 34, -1, -31 },
  { 9344, 26, 31, 34, 3, -31 },
  { 9445, 27, 32, 34, 3, -31 },
  { 9553, 28, 43, 34, 1, -31 },
  { 9704, 26, 43, 34, 4, -31 },
  { 9844, 24, 31, 34, 8, -31 },
  { 9937, 26, 32, 34, 4, -31 },
  { 10041, 21, 40, 34, 8, -39 },
  { 10146, 25, 32, 34, 5, -31 },
  { 10246, 28, 31, 34, 5, -31 },
  { 10355, 31, 31, 34, 4, -31 },
  { 10476, 31, 31, 34, 1, -31 },
  { 10597, 35, 43, 34, -1, -31 },
  { 10786, 30, 31, 34, 1, -31 },
  { 10903, 22, 57, 34, 9, -45 },
  { 11060, 9, 49, 34, 12, -41 },
  { 11116, 22, 57, 34, 5, -45 },
  { 11273, 31, 9, 34, 1, -22 },
};

const GFXfont RobotoMono_ThinItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic58pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_THINITALIC58PT7B_H_
