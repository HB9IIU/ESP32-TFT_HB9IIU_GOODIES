#ifndef _ROBOTOMONO_THINITALIC43PT7B_H_
#define _ROBOTOMONO_THINITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x63, 0x42, 0x42, 0x42, 0x42, 0xC6, 0x84,
  0x84, 0x00, 0x04, 0x04, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x40, 0x00,
  0x40, 0x20, 0x00, 0x20, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x10, 0x08, 0x00,
  0x08, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x00, 0x02, 0x03, 0x00,
  0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x40,
  0x00, 0x40, 0x20, 0x00, 0x20, 0x20, 0x07, 0xFF, 0xFF, 0xC0, 0x10, 0x08,
  0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x00, 0x02, 0x02,
  0x00, 0x02, 0x01, 0x00, 0x01, 0x01, 0x80, 0x00, 0x80, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x3F, 0x00, 0x0E, 0x1C, 0x03, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00,
  0x30, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x11, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x4C, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0x20, 0x03,
  0x01, 0x80, 0xC0, 0x0F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x03, 0x98, 0x00, 0x20, 0x80, 0x04,
  0x04, 0x00, 0xC0, 0x40, 0x68, 0x04, 0x0C, 0x80, 0x40, 0x88, 0x0C, 0x10,
  0x80, 0x83, 0x08, 0x08, 0x20, 0x81, 0x84, 0x08, 0x10, 0xC0, 0xC2, 0x08,
  0x07, 0xC1, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x1C, 0x01, 0x87, 0x60, 0x10, 0xC3, 0x02, 0x18, 0x10, 0x61, 0x01, 0x04,
  0x10, 0x10, 0x83, 0x01, 0x10, 0x20, 0x13, 0x02, 0x01, 0x20, 0x20, 0x34,
  0x02, 0x02, 0x00, 0x30, 0x60, 0x01, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x03, 0x18, 0x00, 0x20, 0x60, 0x02, 0x01, 0x00, 0x30, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x30, 0x02, 0x01, 0x00, 0x10, 0x10,
  0x00, 0x83, 0x00, 0x02, 0x30, 0x00, 0x13, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x68, 0x00, 0x06, 0x60, 0x00, 0x41, 0x00, 0x04, 0x04, 0x02,
  0x60, 0x30, 0x32, 0x00, 0x81, 0x20, 0x02, 0x09, 0x00, 0x10, 0xC8, 0x00,
  0x44, 0xC0, 0x03, 0x66, 0x00, 0x0E, 0x10, 0x00, 0x20, 0x80, 0x07, 0x82,
  0x00, 0x64, 0x18, 0x0E, 0x10, 0x3F, 0xC0, 0xC0, 0x55, 0xEA, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x0C, 0x04, 0x1D, 0xE2, 0x1C, 0x0F, 0xB8,
  0x00, 0x70, 0x00, 0x14, 0x00, 0x09, 0x80, 0x04, 0x20, 0x03, 0x04, 0x01,
  0x81, 0x80, 0xC0, 0x20, 0x60, 0x04, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xF0, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x08, 0x84, 0x21, 0x11, 0x98, 0xFF, 0xFF, 0xFF, 0xFC, 0xD8,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x0C, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x04, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x32, 0x00, 0x05, 0x20, 0x01,
  0x92, 0x00, 0x31, 0x20, 0x06, 0x14, 0x00, 0xC3, 0x40, 0x10, 0x24, 0x02,
  0x02, 0x40, 0x40, 0x24, 0x18, 0x02, 0xC3, 0x00, 0x28, 0x60, 0x04, 0x8C,
  0x00, 0x49, 0x00, 0x04, 0xA0, 0x00, 0xCC, 0x00, 0x08, 0x80, 0x00, 0x84,
  0x00, 0x10, 0x40, 0x03, 0x06, 0x00, 0x60, 0x20, 0x0C, 0x01, 0x01, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x20, 0x18, 0x1D, 0x0E, 0x26, 0x05, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x3E,
  0x00, 0x0C, 0x18, 0x03, 0x00, 0x40, 0x60, 0x02, 0x04, 0x00, 0x30, 0x80,
  0x01, 0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0x06, 0x00, 0x60, 0x08,
  0x04, 0x00, 0x20, 0x60, 0x01, 0x06, 0x00, 0x0C, 0x20, 0x00, 0x21, 0x00,
  0x01, 0x10, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x46, 0x00, 0x02,
  0x10, 0x00, 0x20, 0xC0, 0x03, 0x02, 0x00, 0x30, 0x0C, 0x07, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x19, 0x00, 0x01, 0x88, 0x00,
  0x18, 0x40, 0x00, 0x82, 0x00, 0x08, 0x10, 0x00, 0x81, 0x80, 0x0C, 0x08,
  0x00, 0xC0, 0x40, 0x04, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x40,
  0x0C, 0x06, 0x00, 0x40, 0x60, 0x02, 0x02, 0x00, 0x10, 0x20, 0x00, 0x83,
  0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x3F, 0xC0, 0x0F, 0x03,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x80,
  0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x87,
  0xF0, 0x27, 0x06, 0x12, 0x00, 0x45, 0x00, 0x09, 0x80, 0x02, 0xC0, 0x00,
  0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x44, 0x00, 0x31, 0x00,
  0x08, 0x20, 0x04, 0x06, 0x06, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xC3, 0x80, 0x18, 0x03, 0x00, 0xC0,
  0x06, 0x02, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0xC2, 0x00, 0x03,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x83, 0x00, 0x04, 0x04,
  0x00, 0x20, 0x08, 0x03, 0x00, 0x1C, 0x78, 0x00, 0x3F, 0x80, 0x03, 0x01,
  0x80, 0x30, 0x03, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x31,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x00,
  0x00, 0x84, 0x00, 0x04, 0x18, 0x00, 0x30, 0x30, 0x01, 0x80, 0x60, 0x18,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x70, 0xE0, 0x18, 0x06, 0x04,
  0x00, 0x41, 0x80, 0x0C, 0x60, 0x00, 0x88, 0x00, 0x13, 0x00, 0x03, 0x40,
  0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x00, 0xB0, 0x00, 0x12, 0x00, 0x06, 0x40, 0x01, 0x44, 0x00, 0x50, 0xC0,
  0x12, 0x0C, 0x0C, 0x40, 0xFE, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x03, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x30, 0x20, 0x20, 0x20, 0x40, 0xC0, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x20, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x1C, 0x30, 0x60, 0x11, 0x00, 0x36, 0x00, 0x28, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x02, 0x06, 0x00, 0x03, 0x04, 0x02, 0x01, 0x0C, 0x1F, 0x81, 0x18, 0x30,
  0x41, 0x10, 0x60, 0x41, 0x30, 0x40, 0x41, 0x20, 0x80, 0x81, 0x20, 0x80,
  0x81, 0x41, 0x00, 0x81, 0x41, 0x01, 0x83, 0x41, 0x01, 0x02, 0xC2, 0x01,
  0x02, 0x82, 0x01, 0x02, 0x82, 0x02, 0x06, 0x82, 0x02, 0x04, 0x82, 0x06,
  0x04, 0x82, 0x0E, 0x08, 0x82, 0x0A, 0x18, 0x82, 0x32, 0x30, 0xC1, 0xE1,
  0xE0, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x05, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00,
  0x32, 0x00, 0x01, 0x18, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00, 0x0C, 0x10,
  0x00, 0x40, 0x80, 0x06, 0x04, 0x00, 0x20, 0x20, 0x03, 0x01, 0x80, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0xC0, 0x08, 0x04, 0x00, 0x40,
  0x60, 0x02, 0x03, 0xFF, 0xF8, 0x30, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00,
  0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x00, 0xA0,
  0x00, 0x07, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0x00,
  0x18, 0x08, 0x00, 0x60, 0x40, 0x01, 0x02, 0x00, 0x04, 0x30, 0x00, 0x21,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00,
  0x61, 0x80, 0x06, 0x08, 0x00, 0x60, 0x40, 0x1C, 0x03, 0xFF, 0xC0, 0x10,
  0x01, 0x80, 0x80, 0x02, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x03,
  0x10, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00,
  0x03, 0x10, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x30, 0x60, 0x07, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x0C, 0x00, 0xC0, 0x10, 0x0C,
  0x00, 0x40, 0x40, 0x03, 0x04, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02,
  0x20, 0x00, 0x19, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x12, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x10,
  0x00, 0x40, 0x80, 0x04, 0x02, 0x00, 0x40, 0x08, 0x0C, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x20, 0x00, 0x40, 0x80, 0x01, 0x82, 0x00, 0x02, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x21, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x10, 0x00,
  0x0C, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80,
  0x00, 0xC4, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x02,
  0x04, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x80, 0x0C, 0x02, 0x00, 0xE0, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x06, 0x0C, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x40, 0xC0, 0x03,
  0x04, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x03, 0x20, 0x00, 0x09, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x01, 0xFF, 0x20, 0x00,
  0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80, 0x01,
  0x02, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x02, 0x00, 0x03,
  0x02, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x04,
  0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x08,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x08, 0x1F, 0xFF, 0xF8, 0x10, 0x00, 0x08,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20, 0x00, 0x10,
  0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20,
  0x40, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x30, 0x10, 0x00,
  0x80, 0x60, 0x0C, 0x00, 0xC0, 0x60, 0x01, 0xFE, 0x00, 0x00, 0x02, 0x00,
  0x03, 0x02, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x04, 0x00,
  0x30, 0x04, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x08, 0x03,
  0x00, 0x08, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x13, 0x40, 0x00, 0x16, 0x20,
  0x00, 0x1C, 0x30, 0x00, 0x18, 0x10, 0x00, 0x30, 0x18, 0x00, 0x20, 0x08,
  0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x60, 0x01, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x40, 0x00,
  0x40, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0xFE, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00,
  0xE0, 0xA0, 0x01, 0x41, 0x60, 0x06, 0x82, 0x40, 0x09, 0x04, 0x80, 0x22,
  0x19, 0x00, 0x48, 0x22, 0x01, 0x10, 0x44, 0x06, 0x20, 0x84, 0x08, 0x41,
  0x08, 0x30, 0x82, 0x10, 0x43, 0x0C, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x48, 0x10, 0x40, 0xB0, 0x20, 0x81, 0x40, 0x41, 0x03, 0x81, 0x86, 0x06,
  0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x20, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04,
  0x10, 0x00, 0x08, 0x20, 0x00, 0x30, 0x00, 0x02, 0x00, 0x03, 0x02, 0x00,
  0x02, 0x05, 0x00, 0x02, 0x05, 0x00, 0x02, 0x05, 0x00, 0x02, 0x04, 0x80,
  0x02, 0x04, 0x80, 0x04, 0x04, 0x80, 0x04, 0x08, 0x40, 0x04, 0x08, 0x40,
  0x04, 0x08, 0x20, 0x04, 0x08, 0x20, 0x04, 0x08, 0x20, 0x08, 0x18, 0x10,
  0x08, 0x10, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08,
  0x18, 0x10, 0x04, 0x10, 0x30, 0x04, 0x10, 0x20, 0x04, 0x10, 0x20, 0x02,
  0x10, 0x20, 0x02, 0x10, 0x20, 0x02, 0x30, 0x20, 0x01, 0x20, 0x40, 0x01,
  0x20, 0x40, 0x00, 0xA0, 0x40, 0x00, 0xA0, 0x40, 0x00, 0xA0, 0x40, 0x00,
  0x60, 0xC0, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x0C, 0x18, 0x03, 0x00, 0xC0,
  0x60, 0x06, 0x0C, 0x00, 0x20, 0x80, 0x03, 0x10, 0x00, 0x11, 0x00, 0x01,
  0x20, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80,
  0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x10, 0x40, 0x03, 0x04,
  0x00, 0x20, 0x20, 0x0C, 0x01, 0x01, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x40, 0x06, 0x01, 0x00, 0x04, 0x08, 0x00, 0x08,
  0x20, 0x00, 0x20, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60,
  0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x10, 0x40, 0x00,
  0xC1, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x20, 0x03, 0x80, 0xFF, 0xF8, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0x83, 0x00, 0x18, 0x02, 0x00, 0xC0, 0x04, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x03, 0x10, 0x00,
  0x04, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x60, 0x00, 0x05,
  0x00, 0x00, 0x14, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x03, 0x30, 0x00, 0x08, 0x40, 0x00, 0x61, 0x00, 0x01, 0x06,
  0x00, 0x08, 0x08, 0x00, 0x40, 0x30, 0x03, 0x00, 0x60, 0x30, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x40, 0x06, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x10, 0x00, 0x20, 0x40,
  0x00, 0x81, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00,
  0x82, 0x00, 0x06, 0x08, 0x00, 0x10, 0x60, 0x00, 0x81, 0x00, 0x04, 0x04,
  0x00, 0x20, 0x10, 0x07, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x40, 0x0C, 0x01,
  0x00, 0x20, 0x06, 0x00, 0x80, 0x08, 0x02, 0x00, 0x20, 0x08, 0x00, 0x40,
  0x20, 0x01, 0x01, 0x00, 0x06, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40,
  0x00, 0xC1, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0x83, 0x80, 0x18, 0x03, 0x00, 0x80, 0x06, 0x04, 0x00, 0x08, 0x30, 0x00,
  0x20, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x30, 0x01, 0x80, 0x60, 0x1C, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x20,
  0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x21, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42,
  0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x31, 0x80, 0x00, 0x84, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00,
  0x80, 0x20, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20,
  0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x10, 0x40, 0x00, 0x83, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x06, 0x01, 0x00, 0x10, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00,
  0x20, 0x60, 0x01, 0x02, 0x00, 0x08, 0x30, 0x00, 0x61, 0x00, 0x01, 0x18,
  0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x20, 0x06, 0x00,
  0x80, 0x28, 0x02, 0x00, 0xA0, 0x18, 0x02, 0x80, 0x60, 0x12, 0x03, 0x80,
  0x48, 0x0A, 0x01, 0x20, 0x2C, 0x0C, 0x81, 0xB0, 0x22, 0x04, 0xC0, 0x88,
  0x11, 0x02, 0x20, 0xC4, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x61,
  0x08, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82, 0x20, 0x44, 0x08, 0x81, 0x10,
  0x22, 0x04, 0x40, 0x90, 0x13, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x28,
  0x05, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x40, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x60, 0x08, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x01, 0x83, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x40, 0x00, 0x80, 0x10,
  0x00, 0xC0, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x01, 0x00, 0x40, 0x00,
  0x40, 0x40, 0x00, 0x20, 0x60, 0x00, 0x18, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x01,
  0x00, 0x04, 0x00, 0x80, 0x04, 0x00, 0x60, 0x04, 0x00, 0x10, 0x06, 0x00,
  0x0C, 0x02, 0x00, 0x02, 0x02, 0x00, 0x01, 0x82, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x08, 0x80, 0x00, 0xC6, 0x00, 0x04,
  0x10, 0x00, 0x40, 0x80, 0x04, 0x06, 0x00, 0x60, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x06, 0x03, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x06, 0x18, 0x00,
  0x10, 0x80, 0x00, 0x88, 0x00, 0x06, 0xC0, 0x00, 0x14, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xFC,
  0x0F, 0xC0, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20,
  0x20, 0x20, 0x20, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08,
  0x08, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03,
  0x01, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x40, 0x06, 0x80, 0x09, 0x00, 0x22, 0x00, 0x46, 0x01, 0x04,
  0x06, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x61, 0x00, 0x42, 0x00, 0x88,
  0x01, 0x30, 0x03, 0xC0, 0x02, 0xFF, 0xFF, 0x80, 0x84, 0x62, 0x31, 0x00,
  0x7F, 0x00, 0x18, 0x18, 0x06, 0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x21,
  0x80, 0x02, 0x10, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x3F, 0xE0, 0x3F, 0x02, 0x0C, 0x00, 0x43, 0x00, 0x04, 0x20, 0x00,
  0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0xC0, 0x01, 0x84, 0x00,
  0x38, 0x40, 0x06, 0x83, 0x01, 0x88, 0x1F, 0xE0, 0x80, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x87, 0xE0, 0x09, 0xC1,
  0x80, 0xB0, 0x0C, 0x0E, 0x00, 0x40, 0xC0, 0x02, 0x18, 0x00, 0x21, 0x00,
  0x02, 0x10, 0x00, 0x21, 0x00, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x20,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x42,
  0x00, 0x04, 0x40, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x05, 0x00, 0x60,
  0x48, 0x0C, 0x0C, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x70, 0x60, 0x18, 0x02,
  0x06, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x01,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x88, 0x00, 0x31,
  0x00, 0x04, 0x20, 0x01, 0x82, 0x00, 0x60, 0x30, 0x38, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x07, 0xE1, 0x00, 0xC1, 0x88, 0x0C, 0x02, 0x40, 0x80, 0x0A, 0x08, 0x00,
  0x70, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x10,
  0x00, 0x10, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02,
  0x10, 0x00, 0x10, 0x80, 0x01, 0x84, 0x00, 0x08, 0x30, 0x00, 0x40, 0x80,
  0x06, 0x04, 0x00, 0x30, 0x10, 0x06, 0x80, 0xC0, 0x6C, 0x01, 0xFC, 0x40,
  0x00, 0xFE, 0x00, 0x70, 0x60, 0x18, 0x02, 0x06, 0x00, 0x21, 0x80, 0x04,
  0x60, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x83,
  0x00, 0x30, 0x30, 0x18, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF3,
  0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x10, 0x18, 0x31, 0x03,
  0x00, 0x90, 0x40, 0x05, 0x08, 0x00, 0x70, 0x80, 0x02, 0x10, 0x00, 0x21,
  0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x66, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00,
  0x86, 0x00, 0x08, 0x20, 0x01, 0x82, 0x00, 0x18, 0x10, 0x06, 0x81, 0x80,
  0xC8, 0x07, 0xF1, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x80, 0x0C, 0x04, 0x01, 0x80, 0x30, 0x70, 0x01,
  0xFC, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x83, 0xF0, 0x08, 0xE0, 0xC0, 0x98, 0x06, 0x0A, 0x00, 0x21, 0x40,
  0x02, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x31, 0x00, 0x02, 0x30,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x62,
  0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0xC4, 0x00, 0x08, 0xC0, 0x00, 0x88, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x08, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x03, 0x08, 0x00, 0x60,
  0x80, 0x08, 0x18, 0x03, 0x01, 0x00, 0x60, 0x10, 0x0C, 0x01, 0x03, 0x00,
  0x10, 0x60, 0x01, 0x0C, 0x00, 0x31, 0x00, 0x02, 0x70, 0x00, 0x2D, 0x80,
  0x03, 0x0C, 0x00, 0x20, 0x40, 0x02, 0x02, 0x00, 0x60, 0x30, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x04, 0x00, 0xC0, 0x40, 0x06, 0x0C, 0x00, 0x20, 0x80,
  0x03, 0x08, 0x00, 0x18, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x01, 0xFF, 0xFF,
  0x19, 0xF0, 0x7C, 0x16, 0x08, 0xC2, 0x1C, 0x05, 0x01, 0x18, 0x06, 0x01,
  0x10, 0x04, 0x01, 0x10, 0x04, 0x01, 0x20, 0x04, 0x01, 0x20, 0x0C, 0x01,
  0x20, 0x08, 0x01, 0x20, 0x08, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x02,
  0x40, 0x08, 0x02, 0x40, 0x18, 0x02, 0x40, 0x10, 0x02, 0x40, 0x10, 0x04,
  0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0x80, 0x10, 0x04, 0x80, 0x20, 0x04,
  0x80, 0x20, 0x04, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x08, 0x3F, 0x00,
  0x8E, 0x0C, 0x09, 0x80, 0x61, 0xA0, 0x02, 0x14, 0x00, 0x21, 0x80, 0x02,
  0x18, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00, 0x08, 0x40,
  0x00, 0x8C, 0x00, 0x08, 0x80, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x18, 0x18,
  0x06, 0x00, 0xC0, 0xC0, 0x06, 0x08, 0x00, 0x21, 0x00, 0x03, 0x30, 0x00,
  0x12, 0x00, 0x01, 0x60, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x40,
  0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x82, 0x00, 0x10, 0x30, 0x02, 0x01,
  0x80, 0xC0, 0x07, 0xF8, 0x00, 0x04, 0x3F, 0x00, 0x4E, 0x0C, 0x05, 0x80,
  0x60, 0x70, 0x02, 0x0E, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x62,
  0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x28, 0x03, 0x02, 0xC0, 0x60,
  0x63, 0xF8, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFC, 0x20, 0x60, 0xE4, 0x18, 0x04, 0x84, 0x00, 0x51, 0x80,
  0x0E, 0x60, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00,
  0x09, 0x00, 0x03, 0x60, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x0C, 0x80, 0x01, 0x18, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01,
  0x82, 0x00, 0xD0, 0x60, 0x32, 0x03, 0xF8, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x08, 0x1F, 0xC6, 0x38, 0x01, 0x18, 0x00,
  0x48, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0xE0, 0x30, 0x30, 0x03, 0x0C, 0x00, 0x31, 0x00, 0x02, 0x20, 0x00, 0x44,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xD0, 0x00, 0x12, 0x00, 0x02, 0x60, 0x00, 0xC6, 0x00, 0x30, 0x60,
  0x1C, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x3F, 0xFF, 0x81, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x10,
  0x00, 0x31, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x22,
  0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04,
  0x60, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00,
  0x84, 0x00, 0x08, 0xC0, 0x01, 0x84, 0x00, 0x18, 0x40, 0x03, 0x04, 0x00,
  0x70, 0x60, 0x0D, 0x03, 0x03, 0x90, 0x1F, 0xE3, 0x00, 0x80, 0x00, 0x1C,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0xC6, 0x00, 0x08,
  0x20, 0x01, 0x82, 0x00, 0x10, 0x20, 0x02, 0x03, 0x00, 0x20, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x81, 0x80, 0x08, 0x10, 0x00, 0x82,
  0x00, 0x08, 0x20, 0x00, 0xC4, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x07,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x80, 0x10, 0x07, 0x80, 0x60,
  0x0B, 0x00, 0xC0, 0x36, 0x01, 0x80, 0x44, 0x05, 0x00, 0x88, 0x0A, 0x03,
  0x10, 0x34, 0x04, 0x20, 0x48, 0x08, 0x41, 0x98, 0x20, 0x82, 0x30, 0x41,
  0x04, 0x21, 0x82, 0x10, 0x42, 0x04, 0x20, 0x84, 0x08, 0xC1, 0x10, 0x11,
  0x02, 0x20, 0x22, 0x04, 0xC0, 0x48, 0x09, 0x00, 0x90, 0x12, 0x01, 0x40,
  0x28, 0x02, 0x80, 0x50, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x18, 0x18, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x10, 0x06, 0x00, 0x30, 0x18, 0x00, 0x20, 0x60, 0x00, 0x21,
  0x80, 0x00, 0x66, 0x00, 0x00, 0x48, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x09, 0x80, 0x00, 0x31, 0x00, 0x00, 0xC3, 0x00,
  0x03, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x04, 0x03,
  0x00, 0x04, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x18, 0x00, 0x04, 0x02, 0x00,
  0x02, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x02,
  0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06,
  0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x00, 0x02, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x0F, 0x80,
  0x02, 0x60, 0xC0, 0x05, 0x80, 0xC0, 0x12, 0x00, 0xC0, 0x6C, 0x00, 0xC0,
  0x90, 0x00, 0xEE, 0x00, 0x00, 0x70, 0x00,
};

const GFXglyph RobotoMono_ThinItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 8, 8, 25, 11, -32 },
  { 37, 25, 31, 25, 1, -31 },
  { 134, 20, 39, 25, 3, -35 },
  { 232, 20, 31, 25, 3, -31 },
  { 310, 21, 31, 25, 2, -31 },
  { 392, 2, 8, 25, 13, -32 },
  { 394, 12, 44, 25, 8, -34 },
  { 460, 13, 44, 25, 4, -34 },
  { 532, 18, 17, 25, 6, -31 },
  { 571, 20, 22, 25, 3, -25 },
  { 626, 5, 8, 25, 5, -3 },
  { 631, 15, 2, 25, 5, -15 },
  { 635, 3, 2, 25, 10, -2 },
  { 636, 19, 34, 25, 4, -31 },
  { 717, 20, 31, 25, 3, -31 },
  { 795, 11, 31, 25, 7, -31 },
  { 838, 20, 31, 25, 1, -31 },
  { 916, 21, 31, 25, 1, -31 },
  { 998, 21, 31, 25, 1, -31 },
  { 1080, 21, 31, 25, 4, -31 },
  { 1162, 18, 31, 25, 3, -31 },
  { 1232, 20, 31, 25, 5, -31 },
  { 1310, 22, 31, 25, 2, -31 },
  { 1396, 19, 31, 25, 4, -31 },
  { 1470, 6, 20, 25, 11, -20 },
  { 1485, 8, 25, 25, 9, -20 },
  { 1510, 20, 17, 25, 3, -22 },
  { 1553, 20, 10, 25, 3, -19 },
  { 1578, 19, 17, 25, 3, -23 },
  { 1619, 15, 31, 25, 7, -31 },
  { 1678, 24, 31, 25, 1, -31 },
  { 1771, 21, 31, 25, 0, -31 },
  { 1853, 21, 31, 25, 2, -31 },
  { 1935, 21, 31, 25, 3, -31 },
  { 2017, 22, 31, 25, 2, -31 },
  { 2103, 22, 31, 25, 2, -31 },
  { 2189, 23, 31, 25, 2, -31 },
  { 2279, 21, 31, 25, 3, -31 },
  { 2361, 24, 31, 25, 1, -31 },
  { 2454, 22, 31, 25, 2, -31 },
  { 2540, 22, 31, 25, 2, -31 },
  { 2626, 24, 31, 25, 2, -31 },
  { 2719, 17, 31, 25, 3, -31 },
  { 2785, 23, 31, 25, 2, -31 },
  { 2875, 24, 31, 25, 1, -31 },
  { 2968, 20, 31, 25, 3, -31 },
  { 3046, 22, 31, 25, 3, -31 },
  { 3132, 22, 37, 25, 2, -31 },
  { 3234, 22, 31, 25, 2, -31 },
  { 3320, 22, 31, 25, 2, -31 },
  { 3406, 21, 31, 25, 5, -31 },
  { 3488, 22, 31, 25, 3, -31 },
  { 3574, 21, 31, 25, 5, -31 },
  { 3656, 22, 31, 25, 5, -31 },
  { 3742, 25, 31, 25, 1, -31 },
  { 3839, 21, 31, 25, 5, -31 },
  { 3921, 22, 31, 25, 1, -31 },
  { 4007, 12, 42, 25, 7, -35 },
  { 4070, 8, 34, 25, 9, -31 },
  { 4104, 13, 42, 25, 6, -35 },
  { 4173, 15, 17, 25, 5, -31 },
  { 4205, 17, 1, 25, 2, 0 },
  { 4208, 4, 6, 25, 13, -32 },
  { 4211, 20, 23, 25, 2, -23 },
  { 4269, 20, 32, 25, 2, -32 },
  { 4349, 19, 23, 25, 3, -23 },
  { 4404, 21, 32, 25, 3, -32 },
  { 4488, 19, 23, 25, 3, -23 },
  { 4543, 20, 33, 25, 6, -33 },
  { 4626, 20, 32, 25, 2, -23 },
  { 4706, 20, 32, 25, 2, -32 },
  { 4786, 17, 31, 25, 3, -31 },
  { 4852, 20, 40, 25, 0, -31 },
  { 4952, 20, 32, 25, 3, -32 },
  { 5032, 17, 32, 25, 3, -32 },
  { 5100, 24, 23, 25, 0, -23 },
  { 5169, 20, 23, 25, 2, -23 },
  { 5227, 20, 23, 25, 2, -23 },
  { 5285, 20, 32, 25, 1, -23 },
  { 5365, 19, 32, 25, 3, -23 },
  { 5441, 18, 23, 25, 6, -23 },
  { 5493, 19, 23, 25, 3, -23 },
  { 5548, 15, 29, 25, 6, -29 },
  { 5603, 20, 23, 25, 3, -23 },
  { 5661, 20, 23, 25, 4, -23 },
  { 5719, 23, 23, 25, 3, -23 },
  { 5786, 23, 23, 25, 1, -23 },
  { 5853, 26, 32, 25, -1, -23 },
  { 5957, 22, 23, 25, 1, -23 },
  { 6021, 16, 43, 25, 7, -34 },
  { 6107, 7, 37, 25, 9, -31 },
  { 6140, 16, 43, 25, 4, -34 },
  { 6226, 23, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_ThinItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic43pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_THINITALIC43PT7B_H_
