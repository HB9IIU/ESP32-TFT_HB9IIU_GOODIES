#ifndef _ROBOTOMONO_THINITALIC8PT7B_H_
#define _ROBOTOMONO_THINITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x29, 0x96, 0xAE, 0x50, 0x2E, 0xC7, 0x6A, 0x4B, 0xE3,
  0x73, 0x25, 0x24, 0xBF, 0xC0, 0x6A, 0x49, 0x22, 0x55, 0x5A, 0x5F, 0x80,
  0x22, 0xF2, 0xC0, 0xE0, 0x00, 0x25, 0x29, 0x00, 0x76, 0xFB, 0xC0, 0x75,
  0x50, 0x79, 0x12, 0x4F, 0x75, 0x13, 0x9E, 0x13, 0x55, 0xA2, 0x78, 0xC2,
  0xAE, 0x34, 0xF9, 0x9F, 0xF2, 0x24, 0x48, 0x35, 0x57, 0x9F, 0x76, 0xD7,
  0x80, 0x20, 0x30, 0x71, 0x80, 0xFC, 0x61, 0xE0, 0x74, 0xA0, 0x00, 0x33,
  0x77, 0xAF, 0x70, 0x22, 0x55, 0xB9, 0x75, 0x5B, 0x9F, 0x76, 0x4B, 0xC0,
  0x65, 0x59, 0x9E, 0x7A, 0x11, 0x68, 0x78, 0x7A, 0x11, 0x68, 0x40, 0x35,
  0x8B, 0x9F, 0x4A, 0x63, 0xE9, 0x48, 0x72, 0x22, 0x2E, 0x11, 0x11, 0x9E,
  0x4A, 0x99, 0x49, 0x48, 0x92, 0x49, 0xC0, 0x4A, 0x95, 0x69, 0x48, 0x4A,
  0x6B, 0x6B, 0x48, 0x35, 0x99, 0x9F, 0xE9, 0x9E, 0x88, 0x35, 0x99, 0x9F,
  0x10, 0x75, 0x56, 0x99, 0x35, 0x43, 0x9F, 0xF4, 0x44, 0x44, 0x99, 0x9A,
  0xAE, 0x99, 0xAA, 0xC8, 0xDD, 0xDA, 0xAA, 0x4A, 0x88, 0x45, 0x48, 0x9A,
  0xA4, 0x48, 0x71, 0x22, 0x4F, 0x69, 0x29, 0x24, 0xFE, 0x64, 0xA4, 0x96,
  0x4A, 0x80, 0xF0, 0x80, 0x77, 0x9F, 0x46, 0x59, 0x9F, 0xF2, 0x70, 0x2E,
  0xDB, 0xC0, 0xFE, 0x70, 0x7E, 0x44, 0x88, 0x79, 0x9F, 0x1E, 0x46, 0x59,
  0x99, 0x14, 0x22, 0x2F, 0x16, 0x12, 0x22, 0x2C, 0x92, 0xED, 0x40, 0x72,
  0x22, 0x2F, 0xFD, 0x6B, 0x60, 0x79, 0x99, 0x79, 0x9F, 0x79, 0x9F, 0x88,
  0xF6, 0xF2, 0x40, 0xF2, 0x40, 0xF8, 0xF0, 0xE9, 0x4C, 0xB6, 0xF0, 0xBA,
  0xC8, 0xDE, 0xAC, 0x52, 0x69, 0x8A, 0x98, 0x84, 0x40, 0x72, 0x4F, 0x29,
  0x44, 0x92, 0xFE, 0x49, 0x14, 0x94, 0xF0,
};

const GFXglyph RobotoMono_ThinItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 1, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 4, 6, 5, 0, -6 },
  { 13, 4, 6, 5, 0, -6 },
  { 16, 1, 2, 5, 2, -6 },
  { 17, 3, 8, 5, 1, -6 },
  { 20, 2, 8, 5, 1, -6 },
  { 22, 3, 3, 5, 1, -6 },
  { 24, 4, 4, 5, 0, -5 },
  { 26, 1, 2, 5, 1, -1 },
  { 27, 3, 1, 5, 1, -3 },
  { 28, 1, 1, 5, 2, -1 },
  { 29, 3, 6, 5, 1, -6 },
  { 32, 3, 6, 5, 1, -6 },
  { 35, 2, 6, 5, 1, -6 },
  { 37, 4, 6, 5, 0, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 1, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 1, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 1, 3, 5, 2, -3 },
  { 62, 1, 4, 5, 2, -3 },
  { 63, 3, 3, 5, 1, -4 },
  { 65, 3, 2, 5, 1, -4 },
  { 66, 4, 3, 5, 0, -4 },
  { 68, 3, 6, 5, 1, -6 },
  { 71, 5, 6, 5, 0, -6 },
  { 75, 4, 6, 5, 0, -6 },
  { 78, 4, 6, 5, 0, -6 },
  { 81, 3, 6, 5, 1, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 5, 6, 5, 0, -6 },
  { 95, 4, 6, 5, 0, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 4, 6, 5, 0, -6 },
  { 105, 4, 6, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 4, 6, 5, 0, -6 },
  { 126, 4, 6, 5, 1, -6 },
  { 129, 4, 7, 5, 0, -6 },
  { 133, 4, 6, 5, 0, -6 },
  { 136, 4, 6, 5, 0, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 4, 6, 5, 1, -6 },
  { 145, 4, 6, 5, 1, -6 },
  { 148, 4, 6, 5, 1, -6 },
  { 151, 5, 6, 5, 0, -6 },
  { 155, 4, 6, 5, 1, -6 },
  { 158, 4, 6, 5, 0, -6 },
  { 161, 3, 8, 5, 1, -7 },
  { 164, 1, 7, 5, 2, -6 },
  { 165, 3, 8, 5, 1, -7 },
  { 168, 3, 3, 5, 1, -6 },
  { 170, 4, 1, 5, 0, 0 },
  { 171, 1, 1, 5, 2, -6 },
  { 172, 4, 4, 5, 0, -4 },
  { 174, 4, 6, 5, 0, -6 },
  { 177, 3, 4, 5, 1, -4 },
  { 179, 3, 6, 5, 1, -6 },
  { 182, 3, 4, 5, 1, -4 },
  { 184, 4, 6, 5, 1, -6 },
  { 187, 4, 6, 5, 0, -4 },
  { 190, 4, 6, 5, 0, -6 },
  { 193, 4, 6, 5, 0, -6 },
  { 196, 4, 8, 5, 0, -6 },
  { 200, 3, 6, 5, 1, -6 },
  { 203, 4, 6, 5, 0, -6 },
  { 206, 5, 4, 5, 0, -4 },
  { 209, 4, 4, 5, 0, -4 },
  { 211, 4, 4, 5, 0, -4 },
  { 213, 4, 6, 5, 0, -4 },
  { 216, 3, 6, 5, 1, -4 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 3, 4, 5, 1, -4 },
  { 223, 3, 5, 5, 1, -5 },
  { 225, 3, 4, 5, 1, -4 },
  { 227, 4, 4, 5, 1, -4 },
  { 229, 4, 4, 5, 1, -4 },
  { 231, 4, 4, 5, 0, -4 },
  { 233, 5, 6, 5, 0, -4 },
  { 237, 4, 4, 5, 0, -4 },
  { 239, 3, 8, 5, 1, -6 },
  { 242, 1, 7, 5, 2, -6 },
  { 243, 3, 8, 5, 1, -6 },
  { 246, 4, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_ThinItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic8pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_THINITALIC8PT7B_H_
