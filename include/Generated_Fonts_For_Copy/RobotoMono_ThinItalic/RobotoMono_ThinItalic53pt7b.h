#ifndef _ROBOTOMONO_THINITALIC53PT7B_H_
#define _ROBOTOMONO_THINITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0xE0, 0xE0, 0x30, 0xCC, 0x32, 0x0C, 0x82, 0x20, 0x98, 0x26, 0x19,
  0x06, 0x41, 0x90, 0x4C, 0x10, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x40, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x02, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x40, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x20, 0x40,
  0x00, 0x10, 0x60, 0x00, 0x08, 0x20, 0x00, 0x06, 0x10, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x40,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x01, 0x81, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x20, 0x18, 0x02, 0x18, 0x06, 0x00, 0xC4, 0x01,
  0x80, 0x61, 0x00, 0x60, 0x30, 0x40, 0x18, 0x08, 0x30, 0x04, 0x06, 0x0C,
  0x01, 0x03, 0x03, 0x00, 0xC0, 0x80, 0xC0, 0x20, 0x40, 0x10, 0x18, 0x30,
  0x06, 0x0C, 0x18, 0x00, 0xC6, 0x04, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x0F, 0x80, 0x02, 0x07, 0x70, 0x01, 0x83, 0x06, 0x00, 0xC1, 0x80,
  0x80, 0x20, 0x40, 0x30, 0x18, 0x30, 0x0C, 0x0C, 0x08, 0x03, 0x02, 0x02,
  0x00, 0xC1, 0x01, 0x80, 0x20, 0xC0, 0x60, 0x08, 0x60, 0x10, 0x02, 0x10,
  0x04, 0x01, 0x8C, 0x01, 0x80, 0x42, 0x00, 0x60, 0x30, 0x00, 0x08, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x40, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x20,
  0x00, 0x80, 0x08, 0x00, 0x20, 0x06, 0x00, 0x08, 0x03, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x04, 0x30, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x06, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x20,
  0x04, 0x60, 0x0C, 0x03, 0x10, 0x01, 0x00, 0xCC, 0x00, 0x60, 0x22, 0x00,
  0x0C, 0x19, 0x80, 0x01, 0x06, 0x60, 0x00, 0x63, 0x10, 0x00, 0x0C, 0xC4,
  0x00, 0x01, 0x61, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x07,
  0x03, 0x00, 0x06, 0x60, 0x60, 0x03, 0x0C, 0x0E, 0x03, 0x81, 0x01, 0xFF,
  0x80, 0x60, 0x04, 0x00, 0x00, 0x6D, 0xA4, 0xB6, 0x92, 0x00, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x10, 0x04, 0x03, 0xF8, 0x10, 0x7C, 0x3C,
  0x47, 0x80, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x08, 0xC6, 0x21, 0x18, 0x8C, 0x46, 0x20, 0xFF, 0xFF, 0xC0, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x78, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x04, 0x03, 0x00, 0x06, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x08, 0x00, 0x01, 0x18, 0x00, 0x03, 0x10, 0x00, 0x07,
  0x30, 0x00, 0x0D, 0x30, 0x00, 0x19, 0x20, 0x00, 0x31, 0x20, 0x00, 0x61,
  0x60, 0x00, 0x81, 0x60, 0x03, 0x03, 0x60, 0x06, 0x03, 0x40, 0x0C, 0x02,
  0x40, 0x18, 0x02, 0x40, 0x30, 0x02, 0xC0, 0x60, 0x06, 0xC0, 0x80, 0x06,
  0xC3, 0x00, 0x06, 0x86, 0x00, 0x04, 0x8C, 0x00, 0x04, 0x98, 0x00, 0x0C,
  0xB0, 0x00, 0x08, 0xE0, 0x00, 0x08, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x10,
  0xC0, 0x00, 0x30, 0x40, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x20, 0x01, 0x80,
  0x30, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0xE0, 0x0E, 0x80, 0xE2, 0x0E, 0x09, 0xC0, 0x64, 0x01,
  0xA0, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1E,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0x40, 0x10, 0x00, 0x30, 0x18,
  0x00, 0x08, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x84,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x03, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x20, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x01, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0x40, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x08, 0x00, 0x30, 0x02, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0x40, 0x10, 0x00, 0x10, 0x0C, 0x00,
  0x04, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0xF8, 0x00, 0x13, 0xFF, 0x00, 0x1F, 0x00, 0xE0, 0x0E, 0x00,
  0x10, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x08, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0x20, 0x00, 0x20, 0x18, 0x00, 0x30, 0x06, 0x00, 0x70, 0x01, 0xC0, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x01, 0xE0, 0x04,
  0x3F, 0xF8, 0x08, 0xC0, 0x38, 0x36, 0x00, 0x18, 0x58, 0x00, 0x10, 0xE0,
  0x00, 0x33, 0x80, 0x00, 0x26, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD0, 0x00,
  0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x48, 0x00, 0x01, 0x90, 0x00, 0x02,
  0x20, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x40, 0x00, 0x40, 0xC0, 0x01, 0x80,
  0xC0, 0x0E, 0x00, 0xE0, 0x30, 0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x20, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x0C, 0x10, 0x00, 0x02, 0x04, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xE7, 0x80, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x03, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x20, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x0C, 0x18, 0x00, 0x02, 0x03, 0x00, 0x03, 0x80, 0x60, 0x01, 0x80, 0x0E,
  0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xC1, 0xC0, 0x0E, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x81,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x04, 0x80, 0x00,
  0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0xA6, 0x00, 0x03, 0xC6, 0x00, 0x0D,
  0x04, 0x00, 0x32, 0x0E, 0x01, 0xCC, 0x07, 0xFE, 0x18, 0x03, 0xE0, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE1,
  0x80, 0x01, 0x80, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x10, 0x3F, 0xFF,
  0xFF, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xE0, 0xE0, 0x30, 0x06, 0x18, 0x00, 0x42, 0x00,
  0x0C, 0xC0, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x03, 0x02, 0x01, 0xF8, 0x0C, 0x18, 0x0E, 0x70, 0x30, 0xC0, 0x60,
  0x60, 0xC3, 0x03, 0x01, 0x03, 0x18, 0x18, 0x04, 0x0C, 0x40, 0xC0, 0x30,
  0x33, 0x02, 0x00, 0x80, 0xCC, 0x18, 0x02, 0x03, 0x20, 0x60, 0x08, 0x09,
  0x81, 0x00, 0x60, 0x26, 0x0C, 0x01, 0x00, 0x90, 0x20, 0x04, 0x06, 0x40,
  0x80, 0x30, 0x19, 0x02, 0x00, 0xC0, 0x4C, 0x18, 0x02, 0x01, 0x30, 0x60,
  0x18, 0x0C, 0xC1, 0x80, 0x60, 0x23, 0x04, 0x02, 0x80, 0x8C, 0x18, 0x1E,
  0x06, 0x30, 0x60, 0xD8, 0x30, 0xC0, 0x86, 0x21, 0x83, 0x03, 0xF0, 0xFC,
  0x04, 0x03, 0x80, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x10, 0x00, 0x04,
  0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x60, 0x18, 0x00,
  0x10, 0x06, 0x00, 0x0C, 0x00, 0x80, 0x02, 0x00, 0x20, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x18,
  0x00, 0x04, 0x06, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18,
  0x20, 0x00, 0x02, 0x18, 0x00, 0x00, 0x84, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x80, 0x07, 0x00, 0x40, 0x00, 0xC0,
  0x20, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x08, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x18, 0x20, 0x00, 0x18, 0x10, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x07, 0xFF, 0xE0, 0x02, 0x00,
  0x1E, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x1C, 0x08, 0x00, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x07, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x10, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x08, 0x40, 0x00, 0x06, 0x10, 0x00, 0x01, 0x04,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x08, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x20, 0x00, 0x30, 0x04, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x08, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x08, 0x00, 0x06, 0x01,
  0x00, 0x03, 0x80, 0x20, 0x01, 0xC0, 0x04, 0x01, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x07, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x01, 0xFF, 0xCC, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x01, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0xC0, 0x0E, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x1F, 0xFF, 0xFF, 0x81, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x04,
  0x08, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x80, 0x04, 0x00, 0x18, 0x00, 0x20, 0x03, 0x80, 0x01, 0x00, 0x38, 0x00,
  0x08, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0x33, 0x30, 0x00, 0x01, 0x30, 0x80, 0x00,
  0x0A, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30,
  0x03, 0x00, 0x01, 0x80, 0x08, 0x00, 0x08, 0x00, 0x60, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x00, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x80, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x1C, 0x05, 0x00, 0x00, 0xA0, 0x28, 0x00, 0x0D,
  0x01, 0x60, 0x00, 0x58, 0x1B, 0x00, 0x06, 0xC0, 0xC8, 0x00, 0x64, 0x04,
  0x40, 0x02, 0x20, 0x22, 0x00, 0x31, 0x01, 0x18, 0x01, 0x08, 0x08, 0xC0,
  0x18, 0xC0, 0xC2, 0x00, 0x86, 0x06, 0x10, 0x0C, 0x20, 0x20, 0x80, 0xC1,
  0x01, 0x04, 0x04, 0x08, 0x08, 0x30, 0x60, 0xC0, 0x40, 0x82, 0x06, 0x06,
  0x04, 0x30, 0x30, 0x30, 0x21, 0x01, 0x01, 0x01, 0x18, 0x08, 0x08, 0x0D,
  0x80, 0x40, 0x40, 0x28, 0x06, 0x06, 0x01, 0xC0, 0x30, 0x30, 0x0C, 0x01,
  0x01, 0x80, 0x60, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x30, 0x28,
  0x00, 0x03, 0x02, 0x80, 0x00, 0x30, 0x6C, 0x00, 0x02, 0x06, 0x40, 0x00,
  0x20, 0x44, 0x00, 0x02, 0x04, 0x60, 0x00, 0x60, 0x42, 0x00, 0x06, 0x04,
  0x20, 0x00, 0x40, 0xC1, 0x00, 0x04, 0x0C, 0x10, 0x00, 0x40, 0x81, 0x80,
  0x04, 0x08, 0x08, 0x00, 0xC0, 0x80, 0x80, 0x0C, 0x08, 0x0C, 0x00, 0x81,
  0x80, 0x40, 0x08, 0x10, 0x04, 0x00, 0x81, 0x00, 0x20, 0x08, 0x10, 0x02,
  0x01, 0x81, 0x00, 0x30, 0x18, 0x10, 0x01, 0x01, 0x03, 0x00, 0x10, 0x10,
  0x20, 0x01, 0x81, 0x02, 0x00, 0x08, 0x10, 0x20, 0x00, 0x83, 0x02, 0x00,
  0x04, 0x30, 0x60, 0x00, 0x42, 0x06, 0x00, 0x06, 0x20, 0x40, 0x00, 0x22,
  0x04, 0x00, 0x02, 0x20, 0x40, 0x00, 0x36, 0x04, 0x00, 0x01, 0x60, 0xC0,
  0x00, 0x14, 0x0C, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x18,
  0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x0C, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0x40, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x10,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x08, 0x00, 0x08, 0x03, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x08,
  0x00, 0x06, 0x00, 0x80, 0x01, 0xC0, 0x18, 0x00, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0x83, 0x80, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x10,
  0x00, 0x10, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x60, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x18,
  0x04, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xE0,
  0x38, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x30, 0x00, 0xE0, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x08, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x02,
  0x02, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x00, 0x80, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x04, 0x00, 0x80, 0x01, 0x80,
  0x20, 0x00, 0x60, 0x18, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x10, 0x10, 0x00, 0x06, 0x04, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x18, 0x10, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x04,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x0C,
  0x10, 0x00, 0x04, 0x08, 0x00, 0x06, 0x04, 0x00, 0x02, 0x02, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x80, 0x10, 0x00,
  0xC0, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x20, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x08,
  0x04, 0x00, 0x06, 0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0xC0, 0x00,
  0x06, 0x40, 0x00, 0x03, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0x40, 0x06, 0x00, 0x28, 0x01, 0xC0, 0x0D,
  0x00, 0x28, 0x01, 0x20, 0x05, 0x00, 0x24, 0x01, 0xA0, 0x0C, 0x80, 0x24,
  0x01, 0x10, 0x04, 0x80, 0x22, 0x01, 0x90, 0x0C, 0x40, 0x22, 0x01, 0x08,
  0x04, 0x60, 0x21, 0x01, 0x8C, 0x04, 0x20, 0x21, 0x81, 0x84, 0x0C, 0x30,
  0x20, 0x81, 0x86, 0x04, 0x10, 0x20, 0xC1, 0x82, 0x0C, 0x18, 0x20, 0x41,
  0x83, 0x04, 0x08, 0x20, 0x61, 0x81, 0x0C, 0x0C, 0x20, 0x21, 0x81, 0x84,
  0x04, 0x20, 0x31, 0x80, 0x8C, 0x02, 0x20, 0x11, 0x00, 0x44, 0x02, 0x20,
  0x09, 0x80, 0x4C, 0x01, 0x30, 0x09, 0x00, 0x24, 0x01, 0x20, 0x04, 0x80,
  0x2C, 0x00, 0xB0, 0x05, 0x00, 0x14, 0x00, 0xA0, 0x02, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x01, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06,
  0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00,
  0x30, 0x06, 0x00, 0x08, 0x00, 0x80, 0x06, 0x00, 0x20, 0x03, 0x00, 0x0C,
  0x00, 0x80, 0x01, 0x00, 0x60, 0x00, 0x40, 0x30, 0x00, 0x18, 0x08, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x40,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00,
  0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x00,
  0xFE, 0x02, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x03, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x11,
  0x00, 0x0C, 0x40, 0x06, 0x18, 0x01, 0x06, 0x00, 0xC0, 0x80, 0x20, 0x20,
  0x18, 0x08, 0x04, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x10, 0x40, 0x04, 0x30,
  0x01, 0x88, 0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0xC0, 0xFF,
  0xFF, 0xF8, 0xC3, 0x18, 0x61, 0x0C, 0x20, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x06, 0x04, 0x00,
  0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0x04, 0x1C, 0x00, 0x04, 0x30, 0x00,
  0x04, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x78, 0x40, 0x00,
  0xD8, 0x60, 0x03, 0x98, 0x38, 0x0E, 0x18, 0x1F, 0xF8, 0x18, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x04, 0x3F, 0xE0, 0x04, 0x70, 0x30, 0x0D, 0x80, 0x18, 0x0B, 0x00,
  0x0C, 0x0E, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x02, 0x18, 0x00,
  0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x03, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00,
  0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x20, 0x70, 0x00, 0x60, 0xD8, 0x01, 0xC0, 0xCE, 0x07, 0x00, 0x83, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0x01,
  0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x30, 0x00, 0x06, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x03, 0x30, 0x00, 0x04, 0x20, 0x00,
  0x18, 0x60, 0x00, 0x60, 0x40, 0x01, 0x80, 0xC0, 0x06, 0x00, 0xE0, 0x38,
  0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x07, 0xF8, 0x20,
  0x0E, 0x07, 0x10, 0x0C, 0x00, 0xC8, 0x0C, 0x00, 0x2C, 0x0C, 0x00, 0x0E,
  0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x08, 0x60, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x06,
  0x00, 0x0A, 0x01, 0x80, 0x19, 0x00, 0x60, 0x39, 0x80, 0x1F, 0xF0, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF0,
  0x38, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x02, 0x08, 0x00, 0x03, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x03, 0x7F, 0xFF, 0xFF, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x06, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xF0, 0x40, 0x1C, 0x0E,
  0x20, 0x18, 0x01, 0x90, 0x18, 0x00, 0x58, 0x18, 0x00, 0x1C, 0x18, 0x00,
  0x0E, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x86, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0xC0,
  0x00, 0x08, 0x60, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x20, 0x00, 0x38, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x14,
  0x03, 0x00, 0x32, 0x00, 0xC0, 0x73, 0x00, 0x3F, 0xE1, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x18, 0x00, 0x18, 0x06, 0x00, 0x18, 0x01, 0x80,
  0x38, 0x00, 0x70, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x01, 0x80, 0x0C, 0x1F, 0xF0, 0x0C,
  0x38, 0x18, 0x08, 0xC0, 0x0C, 0x09, 0x80, 0x06, 0x0B, 0x00, 0x02, 0x0E,
  0x00, 0x02, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60,
  0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x38, 0x60, 0x00, 0x30, 0x30, 0x00, 0x70, 0x10, 0x00, 0x60, 0x08, 0x00,
  0x60, 0x04, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0x81, 0x80, 0x00, 0x41, 0x80, 0x00, 0x21, 0x80, 0x00, 0x33,
  0xC0, 0x00, 0x1B, 0x20, 0x00, 0x0F, 0x18, 0x00, 0x07, 0x06, 0x00, 0x02,
  0x01, 0x00, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x60, 0x08, 0x00, 0x10,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x40, 0x0C, 0xFE, 0x07, 0xF0, 0x13,
  0x06, 0x38, 0x30, 0x2C, 0x06, 0xC0, 0x20, 0x70, 0x07, 0x00, 0x60, 0xC0,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0x01, 0x86, 0x00, 0x20, 0x03, 0x08, 0x00,
  0x40, 0x06, 0x10, 0x01, 0x80, 0x08, 0x20, 0x03, 0x00, 0x10, 0xC0, 0x04,
  0x00, 0x21, 0x80, 0x08, 0x00, 0x42, 0x00, 0x10, 0x01, 0x84, 0x00, 0x20,
  0x03, 0x08, 0x00, 0xC0, 0x04, 0x10, 0x01, 0x80, 0x08, 0x60, 0x02, 0x00,
  0x10, 0xC0, 0x04, 0x00, 0x21, 0x00, 0x08, 0x00, 0xC2, 0x00, 0x10, 0x01,
  0x84, 0x00, 0x60, 0x02, 0x08, 0x00, 0xC0, 0x04, 0x30, 0x01, 0x00, 0x08,
  0x60, 0x02, 0x00, 0x10, 0x80, 0x04, 0x00, 0x61, 0x00, 0x08, 0x00, 0x82,
  0x00, 0x30, 0x01, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x00, 0x01, 0x80, 0x0C,
  0x1F, 0xF0, 0x0C, 0x38, 0x18, 0x08, 0xC0, 0x0C, 0x09, 0x80, 0x06, 0x0B,
  0x00, 0x02, 0x1E, 0x00, 0x02, 0x1C, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x30, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x04, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x0C, 0x07, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x87, 0xFC, 0x00,
  0xC6, 0x03, 0x00, 0x6C, 0x00, 0xC0, 0x2C, 0x00, 0x30, 0x1C, 0x00, 0x08,
  0x0C, 0x00, 0x06, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x60, 0x00,
  0x04, 0x30, 0x00, 0x02, 0x18, 0x00, 0x01, 0x08, 0x00, 0x01, 0x84, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1E,
  0x00, 0x18, 0x0D, 0x80, 0x18, 0x06, 0x70, 0x38, 0x02, 0x0F, 0xF8, 0x01,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0x04, 0x07, 0x03, 0x88, 0x18, 0x01, 0x90, 0x60, 0x01,
  0xE1, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x40, 0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00, 0x00, 0x98,
  0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x40, 0x00, 0x60, 0xC0, 0x01,
  0x40, 0xC0, 0x0C, 0x80, 0xC0, 0x71, 0x00, 0xFF, 0x86, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x10, 0x1F, 0xF0, 0x41,
  0xC0, 0x03, 0x1C, 0x00, 0x0C, 0xC0, 0x00, 0x34, 0x00, 0x00, 0xA0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0x00, 0xE0, 0x30, 0x00,
  0x60, 0xC0, 0x00, 0x41, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x0C, 0xC0, 0x00,
  0x10, 0x80, 0x00, 0x61, 0x80, 0x03, 0x81, 0xE0, 0x1C, 0x00, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0xE0, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0,
  0x00, 0x30, 0x40, 0x00, 0x70, 0x40, 0x00, 0x70, 0x60, 0x01, 0xB0, 0x30,
  0x03, 0x20, 0x18, 0x0E, 0x20, 0x0F, 0xF8, 0x20, 0x01, 0x00, 0x40, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x40, 0x00, 0x20,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x04, 0x00, 0x18, 0x02, 0x00, 0x08,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x02, 0x00, 0x06, 0x03, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x3C, 0x00, 0xE0, 0x06, 0xC0, 0x0E,
  0x00, 0x6C, 0x00, 0xE0, 0x04, 0xC0, 0x1E, 0x00, 0xCC, 0x01, 0x60, 0x08,
  0xC0, 0x36, 0x01, 0x8C, 0x02, 0x20, 0x18, 0xC0, 0x22, 0x01, 0x04, 0x06,
  0x20, 0x30, 0x40, 0x42, 0x02, 0x04, 0x0C, 0x20, 0x60, 0x40, 0x82, 0x06,
  0x04, 0x18, 0x20, 0x40, 0x41, 0x82, 0x0C, 0x04, 0x10, 0x30, 0x80, 0x43,
  0x03, 0x18, 0x04, 0x20, 0x31, 0x80, 0x46, 0x03, 0x10, 0x04, 0x40, 0x33,
  0x00, 0x64, 0x01, 0x20, 0x06, 0xC0, 0x12, 0x00, 0x68, 0x01, 0x60, 0x07,
  0x80, 0x14, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x40, 0x01, 0x80, 0x00, 0x40, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x08, 0x73,
  0xC0, 0x00, 0x86, 0x07, 0x00, 0x04, 0x60, 0x0C, 0x00, 0x66, 0x00, 0x30,
  0x02, 0x20, 0x00, 0xC0, 0x31, 0x00, 0x03, 0x07, 0x18, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x08, 0x00,
};

const GFXglyph RobotoMono_ThinItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 38, 31, 11, -38 },
  { 39, 10, 11, 31, 13, -40 },
  { 53, 31, 38, 31, 1, -38 },
  { 201, 25, 48, 31, 4, -43 },
  { 351, 26, 39, 31, 3, -38 },
  { 478, 26, 39, 31, 2, -38 },
  { 605, 3, 11, 31, 16, -40 },
  { 610, 16, 54, 31, 9, -42 },
  { 718, 16, 54, 31, 5, -42 },
  { 826, 22, 21, 31, 7, -38 },
  { 884, 26, 27, 31, 3, -31 },
  { 972, 5, 11, 31, 7, -4 },
  { 979, 18, 1, 31, 6, -18 },
  { 982, 3, 3, 31, 12, -3 },
  { 984, 24, 41, 31, 4, -38 },
  { 1107, 24, 39, 31, 4, -38 },
  { 1224, 14, 38, 31, 8, -38 },
  { 1291, 25, 38, 31, 1, -38 },
  { 1410, 26, 39, 31, 1, -38 },
  { 1537, 26, 38, 31, 1, -38 },
  { 1661, 25, 39, 31, 5, -38 },
  { 1783, 23, 39, 31, 3, -38 },
  { 1896, 23, 38, 31, 7, -38 },
  { 2006, 26, 39, 31, 3, -38 },
  { 2133, 23, 39, 31, 5, -38 },
  { 2246, 7, 26, 31, 14, -26 },
  { 2269, 10, 33, 31, 11, -26 },
  { 2311, 24, 21, 31, 4, -28 },
  { 2374, 24, 12, 31, 4, -23 },
  { 2410, 24, 21, 31, 3, -28 },
  { 2473, 19, 38, 31, 9, -38 },
  { 2564, 30, 38, 31, 1, -38 },
  { 2707, 26, 38, 31, 0, -38 },
  { 2831, 25, 38, 31, 3, -38 },
  { 2950, 26, 39, 31, 3, -38 },
  { 3077, 27, 38, 31, 2, -38 },
  { 3206, 27, 38, 31, 3, -38 },
  { 3335, 27, 38, 31, 3, -38 },
  { 3464, 26, 39, 31, 3, -38 },
  { 3591, 28, 38, 31, 2, -38 },
  { 3724, 26, 38, 31, 3, -38 },
  { 3848, 27, 39, 31, 2, -38 },
  { 3980, 29, 38, 31, 3, -38 },
  { 4118, 21, 38, 31, 3, -38 },
  { 4218, 29, 38, 31, 2, -38 },
  { 4356, 28, 38, 31, 2, -38 },
  { 4489, 26, 39, 31, 3, -38 },
  { 4616, 28, 38, 31, 3, -38 },
  { 4749, 27, 45, 31, 3, -38 },
  { 4901, 26, 38, 31, 3, -38 },
  { 5025, 26, 39, 31, 3, -38 },
  { 5152, 26, 38, 31, 6, -38 },
  { 5276, 27, 39, 31, 3, -38 },
  { 5408, 25, 38, 31, 6, -38 },
  { 5527, 27, 38, 31, 6, -38 },
  { 5656, 31, 38, 31, 1, -38 },
  { 5804, 26, 38, 31, 6, -38 },
  { 5928, 28, 38, 31, 1, -38 },
  { 6061, 16, 51, 31, 8, -43 },
  { 6163, 10, 41, 31, 11, -38 },
  { 6215, 15, 51, 31, 8, -43 },
  { 6311, 18, 21, 31, 7, -38 },
  { 6359, 21, 1, 31, 2, 0 },
  { 6362, 5, 7, 31, 16, -39 },
  { 6367, 24, 30, 31, 3, -29 },
  { 6457, 24, 41, 31, 3, -40 },
  { 6580, 23, 30, 31, 4, -29 },
  { 6667, 25, 41, 31, 4, -40 },
  { 6796, 24, 30, 31, 3, -29 },
  { 6886, 25, 40, 31, 7, -40 },
  { 7011, 25, 40, 31, 2, -29 },
  { 7136, 24, 40, 31, 3, -40 },
  { 7256, 22, 38, 31, 3, -38 },
  { 7361, 24, 49, 31, 0, -38 },
  { 7508, 25, 40, 31, 4, -40 },
  { 7633, 22, 40, 31, 3, -40 },
  { 7743, 31, 29, 31, -1, -29 },
  { 7856, 24, 29, 31, 3, -29 },
  { 7943, 24, 30, 31, 3, -29 },
  { 8033, 25, 40, 31, 1, -29 },
  { 8158, 23, 40, 31, 4, -29 },
  { 8273, 22, 29, 31, 7, -29 },
  { 8353, 23, 30, 31, 4, -29 },
  { 8440, 19, 37, 31, 7, -36 },
  { 8528, 24, 29, 31, 4, -28 },
  { 8615, 25, 28, 31, 5, -28 },
  { 8703, 28, 28, 31, 4, -28 },
  { 8801, 28, 28, 31, 1, -28 },
  { 8899, 32, 39, 31, -1, -28 },
  { 9055, 27, 28, 31, 1, -28 },
  { 9150, 21, 52, 31, 8, -41 },
  { 9287, 9, 45, 31, 11, -38 },
  { 9338, 21, 52, 31, 4, -41 },
  { 9475, 29, 9, 31, 1, -20 },
};

const GFXfont RobotoMono_ThinItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic53pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_THINITALIC53PT7B_H_
