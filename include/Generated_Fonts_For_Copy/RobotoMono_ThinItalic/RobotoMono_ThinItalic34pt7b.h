#ifndef _ROBOTOMONO_THINITALIC34PT7B_H_
#define _ROBOTOMONO_THINITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x20,
  0x00, 0x00, 0x01, 0x18, 0x45, 0x18, 0xA2, 0x8A, 0x28, 0x80, 0x00, 0x10,
  0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04,
  0x08, 0x00, 0x81, 0x01, 0xFF, 0xFF, 0x00, 0x81, 0x00, 0x10, 0x20, 0x01,
  0x02, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00,
  0x40, 0x80, 0x7F, 0xFF, 0x88, 0x41, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00,
  0x08, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x03, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x1D, 0xC0, 0x30, 0x10, 0x30,
  0x04, 0x10, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x22, 0x00, 0x12, 0x00, 0x08, 0x80,
  0x08, 0x40, 0x04, 0x30, 0x04, 0x0C, 0x04, 0x03, 0xFC, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x21, 0x00, 0x41, 0x02,
  0x41, 0x02, 0x81, 0x04, 0x81, 0x08, 0x81, 0x08, 0x82, 0x10, 0x82, 0x20,
  0x4C, 0x40, 0x38, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x0E, 0x02, 0x31,
  0x04, 0x21, 0x0C, 0x41, 0x08, 0x41, 0x10, 0x81, 0x20, 0x81, 0x20, 0x81,
  0x40, 0x82, 0x00, 0x42, 0x00, 0x7C, 0x00, 0x40, 0x01, 0xB0, 0x02, 0x08,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x08, 0x20,
  0x04, 0x40, 0x05, 0x80, 0x02, 0x00, 0x06, 0x00, 0x19, 0x00, 0x30, 0x81,
  0x20, 0x81, 0x40, 0x41, 0x80, 0x22, 0x80, 0x22, 0x80, 0x14, 0x80, 0x14,
  0x80, 0x08, 0xC0, 0x14, 0x60, 0x64, 0x3F, 0x82, 0x55, 0x68, 0x00, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x82, 0x0D, 0xC9,
  0xC0, 0xF8, 0x01, 0x80, 0x0D, 0x00, 0x62, 0x01, 0x08, 0x08, 0x10, 0x40,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x11, 0x22, 0x24, 0xC0, 0xFF, 0xF0, 0xF0, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x00, 0x00, 0x20, 0x01,
  0xDC, 0x06, 0x06, 0x0C, 0x02, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x03, 0x20, 0x05, 0x20, 0x09, 0x40, 0x11, 0x40, 0x61, 0x40, 0xC1, 0x41,
  0x02, 0x42, 0x02, 0x44, 0x02, 0x88, 0x02, 0x90, 0x02, 0xE0, 0x04, 0x40,
  0x04, 0x40, 0x08, 0x40, 0x08, 0x60, 0x10, 0x20, 0x20, 0x1F, 0xC0, 0x01,
  0x83, 0x4E, 0x58, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x00, 0x40, 0x03, 0xB8, 0x04, 0x04, 0x08, 0x02, 0x10, 0x02,
  0x10, 0x01, 0x20, 0x01, 0x20, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0xDC, 0x06, 0x02, 0x08, 0x01,
  0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08,
  0x40, 0x08, 0x20, 0x30, 0x1F, 0xC0, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0A,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x64, 0x00, 0x44, 0x00, 0x84, 0x01, 0x04,
  0x02, 0x04, 0x04, 0x08, 0x0C, 0x08, 0x08, 0x08, 0x10, 0x08, 0x20, 0x08,
  0x40, 0x08, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x07, 0xFF, 0x82, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x13, 0xF0, 0x0E, 0x04, 0x04, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x01, 0x02, 0x01, 0x80, 0x81, 0x80, 0x3F, 0x00, 0x00, 0x06, 0x00,
  0xF0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x47, 0xC0, 0xB0, 0x62, 0x80, 0x46, 0x00, 0x48, 0x00, 0x90,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x88, 0x01, 0x10, 0x04, 0x10, 0x10, 0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0xEE, 0x01, 0x80, 0x81,
  0x80, 0x20, 0x80, 0x10, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x01, 0x82, 0x01, 0x81, 0x81, 0x00, 0x3F, 0x00, 0x60, 0xC0, 0x40,
  0x10, 0x40, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48,
  0x00, 0x24, 0x00, 0x21, 0x00, 0x20, 0x40, 0x60, 0x1F, 0xE0, 0x00, 0x00,
  0xC0, 0x0E, 0x60, 0x20, 0x20, 0x80, 0x22, 0x00, 0x44, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x34, 0x00, 0x48,
  0x01, 0x98, 0x05, 0x18, 0x32, 0x1F, 0x88, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x7C, 0x00, 0x13, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x04, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x20, 0x84, 0x10, 0x80, 0x00,
  0x02, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x77,
  0x04, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0x00, 0x30, 0x10, 0x18, 0x01, 0x06, 0x00, 0x20,
  0x80, 0x02, 0x20, 0xF8, 0x48, 0x21, 0x09, 0x08, 0x21, 0x42, 0x04, 0x28,
  0x41, 0x05, 0x10, 0x20, 0xC2, 0x04, 0x28, 0x40, 0x85, 0x10, 0x20, 0xA2,
  0x04, 0x14, 0x41, 0x84, 0x88, 0x30, 0x91, 0x0A, 0x22, 0x1E, 0x78, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x7F, 0x00, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x81, 0x00, 0x40, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x10, 0x04, 0x0F, 0xFF, 0x08,
  0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05,
  0x00, 0x01, 0x0F, 0xF8, 0x08, 0x06, 0x10, 0x02, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x02, 0x20, 0x04, 0x20, 0x18,
  0x3F, 0xE0, 0x20, 0x18, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x30,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0xEE, 0x01, 0x80, 0x81, 0x80, 0x20, 0x80,
  0x10, 0x80, 0x08, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x90, 0x00, 0x84, 0x00, 0x42, 0x00,
  0x41, 0x00, 0x40, 0x40, 0x40, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x02, 0x01,
  0x80, 0x80, 0x10, 0x20, 0x04, 0x08, 0x00, 0x82, 0x00, 0x21, 0x00, 0x04,
  0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00,
  0x44, 0x00, 0x21, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x06, 0x04, 0x06, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0x84, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x07, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x84, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0xEE,
  0x01, 0x80, 0x81, 0x80, 0x21, 0x80, 0x10, 0x80, 0x08, 0x80, 0x02, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x03, 0xFD, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x80, 0x10, 0x60, 0x30, 0x1F,
  0xE0, 0x00, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x22, 0x00, 0x08, 0xFF, 0xFC, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x02, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x10, 0x0F, 0xFF, 0x80, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x40, 0x08, 0x10, 0x04,
  0x02, 0x02, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x61, 0x00, 0x10, 0x20, 0x04,
  0x08, 0x03, 0x01, 0x00, 0xC0, 0x20, 0x30, 0x04, 0x0C, 0x00, 0x83, 0x00,
  0x10, 0xC0, 0x04, 0x20, 0x00, 0x88, 0x00, 0x12, 0x80, 0x02, 0x90, 0x00,
  0x61, 0x00, 0x08, 0x20, 0x02, 0x02, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x00, 0x81, 0x00, 0x08, 0x20, 0x01, 0x04,
  0x00, 0x10, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0x0C, 0x00, 0x61, 0x80,
  0x18, 0x30, 0x03, 0x05, 0x00, 0xA0, 0xA0, 0x14, 0x24, 0x04, 0x84, 0x81,
  0x90, 0x90, 0x24, 0x11, 0x08, 0x82, 0x21, 0x10, 0x44, 0x42, 0x10, 0x88,
  0x42, 0x12, 0x08, 0x42, 0x42, 0x08, 0x30, 0x41, 0x04, 0x08, 0x20, 0x01,
  0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x08, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04,
  0x28, 0x01, 0x12, 0x00, 0x44, 0x80, 0x21, 0x10, 0x08, 0x44, 0x02, 0x11,
  0x00, 0x84, 0x20, 0x22, 0x08, 0x08, 0x81, 0x04, 0x20, 0x41, 0x08, 0x10,
  0x42, 0x02, 0x10, 0x80, 0x84, 0x40, 0x21, 0x10, 0x04, 0x84, 0x01, 0x21,
  0x00, 0x28, 0x40, 0x0A, 0x10, 0x02, 0x88, 0x00, 0x62, 0x00, 0x10, 0x00,
  0x20, 0x01, 0xDC, 0x06, 0x06, 0x0C, 0x02, 0x08, 0x01, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1F,
  0xC0, 0x0F, 0xFC, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x42,
  0x00, 0x10, 0x80, 0x18, 0x20, 0x1C, 0x0F, 0xF8, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0xEE, 0x01,
  0x80, 0x81, 0x00, 0x21, 0x00, 0x10, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90,
  0x00, 0x88, 0x00, 0x42, 0x00, 0x41, 0x00, 0x40, 0x40, 0x40, 0x1F, 0xC0,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x0F, 0xF8, 0x04,
  0x03, 0x02, 0x00, 0xC2, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04,
  0x20, 0x02, 0x10, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84, 0x01, 0x82, 0x03,
  0x01, 0xFE, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x10, 0x20, 0x08, 0x10,
  0x04, 0x08, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x11, 0x00, 0x08,
  0x00, 0x20, 0x01, 0xEE, 0x01, 0x00, 0x81, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x04, 0x80, 0x02, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x21, 0x00,
  0x30, 0x40, 0x30, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x01, 0x04, 0x00, 0x82, 0x00, 0x80, 0x80, 0x80, 0x3F, 0x80,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x20, 0x40, 0x20, 0x80, 0x20, 0x80, 0x11, 0x00, 0x11, 0x00,
  0x12, 0x00, 0x12, 0x00, 0x14, 0x00, 0x14, 0x00, 0x14, 0x00, 0x08, 0x00,
  0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x50, 0x30, 0x28, 0x28, 0x14, 0x14,
  0x12, 0x0A, 0x09, 0x09, 0x04, 0x84, 0x82, 0x42, 0x42, 0x22, 0x21, 0x11,
  0x10, 0x88, 0x88, 0x84, 0x84, 0x42, 0x42, 0x21, 0x21, 0x20, 0xA0, 0x50,
  0x50, 0x28, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x04, 0x00, 0x10, 0x40, 0x02, 0x02, 0x00, 0x40, 0x20,
  0x08, 0x01, 0x00, 0x80, 0x10, 0x10, 0x00, 0x82, 0x00, 0x08, 0x40, 0x00,
  0x44, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x02, 0x00, 0x00, 0x50, 0x00,
  0x05, 0x00, 0x00, 0x90, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x60, 0x40,
  0x04, 0x04, 0x00, 0x80, 0x20, 0x10, 0x02, 0x02, 0x00, 0x10, 0x20, 0x01,
  0x0C, 0x00, 0x08, 0x80, 0x01, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20,
  0x08, 0x20, 0x10, 0x20, 0x10, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x08,
  0x80, 0x09, 0x00, 0x09, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xC1, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xF8, 0x00, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08,
  0x20, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x07,
  0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0xF8, 0x00, 0x00, 0x80, 0x18, 0x02, 0x80, 0x24, 0x04,
  0x40, 0x44, 0x08, 0x40, 0x82, 0x10, 0x22, 0x02, 0x20, 0x24, 0x02, 0xC0,
  0x10, 0xFF, 0xFC, 0xC4, 0x23, 0x03, 0xF8, 0x18, 0x08, 0x40, 0x08, 0x80,
  0x12, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x07, 0xFC, 0x30, 0x09,
  0x80, 0x12, 0x00, 0x28, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40, 0x1C, 0x40,
  0x68, 0x7F, 0x10, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x13, 0xF0, 0x28, 0x10, 0xA0, 0x11,
  0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x30, 0x02, 0x60, 0x08,
  0xA0, 0x21, 0x3F, 0x80, 0x03, 0xF8, 0x08, 0x18, 0x20, 0x10, 0x80, 0x12,
  0x00, 0x24, 0x00, 0x50, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x90, 0x02, 0x30, 0x08, 0x20, 0x20,
  0x3F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x03, 0xF1, 0x06, 0x05, 0x06,
  0x01, 0x82, 0x00, 0xC2, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08,
  0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x82, 0x00,
  0x41, 0x00, 0x20, 0x80, 0x30, 0x20, 0x68, 0x0F, 0xC4, 0x00, 0x03, 0xF8,
  0x04, 0x0C, 0x08, 0x06, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x7F, 0xFE, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x08, 0x30, 0x10, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x01, 0xF8, 0x83, 0x02, 0x83, 0x00, 0xC1, 0x00, 0x61, 0x00,
  0x10, 0x80, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x18,
  0x10, 0x34, 0x07, 0xE2, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x83, 0x00, 0x80, 0x40, 0x80, 0x1F, 0x80, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x11,
  0xF8, 0x4C, 0x08, 0xA0, 0x09, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x10, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x3F, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x60, 0x3F,
  0x00, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x03, 0x10, 0x06, 0x10, 0x08,
  0x10, 0x10, 0x10, 0x60, 0x10, 0x80, 0x21, 0x00, 0x26, 0x00, 0x2E, 0x00,
  0x31, 0x00, 0x21, 0x00, 0x40, 0x80, 0x40, 0x40, 0x40, 0x60, 0x40, 0x20,
  0x40, 0x10, 0x40, 0x08, 0x80, 0x0C, 0x07, 0xF0, 0x20, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x03, 0xFF, 0xF0, 0x17, 0xC7, 0xC5, 0x05, 0x04, 0xC0, 0xC0, 0x90,
  0x10, 0x12, 0x02, 0x02, 0x40, 0x40, 0x48, 0x08, 0x0A, 0x02, 0x01, 0x40,
  0x40, 0x48, 0x08, 0x09, 0x01, 0x01, 0x20, 0x20, 0x24, 0x04, 0x05, 0x01,
  0x00, 0xA0, 0x20, 0x24, 0x04, 0x04, 0x80, 0x80, 0x90, 0x10, 0x10, 0x11,
  0xF8, 0x4C, 0x08, 0xA0, 0x09, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x00,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x10, 0x03, 0xF0, 0x0C,
  0x0C, 0x18, 0x04, 0x30, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1F, 0xC0, 0x09, 0xF8, 0x0A,
  0x04, 0x14, 0x02, 0x18, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20,
  0x04, 0x60, 0x04, 0x60, 0x08, 0x50, 0x10, 0x4F, 0xE0, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03,
  0xF1, 0x0C, 0x0A, 0x18, 0x06, 0x10, 0x06, 0x20, 0x02, 0x20, 0x02, 0x40,
  0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x18, 0x20, 0x68, 0x1F, 0x88, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x11, 0xFC, 0x98, 0x02, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x0C,
  0x04, 0x10, 0x02, 0x10, 0x02, 0x20, 0x01, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x40, 0x08, 0x20, 0x18, 0x1F, 0xE0, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0xFC, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x1F, 0x80, 0x20,
  0x02, 0x40, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90,
  0x03, 0x20, 0x04, 0x40, 0x18, 0x40, 0xD0, 0x7E, 0x20, 0x80, 0x01, 0x80,
  0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x0C, 0x20, 0x08, 0x20, 0x10, 0x20,
  0x10, 0x20, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x09,
  0x00, 0x09, 0x00, 0x0A, 0x00, 0x0A, 0x00, 0x04, 0x00, 0x80, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x50, 0x30, 0x28, 0x28, 0x24, 0x14, 0x12, 0x12, 0x09,
  0x09, 0x08, 0x88, 0x84, 0x44, 0x22, 0x22, 0x12, 0x12, 0x09, 0x09, 0x05,
  0x05, 0x02, 0x82, 0x81, 0x41, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x00,
  0x10, 0x00, 0xC2, 0x00, 0x40, 0x40, 0x20, 0x10, 0x18, 0x02, 0x0C, 0x00,
  0xC6, 0x00, 0x13, 0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x16,
  0x00, 0x08, 0x80, 0x04, 0x10, 0x02, 0x04, 0x01, 0x00, 0x80, 0x80, 0x10,
  0x40, 0x04, 0x30, 0x00, 0x80, 0x08, 0x00, 0x18, 0x40, 0x00, 0x82, 0x00,
  0x08, 0x08, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x20, 0x02, 0x03, 0x00, 0x10, 0x10, 0x00, 0x41, 0x00, 0x02, 0x08,
  0x00, 0x10, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x00,
  0xA0, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x04, 0x20,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x40, 0x14, 0x08, 0x0A, 0x01, 0x02,
  0x80, 0x33, 0x00, 0x03, 0x00,
};

const GFXglyph RobotoMono_ThinItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 24, 20, 7, -24 },
  { 16, 6, 7, 20, 9, -26 },
  { 22, 20, 24, 20, 0, -24 },
  { 82, 17, 31, 20, 2, -28 },
  { 148, 16, 25, 20, 2, -25 },
  { 198, 16, 25, 20, 2, -25 },
  { 248, 2, 7, 20, 10, -26 },
  { 250, 10, 35, 20, 6, -27 },
  { 294, 10, 35, 20, 3, -27 },
  { 338, 14, 13, 20, 5, -24 },
  { 361, 16, 18, 20, 2, -20 },
  { 397, 4, 7, 20, 4, -3 },
  { 401, 12, 1, 20, 4, -12 },
  { 403, 2, 2, 20, 8, -2 },
  { 404, 15, 26, 20, 3, -24 },
  { 453, 16, 25, 20, 2, -25 },
  { 503, 9, 24, 20, 5, -24 },
  { 530, 16, 25, 20, 1, -25 },
  { 580, 16, 25, 20, 1, -25 },
  { 630, 16, 24, 20, 1, -24 },
  { 678, 17, 24, 20, 3, -24 },
  { 729, 15, 25, 20, 2, -25 },
  { 776, 15, 24, 20, 4, -24 },
  { 821, 17, 25, 20, 2, -25 },
  { 875, 15, 25, 20, 3, -25 },
  { 922, 4, 17, 20, 9, -17 },
  { 931, 6, 21, 20, 7, -17 },
  { 947, 15, 14, 20, 3, -18 },
  { 974, 16, 8, 20, 2, -15 },
  { 990, 15, 14, 20, 2, -18 },
  { 1017, 13, 25, 20, 5, -25 },
  { 1058, 19, 24, 20, 1, -24 },
  { 1115, 17, 24, 20, 0, -24 },
  { 1166, 16, 24, 20, 2, -24 },
  { 1214, 17, 25, 20, 2, -25 },
  { 1268, 18, 24, 20, 1, -24 },
  { 1322, 17, 24, 20, 2, -24 },
  { 1373, 17, 24, 20, 2, -24 },
  { 1424, 17, 25, 20, 2, -25 },
  { 1478, 18, 24, 20, 1, -24 },
  { 1532, 17, 24, 20, 2, -24 },
  { 1583, 18, 24, 20, 1, -24 },
  { 1637, 19, 24, 20, 2, -24 },
  { 1694, 14, 24, 20, 2, -24 },
  { 1736, 19, 24, 20, 1, -24 },
  { 1793, 18, 24, 20, 1, -24 },
  { 1847, 16, 25, 20, 2, -25 },
  { 1897, 18, 24, 20, 2, -24 },
  { 1951, 17, 29, 20, 2, -25 },
  { 2013, 17, 24, 20, 2, -24 },
  { 2064, 17, 25, 20, 2, -25 },
  { 2118, 17, 24, 20, 4, -24 },
  { 2169, 17, 24, 20, 2, -24 },
  { 2220, 16, 24, 20, 4, -24 },
  { 2268, 17, 24, 20, 4, -24 },
  { 2319, 20, 24, 20, 0, -24 },
  { 2379, 16, 24, 20, 4, -24 },
  { 2427, 18, 24, 20, 1, -24 },
  { 2481, 10, 33, 20, 5, -28 },
  { 2523, 6, 26, 20, 7, -24 },
  { 2543, 10, 33, 20, 5, -28 },
  { 2585, 12, 13, 20, 4, -24 },
  { 2605, 14, 1, 20, 1, 0 },
  { 2607, 4, 4, 20, 10, -25 },
  { 2609, 15, 18, 20, 2, -18 },
  { 2643, 15, 26, 20, 2, -26 },
  { 2692, 15, 18, 20, 2, -18 },
  { 2726, 17, 26, 20, 2, -26 },
  { 2782, 16, 18, 20, 2, -18 },
  { 2818, 16, 26, 20, 5, -26 },
  { 2870, 17, 25, 20, 1, -18 },
  { 2924, 15, 26, 20, 2, -26 },
  { 2973, 14, 24, 20, 2, -24 },
  { 3015, 15, 31, 20, 0, -24 },
  { 3074, 16, 26, 20, 2, -26 },
  { 3126, 14, 26, 20, 2, -26 },
  { 3172, 19, 18, 20, 0, -18 },
  { 3215, 15, 18, 20, 2, -18 },
  { 3249, 16, 18, 20, 2, -18 },
  { 3285, 16, 25, 20, 1, -18 },
  { 3335, 16, 25, 20, 2, -18 },
  { 3385, 14, 18, 20, 5, -18 },
  { 3417, 16, 18, 20, 2, -18 },
  { 3453, 13, 23, 20, 4, -23 },
  { 3491, 15, 18, 20, 3, -18 },
  { 3525, 16, 18, 20, 3, -18 },
  { 3561, 17, 18, 20, 3, -18 },
  { 3600, 18, 18, 20, 1, -18 },
  { 3641, 21, 25, 20, -1, -18 },
  { 3707, 17, 18, 20, 1, -18 },
  { 3746, 13, 34, 20, 5, -27 },
  { 3802, 6, 28, 20, 7, -24 },
  { 3823, 13, 34, 20, 3, -27 },
  { 3879, 18, 6, 20, 1, -13 },
};

const GFXfont RobotoMono_ThinItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic34pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_THINITALIC34PT7B_H_
