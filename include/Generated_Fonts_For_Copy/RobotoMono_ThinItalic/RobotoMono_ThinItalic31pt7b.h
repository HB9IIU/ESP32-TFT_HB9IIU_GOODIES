#ifndef _ROBOTOMONO_THINITALIC31PT7B_H_
#define _ROBOTOMONO_THINITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x00,
  0x00, 0x04, 0x20, 0x4A, 0x63, 0x18, 0xCC, 0x00, 0x20, 0x80, 0x10, 0x40,
  0x04, 0x10, 0x01, 0x04, 0x00, 0x82, 0x00, 0x20, 0x81, 0xFF, 0xFC, 0x04,
  0x10, 0x01, 0x04, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08, 0x20, 0x04, 0x08,
  0x01, 0x04, 0x00, 0x41, 0x03, 0xFF, 0xFC, 0x08, 0x20, 0x02, 0x08, 0x01,
  0x02, 0x00, 0x41, 0x00, 0x10, 0x40, 0x08, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x1D, 0xC0, 0x40, 0xC1, 0x00, 0x84, 0x00, 0x88, 0x01,
  0x10, 0x02, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x88, 0x01, 0x10, 0x04, 0x10, 0x10, 0x1F, 0xC0, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x3C, 0x00, 0x84, 0x01, 0x08, 0x34, 0x10, 0x48, 0x21, 0x10,
  0x42, 0x20, 0x88, 0x42, 0x20, 0x8C, 0x40, 0xE1, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x23, 0x80, 0x88, 0x82, 0x20, 0x84, 0x41, 0x10, 0x82, 0x42, 0x04,
  0x84, 0x12, 0x08, 0x20, 0x08, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x02, 0x08,
  0x04, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04, 0x20, 0x04, 0x40,
  0x04, 0x80, 0x03, 0x00, 0x06, 0x00, 0x09, 0x00, 0x10, 0x81, 0x20, 0x82,
  0x20, 0x42, 0x40, 0x22, 0x40, 0x24, 0x40, 0x14, 0x40, 0x08, 0x40, 0x18,
  0x20, 0x64, 0x1F, 0x82, 0x55, 0xA0, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x0C, 0x21, 0x9D, 0x70, 0x1C, 0x00, 0xA0, 0x09,
  0x00, 0x84, 0x08, 0x10, 0x80, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x24, 0xA5, 0x00, 0xFF, 0xC0, 0x70, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x03, 0xF0, 0x08, 0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x88,
  0x02, 0xA0, 0x09, 0x40, 0x24, 0x80, 0x89, 0x02, 0x12, 0x18, 0x28, 0x40,
  0x51, 0x00, 0xA4, 0x02, 0x50, 0x04, 0xC0, 0x09, 0x00, 0x21, 0x00, 0x42,
  0x01, 0x02, 0x04, 0x03, 0xF0, 0x00, 0x03, 0x0E, 0x72, 0x82, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x03, 0xF0, 0x30, 0x21, 0x00, 0x44, 0x01, 0x20,
  0x04, 0x80, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x08, 0x18, 0x20,
  0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x1F, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x42, 0x00, 0x86, 0x06, 0x03, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x60, 0x01, 0x40, 0x04, 0x80, 0x11,
  0x00, 0x42, 0x00, 0x84, 0x02, 0x10, 0x08, 0x20, 0x20, 0x40, 0x80, 0x82,
  0x01, 0x04, 0x02, 0x10, 0x08, 0x7F, 0xFF, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x27, 0x80,
  0x70, 0xC0, 0x80, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x84, 0x01, 0x04, 0x0C, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x30, 0x4E, 0x62, 0x80, 0x98, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x04, 0x80, 0x42, 0x04, 0x0F,
  0xC0, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x08, 0x08, 0x20, 0x10, 0x80, 0x11,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x10, 0x08, 0x10, 0x20, 0x1F,
  0x80, 0x61, 0x83, 0x00, 0x88, 0x01, 0x10, 0x01, 0x40, 0x02, 0x80, 0x05,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x84, 0x02, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0xC0, 0x88, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x80, 0x34, 0x02, 0x90, 0x68, 0x7C, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x3E, 0x00, 0x13, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x04, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x41, 0x08, 0x00, 0x00, 0x04, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x20, 0x00, 0x1F, 0x84, 0x09, 0x00, 0xA0, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00,
  0xFC, 0x01, 0x81, 0x81, 0x00, 0x41, 0x00, 0x11, 0x06, 0x09, 0x0C, 0xC4,
  0x88, 0x22, 0x84, 0x21, 0x44, 0x10, 0xC2, 0x08, 0x62, 0x04, 0x31, 0x04,
  0x28, 0x82, 0x14, 0x41, 0x0A, 0x21, 0x85, 0x11, 0x44, 0x89, 0x24, 0x43,
  0x0C, 0x20, 0x00, 0x08, 0x00, 0x02, 0x02, 0x00, 0xFE, 0x00, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x84, 0x01, 0x08, 0x04, 0x10, 0x08, 0x10, 0x20, 0x20, 0x40, 0x41, 0x00,
  0x82, 0x01, 0x0B, 0xFE, 0x10, 0x04, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14,
  0x00, 0x30, 0x00, 0x40, 0x1F, 0xF0, 0x20, 0x10, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x60, 0xFF,
  0x02, 0x01, 0x84, 0x00, 0x88, 0x01, 0x10, 0x01, 0x20, 0x02, 0x80, 0x05,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x06, 0x1F, 0xF0, 0x00, 0x03, 0xF0,
  0x08, 0x10, 0x20, 0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x42, 0x01, 0x02,
  0x04, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x08, 0x0C, 0x08, 0x04, 0x10, 0x02,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x18, 0x40, 0x30, 0x40, 0x40, 0xFF, 0x80,
  0x1F, 0xFF, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x08, 0x18, 0x20, 0x10, 0x80, 0x12,
  0x00, 0x24, 0x00, 0x50, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x1F, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x22, 0x00, 0x42, 0x03, 0x03, 0xF8, 0x00, 0x08, 0x00,
  0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x0F, 0xFF, 0x84, 0x00, 0x42,
  0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02,
  0x10, 0x01, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x40, 0x1F, 0xFE, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x20, 0x20, 0x40, 0x1F, 0x80, 0x10,
  0x01, 0x88, 0x01, 0x04, 0x01, 0x02, 0x01, 0x01, 0x01, 0x00, 0x81, 0x00,
  0x81, 0x00, 0x41, 0x00, 0x21, 0x00, 0x11, 0x00, 0x0B, 0x80, 0x0B, 0x40,
  0x06, 0x10, 0x02, 0x04, 0x01, 0x02, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x10, 0x20, 0x04, 0x10, 0x02, 0x08, 0x00, 0x84, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x08, 0x01, 0x84, 0x00, 0xC5,
  0x00, 0xA2, 0x80, 0x61, 0x40, 0x50, 0xA0, 0x48, 0x48, 0x24, 0x24, 0x22,
  0x22, 0x11, 0x11, 0x11, 0x08, 0x88, 0x84, 0x28, 0x42, 0x18, 0x21, 0x0C,
  0x11, 0x04, 0x08, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x84, 0x00, 0x40, 0x08, 0x00, 0x84, 0x00, 0x45, 0x00,
  0x42, 0x80, 0x21, 0x40, 0x10, 0x90, 0x08, 0x48, 0x04, 0x42, 0x04, 0x21,
  0x02, 0x10, 0x81, 0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x22, 0x02, 0x21,
  0x01, 0x10, 0x80, 0x48, 0x40, 0x24, 0x20, 0x12, 0x10, 0x05, 0x10, 0x03,
  0x08, 0x00, 0x84, 0x00, 0x40, 0x03, 0xF0, 0x08, 0x10, 0x20, 0x10, 0x80,
  0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x06,
  0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x22, 0x00, 0x42, 0x01, 0x02, 0x04, 0x03, 0xF0, 0x00, 0x0F,
  0xF8, 0x10, 0x04, 0x10, 0x02, 0x10, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x30, 0x3F,
  0xC0, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x18, 0x10, 0x20,
  0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x42, 0x01, 0x06, 0x04, 0x03, 0xF0,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x1F, 0xF0, 0x20, 0x10,
  0x40, 0x10, 0x80, 0x11, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20,
  0x04, 0x40, 0x10, 0x80, 0x42, 0x03, 0x07, 0xF8, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10,
  0x01, 0x00, 0x03, 0xF8, 0x18, 0x18, 0x40, 0x10, 0x80, 0x12, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x80, 0x05, 0x00, 0x12,
  0x00, 0x22, 0x00, 0x86, 0x02, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x10, 0x80, 0x10, 0x40, 0x20, 0x20, 0x40, 0x1F, 0x80, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x44, 0x02, 0x10, 0x08,
  0x40, 0x41, 0x01, 0x04, 0x04, 0x10, 0x20, 0x40, 0x80, 0x84, 0x02, 0x10,
  0x08, 0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x80, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82,
  0x82, 0x82, 0x84, 0x84, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0x90, 0xA0, 0x90, 0xA0, 0xA0, 0xA0,
  0xA0, 0xC0, 0xA0, 0xC0, 0x40, 0xC0, 0x40, 0x80, 0x40, 0x08, 0x00, 0x60,
  0x80, 0x10, 0x10, 0x02, 0x01, 0x00, 0x80, 0x20, 0x20, 0x02, 0x08, 0x00,
  0x42, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x14, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x84, 0x00, 0x20, 0x80, 0x04,
  0x08, 0x01, 0x01, 0x00, 0x40, 0x10, 0x10, 0x02, 0x02, 0x00, 0x21, 0x80,
  0x04, 0x00, 0x80, 0x07, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x02, 0x08,
  0x04, 0x08, 0x10, 0x10, 0x40, 0x20, 0x80, 0x22, 0x00, 0x48, 0x00, 0x90,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x00, 0xFF, 0xF8, 0x0F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x07, 0x80, 0x81, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x82, 0x04, 0x10,
  0x41, 0x04, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x0F, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x07, 0x80, 0x01, 0x00, 0xC0, 0x50, 0x12, 0x08,
  0x82, 0x21, 0x08, 0x42, 0x20, 0x50, 0x14, 0x06, 0x01, 0xFF, 0xF8, 0xC8,
  0x90, 0x03, 0xC0, 0x30, 0xC1, 0x00, 0x88, 0x02, 0x20, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x0F, 0xF8, 0xC0, 0x24, 0x00, 0xA0, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x03, 0x30, 0x34, 0x7F, 0x10, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x18, 0x09, 0x8C, 0x28, 0x08, 0xC0,
  0x22, 0x00, 0x88, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x28, 0x01, 0x20, 0x04, 0xC0, 0x22, 0x81, 0x09, 0xF8, 0x00,
  0x01, 0x80, 0x18, 0xC1, 0x80, 0x84, 0x02, 0x20, 0x05, 0x00, 0x14, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x19, 0x00,
  0x44, 0x02, 0x08, 0x10, 0x1F, 0x80, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0xF1, 0x06, 0x12, 0x18, 0x14, 0x40,
  0x18, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x04,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x84, 0x03, 0x0C, 0x0A, 0x07,
  0xE8, 0x00, 0x01, 0xC0, 0x18, 0xC1, 0x80, 0x84, 0x02, 0x20, 0x05, 0x00,
  0x14, 0x00, 0x5F, 0xFF, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x01, 0x08, 0x08, 0x1F, 0xC0, 0x00, 0x2C, 0x01, 0x84,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0xFB,
  0xF0, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x0C, 0x24, 0x30, 0x28, 0x40,
  0x31, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x02, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x84, 0x01, 0x08, 0x06, 0x08, 0x14, 0x0F,
  0xD0, 0x00, 0x20, 0x00, 0x40, 0x01, 0x08, 0x02, 0x08, 0x08, 0x0C, 0x60,
  0x07, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x1E, 0x09, 0x84, 0x28, 0x08, 0xC0, 0x22, 0x00, 0x48, 0x01, 0x40,
  0x05, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x03, 0x80, 0xF0, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x88, 0x06, 0x10, 0x10,
  0x40, 0x40, 0x81, 0x01, 0x0C, 0x02, 0x20, 0x04, 0x80, 0x0F, 0x00, 0x31,
  0x00, 0x41, 0x00, 0x83, 0x01, 0x02, 0x02, 0x02, 0x04, 0x02, 0x10, 0x04,
  0x20, 0x04, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0xFF, 0xF0, 0x03, 0x06, 0x16, 0x6C, 0x4C, 0x18, 0x24, 0x08, 0x12, 0x04,
  0x09, 0x02, 0x05, 0x01, 0x02, 0x80, 0x81, 0x40, 0x80, 0xA0, 0x40, 0x50,
  0x20, 0x48, 0x10, 0x28, 0x08, 0x14, 0x04, 0x0A, 0x04, 0x05, 0x02, 0x02,
  0x81, 0x02, 0x00, 0x01, 0xE0, 0x98, 0x42, 0x80, 0x8C, 0x02, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x02,
  0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x10, 0x03, 0x80, 0x30,
  0xC1, 0x00, 0x88, 0x02, 0x60, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x44, 0x02, 0x18,
  0x10, 0x1F, 0x80, 0x00, 0xC0, 0x4C, 0x61, 0x40, 0x86, 0x01, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01,
  0x40, 0x09, 0x00, 0x26, 0x01, 0x1C, 0x08, 0x4F, 0xC2, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x30, 0x91,
  0x81, 0x4C, 0x03, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x44, 0x03, 0x08, 0x14,
  0x1F, 0xA0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x78, 0x9C, 0x05, 0x00, 0x50, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x30, 0xC1, 0x00, 0x88, 0x01,
  0x20, 0x04, 0x80, 0x02, 0x00, 0x06, 0x00, 0x07, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0A, 0x00, 0x28, 0x01, 0x10, 0x08, 0x3F, 0xC0, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xC2, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0xF8, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x28, 0x01, 0x20,
  0x04, 0x80, 0x11, 0x00, 0xC4, 0x05, 0x0F, 0xE4, 0x80, 0x06, 0x00, 0x24,
  0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x82, 0x04, 0x08, 0x10, 0x20, 0x80,
  0x82, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x50, 0x00, 0xC0, 0x02, 0x00,
  0x80, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x42, 0x82, 0x44, 0x84,
  0x44, 0x84, 0x44, 0x88, 0x48, 0x48, 0x48, 0x48, 0x50, 0x50, 0x50, 0x50,
  0x50, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0x10, 0x03, 0x08, 0x04,
  0x08, 0x08, 0x04, 0x10, 0x02, 0x30, 0x02, 0x60, 0x01, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x02, 0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x10, 0x20, 0x10,
  0x40, 0x08, 0x80, 0x0C, 0x18, 0x00, 0x61, 0x00, 0x08, 0x20, 0x02, 0x02,
  0x00, 0x40, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x10, 0x20, 0x02,
  0x04, 0x00, 0x41, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x7F, 0xFE, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x11, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44,
  0x44, 0x44, 0x88, 0x88, 0x88, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x50, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30,
  0x04, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x62, 0x01, 0x41, 0x01, 0x80, 0x82,
  0x80, 0x7C,
};

const GFXglyph RobotoMono_ThinItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 5, 22, 18, 6, -22 },
  { 15, 5, 6, 18, 8, -23 },
  { 19, 18, 22, 18, 0, -22 },
  { 69, 15, 28, 18, 2, -25 },
  { 122, 15, 22, 18, 2, -22 },
  { 164, 16, 22, 18, 1, -22 },
  { 208, 2, 6, 18, 9, -23 },
  { 210, 10, 32, 18, 5, -25 },
  { 250, 9, 32, 18, 3, -25 },
  { 286, 13, 12, 18, 4, -22 },
  { 306, 15, 16, 18, 2, -18 },
  { 336, 3, 6, 18, 4, -2 },
  { 339, 10, 1, 18, 4, -11 },
  { 341, 2, 2, 18, 7, -2 },
  { 342, 14, 24, 18, 3, -22 },
  { 384, 15, 22, 18, 2, -22 },
  { 426, 8, 22, 18, 5, -22 },
  { 448, 14, 22, 18, 1, -22 },
  { 487, 15, 22, 18, 1, -22 },
  { 529, 15, 22, 18, 1, -22 },
  { 571, 15, 22, 18, 3, -22 },
  { 613, 13, 22, 18, 2, -22 },
  { 649, 14, 22, 18, 4, -22 },
  { 688, 15, 22, 18, 2, -22 },
  { 730, 13, 22, 18, 3, -22 },
  { 766, 4, 15, 18, 8, -15 },
  { 774, 6, 19, 18, 6, -15 },
  { 789, 14, 12, 18, 2, -16 },
  { 810, 14, 7, 18, 2, -14 },
  { 823, 14, 12, 18, 2, -16 },
  { 844, 11, 22, 18, 5, -22 },
  { 875, 17, 22, 18, 1, -22 },
  { 922, 15, 22, 18, 0, -22 },
  { 964, 15, 22, 18, 2, -22 },
  { 1006, 15, 22, 18, 2, -22 },
  { 1048, 16, 22, 18, 1, -22 },
  { 1092, 16, 22, 18, 2, -22 },
  { 1136, 16, 22, 18, 2, -22 },
  { 1180, 15, 22, 18, 2, -22 },
  { 1222, 17, 22, 18, 1, -22 },
  { 1269, 15, 22, 18, 2, -22 },
  { 1311, 16, 22, 18, 1, -22 },
  { 1355, 17, 22, 18, 2, -22 },
  { 1402, 12, 22, 18, 2, -22 },
  { 1435, 17, 22, 18, 1, -22 },
  { 1482, 17, 22, 18, 1, -22 },
  { 1529, 15, 22, 18, 2, -22 },
  { 1571, 16, 22, 18, 2, -22 },
  { 1615, 15, 26, 18, 2, -22 },
  { 1664, 15, 22, 18, 2, -22 },
  { 1706, 15, 22, 18, 2, -22 },
  { 1748, 15, 22, 18, 4, -22 },
  { 1790, 16, 22, 18, 2, -22 },
  { 1834, 14, 22, 18, 4, -22 },
  { 1873, 16, 22, 18, 3, -22 },
  { 1917, 19, 22, 18, 0, -22 },
  { 1970, 15, 22, 18, 4, -22 },
  { 2012, 16, 22, 18, 1, -22 },
  { 2056, 9, 30, 18, 5, -25 },
  { 2090, 6, 24, 18, 6, -22 },
  { 2108, 9, 30, 18, 5, -25 },
  { 2142, 10, 12, 18, 4, -22 },
  { 2157, 13, 1, 18, 1, 0 },
  { 2159, 3, 4, 18, 9, -23 },
  { 2161, 14, 17, 18, 2, -17 },
  { 2191, 14, 23, 18, 2, -23 },
  { 2232, 14, 17, 18, 2, -17 },
  { 2262, 15, 23, 18, 2, -23 },
  { 2306, 14, 17, 18, 2, -17 },
  { 2336, 15, 24, 18, 4, -24 },
  { 2381, 15, 24, 18, 1, -17 },
  { 2426, 14, 23, 18, 2, -23 },
  { 2467, 12, 22, 18, 2, -22 },
  { 2500, 14, 29, 18, 0, -22 },
  { 2551, 15, 23, 18, 2, -23 },
  { 2595, 12, 23, 18, 2, -23 },
  { 2630, 17, 17, 18, 0, -17 },
  { 2667, 14, 17, 18, 2, -17 },
  { 2697, 14, 17, 18, 2, -17 },
  { 2727, 14, 23, 18, 1, -17 },
  { 2768, 14, 23, 18, 2, -17 },
  { 2809, 13, 17, 18, 4, -17 },
  { 2837, 14, 17, 18, 2, -17 },
  { 2867, 11, 21, 18, 4, -21 },
  { 2896, 14, 16, 18, 2, -16 },
  { 2924, 14, 16, 18, 3, -16 },
  { 2952, 16, 16, 18, 2, -16 },
  { 2984, 16, 16, 18, 1, -16 },
  { 3016, 19, 23, 18, -1, -16 },
  { 3071, 15, 16, 18, 1, -16 },
  { 3101, 12, 31, 18, 5, -24 },
  { 3148, 4, 26, 18, 7, -22 },
  { 3161, 12, 31, 18, 3, -24 },
  { 3208, 16, 5, 18, 1, -12 },
};

const GFXfont RobotoMono_ThinItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic31pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_THINITALIC31PT7B_H_
