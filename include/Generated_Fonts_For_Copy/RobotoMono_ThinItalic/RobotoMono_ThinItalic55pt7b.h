#ifndef _ROBOTOMONO_THINITALIC55PT7B_H_
#define _ROBOTOMONO_THINITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0xE0, 0xC0, 0x20, 0xC8, 0x36, 0x09, 0x82, 0x60, 0x90, 0x64,
  0x19, 0x04, 0xC1, 0x30, 0x48, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0x80, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x10,
  0x02, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20,
  0x04, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x40,
  0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x00, 0x40, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x08, 0x01, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x08, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40, 0x10, 0x02,
  0x18, 0x02, 0x00, 0x63, 0x00, 0x40, 0x18, 0x40, 0x08, 0x06, 0x08, 0x01,
  0x01, 0x83, 0x00, 0x60, 0x20, 0x60, 0x0C, 0x0C, 0x0C, 0x01, 0x03, 0x01,
  0x80, 0x60, 0x40, 0x10, 0x08, 0x18, 0x03, 0x03, 0x06, 0x00, 0x30, 0xC1,
  0x80, 0x03, 0xF0, 0x20, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x81,
  0xFC, 0x00, 0x30, 0x60, 0xC0, 0x0C, 0x18, 0x08, 0x03, 0x02, 0x01, 0x00,
  0x40, 0xC0, 0x30, 0x18, 0x10, 0x06, 0x06, 0x06, 0x00, 0xC0, 0x80, 0xC0,
  0x18, 0x30, 0x10, 0x03, 0x0C, 0x02, 0x00, 0x41, 0x00, 0x40, 0x08, 0x60,
  0x08, 0x03, 0x18, 0x01, 0x00, 0x40, 0x00, 0x20, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x83, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x40, 0x08, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x10, 0x01, 0x00, 0x04,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x08, 0x18, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x10, 0x01, 0x18, 0x06, 0x00, 0x4C, 0x00, 0xC0, 0x32,
  0x00, 0x10, 0x0D, 0x80, 0x06, 0x02, 0x40, 0x00, 0xC1, 0xB0, 0x00, 0x10,
  0x4C, 0x00, 0x06, 0x33, 0x00, 0x00, 0xD8, 0xC0, 0x00, 0x16, 0x30, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0xC1, 0x00, 0x00, 0xD0, 0x60, 0x00, 0x66, 0x0C,
  0x00, 0x70, 0xC1, 0xC0, 0x70, 0x30, 0x1F, 0xF0, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x32, 0x22, 0x66, 0x44, 0x4C, 0xC0, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x30, 0x04, 0x03, 0xF8, 0x30, 0x78, 0x78, 0xCF, 0x00, 0x3F,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0xC3, 0x00, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x86, 0x18, 0x43, 0x08, 0x63, 0x08,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x04,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x71, 0x00, 0x00, 0x69, 0x80, 0x00, 0x64, 0xC0, 0x00,
  0x62, 0x40, 0x00, 0x61, 0x20, 0x00, 0xC0, 0x90, 0x00, 0xC0, 0xD8, 0x00,
  0xC0, 0x6C, 0x00, 0xC0, 0x26, 0x00, 0xC0, 0x12, 0x00, 0xC0, 0x09, 0x00,
  0xC0, 0x04, 0x81, 0x80, 0x06, 0xC1, 0x80, 0x03, 0x61, 0x80, 0x01, 0x31,
  0x80, 0x00, 0x91, 0x80, 0x00, 0xC9, 0x80, 0x00, 0x65, 0x80, 0x00, 0x23,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x08,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x08, 0x03, 0xC0, 0x72, 0x0E, 0x33, 0xC1, 0xF0, 0x0E, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x01, 0x00, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x08, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x1C, 0x00,
  0x38, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x10, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x70,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x80, 0x30, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x01, 0x80,
  0x02, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x08, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x07, 0x00, 0x00, 0x47,
  0xFE, 0x00, 0x0B, 0x80, 0xE0, 0x03, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x08,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x10, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x0F, 0x00, 0x18, 0x7F, 0xE0, 0x11,
  0xC0, 0x38, 0x33, 0x00, 0x1C, 0x34, 0x00, 0x0C, 0x28, 0x00, 0x06, 0x30,
  0x00, 0x02, 0x70, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x0C, 0x60, 0x00, 0x08, 0x20, 0x00, 0x18, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x00,
  0xC0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x08, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x60, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xE0, 0x30, 0x03, 0x80, 0x18, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x02, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x0A, 0x60, 0x00, 0x1E,
  0x30, 0x00, 0x36, 0x10, 0x00, 0x64, 0x18, 0x01, 0xC4, 0x0E, 0x07, 0x0C,
  0x03, 0xFE, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x06, 0x0F, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0,
  0x00, 0xC0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x08, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF0,
  0x07, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00,
  0x24, 0x00, 0x02, 0xC0, 0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0xFC, 0x06, 0x0C, 0x07,
  0x1C, 0x0C, 0x30, 0x18, 0x0C, 0x18, 0x60, 0x60, 0x10, 0x11, 0x80, 0x80,
  0x20, 0x23, 0x03, 0x00, 0xC0, 0xC4, 0x0C, 0x01, 0x01, 0x98, 0x10, 0x02,
  0x03, 0x20, 0x60, 0x0C, 0x06, 0x40, 0xC0, 0x18, 0x0D, 0x81, 0x00, 0x20,
  0x13, 0x06, 0x00, 0x40, 0x24, 0x0C, 0x01, 0x80, 0xC8, 0x10, 0x02, 0x01,
  0xB0, 0x20, 0x04, 0x02, 0x60, 0x40, 0x18, 0x04, 0xC0, 0x80, 0x30, 0x19,
  0x81, 0x00, 0xE0, 0x23, 0x02, 0x03, 0x80, 0xC6, 0x04, 0x05, 0x01, 0x0C,
  0x08, 0x13, 0x06, 0x18, 0x18, 0xE2, 0x18, 0x10, 0x1F, 0x07, 0xE0, 0x20,
  0x08, 0x02, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x08, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x40,
  0x10, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x30, 0x00,
  0x40, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0F,
  0xFF, 0xFE, 0x01, 0x80, 0x00, 0x40, 0x20, 0x00, 0x08, 0x0C, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x22, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xF0, 0x00, 0x60,
  0x07, 0x80, 0x0C, 0x00, 0x1C, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08,
  0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x08, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x30, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06,
  0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x07, 0x00,
  0x18, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x10, 0x03, 0xC0, 0x01, 0x00, 0x07,
  0x00, 0x10, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x02,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x08, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x40, 0x01, 0xC0, 0x04,
  0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x01, 0xC0,
  0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x04, 0x20, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0xFF, 0xE2, 0x00, 0x3F, 0xFC, 0xC0, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x08, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x78, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0xC0, 0x08,
  0x00, 0x0E, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x87, 0x00, 0x00, 0x02, 0x76, 0x00, 0x00, 0x1B, 0x0C, 0x00, 0x00, 0x78,
  0x10, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x03, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x04,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x80, 0x40, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1A, 0x02, 0xC0,
  0x00, 0x68, 0x09, 0x00, 0x03, 0x60, 0x24, 0x00, 0x0D, 0x81, 0x90, 0x00,
  0x66, 0x06, 0x60, 0x01, 0x10, 0x19, 0x80, 0x0C, 0x40, 0x42, 0x00, 0x21,
  0x01, 0x08, 0x01, 0x8C, 0x04, 0x20, 0x0C, 0x30, 0x30, 0xC0, 0x30, 0x80,
  0xC3, 0x01, 0x82, 0x03, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x60, 0x20,
  0x40, 0x81, 0x80, 0x81, 0x86, 0x06, 0x06, 0x06, 0x30, 0x10, 0x18, 0x08,
  0x80, 0x40, 0x60, 0x26, 0x01, 0x01, 0x00, 0x90, 0x0C, 0x04, 0x03, 0xC0,
  0x30, 0x10, 0x0E, 0x00, 0xC0, 0xC0, 0x18, 0x02, 0x03, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x1C, 0x00, 0x00, 0x40, 0xE0, 0x00, 0x02, 0x05, 0x00, 0x00,
  0x30, 0x2C, 0x00, 0x01, 0x81, 0x20, 0x00, 0x08, 0x19, 0x00, 0x00, 0x40,
  0xCC, 0x00, 0x02, 0x06, 0x20, 0x00, 0x30, 0x21, 0x80, 0x01, 0x81, 0x04,
  0x00, 0x0C, 0x08, 0x20, 0x00, 0x40, 0xC1, 0x80, 0x02, 0x06, 0x04, 0x00,
  0x10, 0x20, 0x20, 0x01, 0x81, 0x01, 0x80, 0x0C, 0x08, 0x04, 0x00, 0x60,
  0x40, 0x30, 0x02, 0x06, 0x00, 0x80, 0x10, 0x30, 0x04, 0x00, 0x81, 0x00,
  0x30, 0x0C, 0x08, 0x00, 0x80, 0x60, 0x40, 0x04, 0x02, 0x02, 0x00, 0x10,
  0x10, 0x30, 0x00, 0x80, 0x81, 0x80, 0x06, 0x04, 0x08, 0x00, 0x10, 0x60,
  0x40, 0x00, 0x83, 0x02, 0x00, 0x06, 0x10, 0x10, 0x00, 0x10, 0x81, 0x80,
  0x00, 0x84, 0x0C, 0x00, 0x02, 0x20, 0x40, 0x00, 0x13, 0x02, 0x00, 0x00,
  0xD8, 0x10, 0x00, 0x02, 0x80, 0x80, 0x00, 0x14, 0x0C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x88, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0C,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x18, 0x00, 0x18, 0x01, 0x00, 0x06,
  0x00, 0x10, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x20, 0x01, 0xE0, 0x02, 0x00,
  0x03, 0x80, 0x20, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x07, 0x01, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x78, 0x01, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x02, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x20, 0x07, 0xC0,
  0x0C, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x04, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x08,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x18, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x07, 0x00, 0x3F, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x10, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00,
  0x04, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x08, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x86, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x08, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x08, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x10, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x04, 0x00, 0x0C,
  0x00, 0x80, 0x01, 0x00, 0x10, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x80, 0x18, 0x00, 0x10, 0x03, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x10, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x28, 0x00, 0xE0, 0x02,
  0x80, 0x0A, 0x00, 0x68, 0x00, 0xA0, 0x04, 0x80, 0x1A, 0x00, 0x48, 0x01,
  0x20, 0x0C, 0x80, 0x32, 0x00, 0xC8, 0x03, 0x20, 0x08, 0x80, 0x22, 0x00,
  0x88, 0x06, 0x20, 0x18, 0x80, 0x62, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80,
  0xC2, 0x03, 0x08, 0x0C, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x18, 0x20,
  0x60, 0x81, 0x83, 0x04, 0x08, 0x10, 0x30, 0x40, 0x83, 0x03, 0x0C, 0x08,
  0x20, 0x30, 0x80, 0x82, 0x03, 0x08, 0x08, 0x60, 0x31, 0x80, 0x84, 0x03,
  0x18, 0x08, 0x40, 0x31, 0x00, 0x8C, 0x03, 0x10, 0x08, 0x80, 0x33, 0x00,
  0x98, 0x03, 0x20, 0x09, 0x80, 0x32, 0x00, 0x90, 0x03, 0x60, 0x0B, 0x00,
  0x34, 0x00, 0xB0, 0x03, 0x40, 0x0A, 0x00, 0x1C, 0x00, 0xA0, 0x01, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x04,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x01, 0x00, 0x02,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x40, 0x04, 0x00, 0x08,
  0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x18, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x28, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0x00, 0xC0,
  0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0xC0, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00,
  0x02, 0x60, 0x00, 0xCC, 0x00, 0x30, 0x80, 0x06, 0x10, 0x01, 0x83, 0x00,
  0x20, 0x60, 0x0C, 0x04, 0x01, 0x00, 0x80, 0x60, 0x18, 0x18, 0x03, 0x03,
  0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0x86, 0x00, 0x18, 0x80, 0x03, 0x30,
  0x00, 0x2C, 0x00, 0x06, 0xFF, 0xFF, 0xFC, 0x86, 0x10, 0xC2, 0x18, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x07, 0x00, 0x30, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x04, 0x10, 0x00,
  0x02, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xFC, 0x07,
  0xE0, 0x04, 0x0F, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x66, 0x00, 0x00, 0x23, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x1E, 0x10, 0x00, 0x3B,
  0x0C, 0x00, 0x31, 0x83, 0x80, 0xF0, 0xC0, 0x7F, 0xE0, 0x60, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x41, 0xFF, 0x00, 0x23, 0x80, 0xC0, 0x13, 0x00, 0x30,
  0x1B, 0x00, 0x0C, 0x0E, 0x00, 0x02, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x02, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x03, 0x02, 0x80, 0x03, 0x03,
  0x30, 0x03, 0x01, 0x8C, 0x07, 0x00, 0xC3, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0x38, 0x01, 0x80,
  0x0C, 0x07, 0x00, 0x04, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00,
  0x02, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0x40, 0x00,
  0x18, 0x40, 0x00, 0x10, 0x60, 0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x01,
  0xC0, 0x0C, 0x07, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x07, 0x00, 0xC0, 0x07, 0xFC, 0x10, 0x03, 0x80, 0xE2, 0x00, 0xE0, 0x06,
  0x40, 0x30, 0x00, 0x58, 0x0C, 0x00, 0x0F, 0x01, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x08, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x18, 0x06,
  0x00, 0x07, 0x00, 0x40, 0x01, 0xA0, 0x0C, 0x00, 0x6C, 0x00, 0xE0, 0x79,
  0x80, 0x07, 0xFC, 0x30, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x1C, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x38, 0x00, 0x20,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x04, 0x18, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x0B, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x06, 0x06, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00,
  0x70, 0x1E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x08, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x20, 0x03, 0xFE, 0x08, 0x01, 0xC0, 0x71,
  0x00, 0x70, 0x03, 0x20, 0x18, 0x00, 0x2C, 0x06, 0x00, 0x07, 0x80, 0x80,
  0x00, 0x70, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x20, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x10,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x20, 0x00, 0xD0, 0x06, 0x00, 0x36,
  0x00, 0x70, 0x3C, 0xC0, 0x03, 0xFE, 0x18, 0x00, 0x08, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x38, 0x00, 0x40, 0xFF, 0x80, 0x21, 0xC0, 0x60, 0x31, 0x80, 0x18, 0x19,
  0x80, 0x06, 0x09, 0x00, 0x01, 0x05, 0x00, 0x00, 0x83, 0x00, 0x00, 0x43,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04,
  0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x08, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x02, 0x10, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x01, 0xC1, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0xE0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x38, 0x00,
  0x80, 0x18, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x07, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x41, 0x80, 0x00, 0x11, 0xC0, 0x00, 0x04, 0xD8,
  0x00, 0x03, 0x62, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x08,
  0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x01, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x40, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x20,
  0x06, 0x7F, 0x83, 0xFC, 0x04, 0xE0, 0xC7, 0x06, 0x05, 0x80, 0x4C, 0x03,
  0x07, 0x00, 0x78, 0x03, 0x06, 0x00, 0x70, 0x01, 0x0C, 0x00, 0x60, 0x01,
  0x0C, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x08, 0x00, 0x40, 0x03,
  0x08, 0x00, 0x40, 0x02, 0x08, 0x00, 0x40, 0x02, 0x18, 0x00, 0x40, 0x02,
  0x18, 0x00, 0xC0, 0x02, 0x10, 0x00, 0xC0, 0x06, 0x10, 0x00, 0x80, 0x06,
  0x10, 0x00, 0x80, 0x04, 0x10, 0x00, 0x80, 0x04, 0x30, 0x01, 0x80, 0x04,
  0x30, 0x01, 0x80, 0x0C, 0x20, 0x01, 0x80, 0x0C, 0x20, 0x01, 0x00, 0x0C,
  0x20, 0x01, 0x00, 0x08, 0x20, 0x01, 0x00, 0x08, 0x60, 0x03, 0x00, 0x08,
  0x60, 0x03, 0x00, 0x18, 0x40, 0x02, 0x00, 0x18, 0x40, 0x02, 0x00, 0x10,
  0x40, 0x02, 0x00, 0x10, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x02,
  0x07, 0xFC, 0x03, 0x0E, 0x03, 0x01, 0x8C, 0x00, 0xC0, 0xC8, 0x00, 0x30,
  0x48, 0x00, 0x18, 0x28, 0x00, 0x04, 0x18, 0x00, 0x02, 0x1C, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x04, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3C, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x04, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x10, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x38,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x41,
  0xFF, 0x00, 0x11, 0xC0, 0x60, 0x04, 0xC0, 0x0C, 0x03, 0x60, 0x01, 0x80,
  0xE0, 0x00, 0x20, 0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x18, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02,
  0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x08, 0x18, 0x00, 0x06, 0x07, 0x00, 0x03, 0x01, 0x40, 0x01, 0x80, 0xD8,
  0x00, 0xC0, 0x33, 0x80, 0xE0, 0x0C, 0x3F, 0xE0, 0x02, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xC1, 0x01, 0xE0, 0x71, 0x03, 0x80, 0x19, 0x06, 0x00, 0x0B,
  0x0C, 0x00, 0x0F, 0x08, 0x00, 0x07, 0x18, 0x00, 0x06, 0x10, 0x00, 0x02,
  0x30, 0x00, 0x02, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x20, 0x00, 0xD0, 0x30, 0x01, 0x90, 0x1C, 0x0F, 0x30,
  0x07, 0xFC, 0x30, 0x00, 0x80, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x0C, 0x0F, 0xFC, 0x18, 0x78, 0x00, 0x21, 0x80, 0x00,
  0x46, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xC0, 0x3C,
  0x03, 0x00, 0x0E, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x01,
  0x18, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x38,
  0x30, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x08,
  0x00, 0x01, 0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x02, 0x18, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x61, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x78, 0x30, 0x00, 0x68, 0x0C, 0x00, 0xE4, 0x03,
  0x01, 0xE2, 0x00, 0xFF, 0xC3, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x02, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x04, 0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0x80,
  0x18, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x40, 0x00, 0x01, 0x30, 0x00, 0x00, 0x58, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x1E,
  0x00, 0x30, 0x00, 0xB0, 0x01, 0x80, 0x0D, 0x80, 0x1C, 0x00, 0x4C, 0x00,
  0xA0, 0x06, 0x60, 0x0D, 0x80, 0x31, 0x00, 0x6C, 0x01, 0x08, 0x02, 0x60,
  0x18, 0x40, 0x33, 0x00, 0x82, 0x01, 0x18, 0x0C, 0x10, 0x18, 0xC0, 0x60,
  0x80, 0x86, 0x02, 0x04, 0x04, 0x10, 0x30, 0x20, 0x60, 0x81, 0x01, 0x02,
  0x04, 0x18, 0x08, 0x30, 0x20, 0xC0, 0x61, 0x01, 0x04, 0x03, 0x18, 0x08,
  0x60, 0x18, 0x80, 0x42, 0x00, 0xC4, 0x03, 0x30, 0x06, 0x60, 0x19, 0x80,
  0x32, 0x00, 0xC8, 0x01, 0xB0, 0x06, 0xC0, 0x0D, 0x00, 0x34, 0x00, 0x68,
  0x00, 0xA0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x18, 0x00, 0x06, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x00,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x31, 0xC1, 0xC0, 0x00, 0x8C,
  0x01, 0x80, 0x06, 0x20, 0x03, 0x00, 0x19, 0x80, 0x06, 0x00, 0xC4, 0x00,
  0x0C, 0x06, 0x10, 0x00, 0x1E, 0x70, 0xC0, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_ThinItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 39, 32, 12, -39 },
  { 40, 10, 11, 32, 14, -41 },
  { 54, 32, 39, 32, 1, -39 },
  { 210, 26, 51, 32, 4, -45 },
  { 376, 27, 41, 32, 3, -40 },
  { 515, 26, 41, 32, 3, -40 },
  { 649, 4, 11, 32, 16, -41 },
  { 655, 16, 57, 32, 10, -44 },
  { 769, 16, 57, 32, 5, -44 },
  { 883, 22, 21, 32, 8, -39 },
  { 941, 27, 28, 32, 3, -32 },
  { 1036, 6, 11, 32, 7, -4 },
  { 1045, 19, 2, 32, 6, -19 },
  { 1050, 3, 3, 32, 13, -3 },
  { 1052, 24, 42, 32, 5, -39 },
  { 1178, 25, 41, 32, 4, -40 },
  { 1307, 13, 39, 32, 9, -39 },
  { 1371, 26, 40, 32, 1, -40 },
  { 1501, 27, 41, 32, 1, -40 },
  { 1640, 27, 39, 32, 1, -39 },
  { 1772, 27, 40, 32, 5, -39 },
  { 1907, 24, 41, 32, 3, -40 },
  { 2030, 24, 39, 32, 7, -39 },
  { 2147, 27, 41, 32, 3, -40 },
  { 2286, 24, 41, 32, 5, -40 },
  { 2409, 8, 27, 32, 14, -27 },
  { 2436, 11, 34, 32, 11, -27 },
  { 2483, 25, 22, 32, 4, -29 },
  { 2552, 25, 12, 32, 4, -24 },
  { 2590, 25, 22, 32, 3, -29 },
  { 2659, 20, 40, 32, 9, -40 },
  { 2759, 31, 39, 32, 1, -39 },
  { 2911, 27, 39, 32, 0, -39 },
  { 3043, 27, 39, 32, 3, -39 },
  { 3175, 27, 41, 32, 3, -40 },
  { 3314, 28, 39, 32, 2, -39 },
  { 3451, 28, 39, 32, 3, -39 },
  { 3588, 29, 39, 32, 3, -39 },
  { 3730, 27, 41, 32, 3, -40 },
  { 3869, 29, 39, 32, 2, -39 },
  { 4011, 28, 39, 32, 3, -39 },
  { 4148, 28, 40, 32, 2, -39 },
  { 4288, 30, 39, 32, 3, -39 },
  { 4435, 22, 39, 32, 3, -39 },
  { 4543, 30, 39, 32, 2, -39 },
  { 4690, 29, 39, 32, 2, -39 },
  { 4832, 27, 41, 32, 3, -40 },
  { 4971, 28, 39, 32, 4, -39 },
  { 5108, 28, 47, 32, 3, -40 },
  { 5273, 27, 39, 32, 3, -39 },
  { 5405, 27, 41, 32, 3, -40 },
  { 5544, 26, 39, 32, 7, -39 },
  { 5671, 27, 40, 32, 4, -39 },
  { 5806, 27, 39, 32, 6, -39 },
  { 5938, 28, 39, 32, 6, -39 },
  { 6075, 32, 39, 32, 1, -39 },
  { 6231, 27, 39, 32, 6, -39 },
  { 6363, 29, 39, 32, 1, -39 },
  { 6505, 16, 53, 32, 9, -45 },
  { 6611, 10, 42, 32, 11, -39 },
  { 6664, 16, 53, 32, 8, -45 },
  { 6770, 19, 21, 32, 7, -39 },
  { 6820, 22, 1, 32, 2, 0 },
  { 6823, 5, 7, 32, 17, -41 },
  { 6828, 25, 31, 32, 3, -30 },
  { 6925, 25, 42, 32, 3, -41 },
  { 7057, 24, 31, 32, 4, -30 },
  { 7150, 27, 42, 32, 4, -41 },
  { 7292, 25, 31, 32, 3, -30 },
  { 7389, 26, 42, 32, 7, -42 },
  { 7526, 27, 42, 32, 2, -30 },
  { 7668, 25, 41, 32, 3, -41 },
  { 7797, 22, 39, 32, 3, -39 },
  { 7905, 25, 51, 32, 0, -39 },
  { 8065, 26, 41, 32, 4, -41 },
  { 8199, 22, 41, 32, 3, -41 },
  { 8312, 32, 30, 32, -1, -30 },
  { 8432, 25, 30, 32, 3, -30 },
  { 8526, 25, 31, 32, 3, -30 },
  { 8623, 26, 41, 32, 1, -30 },
  { 8757, 24, 41, 32, 4, -30 },
  { 8880, 23, 30, 32, 7, -30 },
  { 8967, 24, 31, 32, 4, -30 },
  { 9060, 20, 38, 32, 7, -37 },
  { 9155, 25, 30, 32, 4, -29 },
  { 9249, 26, 29, 32, 5, -29 },
  { 9344, 29, 29, 32, 4, -29 },
  { 9450, 29, 29, 32, 1, -29 },
  { 9556, 33, 41, 32, -1, -29 },
  { 9726, 28, 29, 32, 1, -29 },
  { 9828, 21, 55, 32, 9, -43 },
  { 9973, 8, 46, 32, 12, -39 },
  { 10019, 21, 55, 32, 5, -43 },
  { 10164, 30, 9, 32, 1, -21 },
};

const GFXfont RobotoMono_ThinItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic55pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_THINITALIC55PT7B_H_
