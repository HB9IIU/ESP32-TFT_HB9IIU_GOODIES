#ifndef _ROBOTOMONO_THINITALIC69PT7B_H_
#define _ROBOTOMONO_THINITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x18, 0x18, 0xC0,
  0xCC, 0x06, 0x60, 0x23, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x60, 0x23,
  0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x60, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x04,
  0x00, 0x10, 0x60, 0x03, 0x00, 0x1C, 0x60, 0x01, 0x80, 0x0C, 0x30, 0x00,
  0xC0, 0x0C, 0x18, 0x00, 0x40, 0x0C, 0x08, 0x00, 0x60, 0x06, 0x0C, 0x00,
  0x30, 0x06, 0x06, 0x00, 0x18, 0x06, 0x03, 0x00, 0x0C, 0x07, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18,
  0x03, 0x01, 0x80, 0x0C, 0x03, 0x01, 0x80, 0x03, 0x07, 0x01, 0x80, 0x00,
  0xFF, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x30, 0x1F,
  0xF0, 0x00, 0x30, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x06, 0x00, 0x18, 0x0C,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x06,
  0x00, 0x10, 0x0C, 0x03, 0x00, 0x08, 0x0C, 0x01, 0x80, 0x0C, 0x06, 0x01,
  0x80, 0x06, 0x06, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x01, 0x87, 0x00,
  0x30, 0x00, 0xC3, 0x00, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x63, 0x00,
  0x06, 0x00, 0x70, 0x80, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x08, 0xE0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x30,
  0x60, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x06, 0x18, 0x00, 0x18, 0x01,
  0x86, 0x00, 0x03, 0x00, 0x63, 0x00, 0x00, 0xC0, 0x30, 0xC0, 0x00, 0x18,
  0x0C, 0x60, 0x00, 0x07, 0x07, 0x18, 0x00, 0x00, 0xC1, 0x86, 0x00, 0x00,
  0x18, 0xE1, 0x80, 0x00, 0x06, 0x30, 0x60, 0x00, 0x00, 0xD8, 0x18, 0x00,
  0x00, 0x1E, 0x06, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x30,
  0x00, 0x01, 0xD8, 0x0E, 0x00, 0x00, 0xE6, 0x01, 0xC0, 0x00, 0xF0, 0xC0,
  0x38, 0x00, 0x70, 0x18, 0x07, 0xC1, 0xF0, 0x06, 0x00, 0x7F, 0xF0, 0x00,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x8C, 0x63, 0x18, 0xC4, 0x63, 0x18,
  0xC4, 0x60, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x60, 0x07, 0xF8, 0x06, 0x03, 0xF3, 0xF0, 0x61, 0xF8, 0x07, 0xE6,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x08, 0x30, 0x60,
  0xC1, 0x86, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0x6F, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x1F, 0x18, 0x00, 0x00, 0x3B, 0x18, 0x00, 0x00, 0x73,
  0x18, 0x00, 0x00, 0xE3, 0x10, 0x00, 0x01, 0x83, 0x30, 0x00, 0x03, 0x02,
  0x30, 0x00, 0x06, 0x02, 0x30, 0x00, 0x0C, 0x06, 0x30, 0x00, 0x38, 0x06,
  0x30, 0x00, 0x70, 0x06, 0x20, 0x00, 0xE0, 0x06, 0x60, 0x01, 0x80, 0x06,
  0x60, 0x03, 0x00, 0x04, 0x60, 0x06, 0x00, 0x0C, 0x60, 0x0C, 0x00, 0x0C,
  0x40, 0x38, 0x00, 0x0C, 0xC0, 0x70, 0x00, 0x0C, 0xC0, 0xE0, 0x00, 0x08,
  0xC1, 0x80, 0x00, 0x18, 0xC3, 0x00, 0x00, 0x18, 0xC6, 0x00, 0x00, 0x18,
  0xCC, 0x00, 0x00, 0x30, 0xF8, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x1F,
  0x30, 0x3C, 0x10, 0x78, 0x19, 0xF0, 0x0D, 0xC0, 0x06, 0x80, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x7F, 0x00, 0x00,
  0x18, 0xFF, 0xF0, 0x00, 0x06, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0xC0, 0x03,
  0x07, 0xFF, 0xC0, 0x18, 0x78, 0x03, 0xC0, 0x67, 0x00, 0x03, 0x81, 0x38,
  0x00, 0x06, 0x0D, 0x80, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0x63, 0x00,
  0x00, 0x32, 0x0C, 0x00, 0x07, 0x30, 0x70, 0x00, 0x71, 0x81, 0xC0, 0x1E,
  0x0C, 0x03, 0xFF, 0xE0, 0xC0, 0x0F, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x03,
  0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x70,
  0x00, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x78, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x02, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x7F,
  0x00, 0x30, 0x18, 0x01, 0xFF, 0x80, 0x60, 0x70, 0x0E, 0x03, 0x80, 0xC0,
  0xC0, 0x38, 0x03, 0x01, 0x83, 0x00, 0x60, 0x04, 0x03, 0x06, 0x01, 0x80,
  0x18, 0x06, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x30, 0x0C, 0x00, 0x60, 0x18,
  0xC0, 0x30, 0x00, 0x80, 0x31, 0x80, 0x60, 0x03, 0x00, 0x63, 0x01, 0x80,
  0x06, 0x00, 0xCC, 0x03, 0x00, 0x08, 0x01, 0x98, 0x04, 0x00, 0x30, 0x02,
  0x30, 0x18, 0x00, 0x60, 0x0C, 0x40, 0x30, 0x00, 0xC0, 0x19, 0x80, 0x60,
  0x01, 0x00, 0x33, 0x01, 0x80, 0x06, 0x00, 0x66, 0x03, 0x00, 0x0C, 0x01,
  0x8C, 0x06, 0x00, 0x18, 0x03, 0x10, 0x0C, 0x00, 0x60, 0x06, 0x20, 0x18,
  0x00, 0xC0, 0x18, 0x40, 0x20, 0x03, 0x80, 0x31, 0x80, 0x40, 0x0F, 0x00,
  0x63, 0x00, 0x80, 0x1E, 0x01, 0x86, 0x01, 0x00, 0x6C, 0x03, 0x04, 0x03,
  0x01, 0x98, 0x0C, 0x0C, 0x06, 0x06, 0x30, 0x30, 0x18, 0x06, 0x38, 0x39,
  0xC0, 0x30, 0x07, 0xE0, 0x3F, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x40, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x20, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x07, 0x00, 0x40, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x30, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x04, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x1C, 0x08, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x3C, 0x03, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0x30,
  0x00, 0x1F, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x07,
  0x00, 0x00, 0x02, 0x00, 0x38, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x38, 0x00, 0x00, 0x00, 0x41, 0xE0, 0x00, 0x00, 0x03,
  0x0F, 0x80, 0x00, 0x00, 0x0C, 0x73, 0x00, 0x00, 0x00, 0x33, 0x86, 0x00,
  0x00, 0x00, 0xDC, 0x18, 0x00, 0x00, 0x02, 0xC0, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x40, 0x00,
  0x01, 0xA0, 0x1B, 0x00, 0x00, 0x1F, 0x00, 0xD8, 0x00, 0x00, 0xD8, 0x06,
  0xC0, 0x00, 0x0E, 0xC0, 0x36, 0x00, 0x00, 0x66, 0x01, 0x10, 0x00, 0x06,
  0x20, 0x18, 0xC0, 0x00, 0x31, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x31, 0x80, 0x01, 0x86, 0x01, 0x84, 0x00, 0x1C, 0x30,
  0x08, 0x30, 0x00, 0xC1, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x30, 0x60, 0x06, 0x06, 0x01, 0x81, 0x00, 0x30, 0x30, 0x08,
  0x08, 0x03, 0x01, 0x80, 0x40, 0x60, 0x38, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x18, 0x06, 0x01, 0x80, 0x40, 0xC0, 0x30, 0x0C, 0x02,
  0x0C, 0x01, 0x80, 0x40, 0x18, 0x60, 0x0C, 0x06, 0x00, 0xC6, 0x00, 0xC0,
  0x30, 0x06, 0x60, 0x06, 0x01, 0x80, 0x13, 0x00, 0x30, 0x0C, 0x00, 0xB0,
  0x01, 0x80, 0x60, 0x07, 0x80, 0x0C, 0x02, 0x00, 0x38, 0x00, 0x40, 0x30,
  0x01, 0xC0, 0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x00,
  0x30, 0x0D, 0x00, 0x00, 0x01, 0x80, 0x6C, 0x00, 0x00, 0x08, 0x02, 0x60,
  0x00, 0x00, 0xC0, 0x11, 0x00, 0x00, 0x06, 0x01, 0x8C, 0x00, 0x00, 0x30,
  0x0C, 0x60, 0x00, 0x01, 0x80, 0x61, 0x00, 0x00, 0x0C, 0x03, 0x0C, 0x00,
  0x00, 0x40, 0x10, 0x20, 0x00, 0x06, 0x01, 0x81, 0x80, 0x00, 0x30, 0x0C,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x20, 0x00, 0x0C, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x0C, 0x00, 0x02, 0x00, 0x80, 0x20, 0x00, 0x30, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x02, 0x00, 0x80, 0x04, 0x00, 0x10, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x04, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x10, 0x04, 0x00, 0x06, 0x00,
  0x80, 0x20, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x60, 0x18, 0x00,
  0x06, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x06, 0x00, 0x00, 0x80, 0x80,
  0x20, 0x00, 0x06, 0x0C, 0x01, 0x00, 0x00, 0x10, 0x60, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x06, 0x00, 0x00, 0x10, 0xC0, 0x30,
  0x00, 0x00, 0xC4, 0x01, 0x00, 0x00, 0x06, 0x60, 0x08, 0x00, 0x00, 0x13,
  0x00, 0xC0, 0x00, 0x00, 0xD8, 0x06, 0x00, 0x00, 0x02, 0xC0, 0x30, 0x00,
  0x00, 0x1E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x04, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0x00, 0x00, 0x70, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x03,
  0x40, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x1C, 0x00, 0x09, 0x00, 0x06, 0x80,
  0x01, 0x20, 0x00, 0xD0, 0x00, 0x64, 0x00, 0x1A, 0x00, 0x0C, 0x80, 0x06,
  0x40, 0x01, 0x10, 0x00, 0xC8, 0x00, 0x62, 0x00, 0x19, 0x80, 0x0C, 0x40,
  0x06, 0x30, 0x01, 0x08, 0x00, 0xC6, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x0C,
  0x20, 0x06, 0x18, 0x01, 0x04, 0x00, 0xC3, 0x00, 0x60, 0x80, 0x18, 0x60,
  0x0C, 0x10, 0x06, 0x0C, 0x01, 0x02, 0x00, 0xC1, 0x80, 0x60, 0x40, 0x18,
  0x30, 0x0C, 0x08, 0x06, 0x06, 0x01, 0x81, 0x00, 0xC0, 0xC0, 0x20, 0x20,
  0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x30, 0x0C, 0x0C, 0x02, 0x06, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x30,
  0x20, 0x08, 0x30, 0x06, 0x0C, 0x01, 0x06, 0x00, 0xC1, 0x80, 0x20, 0xC0,
  0x18, 0x20, 0x04, 0x30, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x61, 0x80, 0x10,
  0xC0, 0x0C, 0x20, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x46, 0x00, 0x11, 0x80,
  0x08, 0xC0, 0x02, 0x30, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x26, 0x00, 0x0D,
  0x80, 0x04, 0xC0, 0x01, 0xB0, 0x00, 0xB0, 0x00, 0x24, 0x00, 0x16, 0x00,
  0x05, 0x80, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x08, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x1C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0xC0, 0xF0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x78, 0x60, 0x00, 0x01, 0xB0, 0x60,
  0x00, 0x0E, 0x60, 0xE0, 0x00, 0x38, 0xC0, 0xE0, 0x01, 0xE1, 0x80, 0xF0,
  0x1F, 0x03, 0x00, 0x7F, 0xF8, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0xFF,
  0x00, 0x03, 0x07, 0xFF, 0x80, 0x04, 0x3C, 0x03, 0x80, 0x08, 0xE0, 0x01,
  0x80, 0x33, 0x00, 0x01, 0x80, 0x6C, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0x2C, 0x00, 0x03, 0x80, 0xCC, 0x00, 0x0E, 0x01, 0x8E, 0x00, 0x38,
  0x03, 0x0F, 0x03, 0xE0, 0x06, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x01, 0xE0, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0x1F, 0xFE, 0x06, 0x00, 0x3C,
  0x03, 0xC6, 0x00, 0x38, 0x00, 0x73, 0x00, 0x38, 0x00, 0x19, 0x80, 0x38,
  0x00, 0x06, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x1D, 0x80, 0x06, 0x00,
  0x38, 0xC0, 0x01, 0xC0, 0xF8, 0x60, 0x00, 0x7F, 0xF0, 0x30, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x78, 0x40, 0x07,
  0x00, 0x0E, 0x60, 0x07, 0x00, 0x03, 0x30, 0x07, 0x00, 0x00, 0xD8, 0x07,
  0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x03, 0xC0, 0x0C, 0x00,
  0x03, 0xE0, 0x03, 0x00, 0x03, 0xB0, 0x00, 0xC0, 0x07, 0x98, 0x00, 0x3C,
  0x1F, 0x0C, 0x00, 0x0F, 0xFE, 0x06, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x3F,
  0xC0, 0x01, 0x01, 0xFF, 0xF0, 0x03, 0x07, 0x80, 0x38, 0x03, 0x0E, 0x00,
  0x1C, 0x03, 0x18, 0x00, 0x0C, 0x03, 0x30, 0x00, 0x06, 0x02, 0x60, 0x00,
  0x06, 0x02, 0xC0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x02, 0x07, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x38, 0x02, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x04, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x08, 0x38, 0x00, 0x00, 0x18, 0x78, 0x00, 0x00, 0x18, 0xF8, 0x00,
  0x00, 0x1B, 0x8C, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0x38, 0x0C, 0x38, 0x0E, 0x03, 0x60,
  0x06, 0x70, 0x06, 0x02, 0xC0, 0x06, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x80,
  0x03, 0x03, 0x00, 0x03, 0x80, 0x03, 0x07, 0x00, 0x03, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x00, 0x02, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x10, 0x00, 0x18, 0x00, 0x08, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x30, 0x00, 0x10, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x20, 0x00, 0x30, 0x00, 0x10, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x60, 0x00, 0x30, 0x00, 0x30, 0x60, 0x00, 0x20, 0x00, 0x30, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x30, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x40, 0x00, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x80, 0x3F, 0xC0, 0x01, 0x01, 0xFF, 0xF0, 0x03, 0x07, 0x80, 0x38,
  0x03, 0x0E, 0x00, 0x1C, 0x03, 0x18, 0x00, 0x0C, 0x03, 0x30, 0x00, 0x06,
  0x02, 0x60, 0x00, 0x06, 0x02, 0xC0, 0x00, 0x06, 0x07, 0x80, 0x00, 0x02,
  0x07, 0x00, 0x00, 0x02, 0x07, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x7F, 0xF8, 0x00, 0x10, 0xF0, 0x0E,
  0x00, 0x18, 0xE0, 0x01, 0x80, 0x0C, 0xC0, 0x00, 0x60, 0x06, 0xC0, 0x00,
  0x18, 0x03, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x1B, 0x00, 0x00, 0xE0, 0x0C, 0xC0, 0x00, 0xE0, 0x06, 0x38, 0x01, 0xE0,
  0x03, 0x0F, 0x03, 0xC0, 0x01, 0x81, 0xFF, 0xC0, 0x00, 0x80, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x0C, 0x01, 0xE0, 0x1E, 0x10, 0x07, 0x00, 0x0E, 0x60, 0x1C,
  0x00, 0x0E, 0xC0, 0x70, 0x00, 0x0D, 0x81, 0xC0, 0x00, 0x0F, 0x03, 0x00,
  0x00, 0x1E, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x0F, 0x80, 0x30, 0x00, 0x3B, 0x00, 0x30, 0x01, 0xE6, 0x00, 0x3C,
  0x1F, 0x0C, 0x00, 0x3F, 0xF8, 0x18, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x18, 0x07, 0xFF, 0xC0, 0xC0, 0xF8, 0x00,
  0x06, 0x1E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x06,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x82, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x78, 0x18, 0x00, 0x01, 0xF0, 0x18,
  0x00, 0x07, 0x60, 0x38, 0x00, 0x1C, 0xC0, 0x38, 0x00, 0xE3, 0x00, 0x3C,
  0x0F, 0x86, 0x00, 0x3F, 0xFC, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x06, 0xC0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x0A, 0x00, 0x04, 0x40, 0x01,
  0xA0, 0x00, 0xC4, 0x00, 0x1A, 0x00, 0x0C, 0x60, 0x03, 0x20, 0x01, 0x86,
  0x00, 0x33, 0x00, 0x18, 0x60, 0x02, 0x30, 0x01, 0x86, 0x00, 0x63, 0x00,
  0x30, 0x60, 0x06, 0x30, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x0C,
  0x30, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0x60, 0x18, 0x30, 0x0C, 0x06,
  0x01, 0x83, 0x00, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x06, 0x03, 0x03, 0x01,
  0x80, 0x60, 0x60, 0x10, 0x18, 0x06, 0x06, 0x01, 0x03, 0x00, 0x60, 0x40,
  0x10, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x02,
  0x18, 0x01, 0x86, 0x00, 0x21, 0x80, 0x18, 0xC0, 0x02, 0x30, 0x01, 0x8C,
  0x00, 0x23, 0x00, 0x19, 0x80, 0x02, 0x20, 0x01, 0x98, 0x00, 0x36, 0x00,
  0x19, 0x80, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x03,
  0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC3, 0x81, 0xC0, 0x00, 0x0C,
  0x30, 0x03, 0x00, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x30,
  0x00, 0x31, 0x80, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x03, 0x80, 0x38, 0xC0,
  0x00, 0x0E, 0x03, 0x86, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00,
};

const GFXglyph RobotoMono_ThinItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 11, 49, 41, 14, -49 },
  { 69, 13, 14, 41, 17, -52 },
  { 92, 40, 49, 41, 1, -49 },
  { 337, 33, 63, 41, 5, -56 },
  { 597, 33, 51, 41, 4, -50 },
  { 808, 34, 51, 41, 3, -50 },
  { 1025, 5, 14, 41, 20, -52 },
  { 1034, 21, 71, 41, 12, -55 },
  { 1221, 21, 71, 41, 6, -55 },
  { 1408, 28, 27, 41, 10, -49 },
  { 1503, 33, 36, 41, 4, -41 },
  { 1652, 7, 14, 41, 9, -5 },
  { 1665, 24, 1, 41, 8, -23 },
  { 1668, 4, 4, 41, 16, -4 },
  { 1670, 31, 53, 41, 6, -49 },
  { 1876, 32, 51, 41, 5, -50 },
  { 2080, 17, 49, 41, 11, -49 },
  { 2185, 32, 50, 41, 2, -50 },
  { 2385, 33, 51, 41, 2, -50 },
  { 2596, 33, 49, 41, 2, -49 },
  { 2799, 34, 50, 41, 6, -49 },
  { 3012, 30, 51, 41, 4, -50 },
  { 3204, 30, 49, 41, 9, -49 },
  { 3388, 34, 51, 41, 4, -50 },
  { 3605, 29, 51, 41, 7, -50 },
  { 3790, 9, 34, 41, 18, -34 },
  { 3829, 13, 43, 41, 14, -34 },
  { 3899, 30, 27, 41, 6, -36 },
  { 4001, 32, 15, 41, 5, -30 },
  { 4061, 31, 27, 41, 4, -36 },
  { 4166, 25, 50, 41, 11, -50 },
  { 4323, 39, 51, 41, 1, -50 },
  { 4572, 34, 49, 41, 0, -49 },
  { 4781, 33, 49, 41, 4, -49 },
  { 4984, 34, 51, 41, 4, -50 },
  { 5201, 35, 49, 41, 3, -49 },
  { 5416, 35, 49, 41, 4, -49 },
  { 5631, 36, 49, 41, 4, -49 },
  { 5852, 34, 51, 41, 4, -50 },
  { 6069, 37, 49, 41, 2, -49 },
  { 6296, 35, 49, 41, 3, -49 },
  { 6511, 35, 50, 41, 3, -49 },
  { 6730, 38, 49, 41, 4, -49 },
  { 6963, 28, 49, 41, 4, -49 },
  { 7135, 37, 49, 41, 3, -49 },
  { 7362, 37, 49, 41, 2, -49 },
  { 7589, 33, 51, 41, 4, -50 },
  { 7800, 36, 49, 41, 4, -49 },
  { 8021, 34, 59, 41, 4, -50 },
  { 8272, 34, 49, 41, 4, -49 },
  { 8481, 34, 51, 41, 4, -50 },
  { 8698, 34, 49, 41, 8, -49 },
  { 8907, 34, 50, 41, 5, -49 },
  { 9120, 33, 49, 41, 8, -49 },
  { 9323, 35, 49, 41, 8, -49 },
  { 9538, 40, 49, 41, 1, -49 },
  { 9783, 33, 49, 41, 8, -49 },
  { 9986, 36, 49, 41, 2, -49 },
  { 10207, 20, 67, 41, 11, -56 },
  { 10375, 13, 53, 41, 14, -49 },
  { 10462, 20, 67, 41, 10, -56 },
  { 10630, 23, 27, 41, 9, -49 },
  { 10708, 28, 2, 41, 2, 0 },
  { 10715, 7, 9, 41, 21, -51 },
  { 10723, 31, 38, 41, 4, -37 },
  { 10871, 31, 53, 41, 4, -52 },
  { 11077, 30, 38, 41, 5, -37 },
  { 11220, 33, 53, 41, 5, -52 },
  { 11439, 32, 38, 41, 4, -37 },
  { 11591, 33, 52, 41, 9, -52 },
  { 11806, 33, 52, 41, 3, -37 },
  { 12021, 32, 52, 41, 3, -52 },
  { 12229, 28, 49, 41, 4, -49 },
  { 12401, 31, 64, 41, 0, -49 },
  { 12649, 32, 52, 41, 5, -52 },
  { 12857, 28, 52, 41, 4, -52 },
  { 13039, 40, 37, 41, -1, -37 },
  { 13224, 32, 37, 41, 3, -37 },
  { 13372, 32, 38, 41, 4, -37 },
  { 13524, 33, 51, 41, 1, -37 },
  { 13735, 31, 51, 41, 5, -37 },
  { 13933, 29, 37, 41, 9, -37 },
  { 14068, 31, 38, 41, 5, -37 },
  { 14216, 25, 47, 41, 9, -46 },
  { 14363, 31, 37, 41, 5, -36 },
  { 14507, 33, 36, 41, 6, -36 },
  { 14656, 36, 36, 41, 5, -36 },
  { 14818, 36, 36, 41, 2, -36 },
  { 14980, 41, 51, 41, -1, -36 },
  { 15242, 36, 36, 41, 1, -36 },
  { 15404, 26, 69, 41, 11, -54 },
  { 15629, 11, 58, 41, 15, -49 },
  { 15709, 26, 69, 41, 6, -54 },
  { 15934, 37, 11, 41, 2, -26 },
};

const GFXfont RobotoMono_ThinItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic69pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_THINITALIC69PT7B_H_
