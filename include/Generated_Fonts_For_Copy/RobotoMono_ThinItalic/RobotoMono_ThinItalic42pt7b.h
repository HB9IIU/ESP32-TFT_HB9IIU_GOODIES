#ifndef _ROBOTOMONO_THINITALIC42PT7B_H_
#define _ROBOTOMONO_THINITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41,
  0x04, 0x30, 0x82, 0x08, 0x20, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x42, 0x85, 0x0A, 0x1C, 0x70, 0xA1, 0x42, 0x84, 0x00, 0x0C, 0x04, 0x00,
  0x08, 0x08, 0x00, 0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x10, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20, 0x1F,
  0xFF, 0xFF, 0x00, 0x40, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x80, 0xC0, 0x00,
  0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x00, 0x03,
  0x01, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00, 0x04, 0x02, 0x00, 0xFF,
  0xFF, 0xF0, 0x04, 0x04, 0x00, 0x08, 0x04, 0x00, 0x08, 0x08, 0x00, 0x08,
  0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x40, 0x40, 0x02, 0x0C, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x31, 0x00, 0x03, 0x10, 0x00, 0x31, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x08,
  0x80, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x02, 0x00, 0x60, 0x30, 0x0C,
  0x00, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x0F, 0x80, 0x00, 0xC6, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x44,
  0x06, 0x06, 0x20, 0x30, 0x21, 0x01, 0x02, 0x08, 0x08, 0x30, 0x40, 0x41,
  0x02, 0x06, 0x10, 0x10, 0x21, 0x00, 0x82, 0x18, 0x03, 0xE0, 0x80, 0x06,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x1F,
  0x00, 0x21, 0x84, 0x02, 0x18, 0x20, 0x20, 0x80, 0x83, 0x0C, 0x04, 0x10,
  0x40, 0x21, 0x02, 0x03, 0x18, 0x10, 0x10, 0x80, 0x80, 0x88, 0x04, 0x0C,
  0x00, 0x20, 0x40, 0x01, 0x84, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0C,
  0x30, 0x01, 0x81, 0x00, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x02,
  0x01, 0x00, 0x20, 0x10, 0x02, 0x02, 0x00, 0x20, 0x40, 0x02, 0x18, 0x00,
  0x13, 0x00, 0x01, 0x60, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00, 0x64, 0x00,
  0x0C, 0x20, 0x01, 0x82, 0x01, 0x30, 0x10, 0x12, 0x01, 0x81, 0x40, 0x08,
  0x34, 0x00, 0x42, 0xC0, 0x06, 0x68, 0x00, 0x24, 0x80, 0x01, 0x8C, 0x00,
  0x18, 0x40, 0x03, 0x86, 0x00, 0x64, 0x30, 0x18, 0x60, 0xFF, 0x03, 0x24,
  0xB4, 0x92, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x07, 0x82, 0x0E, 0x39, 0x38, 0x03,
  0xE0, 0x00, 0xC0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0xC2, 0x00, 0xC0, 0x80,
  0xC0, 0x60, 0xC0, 0x18, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFE, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x18,
  0x84, 0x22, 0x11, 0x18, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x30, 0x0C, 0x03, 0x02, 0x00, 0x20,
  0xC0, 0x02, 0x10, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0x64,
  0x00, 0x14, 0x80, 0x0C, 0xB0, 0x03, 0x14, 0x00, 0xC2, 0x80, 0x20, 0x50,
  0x08, 0x0A, 0x02, 0x03, 0x40, 0x80, 0x58, 0x60, 0x0A, 0x18, 0x01, 0x46,
  0x00, 0x29, 0x00, 0x0D, 0x40, 0x01, 0x30, 0x00, 0x24, 0x00, 0x08, 0xC0,
  0x01, 0x08, 0x00, 0x41, 0x00, 0x18, 0x10, 0x06, 0x03, 0x01, 0x80, 0x1F,
  0xC0, 0x00, 0x00, 0x40, 0x70, 0xE4, 0xE1, 0xC0, 0xA0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x18, 0x03, 0x00, 0x40,
  0x40, 0x06, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02,
  0x10, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x4F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x0C, 0x0C,
  0x03, 0x00, 0x20, 0x60, 0x03, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x11, 0x80, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0xC0, 0x00, 0xC4, 0x00, 0x08,
  0x40, 0x01, 0x02, 0x00, 0x20, 0x18, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00,
  0x64, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x10, 0xC0, 0x02, 0x08, 0x00,
  0x60, 0x80, 0x0C, 0x08, 0x01, 0x80, 0x80, 0x10, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x01, 0x01, 0x80, 0x10, 0x30, 0x01, 0x02, 0x00, 0x10,
  0x40, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x1F, 0x00, 0x17, 0x1C, 0x03, 0x80, 0x20,
  0x20, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x40, 0x04, 0x06, 0x00, 0xC0, 0x30,
  0x18, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x03, 0x00, 0x8F, 0xF0, 0x4C, 0x02, 0x14, 0x00, 0x46,
  0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01,
  0x30, 0x00, 0x84, 0x00, 0x60, 0x80, 0x30, 0x30, 0x18, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x06, 0x03, 0x00, 0x60, 0x0C, 0x04, 0x00, 0x20, 0x60,
  0x01, 0x82, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x82, 0x00, 0x04, 0x08, 0x00, 0x40, 0x60, 0x04, 0x01, 0x80,
  0xC0, 0x03, 0xF8, 0x00, 0x70, 0xE0, 0x0C, 0x00, 0x80, 0xC0, 0x02, 0x0C,
  0x00, 0x18, 0x40, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00,
  0x88, 0x00, 0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x18, 0x00, 0x20, 0x40,
  0x02, 0x01, 0x80, 0x60, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xC0, 0x80,
  0xC0, 0x10, 0x60, 0x02, 0x10, 0x00, 0x88, 0x00, 0x16, 0x00, 0x05, 0x00,
  0x01, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x34, 0x00, 0x09, 0x00, 0x06, 0x40, 0x02, 0x88, 0x01, 0x21,
  0x01, 0x98, 0x3F, 0x84, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x1F, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x38, 0x30, 0xC0, 0x13, 0x00, 0x24, 0x00,
  0x78, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x38, 0x38, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x04,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x0F, 0x02, 0x08, 0x19, 0x82,
  0x10, 0x20, 0x42, 0x10, 0x40, 0x82, 0x20, 0x80, 0x82, 0x20, 0x80, 0x82,
  0x61, 0x01, 0x82, 0x41, 0x01, 0x02, 0x43, 0x01, 0x02, 0xC2, 0x01, 0x02,
  0x82, 0x02, 0x04, 0x82, 0x02, 0x04, 0x82, 0x06, 0x04, 0x82, 0x06, 0x08,
  0x82, 0x0A, 0x08, 0x82, 0x1A, 0x10, 0x82, 0x32, 0x30, 0x81, 0xE3, 0xE0,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x22,
  0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x01, 0x86, 0x00, 0x08, 0x10, 0x00,
  0xC0, 0x80, 0x04, 0x04, 0x00, 0x60, 0x20, 0x02, 0x01, 0x00, 0x30, 0x08,
  0x01, 0x00, 0x60, 0x18, 0x01, 0x00, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x7F,
  0xFE, 0x06, 0x00, 0x10, 0x20, 0x00, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11,
  0x80, 0x00, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x60, 0x00,
  0x0C, 0x07, 0xFE, 0x00, 0x20, 0x1C, 0x01, 0x00, 0x18, 0x08, 0x00, 0x40,
  0x40, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00,
  0x10, 0x40, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x0C, 0x08,
  0x01, 0x80, 0x7F, 0xF0, 0x02, 0x00, 0x60, 0x10, 0x00, 0xC1, 0x00, 0x02,
  0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x11, 0x80,
  0x00, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x60,
  0x80, 0x06, 0x0C, 0x00, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x18,
  0x18, 0x02, 0x00, 0x40, 0x40, 0x06, 0x08, 0x00, 0x21, 0x80, 0x03, 0x10,
  0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x0C, 0x00,
  0x30, 0x40, 0x02, 0x02, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x20, 0x1C, 0x01, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x80, 0x02,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80,
  0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04,
  0x40, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00,
  0x04, 0x40, 0x00, 0x66, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x08,
  0x00, 0x18, 0x40, 0x00, 0x82, 0x00, 0x08, 0x30, 0x01, 0x81, 0x00, 0x18,
  0x08, 0x03, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xFC, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xFC, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x18, 0x02, 0x00, 0x40,
  0x40, 0x02, 0x08, 0x00, 0x21, 0x80, 0x01, 0x10, 0x00, 0x12, 0x00, 0x01,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x3F, 0xE8, 0x03,
  0xFE, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80,
  0x00, 0x48, 0x00, 0x0C, 0x80, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x82,
  0x00, 0x30, 0x10, 0x0E, 0x00, 0xFF, 0x80, 0x06, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00,
  0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10,
  0x20, 0x00, 0x20, 0x40, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01, 0x07,
  0xFF, 0xFE, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x80,
  0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00,
  0x08, 0x10, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x01,
  0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00, 0x08, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00,
  0x18, 0x30, 0x01, 0x80, 0x80, 0x18, 0x03, 0x01, 0x80, 0x0F, 0xF0, 0x00,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x04, 0x04, 0x00, 0x18, 0x04, 0x00, 0x30,
  0x04, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x08, 0x03, 0x00,
  0x08, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x18, 0x00, 0x08, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x10, 0x80, 0x00, 0x11, 0x40, 0x00, 0x12, 0x40, 0x00,
  0x1C, 0x20, 0x00, 0x18, 0x30, 0x00, 0x30, 0x10, 0x00, 0x20, 0x08, 0x00,
  0x20, 0x08, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x01, 0x00, 0x40, 0x01, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0xC0,
  0x40, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0x04, 0x00, 0x0C, 0x38, 0x00, 0x30,
  0xA0, 0x01, 0xC2, 0x80, 0x05, 0x0A, 0x00, 0x2C, 0x28, 0x00, 0xA0, 0xB0,
  0x04, 0x86, 0x40, 0x32, 0x11, 0x00, 0x88, 0x44, 0x06, 0x21, 0x10, 0x11,
  0x84, 0x60, 0x84, 0x10, 0x82, 0x10, 0xC2, 0x10, 0x42, 0x08, 0xC1, 0x08,
  0x22, 0x04, 0x20, 0xD8, 0x20, 0x81, 0x40, 0x82, 0x06, 0x02, 0x18, 0x18,
  0x08, 0x40, 0x00, 0x21, 0x00, 0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80,
  0x00, 0x82, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18,
  0x00, 0x18, 0x28, 0x00, 0x20, 0x50, 0x00, 0x40, 0x90, 0x00, 0x83, 0x20,
  0x01, 0x04, 0x40, 0x02, 0x08, 0x40, 0x0C, 0x10, 0x80, 0x10, 0x21, 0x80,
  0x20, 0x41, 0x00, 0x41, 0x82, 0x00, 0x82, 0x02, 0x01, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x20, 0x10, 0x20, 0x80, 0x30, 0x41,
  0x00, 0x20, 0x82, 0x00, 0x42, 0x04, 0x00, 0x44, 0x08, 0x00, 0x88, 0x10,
  0x01, 0x10, 0x40, 0x01, 0x20, 0x80, 0x02, 0x41, 0x00, 0x07, 0x02, 0x00,
  0x06, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x18,
  0x18, 0x02, 0x00, 0xC0, 0x40, 0x04, 0x08, 0x00, 0x21, 0x80, 0x02, 0x10,
  0x00, 0x23, 0x00, 0x03, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00,
  0x48, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x0C, 0x00,
  0x20, 0x40, 0x06, 0x02, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x20, 0x0E, 0x03, 0x00, 0x18, 0x10, 0x00, 0x20, 0x80, 0x01,
  0x04, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80,
  0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x03, 0x08, 0x00, 0x30,
  0x80, 0x03, 0x04, 0x00, 0x70, 0x3F, 0xFE, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x06, 0x00,
  0xC0, 0x08, 0x04, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x04, 0x60, 0x00,
  0x22, 0x00, 0x01, 0x30, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0xC0,
  0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0x40, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00,
  0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x08, 0x40, 0x00, 0xC2,
  0x00, 0x04, 0x08, 0x00, 0x40, 0x60, 0x04, 0x01, 0x80, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0x00, 0x20, 0x0E, 0x01, 0x00, 0x18, 0x08, 0x00,
  0x60, 0x40, 0x01, 0x02, 0x00, 0x0C, 0x30, 0x00, 0x21, 0x00, 0x01, 0x08,
  0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x21, 0x00, 0x02,
  0x08, 0x00, 0x20, 0x40, 0x02, 0x02, 0x00, 0x60, 0x1F, 0xFC, 0x00, 0x80,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x60, 0x10, 0x01, 0x00,
  0x80, 0x08, 0x04, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x0C, 0x10, 0x00,
  0x20, 0x80, 0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x20, 0x00, 0x7F, 0x80,
  0x0E, 0x07, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x20, 0xC0, 0x01, 0x84, 0x00,
  0x04, 0x20, 0x00, 0x23, 0x00, 0x01, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x04,
  0x40, 0x00, 0x62, 0x00, 0x02, 0x18, 0x00, 0x30, 0x60, 0x03, 0x01, 0x80,
  0x60, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x08, 0x80, 0x00,
  0x44, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0,
  0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00,
  0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88,
  0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80, 0x01,
  0x06, 0x00, 0x18, 0x10, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x07,
  0xF0, 0x00, 0x80, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x2C, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x01,
  0x04, 0x00, 0x30, 0x60, 0x02, 0x02, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x10, 0x01, 0x01, 0x00, 0x10,
  0x20, 0x01, 0x02, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x18, 0x80, 0x00,
  0x88, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xA0, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x05, 0x00, 0xC0, 0x28, 0x0A, 0x01, 0x40, 0x50, 0x12, 0x02, 0x80, 0x90,
  0x24, 0x04, 0x81, 0x20, 0x64, 0x09, 0x02, 0x20, 0x88, 0x11, 0x04, 0x40,
  0x88, 0x22, 0x08, 0x42, 0x10, 0x42, 0x10, 0x82, 0x10, 0x84, 0x20, 0x88,
  0x31, 0x04, 0x41, 0x88, 0x26, 0x0C, 0x81, 0x20, 0x64, 0x09, 0x01, 0x20,
  0x58, 0x0A, 0x02, 0x80, 0x50, 0x14, 0x02, 0x80, 0xE0, 0x1C, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x06, 0x00, 0x02, 0x02, 0x00, 0x04, 0x02, 0x00, 0x08,
  0x01, 0x00, 0x18, 0x01, 0x00, 0x10, 0x00, 0x80, 0x20, 0x00, 0x80, 0x40,
  0x00, 0xC0, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x61, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x82, 0x00,
  0x01, 0x02, 0x00, 0x02, 0x01, 0x00, 0x06, 0x01, 0x00, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x10, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x20, 0x00, 0x60,
  0x40, 0x00, 0x20, 0x80, 0x00, 0x30, 0x80, 0x00, 0x1C, 0x00, 0x02, 0x40,
  0x00, 0x44, 0x00, 0x0C, 0x60, 0x00, 0x82, 0x00, 0x10, 0x20, 0x03, 0x03,
  0x00, 0x20, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x81, 0x00,
  0x08, 0x30, 0x00, 0xC2, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x04, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xC0, 0x81, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x81,
  0x02, 0x03, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x0F,
  0xC0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x80, 0x11, 0x00, 0x22,
  0x00, 0x84, 0x03, 0x08, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x80, 0x41,
  0x00, 0xC4, 0x00, 0x98, 0x01, 0x20, 0x02, 0x80, 0x06, 0xFF, 0xFF, 0xC0,
  0x84, 0x42, 0x30, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x0C, 0x03, 0x02, 0x00,
  0x20, 0x80, 0x06, 0x30, 0x00, 0x44, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x01, 0xFF, 0xE0, 0xE0, 0x04, 0x20, 0x00,
  0x88, 0x00, 0x12, 0x00, 0x06, 0x40, 0x00, 0x98, 0x00, 0x12, 0x00, 0x06,
  0x20, 0x01, 0x44, 0x00, 0x48, 0x40, 0x31, 0x07, 0xF8, 0x20, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x03, 0x00, 0x23, 0xFC,
  0x04, 0x80, 0xC0, 0xE0, 0x0C, 0x18, 0x00, 0x86, 0x00, 0x18, 0x80, 0x01,
  0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0xC8, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x11,
  0x00, 0x02, 0x30, 0x00, 0x86, 0x00, 0x30, 0xE0, 0x0C, 0x16, 0x03, 0x06,
  0x3F, 0x80, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x60, 0x10, 0x30, 0x02, 0x18,
  0x00, 0xC4, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0xB0, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x20,
  0x04, 0x0C, 0x06, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x02, 0x02, 0x03, 0xFC, 0x60, 0x60, 0x34,
  0x0C, 0x01, 0x41, 0x80, 0x0C, 0x10, 0x00, 0xC2, 0x00, 0x04, 0x20, 0x00,
  0xC4, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00,
  0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x04, 0x00, 0x30, 0x40, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x32, 0x01,
  0xFE, 0x20, 0x00, 0x18, 0x00, 0x3F, 0xC0, 0x1C, 0x04, 0x06, 0x00, 0x41,
  0x80, 0x0C, 0x20, 0x00, 0x88, 0x00, 0x13, 0x00, 0x02, 0x40, 0x00, 0x48,
  0x00, 0x0B, 0xFF, 0xFF, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x82, 0x00, 0x20, 0x30, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0xE3, 0x03, 0x01, 0xA0, 0x60, 0x0A, 0x0C,
  0x00, 0x60, 0x80, 0x06, 0x10, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x42,
  0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x0C,
  0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x20, 0x01,
  0x82, 0x00, 0x38, 0x30, 0x07, 0x01, 0x81, 0xD0, 0x0F, 0xF1, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x08, 0x00, 0x40, 0x80,
  0x08, 0x04, 0x01, 0x00, 0x30, 0x60, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x01, 0x80, 0x21, 0xFE, 0x04,
  0xC0, 0x61, 0xB0, 0x04, 0x28, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x01, 0x10,
  0x00, 0x22, 0x00, 0x04, 0xC0, 0x00, 0x90, 0x00, 0x32, 0x00, 0x04, 0x40,
  0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x19, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0x24, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x01, 0x08,
  0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x01, 0x00, 0x60, 0x10, 0x0C, 0x01,
  0x01, 0x00, 0x10, 0x60, 0x03, 0x0C, 0x00, 0x21, 0x80, 0x02, 0x70, 0x00,
  0x2D, 0x00, 0x03, 0x88, 0x00, 0x20, 0xC0, 0x06, 0x04, 0x00, 0x40, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x18, 0x04, 0x00, 0x80, 0x40, 0x04, 0x0C, 0x00,
  0x60, 0x80, 0x02, 0x08, 0x00, 0x18, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0xE0,
  0x38, 0x13, 0xB8, 0xFC, 0x14, 0x09, 0x02, 0x18, 0x0E, 0x03, 0x10, 0x04,
  0x01, 0x10, 0x04, 0x01, 0x30, 0x08, 0x03, 0x20, 0x08, 0x02, 0x20, 0x08,
  0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x02, 0x40, 0x10,
  0x04, 0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0x40, 0x10,
  0x04, 0x40, 0x10, 0x04, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x80, 0x20,
  0x08, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x00, 0x0C, 0x01, 0x0F, 0xF0,
  0x26, 0x03, 0x0D, 0x80, 0x21, 0x40, 0x02, 0x30, 0x00, 0x46, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x26, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x22,
  0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x13, 0x00, 0x02, 0x40, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x03, 0x01, 0x80, 0x40, 0x04,
  0x08, 0x00, 0x61, 0x80, 0x02, 0x30, 0x00, 0x22, 0x00, 0x03, 0x60, 0x00,
  0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x03, 0xC0, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x2C, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08, 0x40,
  0x01, 0x82, 0x00, 0x30, 0x30, 0x06, 0x01, 0x80, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x47, 0xF8, 0x05, 0x80, 0xC0, 0x70, 0x06, 0x0E, 0x00,
  0x20, 0xC0, 0x02, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x18, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x31, 0x00, 0x02, 0x10,
  0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x83,
  0x00, 0x18, 0x38, 0x03, 0x02, 0xC0, 0x60, 0x43, 0xF8, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F,
  0x8C, 0x18, 0x0D, 0x06, 0x00, 0xA1, 0x80, 0x0C, 0x20, 0x01, 0x88, 0x00,
  0x11, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x60, 0x00,
  0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x03, 0x86, 0x00, 0xE0, 0x60, 0x74,
  0x07, 0xF8, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x08, 0x03, 0x08, 0x3F, 0xC4, 0x60, 0x02, 0x40, 0x01, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x18, 0x06, 0x04, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0xCC, 0x00, 0x08, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x60, 0x00,
  0x84, 0x00, 0x30, 0x60, 0x1C, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x90,
  0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x60,
  0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x01, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x01, 0x08, 0x00, 0x61, 0x00,
  0x14, 0x30, 0x06, 0x83, 0x03, 0x20, 0x3F, 0xC4, 0x00, 0x80, 0x00, 0x3C,
  0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x86, 0x00, 0x10,
  0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x06, 0x03, 0x00, 0x40, 0x10, 0x08,
  0x01, 0x00, 0x80, 0x10, 0x10, 0x01, 0x83, 0x00, 0x08, 0x20, 0x00, 0x86,
  0x00, 0x08, 0x40, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x07,
  0x00, 0x00, 0x20, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x2C, 0x07, 0x00,
  0xB0, 0x14, 0x06, 0xC0, 0x50, 0x13, 0x02, 0x40, 0x44, 0x09, 0x02, 0x10,
  0x64, 0x08, 0x41, 0x10, 0x61, 0x04, 0x41, 0x04, 0x21, 0x04, 0x10, 0x84,
  0x20, 0x44, 0x18, 0x81, 0x10, 0x66, 0x04, 0xC0, 0x90, 0x12, 0x02, 0x40,
  0x48, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x60, 0x20,
  0x03, 0x00, 0xC0, 0x18, 0x01, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x30,
  0x00, 0x11, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x48, 0x00, 0x03, 0x30, 0x00, 0x18, 0x40, 0x00, 0xC0,
  0x80, 0x06, 0x03, 0x00, 0x30, 0x04, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0x43, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x81, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x60, 0x10, 0x00,
  0x20, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x18, 0x00, 0x60, 0x08, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x04,
  0x04, 0x00, 0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x09, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x0F, 0x00, 0x02, 0x31, 0x80, 0x08, 0x81, 0x80, 0x12, 0x01, 0x80,
  0x44, 0x01, 0x81, 0x90, 0x00, 0xC6, 0x20, 0x00, 0xF0, 0x00,
};

const GFXglyph RobotoMono_ThinItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 30, 25, 9, -30 },
  { 24, 7, 9, 25, 11, -32 },
  { 32, 24, 30, 25, 1, -30 },
  { 122, 20, 38, 25, 3, -34 },
  { 217, 21, 30, 25, 2, -30 },
  { 296, 20, 30, 25, 2, -30 },
  { 371, 3, 9, 25, 12, -32 },
  { 375, 13, 43, 25, 7, -33 },
  { 445, 12, 43, 25, 4, -33 },
  { 510, 17, 16, 25, 6, -30 },
  { 544, 20, 22, 25, 3, -25 },
  { 599, 5, 8, 25, 5, -3 },
  { 604, 14, 1, 25, 5, -14 },
  { 606, 2, 2, 25, 10, -2 },
  { 607, 19, 33, 25, 3, -30 },
  { 686, 19, 30, 25, 3, -30 },
  { 758, 10, 30, 25, 7, -30 },
  { 796, 20, 30, 25, 1, -30 },
  { 871, 20, 30, 25, 1, -30 },
  { 946, 20, 30, 25, 1, -30 },
  { 1021, 20, 30, 25, 4, -30 },
  { 1096, 18, 30, 25, 3, -30 },
  { 1164, 19, 30, 25, 5, -30 },
  { 1236, 21, 30, 25, 2, -30 },
  { 1315, 18, 30, 25, 4, -30 },
  { 1383, 5, 20, 25, 11, -20 },
  { 1396, 9, 25, 25, 8, -20 },
  { 1425, 19, 17, 25, 3, -22 },
  { 1466, 19, 9, 25, 3, -18 },
  { 1488, 18, 17, 25, 3, -22 },
  { 1527, 15, 30, 25, 7, -30 },
  { 1584, 24, 30, 25, 1, -30 },
  { 1674, 21, 30, 25, 0, -30 },
  { 1753, 21, 30, 25, 2, -30 },
  { 1832, 20, 30, 25, 3, -30 },
  { 1907, 21, 30, 25, 2, -30 },
  { 1986, 22, 30, 25, 2, -30 },
  { 2069, 22, 30, 25, 2, -30 },
  { 2152, 20, 30, 25, 3, -30 },
  { 2227, 23, 30, 25, 1, -30 },
  { 2314, 21, 30, 25, 2, -30 },
  { 2393, 21, 30, 25, 2, -30 },
  { 2472, 24, 30, 25, 2, -30 },
  { 2562, 16, 30, 25, 3, -30 },
  { 2622, 22, 30, 25, 2, -30 },
  { 2705, 23, 30, 25, 1, -30 },
  { 2792, 20, 30, 25, 3, -30 },
  { 2867, 21, 30, 25, 3, -30 },
  { 2946, 21, 35, 25, 2, -30 },
  { 3038, 21, 30, 25, 2, -30 },
  { 3117, 21, 30, 25, 2, -30 },
  { 3196, 20, 30, 25, 5, -30 },
  { 3271, 21, 30, 25, 3, -30 },
  { 3350, 20, 30, 25, 5, -30 },
  { 3425, 21, 30, 25, 5, -30 },
  { 3504, 24, 30, 25, 1, -30 },
  { 3594, 20, 30, 25, 5, -30 },
  { 3669, 22, 30, 25, 1, -30 },
  { 3752, 12, 40, 25, 7, -34 },
  { 3812, 7, 33, 25, 9, -30 },
  { 3841, 12, 40, 25, 6, -34 },
  { 3901, 15, 17, 25, 5, -30 },
  { 3933, 18, 1, 25, 1, 0 },
  { 3936, 4, 5, 25, 13, -31 },
  { 3939, 19, 23, 25, 2, -23 },
  { 3994, 19, 32, 25, 2, -32 },
  { 4070, 18, 23, 25, 3, -23 },
  { 4122, 20, 32, 25, 3, -32 },
  { 4202, 19, 23, 25, 3, -23 },
  { 4257, 19, 32, 25, 6, -32 },
  { 4333, 20, 32, 25, 2, -23 },
  { 4413, 19, 32, 25, 2, -32 },
  { 4489, 16, 30, 25, 3, -30 },
  { 4549, 19, 39, 25, 0, -30 },
  { 4642, 20, 32, 25, 3, -32 },
  { 4722, 16, 32, 25, 3, -32 },
  { 4786, 24, 23, 25, 0, -23 },
  { 4855, 19, 23, 25, 2, -23 },
  { 4910, 20, 23, 25, 2, -23 },
  { 4968, 20, 32, 25, 1, -23 },
  { 5048, 19, 32, 25, 3, -23 },
  { 5124, 17, 23, 25, 6, -23 },
  { 5173, 19, 23, 25, 3, -23 },
  { 5228, 16, 28, 25, 5, -28 },
  { 5284, 19, 22, 25, 3, -22 },
  { 5337, 20, 22, 25, 4, -22 },
  { 5392, 22, 22, 25, 3, -22 },
  { 5453, 22, 22, 25, 1, -22 },
  { 5514, 25, 31, 25, -1, -22 },
  { 5611, 21, 22, 25, 1, -22 },
  { 5669, 16, 42, 25, 7, -33 },
  { 5753, 7, 36, 25, 9, -30 },
  { 5785, 16, 42, 25, 4, -33 },
  { 5869, 23, 7, 25, 1, -16 },
};

const GFXfont RobotoMono_ThinItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic42pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_THINITALIC42PT7B_H_
