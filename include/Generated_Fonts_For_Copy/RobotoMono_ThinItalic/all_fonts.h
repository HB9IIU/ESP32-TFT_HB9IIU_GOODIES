#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoMono_ThinItalic
// Headers: 67

#include "RobotoMono_ThinItalic6pt7b.h"
#include "RobotoMono_ThinItalic7pt7b.h"
#include "RobotoMono_ThinItalic8pt7b.h"
#include "RobotoMono_ThinItalic9pt7b.h"
#include "RobotoMono_ThinItalic10pt7b.h"
#include "RobotoMono_ThinItalic11pt7b.h"
#include "RobotoMono_ThinItalic12pt7b.h"
#include "RobotoMono_ThinItalic13pt7b.h"
#include "RobotoMono_ThinItalic14pt7b.h"
#include "RobotoMono_ThinItalic15pt7b.h"
#include "RobotoMono_ThinItalic16pt7b.h"
#include "RobotoMono_ThinItalic17pt7b.h"
#include "RobotoMono_ThinItalic18pt7b.h"
#include "RobotoMono_ThinItalic19pt7b.h"
#include "RobotoMono_ThinItalic20pt7b.h"
#include "RobotoMono_ThinItalic21pt7b.h"
#include "RobotoMono_ThinItalic22pt7b.h"
#include "RobotoMono_ThinItalic23pt7b.h"
#include "RobotoMono_ThinItalic24pt7b.h"
#include "RobotoMono_ThinItalic25pt7b.h"
#include "RobotoMono_ThinItalic26pt7b.h"
#include "RobotoMono_ThinItalic27pt7b.h"
#include "RobotoMono_ThinItalic28pt7b.h"
#include "RobotoMono_ThinItalic29pt7b.h"
#include "RobotoMono_ThinItalic30pt7b.h"
#include "RobotoMono_ThinItalic31pt7b.h"
#include "RobotoMono_ThinItalic32pt7b.h"
#include "RobotoMono_ThinItalic33pt7b.h"
#include "RobotoMono_ThinItalic34pt7b.h"
#include "RobotoMono_ThinItalic35pt7b.h"
#include "RobotoMono_ThinItalic36pt7b.h"
#include "RobotoMono_ThinItalic37pt7b.h"
#include "RobotoMono_ThinItalic38pt7b.h"
#include "RobotoMono_ThinItalic39pt7b.h"
#include "RobotoMono_ThinItalic40pt7b.h"
#include "RobotoMono_ThinItalic41pt7b.h"
#include "RobotoMono_ThinItalic42pt7b.h"
#include "RobotoMono_ThinItalic43pt7b.h"
#include "RobotoMono_ThinItalic44pt7b.h"
#include "RobotoMono_ThinItalic45pt7b.h"
#include "RobotoMono_ThinItalic46pt7b.h"
#include "RobotoMono_ThinItalic47pt7b.h"
#include "RobotoMono_ThinItalic48pt7b.h"
#include "RobotoMono_ThinItalic49pt7b.h"
#include "RobotoMono_ThinItalic50pt7b.h"
#include "RobotoMono_ThinItalic51pt7b.h"
#include "RobotoMono_ThinItalic52pt7b.h"
#include "RobotoMono_ThinItalic53pt7b.h"
#include "RobotoMono_ThinItalic54pt7b.h"
#include "RobotoMono_ThinItalic55pt7b.h"
#include "RobotoMono_ThinItalic56pt7b.h"
#include "RobotoMono_ThinItalic57pt7b.h"
#include "RobotoMono_ThinItalic58pt7b.h"
#include "RobotoMono_ThinItalic59pt7b.h"
#include "RobotoMono_ThinItalic60pt7b.h"
#include "RobotoMono_ThinItalic61pt7b.h"
#include "RobotoMono_ThinItalic62pt7b.h"
#include "RobotoMono_ThinItalic63pt7b.h"
#include "RobotoMono_ThinItalic64pt7b.h"
#include "RobotoMono_ThinItalic65pt7b.h"
#include "RobotoMono_ThinItalic66pt7b.h"
#include "RobotoMono_ThinItalic67pt7b.h"
#include "RobotoMono_ThinItalic68pt7b.h"
#include "RobotoMono_ThinItalic69pt7b.h"
#include "RobotoMono_ThinItalic70pt7b.h"
#include "RobotoMono_ThinItalic71pt7b.h"
#include "RobotoMono_ThinItalic72pt7b.h"
