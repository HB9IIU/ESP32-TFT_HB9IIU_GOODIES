#ifndef _ROBOTOMONO_THINITALIC24PT7B_H_
#define _ROBOTOMONO_THINITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x00, 0x00, 0x80, 0x59, 0x99,
  0x90, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x10, 0xFF, 0xB0,
  0x42, 0x01, 0x08, 0x04, 0x40, 0x21, 0x00, 0x84, 0x3F, 0xFC, 0x10, 0x80,
  0x42, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x01, 0x00, 0x20, 0x3A, 0x08,
  0x22, 0x02, 0x40, 0x50, 0x09, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x08, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x21, 0xD8, 0x04, 0x00, 0x80,
  0x3C, 0x04, 0x40, 0x44, 0x28, 0x44, 0x84, 0x48, 0x48, 0x49, 0x02, 0x20,
  0x02, 0x00, 0x44, 0x09, 0x90, 0x91, 0x12, 0x12, 0x21, 0x42, 0x10, 0x22,
  0x01, 0xC0, 0x07, 0x80, 0x84, 0x10, 0x41, 0x04, 0x10, 0x81, 0x10, 0x0A,
  0x00, 0xC0, 0x14, 0x02, 0x20, 0x42, 0x14, 0x12, 0x81, 0x28, 0x0C, 0x80,
  0x44, 0x1C, 0x3E, 0x20, 0x5A, 0x80, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x10, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x20, 0x80, 0x04, 0x01, 0x00, 0x43, 0x13, 0x3F, 0x03, 0x01, 0x20, 0x88,
  0x41, 0x00, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF,
  0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x55, 0x80, 0xFF, 0x80,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x06, 0x81, 0x60, 0x4C, 0x11,
  0x84, 0x31, 0x0A, 0x41, 0x70, 0x28, 0x05, 0x01, 0x20, 0x24, 0x08, 0x7E,
  0x00, 0x0C, 0xDC, 0x42, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00,
  0xFF, 0xC0, 0x0F, 0xC2, 0x04, 0x80, 0x90, 0x14, 0x02, 0x00, 0x40, 0x10,
  0x0C, 0x0F, 0x00, 0x10, 0x01, 0x00, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x08,
  0x7E, 0x00, 0x00, 0x40, 0x18, 0x05, 0x00, 0xA0, 0x24, 0x08, 0x82, 0x20,
  0x84, 0x10, 0x84, 0x11, 0x02, 0x40, 0x47, 0xF6, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x2F,
  0x03, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x48, 0x04, 0x80,
  0x84, 0x10, 0x3E, 0x00, 0x03, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x13, 0xE3, 0x82, 0x40, 0x28, 0x05, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x90,
  0x12, 0x04, 0x3F, 0x00, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x81, 0x10, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x10, 0x20, 0x84, 0x0F, 0x83, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x02, 0x40, 0x44, 0x0C, 0x3F, 0x00, 0x0F, 0x86, 0x08, 0x81, 0x20, 0x14,
  0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x48, 0x18, 0x8D, 0x0E, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x30, 0x78, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x04, 0x44, 0x88, 0x00, 0x20, 0x18, 0x1C, 0x0C, 0x06,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x00, 0x3E, 0x20, 0xA0, 0x30, 0x10,
  0x10, 0x08, 0x08, 0x0C, 0x08, 0x08, 0x04, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x03, 0xF0, 0x10, 0x20, 0x80, 0x44, 0x61, 0x22, 0x24,
  0x90, 0x94, 0x44, 0x52, 0x11, 0x48, 0x46, 0x21, 0x28, 0x88, 0xA2, 0x22,
  0x89, 0x91, 0x19, 0x84, 0x00, 0x08, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x08,
  0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x04, 0x40, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x21, 0xFE, 0x20, 0x22, 0x02, 0x40, 0x14, 0x01, 0x80, 0x10, 0x1F,
  0xC1, 0x02, 0x10, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x0C, 0x3F,
  0x84, 0x04, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x48, 0x08, 0xFF,
  0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x05, 0x01, 0x20, 0x24, 0x08, 0x7E,
  0x00, 0x1F, 0xC1, 0x02, 0x20, 0x22, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x28, 0x04, 0x80, 0x88,
  0x10, 0xFE, 0x00, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x3F, 0xC2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xC2, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x00, 0x07,
  0xC0, 0x82, 0x10, 0x12, 0x01, 0x20, 0x14, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x3E, 0x80, 0x28, 0x02, 0x80, 0x24, 0x02, 0x40, 0x22, 0x04, 0x1F,
  0x80, 0x20, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09, 0x00,
  0x48, 0x02, 0x7F, 0xE2, 0x01, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12,
  0x01, 0x10, 0x08, 0x80, 0x40, 0x1F, 0xF0, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x10, 0x0C, 0x40,
  0x41, 0x02, 0x04, 0x10, 0x20, 0x80, 0x84, 0x02, 0x20, 0x09, 0x00, 0x3C,
  0x00, 0x88, 0x04, 0x20, 0x10, 0x40, 0x40, 0x81, 0x02, 0x04, 0x04, 0x20,
  0x10, 0x80, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0x10,
  0x08, 0x80, 0xCC, 0x0A, 0x50, 0x62, 0x85, 0x14, 0x28, 0xA2, 0x49, 0x22,
  0x45, 0x12, 0x31, 0x11, 0x88, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90,
  0x08, 0x80, 0x40, 0x10, 0x09, 0x80, 0x4A, 0x04, 0x50, 0x22, 0x81, 0x12,
  0x09, 0x10, 0x48, 0x82, 0x42, 0x22, 0x11, 0x10, 0x48, 0x82, 0x48, 0x12,
  0x40, 0x52, 0x03, 0x10, 0x08, 0x80, 0x40, 0x0F, 0x82, 0x08, 0x80, 0xA0,
  0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28,
  0x05, 0x01, 0x20, 0x24, 0x08, 0x7E, 0x00, 0x3F, 0xC2, 0x02, 0x20, 0x12,
  0x01, 0x20, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0xC7, 0xE0, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x82,
  0x10, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x40, 0x44, 0x08, 0x3F, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x1F, 0xC1, 0x02, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x02, 0x20, 0xC3, 0xF0, 0x41, 0x04, 0x08, 0x40, 0x84, 0x08,
  0x40, 0x48, 0x04, 0x80, 0x20, 0x07, 0xE1, 0x81, 0x10, 0x12, 0x01, 0x20,
  0x12, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x02, 0x80,
  0x28, 0x02, 0x40, 0x24, 0x04, 0x3F, 0x80, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x00, 0x40, 0x14, 0x01,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x7E, 0x00, 0x80,
  0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0x42, 0x08, 0x42, 0x08,
  0x41, 0x10, 0x22, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x20, 0x00, 0x84,
  0x18, 0x41, 0x8C, 0x28, 0xC2, 0x8C, 0x29, 0x44, 0x92, 0x49, 0x24, 0xA2,
  0x8A, 0x28, 0xA2, 0x8C, 0x28, 0xC3, 0x08, 0x30, 0x82, 0x08, 0x20, 0x82,
  0x00, 0x10, 0x04, 0x20, 0x20, 0x81, 0x01, 0x04, 0x04, 0x20, 0x09, 0x00,
  0x28, 0x00, 0x60, 0x01, 0x00, 0x0A, 0x00, 0x48, 0x02, 0x20, 0x08, 0x40,
  0x41, 0x02, 0x02, 0x10, 0x08, 0xC0, 0x10, 0x80, 0x30, 0x0A, 0x01, 0x20,
  0x44, 0x10, 0x42, 0x08, 0x81, 0x20, 0x14, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xC0, 0x1E, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x70, 0x88, 0x88, 0x44, 0x44, 0x42, 0x22,
  0x22, 0x11, 0x11, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x78,
  0x04, 0x0A, 0x0A, 0x12, 0x12, 0x22, 0x21, 0x41, 0x81, 0xFF, 0xC0, 0x89,
  0x80, 0x07, 0x83, 0x08, 0x80, 0x90, 0x10, 0x02, 0x00, 0x43, 0xF9, 0x01,
  0x40, 0x50, 0x0A, 0x01, 0x20, 0xE3, 0xE4, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x4F, 0x0A, 0x11, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0x50, 0x12, 0x02, 0xC0, 0x97, 0xE0, 0x0F, 0x0C, 0x24, 0x05,
  0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x28, 0x09, 0x04, 0x3E,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x1C, 0x4C, 0x32, 0x02,
  0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81,
  0x8F, 0xD0, 0x0F, 0x0C, 0x24, 0x05, 0x01, 0x80, 0x7F, 0xF8, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x06, 0x3E, 0x00, 0x03, 0xF0, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x0F, 0xF8, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x07, 0xA3,
  0x0C, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x48, 0x09,
  0x01, 0x20, 0x63, 0xF4, 0x01, 0x00, 0x20, 0x08, 0x82, 0x0F, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x4F, 0x8A, 0x09, 0x81, 0x20, 0x24,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x08,
  0x01, 0x80, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC0, 0x00, 0x60,
  0x08, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x41, 0xF0, 0x00, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x48, 0x32, 0x08, 0x42, 0x09, 0x81, 0x40, 0x34, 0x04, 0x81, 0x08,
  0x20, 0x84, 0x10, 0x81, 0x10, 0x10, 0x0F, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x3F, 0xF0, 0x2E, 0x38, 0xC6, 0x22, 0x10, 0x50, 0x41,
  0x41, 0x09, 0x04, 0x24, 0x20, 0x90, 0x82, 0x82, 0x0A, 0x08, 0x28, 0x21,
  0x20, 0x84, 0x84, 0x10, 0x27, 0xC5, 0x04, 0xC0, 0x90, 0x12, 0x02, 0x80,
  0x50, 0x0A, 0x01, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x04, 0x07, 0x83,
  0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x09,
  0x01, 0x20, 0x43, 0xF0, 0x13, 0xC1, 0xC2, 0x10, 0x11, 0x01, 0x10, 0x12,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x22, 0x04, 0x5F, 0x84,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x4C, 0x34, 0x05, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x7E, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x23, 0xCB, 0x03, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1F,
  0x88, 0x14, 0x05, 0x01, 0x40, 0x0C, 0x00, 0xE0, 0x04, 0x00, 0x80, 0x18,
  0x0A, 0x02, 0x7F, 0x00, 0x08, 0x04, 0x02, 0x1F, 0xF1, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x3E, 0x40, 0x28,
  0x05, 0x01, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x12,
  0x02, 0x41, 0xC7, 0xC8, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x08, 0x81,
  0x08, 0x41, 0x10, 0x22, 0x04, 0x80, 0x50, 0x0C, 0x01, 0x00, 0x82, 0x18,
  0x41, 0x86, 0x18, 0xA2, 0x8A, 0x29, 0x24, 0x92, 0x49, 0x24, 0xA2, 0x8A,
  0x28, 0xC3, 0x0C, 0x10, 0x81, 0x00, 0x20, 0x12, 0x02, 0x10, 0x40, 0x88,
  0x09, 0x00, 0x60, 0x02, 0x00, 0x60, 0x09, 0x01, 0x10, 0x20, 0x84, 0x04,
  0x80, 0x40, 0x20, 0x04, 0x80, 0x22, 0x00, 0x84, 0x04, 0x10, 0x10, 0x40,
  0x80, 0x84, 0x02, 0x10, 0x08, 0x80, 0x24, 0x00, 0x50, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x03, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x81, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x0C, 0x0C, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x10, 0x11,
  0x12, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x18,
  0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x81, 0x80,
  0x78, 0x18, 0x41, 0x82, 0x28, 0x1C,
};

const GFXglyph RobotoMono_ThinItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 4, 5, 14, 6, -18 },
  { 13, 14, 17, 14, 0, -17 },
  { 43, 11, 21, 14, 2, -19 },
  { 72, 12, 17, 14, 1, -17 },
  { 98, 12, 17, 14, 1, -17 },
  { 124, 2, 5, 14, 7, -18 },
  { 126, 7, 25, 14, 4, -19 },
  { 148, 7, 25, 14, 2, -19 },
  { 170, 10, 9, 14, 3, -17 },
  { 182, 12, 12, 14, 1, -14 },
  { 200, 2, 5, 14, 3, -2 },
  { 202, 8, 1, 14, 3, -8 },
  { 203, 1, 1, 14, 6, -1 },
  { 204, 11, 18, 14, 2, -17 },
  { 229, 11, 17, 14, 2, -17 },
  { 253, 6, 17, 14, 4, -17 },
  { 266, 11, 17, 14, 1, -17 },
  { 290, 11, 17, 14, 1, -17 },
  { 314, 11, 17, 14, 1, -17 },
  { 338, 12, 17, 14, 2, -17 },
  { 364, 11, 17, 14, 1, -17 },
  { 388, 11, 17, 14, 3, -17 },
  { 412, 12, 17, 14, 1, -17 },
  { 438, 11, 17, 14, 2, -17 },
  { 462, 3, 11, 14, 6, -11 },
  { 467, 4, 14, 14, 5, -11 },
  { 474, 11, 10, 14, 2, -13 },
  { 488, 11, 6, 14, 2, -11 },
  { 497, 11, 10, 14, 1, -13 },
  { 511, 9, 17, 14, 4, -17 },
  { 531, 14, 17, 14, 0, -17 },
  { 561, 12, 17, 14, 0, -17 },
  { 587, 12, 17, 14, 1, -17 },
  { 613, 11, 17, 14, 2, -17 },
  { 637, 12, 17, 14, 1, -17 },
  { 663, 13, 17, 14, 1, -17 },
  { 691, 13, 17, 14, 1, -17 },
  { 719, 12, 17, 14, 1, -17 },
  { 745, 13, 17, 14, 1, -17 },
  { 773, 12, 17, 14, 1, -17 },
  { 799, 12, 17, 14, 1, -17 },
  { 825, 14, 17, 14, 1, -17 },
  { 855, 9, 17, 14, 2, -17 },
  { 875, 13, 17, 14, 1, -17 },
  { 903, 13, 17, 14, 1, -17 },
  { 931, 11, 17, 14, 2, -17 },
  { 955, 12, 17, 14, 2, -17 },
  { 981, 12, 20, 14, 1, -17 },
  { 1011, 12, 17, 14, 1, -17 },
  { 1037, 12, 17, 14, 1, -17 },
  { 1063, 12, 17, 14, 3, -17 },
  { 1089, 12, 17, 14, 2, -17 },
  { 1115, 11, 17, 14, 3, -17 },
  { 1139, 12, 17, 14, 3, -17 },
  { 1165, 14, 17, 14, 0, -17 },
  { 1195, 11, 17, 14, 3, -17 },
  { 1219, 12, 17, 14, 1, -17 },
  { 1245, 7, 24, 14, 4, -20 },
  { 1266, 4, 18, 14, 5, -17 },
  { 1275, 7, 24, 14, 3, -20 },
  { 1296, 8, 9, 14, 3, -17 },
  { 1305, 10, 1, 14, 1, 0 },
  { 1307, 3, 3, 14, 7, -18 },
  { 1309, 11, 13, 14, 1, -13 },
  { 1327, 11, 18, 14, 1, -18 },
  { 1352, 10, 13, 14, 2, -13 },
  { 1369, 11, 18, 14, 2, -18 },
  { 1394, 10, 13, 14, 2, -13 },
  { 1411, 12, 18, 14, 3, -18 },
  { 1438, 11, 18, 14, 1, -13 },
  { 1463, 11, 18, 14, 1, -18 },
  { 1488, 10, 17, 14, 1, -17 },
  { 1510, 11, 22, 14, 0, -17 },
  { 1541, 11, 18, 14, 2, -18 },
  { 1566, 10, 18, 14, 1, -18 },
  { 1589, 14, 13, 14, 0, -13 },
  { 1612, 11, 13, 14, 1, -13 },
  { 1630, 11, 13, 14, 1, -13 },
  { 1648, 12, 18, 14, 0, -13 },
  { 1675, 10, 18, 14, 2, -13 },
  { 1698, 10, 13, 14, 3, -13 },
  { 1715, 10, 13, 14, 2, -13 },
  { 1732, 9, 16, 14, 3, -16 },
  { 1750, 11, 13, 14, 2, -13 },
  { 1768, 11, 13, 14, 2, -13 },
  { 1786, 12, 13, 14, 2, -13 },
  { 1806, 12, 13, 14, 1, -13 },
  { 1826, 14, 18, 14, 0, -13 },
  { 1858, 13, 13, 14, 0, -13 },
  { 1880, 9, 24, 14, 4, -19 },
  { 1907, 4, 20, 14, 5, -17 },
  { 1917, 9, 24, 14, 2, -19 },
  { 1944, 12, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_ThinItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic24pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_THINITALIC24PT7B_H_
