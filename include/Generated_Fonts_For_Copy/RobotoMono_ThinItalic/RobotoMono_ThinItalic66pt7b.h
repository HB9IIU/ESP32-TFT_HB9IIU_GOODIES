#ifndef _ROBOTOMONO_THINITALIC66PT7B_H_
#define _ROBOTOMONO_THINITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x0E, 0x00,
  0x30, 0x33, 0x02, 0x30, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x04,
  0x40, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x88, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0x81, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x10, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03,
  0x00, 0x30, 0x40, 0x03, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x60, 0xC0, 0x02,
  0x00, 0xC0, 0xC0, 0x06, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0xC0, 0x06,
  0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x18,
  0x0C, 0x00, 0x60, 0x38, 0x18, 0x00, 0x70, 0x70, 0x30, 0x00, 0x3F, 0xE0,
  0x30, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x18,
  0x0E, 0x0C, 0x00, 0x18, 0x18, 0x06, 0x00, 0x30, 0x30, 0x02, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x60, 0x60, 0x03, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80,
  0x60, 0x03, 0x03, 0x00, 0x40, 0x03, 0x03, 0x00, 0xC0, 0x02, 0x06, 0x00,
  0xC0, 0x02, 0x0C, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x06, 0x18, 0x00,
  0xC0, 0x06, 0x30, 0x00, 0xC0, 0x0C, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x20,
  0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0xC0, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x18, 0x00, 0x60, 0x03, 0x18, 0x00,
  0x30, 0x06, 0x30, 0x00, 0x18, 0x06, 0x30, 0x00, 0x18, 0x06, 0x60, 0x00,
  0x0C, 0x0C, 0x60, 0x00, 0x06, 0x0C, 0x60, 0x00, 0x06, 0x18, 0x40, 0x00,
  0x03, 0x18, 0x40, 0x00, 0x01, 0xB0, 0x40, 0x00, 0x01, 0xE0, 0x60, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0xE0, 0x30, 0x00,
  0x07, 0x30, 0x18, 0x00, 0x0E, 0x18, 0x0C, 0x00, 0x38, 0x18, 0x07, 0x81,
  0xF0, 0x0C, 0x03, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x18, 0x8C,
  0x63, 0x18, 0xC4, 0x63, 0x18, 0xC4, 0x60, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x2F, 0x00, 0x60, 0x1F, 0x7C, 0x06,
  0x07, 0xC0, 0xF8, 0x63, 0xE0, 0x01, 0xF7, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x38,
  0x00, 0x1C, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83,
  0x0C, 0x18, 0x60, 0xC3, 0x0C, 0x00, 0xFF, 0xFF, 0xFC, 0x27, 0xF6, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x03,
  0x80, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03,
  0x46, 0x00, 0x00, 0x3B, 0x10, 0x00, 0x01, 0xCC, 0xC0, 0x00, 0x0C, 0x33,
  0x00, 0x00, 0x60, 0xCC, 0x00, 0x03, 0x03, 0x30, 0x00, 0x18, 0x0C, 0x80,
  0x00, 0xC0, 0x36, 0x00, 0x0E, 0x00, 0x98, 0x00, 0x70, 0x06, 0x60, 0x03,
  0x80, 0x19, 0x80, 0x18, 0x00, 0x64, 0x00, 0xC0, 0x01, 0x90, 0x06, 0x00,
  0x04, 0xC0, 0x30, 0x00, 0x13, 0x03, 0x80, 0x00, 0xCC, 0x1C, 0x00, 0x03,
  0x30, 0xE0, 0x00, 0x0C, 0xC6, 0x00, 0x00, 0x23, 0x30, 0x00, 0x01, 0x8D,
  0x80, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x1E, 0x20, 0x3C, 0x10, 0x78, 0x19, 0xF0, 0x0C, 0xC0,
  0x06, 0x80, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x07, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x04, 0x3F, 0xF8, 0x00, 0x0C, 0xF8, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x3F, 0x00, 0x18, 0x1F, 0xFE, 0x01, 0x87, 0x80, 0xF0, 0x11, 0xC0,
  0x03, 0x83, 0x30, 0x00, 0x1C, 0x36, 0x00, 0x00, 0xC2, 0xC0, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xF1,
  0x80, 0x00, 0x05, 0x0C, 0x00, 0x00, 0x58, 0x30, 0x00, 0x06, 0xC1, 0x80,
  0x00, 0xE6, 0x07, 0x00, 0x1C, 0x20, 0x1C, 0x03, 0xC3, 0x00, 0x7F, 0xF8,
  0x18, 0x00, 0x7E, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07,
  0x83, 0xC1, 0xC0, 0x00, 0x10, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0x83, 0xC0, 0x38, 0x01, 0xC0, 0xC0, 0x01, 0xC3, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x18, 0x01, 0xFE, 0x01, 0x80, 0xE0, 0x1E, 0x1C, 0x06, 0x03, 0x00, 0xE0,
  0x30, 0x08, 0x18, 0x07, 0x00, 0x40, 0x20, 0x60, 0x18, 0x03, 0x00, 0x83,
  0x00, 0xC0, 0x0C, 0x02, 0x0C, 0x06, 0x00, 0x20, 0x08, 0x60, 0x18, 0x01,
  0x80, 0x21, 0x80, 0xC0, 0x06, 0x01, 0x86, 0x03, 0x00, 0x18, 0x06, 0x30,
  0x18, 0x00, 0x40, 0x18, 0xC0, 0x60, 0x03, 0x00, 0x63, 0x01, 0x80, 0x0C,
  0x01, 0x98, 0x0C, 0x00, 0x20, 0x04, 0x60, 0x30, 0x01, 0x80, 0x31, 0x80,
  0xC0, 0x06, 0x00, 0xC6, 0x02, 0x00, 0x18, 0x03, 0x10, 0x08, 0x00, 0xC0,
  0x08, 0x40, 0x60, 0x03, 0x00, 0x61, 0x01, 0x80, 0x1C, 0x01, 0x8C, 0x06,
  0x00, 0x70, 0x0C, 0x30, 0x18, 0x03, 0xC0, 0x30, 0xC0, 0x60, 0x1A, 0x01,
  0x83, 0x01, 0x80, 0x6C, 0x06, 0x04, 0x02, 0x03, 0x30, 0x30, 0x10, 0x0C,
  0x38, 0xC1, 0x80, 0x60, 0x1F, 0xC1, 0xFC, 0x01, 0x80, 0x3C, 0x03, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x20, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0x10, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x08, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x80,
  0x60, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x78, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x10, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xC0, 0x00, 0xFF, 0xFC,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x30, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x08,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x04, 0x03, 0x80, 0x00, 0x00, 0x40, 0x70, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x0C, 0x36, 0x00,
  0x00, 0x00, 0xC6, 0x60, 0x00, 0x00, 0x08, 0xC3, 0x00, 0x00, 0x00, 0xB8,
  0x30, 0x00, 0x00, 0x1F, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x0B, 0x00,
  0x00, 0x32, 0x01, 0x90, 0x00, 0x03, 0x60, 0x19, 0x80, 0x00, 0x66, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x19, 0x80, 0x00, 0xC6, 0x01, 0x98, 0x00, 0x0C,
  0x40, 0x10, 0x80, 0x01, 0x84, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x30, 0xC0,
  0x03, 0x0C, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x30, 0xC0, 0x06, 0x0C, 0x02,
  0x04, 0x00, 0xC0, 0x80, 0x20, 0x40, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x30, 0x18, 0x06, 0x06, 0x03, 0x01, 0x80, 0x60, 0x20,
  0x60, 0x10, 0x04, 0x02, 0x06, 0x01, 0x00, 0x40, 0x30, 0xC0, 0x30, 0x0C,
  0x03, 0x0C, 0x03, 0x00, 0xC0, 0x31, 0x80, 0x30, 0x0C, 0x01, 0x10, 0x03,
  0x00, 0xC0, 0x13, 0x00, 0x20, 0x08, 0x01, 0xE0, 0x02, 0x01, 0x80, 0x1E,
  0x00, 0x60, 0x18, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x0A, 0x00, 0x00,
  0x06, 0x00, 0xB0, 0x00, 0x00, 0x60, 0x1B, 0x00, 0x00, 0x06, 0x01, 0x90,
  0x00, 0x00, 0x60, 0x19, 0x80, 0x00, 0x04, 0x01, 0x88, 0x00, 0x00, 0x40,
  0x10, 0x80, 0x00, 0x0C, 0x01, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x40, 0x00,
  0x0C, 0x03, 0x06, 0x00, 0x00, 0x80, 0x30, 0x60, 0x00, 0x08, 0x02, 0x02,
  0x00, 0x01, 0x80, 0x20, 0x30, 0x00, 0x18, 0x02, 0x01, 0x00, 0x01, 0x80,
  0x60, 0x10, 0x00, 0x18, 0x06, 0x01, 0x80, 0x01, 0x00, 0x60, 0x08, 0x00,
  0x10, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x40, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x02, 0x00,
  0xC0, 0x02, 0x00, 0x20, 0x08, 0x00, 0x30, 0x06, 0x00, 0x80, 0x01, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x18, 0x00,
  0x08, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x10, 0x00, 0x04, 0x0C, 0x01,
  0x00, 0x00, 0x60, 0xC0, 0x30, 0x00, 0x06, 0x0C, 0x03, 0x00, 0x00, 0x20,
  0xC0, 0x30, 0x00, 0x03, 0x08, 0x03, 0x00, 0x00, 0x30, 0x80, 0x20, 0x00,
  0x01, 0x18, 0x02, 0x00, 0x00, 0x19, 0x80, 0x60, 0x00, 0x00, 0x98, 0x06,
  0x00, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x00, 0xD0, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x04, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x02, 0x00, 0x00, 0x38,
  0x00, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x20, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x18, 0x00, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x02, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x06,
  0xC0, 0x01, 0xC0, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0x4C, 0x00, 0x34, 0x00,
  0x33, 0x00, 0x0D, 0x00, 0x0C, 0xC0, 0x06, 0x40, 0x02, 0x30, 0x01, 0x90,
  0x00, 0x8C, 0x00, 0x64, 0x00, 0x63, 0x00, 0x31, 0x00, 0x10, 0xC0, 0x0C,
  0x40, 0x04, 0x30, 0x02, 0x10, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x20, 0xC0, 0x10, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C,
  0x03, 0x06, 0x01, 0x03, 0x00, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x40, 0x30, 0x60, 0x18, 0x10, 0x0C, 0x18, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x60, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x18, 0x01, 0x84, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0x20, 0x03,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x36, 0x00, 0x09, 0x00,
  0x0D, 0x80, 0x02, 0xC0, 0x03, 0x60, 0x00, 0xB0, 0x00, 0xF0, 0x00, 0x28,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00, 0x06, 0x10, 0x00,
  0x0C, 0x20, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0x01, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x08, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00,
  0xC1, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x60, 0x00, 0x05, 0xC0, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x1C,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0x80, 0x0C, 0x0F, 0x80, 0x00, 0x40, 0xE0, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x1B,
  0x18, 0x00, 0x01, 0x98, 0x60, 0x00, 0x38, 0xC1, 0x80, 0x07, 0x86, 0x07,
  0x81, 0xF0, 0x30, 0x1F, 0xFE, 0x01, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x40, 0xFF, 0xC0, 0x06, 0x1F, 0x07,
  0x80, 0x31, 0xC0, 0x0E, 0x01, 0x98, 0x00, 0x30, 0x0D, 0x80, 0x00, 0xC0,
  0x58, 0x00, 0x03, 0x03, 0x80, 0x00, 0x18, 0x38, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x6C, 0x00, 0x03, 0x03, 0x70, 0x00,
  0x70, 0x19, 0xC0, 0x07, 0x00, 0xC7, 0x81, 0xF0, 0x04, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x1F, 0xF8, 0x18, 0x00, 0x7C, 0x1E, 0x18, 0x00, 0xE0,
  0x07, 0x18, 0x01, 0xC0, 0x01, 0x98, 0x03, 0x00, 0x00, 0x90, 0x06, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x3B, 0x00, 0x1C, 0x00,
  0xF3, 0x00, 0x0F, 0x03, 0xC2, 0x00, 0x03, 0xFF, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x7F, 0xFF, 0xFF, 0xF9, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xFC, 0x0C, 0x00, 0x7C, 0x1E, 0x18, 0x01,
  0xC0, 0x0E, 0x30, 0x07, 0x00, 0x06, 0x60, 0x18, 0x00, 0x04, 0x80, 0x60,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x03, 0xE0, 0x0C, 0x00, 0x0E, 0xC0, 0x0E, 0x00, 0x79, 0x80, 0x0F,
  0x03, 0xC2, 0x00, 0x07, 0xFE, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x3F,
  0xE0, 0x03, 0x07, 0xC1, 0xE0, 0x0C, 0x38, 0x01, 0xC0, 0x21, 0x80, 0x03,
  0x80, 0x8C, 0x00, 0x06, 0x06, 0x60, 0x00, 0x0C, 0x1B, 0x00, 0x00, 0x30,
  0x78, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x40, 0x70,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x3C, 0x00,
  0x00, 0x0C, 0xFC, 0x00, 0x00, 0x13, 0x18, 0x00, 0x00, 0x3C, 0x18, 0x00,
  0x00, 0xF0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x08, 0x00, 0x70, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x01, 0x00, 0x0C, 0x3F, 0xC0,
  0x7F, 0xC0, 0x33, 0xC3, 0x83, 0xC3, 0x80, 0x98, 0x07, 0x38, 0x06, 0x02,
  0xC0, 0x0D, 0xC0, 0x0C, 0x0E, 0x00, 0x16, 0x00, 0x30, 0x70, 0x00, 0x70,
  0x00, 0xC1, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x40, 0x00, 0xC0, 0x00, 0xC1, 0x00, 0x03, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x20, 0xC0,
  0x00, 0x80, 0x00, 0x83, 0x00, 0x02, 0x00, 0x06, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x20, 0x00, 0x60, 0x00, 0x61, 0x80, 0x01, 0x80, 0x01, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x18, 0x00, 0x10, 0x00, 0x30, 0x40, 0x00, 0x40, 0x00,
  0xC1, 0x00, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x00, 0x20, 0xC0, 0x00, 0x80, 0x00, 0x83, 0x00, 0x02, 0x00, 0x06,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x20, 0x00, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x00, 0x04, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x60, 0x00, 0x40, 0x00, 0xC1, 0x00, 0x03, 0x00, 0x03, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x0C,
  0x03, 0xFE, 0x00, 0x30, 0x7C, 0x1E, 0x00, 0xC3, 0x80, 0x1C, 0x02, 0x18,
  0x00, 0x38, 0x08, 0xC0, 0x00, 0x60, 0x66, 0x00, 0x00, 0x81, 0xB0, 0x00,
  0x03, 0x07, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x41, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0xFF,
  0xC0, 0x00, 0xC3, 0xE1, 0xE0, 0x00, 0xC7, 0x00, 0x38, 0x00, 0xDC, 0x00,
  0x18, 0x00, 0xB8, 0x00, 0x0C, 0x00, 0xB0, 0x00, 0x04, 0x01, 0xE0, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01,
  0xC0, 0x1B, 0x00, 0x03, 0x80, 0x19, 0xC0, 0x07, 0x00, 0x18, 0xF0, 0x3C,
  0x00, 0x10, 0x3F, 0xF8, 0x00, 0x30, 0x03, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0xC0, 0x1F, 0x07, 0x86, 0x01, 0xC0, 0x0E, 0x30,
  0x1C, 0x00, 0x19, 0x81, 0x80, 0x00, 0x68, 0x18, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x1C, 0x06, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x3B, 0x00, 0xE0, 0x07, 0x98,
  0x03, 0xC0, 0xF0, 0x80, 0x07, 0xFE, 0x04, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x60,
  0x1F, 0xFC, 0x08, 0x0F, 0xC0, 0x83, 0x07, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x0C, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x34, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xE0,
  0x40, 0x00, 0x07, 0x81, 0x80, 0x00, 0x36, 0x06, 0x00, 0x01, 0xD0, 0x0C,
  0x00, 0x0E, 0xC0, 0x18, 0x00, 0xE3, 0x00, 0x38, 0x1F, 0x0C, 0x00, 0x7F,
  0xF0, 0x30, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1B, 0x00,
  0x07, 0x00, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0xCC,
  0x00, 0x24, 0x00, 0x33, 0x00, 0x19, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x06,
  0x10, 0x03, 0x18, 0x01, 0x84, 0x00, 0xC6, 0x00, 0xC1, 0x00, 0x21, 0x80,
  0x30, 0x40, 0x18, 0x60, 0x18, 0x18, 0x06, 0x18, 0x06, 0x06, 0x03, 0x06,
  0x01, 0x81, 0x80, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x18, 0x18,
  0x18, 0x08, 0x06, 0x04, 0x02, 0x06, 0x01, 0x83, 0x00, 0x81, 0x80, 0x60,
  0xC0, 0x20, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x06, 0x18, 0x03, 0x08, 0x01,
  0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0,
  0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x2C, 0x00, 0x36,
  0x00, 0x0B, 0x00, 0x0D, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0C, 0x70, 0x38, 0x00, 0x01, 0x9C, 0x01, 0xC0, 0x00, 0x63,
  0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x01, 0xC0, 0x03, 0x18, 0x00, 0x1C, 0x00,
  0xE6, 0x00, 0x01, 0xC0, 0x38, 0xC0, 0x00, 0x1E, 0x0E, 0x10, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
};

const GFXglyph RobotoMono_ThinItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 10, 47, 39, 14, -47 },
  { 60, 12, 14, 39, 17, -50 },
  { 81, 38, 47, 39, 1, -47 },
  { 305, 31, 61, 39, 5, -54 },
  { 542, 32, 49, 39, 4, -48 },
  { 738, 32, 49, 39, 3, -48 },
  { 934, 5, 14, 39, 19, -50 },
  { 943, 19, 67, 39, 12, -52 },
  { 1103, 20, 67, 39, 6, -52 },
  { 1271, 28, 26, 39, 9, -47 },
  { 1362, 31, 34, 39, 4, -39 },
  { 1494, 7, 13, 39, 8, -5 },
  { 1506, 22, 1, 39, 8, -22 },
  { 1509, 4, 4, 39, 15, -4 },
  { 1511, 29, 51, 39, 6, -47 },
  { 1696, 30, 49, 39, 5, -48 },
  { 1880, 17, 47, 39, 10, -47 },
  { 1980, 30, 48, 39, 2, -48 },
  { 2160, 32, 49, 39, 2, -48 },
  { 2356, 32, 47, 39, 2, -47 },
  { 2544, 32, 48, 39, 6, -47 },
  { 2736, 28, 49, 39, 4, -48 },
  { 2908, 30, 47, 39, 8, -47 },
  { 3085, 32, 49, 39, 4, -48 },
  { 3281, 29, 49, 39, 6, -48 },
  { 3459, 9, 32, 39, 17, -32 },
  { 3495, 13, 40, 39, 13, -32 },
  { 3560, 30, 26, 39, 5, -34 },
  { 3658, 30, 15, 39, 5, -29 },
  { 3715, 29, 26, 39, 4, -35 },
  { 3810, 23, 48, 39, 11, -48 },
  { 3948, 38, 47, 39, 1, -47 },
  { 4172, 32, 47, 39, 0, -47 },
  { 4360, 32, 47, 39, 3, -47 },
  { 4548, 32, 49, 39, 4, -48 },
  { 4744, 33, 47, 39, 3, -47 },
  { 4938, 33, 47, 39, 4, -47 },
  { 5132, 34, 47, 39, 4, -47 },
  { 5332, 32, 49, 39, 4, -48 },
  { 5528, 36, 47, 39, 2, -47 },
  { 5740, 34, 47, 39, 3, -47 },
  { 5940, 33, 48, 39, 3, -47 },
  { 6138, 36, 47, 39, 4, -47 },
  { 6350, 26, 47, 39, 4, -47 },
  { 6503, 36, 47, 39, 2, -47 },
  { 6715, 36, 47, 39, 2, -47 },
  { 6927, 32, 49, 39, 4, -48 },
  { 7123, 34, 47, 39, 4, -47 },
  { 7323, 34, 56, 39, 3, -48 },
  { 7561, 32, 47, 39, 4, -47 },
  { 7749, 33, 49, 39, 4, -48 },
  { 7952, 32, 47, 39, 8, -47 },
  { 8140, 34, 48, 39, 4, -47 },
  { 8344, 31, 47, 39, 8, -47 },
  { 8527, 34, 47, 39, 7, -47 },
  { 8727, 38, 47, 39, 1, -47 },
  { 8951, 31, 47, 39, 8, -47 },
  { 9134, 34, 47, 39, 2, -47 },
  { 9334, 20, 64, 39, 10, -54 },
  { 9494, 12, 51, 39, 14, -47 },
  { 9571, 19, 64, 39, 10, -54 },
  { 9723, 23, 26, 39, 8, -47 },
  { 9798, 27, 2, 39, 2, 0 },
  { 9805, 6, 9, 39, 20, -49 },
  { 9812, 29, 37, 39, 4, -36 },
  { 9947, 29, 51, 39, 4, -50 },
  { 10132, 28, 37, 39, 5, -36 },
  { 10262, 32, 51, 39, 5, -50 },
  { 10466, 30, 37, 39, 4, -36 },
  { 10605, 31, 50, 39, 9, -50 },
  { 10799, 31, 50, 39, 3, -36 },
  { 10993, 30, 50, 39, 3, -50 },
  { 11181, 27, 47, 39, 4, -47 },
  { 11340, 30, 61, 39, 0, -47 },
  { 11569, 31, 50, 39, 5, -50 },
  { 11763, 27, 50, 39, 4, -50 },
  { 11932, 38, 36, 39, -1, -36 },
  { 12103, 30, 36, 39, 3, -36 },
  { 12238, 30, 37, 39, 4, -36 },
  { 12377, 32, 49, 39, 1, -36 },
  { 12573, 29, 49, 39, 5, -36 },
  { 12751, 27, 36, 39, 9, -36 },
  { 12873, 29, 37, 39, 5, -36 },
  { 13008, 24, 45, 39, 9, -44 },
  { 13143, 30, 36, 39, 5, -35 },
  { 13278, 31, 35, 39, 6, -35 },
  { 13414, 34, 35, 39, 5, -35 },
  { 13563, 34, 35, 39, 2, -35 },
  { 13712, 39, 49, 39, -1, -35 },
  { 13951, 34, 35, 39, 1, -35 },
  { 14100, 26, 65, 39, 10, -51 },
  { 14312, 10, 56, 39, 14, -47 },
  { 14382, 25, 65, 39, 6, -51 },
  { 14586, 35, 11, 39, 2, -25 },
};

const GFXfont RobotoMono_ThinItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic66pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_THINITALIC66PT7B_H_
