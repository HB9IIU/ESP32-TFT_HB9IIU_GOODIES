#ifndef _ROBOTOMONO_THINITALIC33PT7B_H_
#define _ROBOTOMONO_THINITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x40,
  0x00, 0x00, 0x43, 0x00, 0x45, 0x14, 0x51, 0x45, 0x28, 0x80, 0x00, 0x20,
  0x40, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x10, 0x1F, 0xFF, 0xF0, 0x08, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x01,
  0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80, 0x04, 0x08, 0x07,
  0xFF, 0xF8, 0x84, 0x10, 0x00, 0x81, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00,
  0x10, 0x20, 0x01, 0x04, 0x00, 0x20, 0x40, 0x00, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0xF0, 0x03, 0x0C, 0x04, 0x02, 0x08, 0x02, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x20, 0x30,
  0x1F, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x22, 0x00,
  0x41, 0x00, 0x41, 0x02, 0x81, 0x04, 0x81, 0x08, 0x81, 0x18, 0x82, 0x10,
  0x82, 0x20, 0x44, 0x40, 0x78, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x0C,
  0x02, 0x36, 0x04, 0x41, 0x08, 0x41, 0x08, 0x81, 0x10, 0x81, 0x20, 0x81,
  0x20, 0x82, 0x40, 0x82, 0x00, 0x84, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x10,
  0x04, 0x18, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20,
  0x08, 0x40, 0x04, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x11, 0x00,
  0x20, 0x81, 0x40, 0x82, 0x80, 0x42, 0x80, 0x26, 0x80, 0x24, 0x80, 0x18,
  0x80, 0x08, 0x80, 0x38, 0x40, 0x44, 0x3F, 0x82, 0x5A, 0xA8, 0x00, 0xC0,
  0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x0C, 0x23, 0x9D, 0x60, 0x1C, 0x00,
  0xC0, 0x09, 0x00, 0x84, 0x08, 0x30, 0x80, 0x80, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x12, 0x22, 0x24, 0x80, 0xFF, 0xE0,
  0xB0, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x00, 0xF0, 0x03, 0x0C, 0x04, 0x04, 0x08, 0x02, 0x10, 0x02, 0x10, 0x01,
  0x20, 0x03, 0x20, 0x05, 0x20, 0x09, 0x40, 0x11, 0x40, 0x22, 0x40, 0xC2,
  0x41, 0x82, 0x42, 0x02, 0x44, 0x02, 0x88, 0x04, 0x90, 0x04, 0xA0, 0x04,
  0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x30, 0x20, 0x60, 0x1F, 0x80,
  0x03, 0x0D, 0x71, 0x81, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x01,
  0xE0, 0x0C, 0x30, 0x30, 0x10, 0xC0, 0x11, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xFE, 0x00, 0xF0, 0x03, 0x0C,
  0x04, 0x02, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x40, 0x10, 0x20, 0x20, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x14, 0x00, 0x34, 0x00, 0x24, 0x00, 0x44, 0x00, 0x84, 0x01, 0x08,
  0x02, 0x08, 0x06, 0x08, 0x04, 0x08, 0x08, 0x08, 0x10, 0x08, 0x20, 0x10,
  0x40, 0x10, 0xC0, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x23, 0xC0,
  0x3C, 0x20, 0x20, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x20,
  0x60, 0x40, 0x1F, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x9F, 0xC5, 0x81, 0x98,
  0x02, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xA0, 0x02, 0x40, 0x11, 0x00, 0x42, 0x06, 0x07, 0xE0, 0xFF, 0xFE,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x03, 0x0C, 0x04, 0x02,
  0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02,
  0x10, 0x06, 0x08, 0x0C, 0x07, 0x70, 0x07, 0xF0, 0x18, 0x08, 0x20, 0x04,
  0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x40, 0x08, 0x20, 0x30, 0x1F, 0xC0, 0x03, 0xC0, 0x10, 0xC1, 0x80, 0x8C,
  0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x40, 0x0D, 0x00, 0x52, 0x02, 0x86, 0xF2, 0x04, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x1F, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x88, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x41, 0x08, 0x20, 0x00,
  0x04, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x10, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x81, 0x86, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x3C, 0x00, 0x71, 0xC0, 0x30, 0x08, 0x10, 0x03, 0x08, 0x00,
  0x44, 0x1C, 0x11, 0x08, 0xC4, 0x84, 0x11, 0x62, 0x08, 0x50, 0x82, 0x14,
  0x40, 0x86, 0x10, 0x21, 0x84, 0x10, 0x62, 0x04, 0x28, 0x81, 0x0A, 0x20,
  0x82, 0x88, 0x61, 0x22, 0x18, 0x48, 0x59, 0x62, 0x08, 0x20, 0xC0, 0x00,
  0x10, 0x00, 0x03, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x28, 0x00, 0x28, 0x00, 0x44, 0x00, 0x44, 0x00, 0x84, 0x00, 0x84, 0x01,
  0x04, 0x01, 0x04, 0x02, 0x04, 0x02, 0x02, 0x04, 0x02, 0x04, 0x02, 0x08,
  0x02, 0x0F, 0xFE, 0x10, 0x02, 0x10, 0x02, 0x20, 0x01, 0x20, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x0F, 0xF8, 0x10, 0x04, 0x10, 0x02, 0x10,
  0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20,
  0x08, 0x3F, 0xF0, 0x20, 0x70, 0x40, 0x08, 0x40, 0x04, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x18, 0x80,
  0x20, 0xFF, 0xC0, 0x00, 0x70, 0x03, 0x0C, 0x04, 0x02, 0x08, 0x02, 0x10,
  0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x40, 0x08, 0x40, 0x10, 0x20,
  0x60, 0x1F, 0x80, 0x0F, 0xFC, 0x04, 0x03, 0x02, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00,
  0x44, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x40,
  0x02, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x02,
  0x03, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x88, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0F, 0xFE, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x84, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x01, 0x07, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x0C, 0x04, 0x02,
  0x08, 0x02, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0xFE, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x40, 0x04,
  0x40, 0x0C, 0x20, 0x10, 0x1F, 0xE0, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02,
  0x10, 0x01, 0x08, 0x00, 0x43, 0xFF, 0xF0, 0x80, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x44, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x40, 0x0F, 0xFF,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x40, 0x02, 0x20, 0x02,
  0x08, 0x01, 0x04, 0x01, 0x01, 0x03, 0x00, 0x7F, 0x00, 0x08, 0x00, 0xC2,
  0x00, 0x41, 0x00, 0x20, 0x40, 0x10, 0x10, 0x08, 0x04, 0x0C, 0x01, 0x06,
  0x00, 0x83, 0x00, 0x21, 0x80, 0x08, 0xC0, 0x02, 0x60, 0x00, 0xA4, 0x00,
  0x31, 0x00, 0x08, 0x20, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x01, 0x02, 0x00, 0x20, 0x80, 0x08, 0x20, 0x01, 0x08, 0x00,
  0x60, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x03, 0xFF, 0xE0, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x14, 0x30, 0x0A,
  0x12, 0x02, 0x84, 0x81, 0x21, 0x20, 0x48, 0x48, 0x22, 0x12, 0x08, 0x88,
  0x44, 0x42, 0x11, 0x10, 0x84, 0x84, 0x21, 0x41, 0x08, 0x50, 0x42, 0x08,
  0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08,
  0x40, 0x02, 0x20, 0x01, 0x08, 0x00, 0x40, 0x08, 0x00, 0x43, 0x00, 0x10,
  0xC0, 0x08, 0x48, 0x02, 0x12, 0x00, 0x84, 0x80, 0x21, 0x10, 0x08, 0x44,
  0x02, 0x11, 0x01, 0x08, 0x20, 0x42, 0x08, 0x10, 0x81, 0x04, 0x20, 0x41,
  0x08, 0x10, 0x82, 0x02, 0x21, 0x00, 0x88, 0x40, 0x22, 0x10, 0x04, 0x84,
  0x01, 0x21, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0x40, 0x00,
  0xE0, 0x03, 0x0C, 0x04, 0x04, 0x08, 0x02, 0x10, 0x02, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x08, 0x40, 0x10, 0x40, 0x10, 0x20, 0x60, 0x1F, 0x80, 0x0F,
  0xFC, 0x04, 0x01, 0x82, 0x00, 0x42, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x10, 0x01, 0x88, 0x01, 0x84, 0x01,
  0x83, 0xFF, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0x0C, 0x04, 0x02, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x40, 0x10, 0x20, 0x60, 0x1F, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x0F, 0xF8, 0x08, 0x06,
  0x10, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x02, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x10, 0x3F, 0xE0, 0x40, 0x40,
  0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x04, 0x00, 0xF0, 0x03, 0x0C, 0x0C, 0x02,
  0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x40, 0x08, 0x20, 0x10, 0x1F, 0xC0, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x08, 0x03, 0x04, 0x01,
  0x01, 0x03, 0x00, 0x7E, 0x00, 0x80, 0x03, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40,
  0x20, 0x40, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x80, 0x20, 0x80, 0x21,
  0x00, 0x21, 0x00, 0x12, 0x00, 0x12, 0x00, 0x14, 0x00, 0x14, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x81, 0x81, 0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x50, 0x48,
  0x28, 0x24, 0x14, 0x12, 0x12, 0x11, 0x09, 0x08, 0x84, 0x84, 0x44, 0x42,
  0x22, 0x22, 0x12, 0x11, 0x09, 0x08, 0x84, 0x84, 0x82, 0x82, 0x41, 0x41,
  0x20, 0xA0, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x18, 0x18, 0x08, 0x0C, 0x04,
  0x06, 0x02, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x40, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x01, 0x00, 0x10, 0x20, 0x00, 0x84, 0x00, 0x08, 0xC0,
  0x00, 0x48, 0x00, 0x05, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x09, 0x00, 0x01, 0x10, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x40,
  0x40, 0x08, 0x04, 0x01, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x10, 0xC0,
  0x01, 0x00, 0x80, 0x03, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x10,
  0x20, 0x10, 0x20, 0x20, 0x20, 0x40, 0x10, 0x40, 0x10, 0x80, 0x11, 0x00,
  0x0A, 0x00, 0x0A, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xC1, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x03, 0xE0, 0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20,
  0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20, 0x81, 0x04,
  0x07, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xF0,
  0x01, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x44, 0x10, 0x82, 0x10, 0x82, 0x20,
  0x24, 0x05, 0x00, 0xE0, 0x10, 0xFF, 0xFC, 0x88, 0x90, 0x01, 0xE0, 0x0C,
  0x30, 0x60, 0x10, 0x80, 0x22, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x03, 0xFC, 0x38, 0x08, 0x80, 0x12, 0x00, 0x28, 0x00, 0x90, 0x01, 0x20,
  0x06, 0x40, 0x14, 0x40, 0x48, 0x7F, 0x10, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0xE0, 0x16, 0x18,
  0x50, 0x10, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x48, 0x00, 0xA0,
  0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x98, 0x02,
  0x30, 0x04, 0x50, 0x30, 0x9F, 0x80, 0x01, 0xC0, 0x0C, 0x30, 0x20, 0x10,
  0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x01, 0x10, 0x02, 0x20, 0x08,
  0x20, 0x20, 0x3F, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x01, 0xE2, 0x06, 0x12, 0x08, 0x0A,
  0x10, 0x06, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x40, 0x18,
  0x40, 0x18, 0x20, 0x70, 0x1F, 0x90, 0x00, 0xE0, 0x0C, 0x30, 0x20, 0x10,
  0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x7F, 0xFF, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x04,
  0x30, 0x30, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF8, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x03, 0x09, 0x04, 0x05,
  0x08, 0x03, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x20, 0x04, 0x20, 0x0C,
  0x20, 0x0C, 0x10, 0x38, 0x0F, 0xC8, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0xC0, 0x20, 0x20, 0xC0, 0x1F, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x70, 0x23,
  0x08, 0x48, 0x08, 0xA0, 0x11, 0x80, 0x12, 0x00, 0x24, 0x00, 0x50, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x08, 0x00, 0x20, 0x03, 0x80, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x1F, 0xFF, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
  0xFC, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x01, 0x10, 0x06, 0x10, 0x08, 0x10, 0x10, 0x10, 0x60, 0x20, 0xC0, 0x21,
  0x00, 0x22, 0x00, 0x2E, 0x00, 0x32, 0x00, 0x21, 0x00, 0x40, 0x80, 0x40,
  0x80, 0x40, 0x40, 0x40, 0x20, 0x40, 0x30, 0x40, 0x10, 0x80, 0x08, 0x0F,
  0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0xFF, 0xF8, 0x03, 0x83, 0x05, 0x89, 0x88, 0xC0, 0xC1, 0x18,
  0x10, 0x12, 0x02, 0x02, 0x40, 0x40, 0x88, 0x10, 0x12, 0x02, 0x02, 0x40,
  0x40, 0x48, 0x08, 0x09, 0x01, 0x01, 0x20, 0x20, 0x44, 0x08, 0x09, 0x01,
  0x01, 0x20, 0x20, 0x24, 0x04, 0x04, 0x80, 0x80, 0x90, 0x10, 0x20, 0x10,
  0xF0, 0x46, 0x10, 0x90, 0x11, 0x40, 0x23, 0x00, 0x44, 0x00, 0x48, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x10, 0x01, 0xC0, 0x0C,
  0x30, 0x60, 0x30, 0x80, 0x22, 0x00, 0x28, 0x00, 0x50, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x01, 0x20,
  0x02, 0x20, 0x08, 0x20, 0x60, 0x3F, 0x00, 0x00, 0xE0, 0x16, 0x18, 0x50,
  0x10, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x48, 0x00, 0x98, 0x02, 0x30,
  0x0C, 0x50, 0x30, 0x9F, 0x81, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x0C, 0x24, 0x20, 0x28,
  0x80, 0x32, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x0A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x88, 0x01, 0x10, 0x06, 0x20, 0x0C,
  0x20, 0x70, 0x3F, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x7C, 0x46, 0x01, 0x20, 0x07, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x01, 0xE0, 0x0C, 0x30, 0x60, 0x10, 0x80, 0x12, 0x00, 0x24, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xA0, 0x01, 0x20, 0x04, 0x60, 0x10, 0x3F, 0xC0, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xFC, 0x60, 0x05, 0x00, 0x14,
  0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x07, 0x10, 0x34,
  0x3F, 0x20, 0x80, 0x03, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08,
  0x20, 0x10, 0x20, 0x10, 0x20, 0x20, 0x20, 0x40, 0x10, 0x40, 0x10, 0x80,
  0x10, 0x80, 0x11, 0x00, 0x0B, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x81, 0x81, 0xC0, 0xC0, 0xA0, 0xA0, 0x50, 0x50, 0x48, 0x28, 0x24, 0x24,
  0x22, 0x12, 0x11, 0x11, 0x08, 0x88, 0x88, 0x48, 0x44, 0x24, 0x24, 0x12,
  0x12, 0x0A, 0x09, 0x05, 0x03, 0x03, 0x01, 0x81, 0x80, 0x80, 0x80, 0x40,
  0x00, 0x18, 0x01, 0x84, 0x01, 0x01, 0x01, 0x00, 0x81, 0x80, 0x21, 0x80,
  0x09, 0x80, 0x05, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xA0, 0x00, 0x88,
  0x00, 0x84, 0x00, 0x81, 0x00, 0x80, 0x40, 0x80, 0x20, 0x80, 0x08, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x40, 0x40, 0x04,
  0x04, 0x00, 0x80, 0x40, 0x18, 0x02, 0x01, 0x00, 0x20, 0x20, 0x02, 0x02,
  0x00, 0x20, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x09,
  0x00, 0x00, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x21, 0x08,
  0x84, 0x20, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0xA0, 0xC0, 0x60, 0x30, 0x50, 0x0C,
  0x68, 0x01, 0xC0,
};

const GFXglyph RobotoMono_ThinItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 6, 7, 19, 8, -25 },
  { 22, 20, 23, 19, 0, -23 },
  { 80, 16, 30, 19, 2, -27 },
  { 140, 16, 24, 19, 2, -24 },
  { 188, 16, 24, 19, 2, -24 },
  { 236, 2, 7, 19, 10, -25 },
  { 238, 10, 34, 19, 6, -26 },
  { 281, 10, 34, 19, 3, -26 },
  { 324, 13, 12, 19, 5, -23 },
  { 344, 16, 17, 19, 2, -19 },
  { 378, 4, 7, 19, 4, -3 },
  { 382, 11, 1, 19, 4, -11 },
  { 384, 2, 2, 19, 8, -2 },
  { 385, 15, 25, 19, 3, -23 },
  { 432, 16, 24, 19, 2, -24 },
  { 480, 8, 23, 19, 5, -23 },
  { 503, 15, 24, 19, 1, -24 },
  { 548, 16, 24, 19, 1, -24 },
  { 596, 16, 23, 19, 1, -23 },
  { 642, 16, 23, 19, 3, -23 },
  { 688, 14, 24, 19, 2, -24 },
  { 730, 15, 23, 19, 4, -23 },
  { 774, 16, 24, 19, 2, -24 },
  { 822, 14, 24, 19, 3, -24 },
  { 864, 4, 16, 19, 9, -16 },
  { 872, 6, 20, 19, 7, -16 },
  { 887, 14, 13, 19, 3, -17 },
  { 910, 15, 7, 19, 2, -14 },
  { 924, 15, 13, 19, 2, -17 },
  { 949, 12, 24, 19, 5, -24 },
  { 985, 18, 24, 19, 1, -24 },
  { 1039, 16, 23, 19, 0, -23 },
  { 1085, 16, 23, 19, 2, -23 },
  { 1131, 16, 24, 19, 2, -24 },
  { 1179, 17, 23, 19, 1, -23 },
  { 1228, 17, 23, 19, 2, -23 },
  { 1277, 17, 23, 19, 2, -23 },
  { 1326, 16, 24, 19, 2, -24 },
  { 1374, 18, 23, 19, 1, -23 },
  { 1426, 16, 23, 19, 2, -23 },
  { 1472, 17, 23, 19, 1, -23 },
  { 1521, 18, 23, 19, 2, -23 },
  { 1573, 13, 23, 19, 2, -23 },
  { 1611, 18, 23, 19, 1, -23 },
  { 1663, 18, 23, 19, 1, -23 },
  { 1715, 16, 24, 19, 2, -24 },
  { 1763, 17, 23, 19, 2, -23 },
  { 1812, 16, 28, 19, 2, -24 },
  { 1868, 16, 23, 19, 2, -23 },
  { 1914, 16, 24, 19, 2, -24 },
  { 1962, 16, 23, 19, 4, -23 },
  { 2008, 17, 23, 19, 2, -23 },
  { 2057, 16, 23, 19, 4, -23 },
  { 2103, 17, 23, 19, 4, -23 },
  { 2152, 20, 23, 19, 0, -23 },
  { 2210, 16, 23, 19, 4, -23 },
  { 2256, 17, 23, 19, 1, -23 },
  { 2305, 10, 32, 19, 5, -27 },
  { 2345, 6, 25, 19, 7, -23 },
  { 2364, 9, 32, 19, 5, -27 },
  { 2400, 11, 12, 19, 4, -23 },
  { 2417, 14, 1, 19, 1, 0 },
  { 2419, 3, 4, 19, 10, -24 },
  { 2421, 15, 18, 19, 2, -18 },
  { 2455, 15, 25, 19, 2, -25 },
  { 2502, 15, 18, 19, 2, -18 },
  { 2536, 16, 25, 19, 2, -25 },
  { 2586, 15, 18, 19, 2, -18 },
  { 2620, 16, 25, 19, 4, -25 },
  { 2670, 16, 25, 19, 1, -18 },
  { 2720, 15, 25, 19, 2, -25 },
  { 2767, 13, 24, 19, 2, -24 },
  { 2806, 15, 31, 19, 0, -24 },
  { 2865, 16, 25, 19, 2, -25 },
  { 2915, 13, 25, 19, 2, -25 },
  { 2956, 19, 18, 19, 0, -18 },
  { 2999, 15, 18, 19, 2, -18 },
  { 3033, 15, 18, 19, 2, -18 },
  { 3067, 15, 25, 19, 1, -18 },
  { 3114, 15, 25, 19, 2, -18 },
  { 3161, 14, 18, 19, 4, -18 },
  { 3193, 15, 18, 19, 2, -18 },
  { 3227, 12, 22, 19, 4, -22 },
  { 3260, 14, 17, 19, 3, -17 },
  { 3290, 16, 17, 19, 3, -17 },
  { 3324, 17, 17, 19, 3, -17 },
  { 3361, 17, 17, 19, 1, -17 },
  { 3398, 20, 24, 19, -1, -17 },
  { 3458, 17, 17, 19, 1, -17 },
  { 3495, 13, 33, 19, 5, -26 },
  { 3549, 5, 27, 19, 7, -23 },
  { 3566, 12, 33, 19, 3, -26 },
  { 3616, 17, 5, 19, 1, -12 },
};

const GFXfont RobotoMono_ThinItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic33pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_THINITALIC33PT7B_H_
