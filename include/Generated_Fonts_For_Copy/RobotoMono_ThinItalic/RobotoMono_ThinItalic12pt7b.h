#ifndef _ROBOTOMONO_THINITALIC12PT7B_H_
#define _ROBOTOMONO_THINITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xF0, 0x12, 0x24, 0x53, 0x72, 0x85, 0x3F, 0x28, 0x50,
  0x10, 0xE4, 0x61, 0x40, 0x81, 0x82, 0x8B, 0x42, 0x00, 0x42, 0xAA, 0xB4,
  0x20, 0xE5, 0x69, 0x38, 0x32, 0x54, 0xC4, 0x56, 0x71, 0xF8, 0xC0, 0x12,
  0x44, 0x88, 0x88, 0x88, 0x88, 0x40, 0x22, 0x11, 0x11, 0x11, 0x22, 0x24,
  0x80, 0x21, 0x2E, 0xC9, 0x00, 0x21, 0x09, 0xF2, 0x10, 0xE0, 0xF8, 0x80,
  0x08, 0x42, 0x21, 0x11, 0x08, 0x84, 0x00, 0x32, 0x63, 0x1B, 0xE6, 0x31,
  0xF0, 0x3C, 0x92, 0x92, 0x40, 0x39, 0x14, 0x41, 0x08, 0x42, 0x10, 0xF8,
  0x19, 0x94, 0x41, 0x38, 0x10, 0x61, 0x78, 0x04, 0x31, 0x45, 0x29, 0x2F,
  0xC2, 0x08, 0x3D, 0x04, 0x1C, 0x88, 0x20, 0xA2, 0xF0, 0x1B, 0x11, 0xE8,
  0xC6, 0x31, 0xF0, 0xF8, 0x44, 0x42, 0x21, 0x10, 0x80, 0x39, 0x18, 0x62,
  0x72, 0x28, 0xA2, 0xF0, 0x32, 0x63, 0x18, 0xEC, 0xA2, 0xE0, 0x40, 0x20,
  0x20, 0x00, 0x94, 0x1B, 0x30, 0x70, 0xFF, 0xC0, 0xE0, 0x87, 0xC0, 0x69,
  0x11, 0x24, 0x40, 0x80, 0x1C, 0x45, 0x6B, 0x5A, 0xB5, 0x6F, 0x40, 0x78,
  0x08, 0x21, 0x8A, 0x25, 0x17, 0xE1, 0x84, 0x72, 0x63, 0x1F, 0x46, 0x31,
  0xF0, 0x39, 0x18, 0x60, 0x82, 0x08, 0xA2, 0xF0, 0x72, 0x28, 0x61, 0x86,
  0x18, 0xA2, 0xF0, 0x7D, 0x08, 0x20, 0xFA, 0x08, 0x20, 0xF0, 0x7D, 0x08,
  0x20, 0xFA, 0x08, 0x20, 0x80, 0x39, 0x18, 0x60, 0x82, 0x68, 0xA2, 0xF0,
  0x22, 0x85, 0x0A, 0x17, 0xC8, 0xA1, 0x42, 0x84, 0x7C, 0x42, 0x08, 0x20,
  0x82, 0x08, 0xF0, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x44, 0x78, 0x45,
  0x29, 0x28, 0xC2, 0x89, 0x24, 0x88, 0x42, 0x11, 0x08, 0x42, 0x10, 0xF8,
  0x22, 0x44, 0x9B, 0x55, 0xAA, 0x91, 0x42, 0x84, 0x22, 0x45, 0x8A, 0x95,
  0x4A, 0xA3, 0x42, 0x84, 0x31, 0x28, 0x61, 0x86, 0x18, 0xA2, 0xF0, 0x79,
  0x14, 0x61, 0x8B, 0xC8, 0x20, 0x80, 0x39, 0x18, 0x61, 0x86, 0x18, 0xA2,
  0xF0, 0x40, 0x80, 0x79, 0x18, 0x61, 0x8B, 0xC9, 0x22, 0x88, 0x39, 0x18,
  0x60, 0x70, 0x20, 0xA2, 0xF0, 0xFC, 0x41, 0x08, 0x20, 0x82, 0x08, 0x40,
  0x46, 0x18, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x86, 0x18, 0x92, 0x49, 0x45,
  0x08, 0x40, 0x96, 0x59, 0x6D, 0xB7, 0x69, 0xA4, 0x90, 0x42, 0x44, 0x90,
  0xC1, 0x02, 0x0A, 0x22, 0x84, 0x86, 0x14, 0x94, 0x50, 0x82, 0x08, 0x40,
  0x3E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0xF8, 0x29, 0x24, 0xA4, 0x92,
  0x60, 0x91, 0x24, 0x91, 0x24, 0x24, 0x92, 0x4A, 0x49, 0x60, 0x22, 0x69,
  0x90, 0xF8, 0xC0, 0x7C, 0x5F, 0x18, 0xF8, 0x42, 0x2D, 0x98, 0xC6, 0x31,
  0xF0, 0x7C, 0x61, 0x08, 0xF8, 0x04, 0x13, 0x52, 0x8A, 0x28, 0xA2, 0xF0,
  0x7C, 0x7F, 0x08, 0x78, 0x3A, 0x3C, 0x84, 0x22, 0x10, 0x80, 0x7C, 0x63,
  0x18, 0xF8, 0x52, 0x60, 0x42, 0x2C, 0x98, 0xC6, 0x31, 0x88, 0x10, 0x18,
  0x22, 0x10, 0x84, 0xF8, 0x08, 0x0C, 0x10, 0x84, 0x22, 0x10, 0x89, 0x80,
  0x41, 0x04, 0x62, 0xB3, 0x0A, 0x24, 0x88, 0x70, 0x84, 0x22, 0x10, 0x84,
  0xF8, 0x7F, 0x26, 0x4C, 0x99, 0x34, 0x80, 0x7C, 0x63, 0x18, 0xC4, 0x7C,
  0x63, 0x18, 0xF8, 0x7D, 0x14, 0x51, 0x45, 0xE8, 0x20, 0x7C, 0x63, 0x18,
  0xF8, 0x42, 0x7C, 0x21, 0x08, 0x40, 0x7C, 0x18, 0x38, 0xF8, 0x4F, 0x44,
  0x48, 0x8E, 0x8C, 0x63, 0x18, 0xF8, 0x86, 0x25, 0x14, 0x61, 0x00, 0xA6,
  0x9D, 0xB6, 0x92, 0x40, 0x66, 0x50, 0x41, 0x84, 0x90, 0x80, 0x42, 0x89,
  0x11, 0x43, 0x04, 0x08, 0x20, 0x80, 0x7C, 0x21, 0x08, 0x43, 0xF0, 0x12,
  0x24, 0x48, 0x44, 0x44, 0x42, 0xFF, 0xE0, 0x20, 0x84, 0x21, 0x04, 0xC4,
  0x21, 0x11, 0x00, 0x61, 0x3C,
};

const GFXglyph RobotoMono_ThinItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 2, 2, 7, 3, -9 },
  { 4, 7, 9, 7, 0, -9 },
  { 12, 6, 11, 7, 1, -10 },
  { 21, 6, 9, 7, 1, -9 },
  { 28, 5, 9, 7, 1, -9 },
  { 34, 1, 2, 7, 3, -9 },
  { 35, 4, 13, 7, 2, -10 },
  { 42, 4, 13, 7, 1, -10 },
  { 49, 5, 5, 7, 2, -9 },
  { 53, 5, 6, 7, 1, -7 },
  { 57, 1, 3, 7, 2, -1 },
  { 58, 5, 1, 7, 1, -4 },
  { 59, 1, 1, 7, 3, -1 },
  { 60, 5, 10, 7, 1, -9 },
  { 67, 5, 9, 7, 1, -9 },
  { 73, 3, 9, 7, 2, -9 },
  { 77, 6, 9, 7, 0, -9 },
  { 84, 6, 9, 7, 0, -9 },
  { 91, 6, 9, 7, 0, -9 },
  { 98, 6, 9, 7, 1, -9 },
  { 105, 5, 9, 7, 1, -9 },
  { 111, 5, 9, 7, 2, -9 },
  { 117, 6, 9, 7, 1, -9 },
  { 124, 5, 9, 7, 1, -9 },
  { 130, 2, 6, 7, 3, -6 },
  { 132, 3, 8, 7, 2, -6 },
  { 135, 5, 4, 7, 1, -6 },
  { 138, 5, 2, 7, 1, -5 },
  { 140, 5, 4, 7, 1, -6 },
  { 143, 4, 9, 7, 2, -9 },
  { 148, 7, 9, 7, 0, -9 },
  { 156, 6, 9, 7, 0, -9 },
  { 163, 5, 9, 7, 1, -9 },
  { 169, 6, 9, 7, 1, -9 },
  { 176, 6, 9, 7, 1, -9 },
  { 183, 6, 9, 7, 1, -9 },
  { 190, 6, 9, 7, 1, -9 },
  { 197, 6, 9, 7, 1, -9 },
  { 204, 7, 9, 7, 0, -9 },
  { 212, 6, 9, 7, 1, -9 },
  { 219, 7, 9, 7, 0, -9 },
  { 227, 6, 9, 7, 1, -9 },
  { 234, 5, 9, 7, 1, -9 },
  { 240, 7, 9, 7, 0, -9 },
  { 248, 7, 9, 7, 0, -9 },
  { 256, 6, 9, 7, 1, -9 },
  { 263, 6, 9, 7, 1, -9 },
  { 270, 6, 11, 7, 1, -9 },
  { 279, 6, 9, 7, 1, -9 },
  { 286, 6, 9, 7, 1, -9 },
  { 293, 6, 9, 7, 1, -9 },
  { 300, 6, 9, 7, 1, -9 },
  { 307, 6, 9, 7, 1, -9 },
  { 314, 6, 9, 7, 1, -9 },
  { 321, 7, 9, 7, 0, -9 },
  { 329, 6, 9, 7, 1, -9 },
  { 336, 7, 9, 7, 0, -9 },
  { 344, 3, 12, 7, 2, -10 },
  { 349, 3, 10, 7, 2, -9 },
  { 353, 3, 12, 7, 2, -10 },
  { 358, 4, 5, 7, 2, -9 },
  { 361, 5, 1, 7, 0, 0 },
  { 362, 1, 2, 7, 4, -9 },
  { 363, 5, 6, 7, 1, -6 },
  { 367, 5, 9, 7, 1, -9 },
  { 373, 5, 6, 7, 1, -6 },
  { 377, 6, 9, 7, 1, -9 },
  { 384, 5, 6, 7, 1, -6 },
  { 388, 5, 9, 7, 2, -9 },
  { 394, 5, 9, 7, 1, -6 },
  { 400, 5, 9, 7, 1, -9 },
  { 406, 5, 9, 7, 1, -9 },
  { 412, 5, 12, 7, 0, -9 },
  { 420, 6, 9, 7, 1, -9 },
  { 427, 5, 9, 7, 1, -9 },
  { 433, 7, 6, 7, 0, -6 },
  { 439, 5, 6, 7, 1, -6 },
  { 443, 5, 6, 7, 1, -6 },
  { 447, 6, 8, 7, 0, -6 },
  { 453, 5, 8, 7, 1, -6 },
  { 458, 5, 6, 7, 2, -6 },
  { 462, 5, 6, 7, 1, -6 },
  { 466, 4, 8, 7, 2, -8 },
  { 470, 5, 6, 7, 1, -6 },
  { 474, 6, 6, 7, 1, -6 },
  { 479, 6, 6, 7, 1, -6 },
  { 484, 7, 6, 7, 0, -6 },
  { 490, 7, 9, 7, 0, -6 },
  { 498, 6, 6, 7, 0, -6 },
  { 503, 4, 12, 7, 2, -9 },
  { 509, 1, 11, 7, 3, -9 },
  { 511, 5, 12, 7, 1, -9 },
  { 519, 7, 2, 7, 0, -5 },
};

const GFXfont RobotoMono_ThinItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic12pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_THINITALIC12PT7B_H_
