#ifndef _ROBOTOMONO_THINITALIC65PT7B_H_
#define _ROBOTOMONO_THINITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x18,
  0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x02, 0x20, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x44, 0x0C, 0xC0, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x20, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x80, 0x06, 0x30, 0x01, 0x00, 0x18, 0x60, 0x02,
  0x00, 0x60, 0x80, 0x04, 0x00, 0xC3, 0x00, 0x18, 0x03, 0x06, 0x00, 0x30,
  0x0C, 0x0C, 0x00, 0x60, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x30, 0x03, 0x01,
  0x80, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x80, 0x30, 0x30,
  0x01, 0x80, 0xC0, 0xC0, 0x01, 0x87, 0x01, 0x80, 0x01, 0xFC, 0x06, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x07, 0x80,
  0x00, 0x60, 0x3F, 0xC0, 0x01, 0x80, 0xE1, 0xC0, 0x03, 0x03, 0x01, 0x80,
  0x0C, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0xE0, 0x60, 0x06, 0x01,
  0x80, 0xC0, 0x0C, 0x06, 0x01, 0x00, 0x18, 0x18, 0x06, 0x00, 0x30, 0x30,
  0x0C, 0x00, 0x60, 0xC0, 0x18, 0x00, 0xC3, 0x00, 0x20, 0x01, 0x86, 0x00,
  0x40, 0x02, 0x18, 0x00, 0x80, 0x0C, 0x60, 0x01, 0x80, 0x18, 0x40, 0x03,
  0x00, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x80, 0x00, 0x40, 0x01, 0x80, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0x20, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x0C, 0x00, 0xC0, 0x02, 0x18, 0x00, 0x60, 0x06, 0x18, 0x00, 0x30,
  0x06, 0x30, 0x00, 0x30, 0x06, 0x30, 0x00, 0x18, 0x0C, 0x60, 0x00, 0x08,
  0x0C, 0x60, 0x00, 0x0C, 0x18, 0x60, 0x00, 0x06, 0x18, 0x40, 0x00, 0x06,
  0x30, 0x40, 0x00, 0x03, 0x30, 0x40, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0xE0, 0x30, 0x00, 0x07,
  0x60, 0x18, 0x00, 0x1C, 0x30, 0x1C, 0x00, 0x38, 0x18, 0x07, 0x81, 0xE0,
  0x18, 0x03, 0xFF, 0x80, 0x0C, 0x00, 0x78, 0x00, 0x00, 0x33, 0x33, 0x32,
  0x66, 0x66, 0x44, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x40, 0x06, 0x00, 0xFF,
  0x00, 0xC0, 0x7C, 0xF8, 0x10, 0x7C, 0x03, 0xE2, 0x7C, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x70, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0xC0, 0x10, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x61, 0xC3,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x2F, 0xFE, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xF1, 0x80,
  0x00, 0x06, 0xC4, 0x00, 0x00, 0x73, 0x30, 0x00, 0x03, 0x8C, 0xC0, 0x00,
  0x18, 0x23, 0x00, 0x00, 0xC0, 0x88, 0x00, 0x06, 0x02, 0x20, 0x00, 0x30,
  0x19, 0x80, 0x01, 0x80, 0x66, 0x00, 0x1C, 0x01, 0x98, 0x00, 0xE0, 0x06,
  0x60, 0x06, 0x00, 0x11, 0x00, 0x30, 0x00, 0xC4, 0x01, 0x80, 0x03, 0x30,
  0x0C, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x33, 0x07, 0x00, 0x00, 0x8C, 0x38,
  0x00, 0x06, 0x31, 0xC0, 0x00, 0x18, 0x8C, 0x00, 0x00, 0x62, 0x60, 0x00,
  0x01, 0x0B, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0xC0, 0x3C, 0x60, 0x78, 0x30, 0xF0, 0x19, 0xE0, 0x09, 0x80, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x70, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x33, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x70, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0xFF, 0x80, 0x18, 0x7E, 0x3E, 0x01, 0x0E, 0x00, 0x70, 0x33,
  0x80, 0x01, 0x83, 0x60, 0x00, 0x0C, 0x2C, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x0E,
  0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x16, 0x30, 0x00, 0x06, 0x61, 0x80,
  0x00, 0xC4, 0x0C, 0x00, 0x38, 0xC0, 0x60, 0x0F, 0x0C, 0x03, 0xFF, 0xC0,
  0x80, 0x0F, 0xF0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x02, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0x03, 0xC1, 0xC0,
  0x00, 0x20, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xE0, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x1C,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x02, 0x20, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x03, 0xE0, 0x06, 0x03, 0x00, 0x7F, 0xC0,
  0x30, 0x30, 0x0E, 0x07, 0x01, 0x83, 0x80, 0xE0, 0x18, 0x0C, 0x18, 0x06,
  0x00, 0xC0, 0x61, 0x80, 0x60, 0x04, 0x03, 0x0C, 0x06, 0x00, 0x60, 0x18,
  0xC0, 0x30, 0x03, 0x00, 0xC6, 0x03, 0x00, 0x10, 0x06, 0x30, 0x18, 0x00,
  0x80, 0x33, 0x01, 0x80, 0x0C, 0x01, 0x18, 0x0C, 0x00, 0x60, 0x08, 0xC0,
  0x40, 0x02, 0x00, 0xC4, 0x06, 0x00, 0x30, 0x06, 0x60, 0x30, 0x01, 0x80,
  0x33, 0x01, 0x80, 0x0C, 0x01, 0x18, 0x08, 0x00, 0x40, 0x18, 0x80, 0xC0,
  0x06, 0x00, 0xC4, 0x06, 0x00, 0x30, 0x06, 0x20, 0x30, 0x03, 0x80, 0x63,
  0x01, 0x80, 0x18, 0x03, 0x18, 0x0C, 0x01, 0xC0, 0x10, 0xC0, 0x60, 0x1A,
  0x01, 0x86, 0x03, 0x00, 0x90, 0x18, 0x30, 0x18, 0x0C, 0x80, 0xC0, 0x80,
  0x61, 0xC6, 0x1C, 0x06, 0x03, 0xFC, 0x1F, 0xC0, 0x30, 0x0F, 0x80, 0xF8,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x02, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x18, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x40, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x03, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x0C,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x08, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x07, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x40, 0x00, 0x07, 0x00, 0x20, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xFC, 0xC0, 0x01, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x30, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x18, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x38, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x04, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x70,
  0x00, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x00, 0x18, 0x78, 0x00, 0x00, 0x02, 0x19, 0x80, 0x00, 0x00,
  0x46, 0x30, 0x00, 0x00, 0x19, 0x83, 0x00, 0x00, 0x03, 0x60, 0x60, 0x00,
  0x00, 0x78, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x10, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xB0, 0x00, 0x03, 0x60, 0x1B, 0x00,
  0x00, 0x36, 0x01, 0xB0, 0x00, 0x06, 0x40, 0x19, 0x00, 0x00, 0x64, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x11, 0x80, 0x01, 0x8C, 0x01, 0x18, 0x00, 0x18,
  0xC0, 0x31, 0x80, 0x03, 0x0C, 0x03, 0x08, 0x00, 0x30, 0x80, 0x30, 0xC0,
  0x06, 0x08, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x20, 0xC0, 0x0C, 0x18, 0x02,
  0x04, 0x01, 0x81, 0x80, 0x60, 0x40, 0x18, 0x18, 0x06, 0x06, 0x03, 0x01,
  0x00, 0x60, 0x60, 0x30, 0x30, 0x06, 0x06, 0x06, 0x03, 0x00, 0x40, 0x20,
  0x60, 0x30, 0x0C, 0x02, 0x0C, 0x03, 0x00, 0xC0, 0x31, 0x80, 0x30, 0x0C,
  0x03, 0x18, 0x02, 0x00, 0xC0, 0x33, 0x00, 0x60, 0x0C, 0x01, 0x30, 0x06,
  0x00, 0x80, 0x16, 0x00, 0x60, 0x18, 0x01, 0x60, 0x06, 0x01, 0x80, 0x1C,
  0x00, 0x40, 0x18, 0x01, 0x80, 0x04, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x50, 0x00, 0x00, 0x20, 0x1B, 0x00, 0x00, 0x04,
  0x03, 0x60, 0x00, 0x01, 0x80, 0x64, 0x00, 0x00, 0x30, 0x08, 0xC0, 0x00,
  0x06, 0x01, 0x18, 0x00, 0x00, 0xC0, 0x21, 0x00, 0x00, 0x10, 0x0C, 0x30,
  0x00, 0x02, 0x01, 0x82, 0x00, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x18, 0x04,
  0x0C, 0x00, 0x03, 0x00, 0x80, 0x80, 0x00, 0x60, 0x30, 0x18, 0x00, 0x08,
  0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x0C, 0x02, 0x00, 0x40, 0x01, 0x80, 0x40, 0x0C, 0x00, 0x30, 0x18, 0x01,
  0x80, 0x04, 0x03, 0x00, 0x10, 0x00, 0x80, 0x60, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x06, 0x01, 0x00, 0x04, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x10,
  0x0C, 0x00, 0x08, 0x02, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x30,
  0x18, 0x06, 0x00, 0x02, 0x03, 0x00, 0x80, 0x00, 0x60, 0x60, 0x10, 0x00,
  0x0C, 0x08, 0x06, 0x00, 0x00, 0x81, 0x00, 0xC0, 0x00, 0x18, 0x60, 0x18,
  0x00, 0x01, 0x0C, 0x02, 0x00, 0x00, 0x31, 0x80, 0x40, 0x00, 0x06, 0x30,
  0x08, 0x00, 0x00, 0x44, 0x03, 0x00, 0x00, 0x0C, 0x80, 0x60, 0x00, 0x01,
  0xB0, 0x0C, 0x00, 0x00, 0x16, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x00,
  0x00, 0x38, 0x04, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0xC0, 0x0C, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x08, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x04, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x2C, 0x00, 0x3C, 0x00, 0x36, 0x00, 0x1E, 0x00,
  0x1B, 0x00, 0x0B, 0x00, 0x09, 0x80, 0x0D, 0x80, 0x0C, 0xC0, 0x06, 0xC0,
  0x06, 0x60, 0x02, 0x60, 0x02, 0x30, 0x03, 0x30, 0x03, 0x18, 0x01, 0x98,
  0x01, 0x8C, 0x00, 0x8C, 0x00, 0x86, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x21, 0x80, 0x30, 0xC0, 0x30, 0x40, 0x10, 0x60, 0x18,
  0x20, 0x18, 0x30, 0x18, 0x10, 0x0C, 0x18, 0x0C, 0x08, 0x04, 0x0C, 0x06,
  0x04, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x81,
  0x80, 0x81, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0x40, 0x30,
  0x60, 0x18, 0x20, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x06,
  0x18, 0x03, 0x08, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0xC4, 0x00, 0x62, 0x00, 0x66, 0x00, 0x33, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x19, 0x00, 0x0C, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0x60,
  0x03, 0x40, 0x01, 0xA0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xA0, 0x00,
  0x0C, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0x40, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x20,
  0x06, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18,
  0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0x23, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC1, 0x06, 0x08, 0x30, 0x61, 0x83, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x0D, 0x06, 0x00, 0x00, 0xEC, 0x0C, 0x00, 0x07, 0x30, 0x38, 0x00,
  0x70, 0xC0, 0x38, 0x0F, 0x83, 0x00, 0x7F, 0xF8, 0x0C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x07, 0xE0, 0x00, 0xC1, 0xFF, 0xC0, 0x06,
  0x3C, 0x03, 0x80, 0x33, 0x80, 0x0E, 0x01, 0x30, 0x00, 0x30, 0x0B, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x0C, 0x0D, 0x00, 0x00, 0xE0, 0x6C, 0x00, 0x0E, 0x03,
  0x38, 0x00, 0xE0, 0x18, 0xF0, 0x3C, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x78,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xF0,
  0x3E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x06, 0x00, 0x1F, 0xFC, 0x08, 0x00,
  0xF0, 0x0E, 0x10, 0x03, 0x80, 0x06, 0x60, 0x0E, 0x00, 0x06, 0xC0, 0x38,
  0x00, 0x05, 0x80, 0x60, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x02, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x78, 0x02,
  0x00, 0x01, 0xA0, 0x06, 0x00, 0x06, 0x40, 0x06, 0x00, 0x39, 0x80, 0x07,
  0x03, 0xE3, 0x00, 0x07, 0xFF, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x6F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFB, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x08, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x0C, 0x00, 0xF0,
  0x0E, 0x10, 0x03, 0x80, 0x06, 0x60, 0x0E, 0x00, 0x06, 0xC0, 0x38, 0x00,
  0x05, 0x80, 0x60, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x78, 0x03, 0x00,
  0x01, 0xF0, 0x06, 0x00, 0x07, 0x40, 0x06, 0x00, 0x39, 0x80, 0x07, 0x03,
  0xE3, 0x00, 0x07, 0xFF, 0x06, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x07, 0xF0, 0x00, 0xC0, 0xFF, 0xF0,
  0x03, 0x0F, 0x00, 0xE0, 0x08, 0x70, 0x00, 0xC0, 0x23, 0x00, 0x03, 0x01,
  0x98, 0x00, 0x06, 0x06, 0xC0, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x20, 0x50,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x01, 0x00,
  0x01, 0xC0, 0x04, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x07,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x20, 0x1C, 0x00,
  0x00, 0x80, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x01, 0x9F, 0x00, 0x00, 0x04, 0xC6, 0x00, 0x00, 0x36,
  0x1C, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0,
  0x04, 0x00, 0x03, 0x80, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x0C, 0x7F, 0xC0, 0xFF, 0xC0, 0x27, 0x01, 0x87, 0x03, 0x00, 0xB8, 0x03,
  0x70, 0x06, 0x03, 0x80, 0x0D, 0x80, 0x08, 0x1E, 0x00, 0x3C, 0x00, 0x20,
  0x70, 0x00, 0xE0, 0x00, 0xC1, 0x80, 0x03, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0x00, 0x20, 0x40, 0x00, 0xC0, 0x00, 0x83,
  0x00, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x30, 0x00, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0x80, 0x01, 0x82, 0x00, 0x06, 0x00, 0x04, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x60, 0x00, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x00,
  0x03, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x00, 0x20, 0x40,
  0x00, 0xC0, 0x00, 0x83, 0x00, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x30, 0x00, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x01, 0x82, 0x00,
  0x06, 0x00, 0x04, 0x08, 0x00, 0x18, 0x00, 0x10, 0x60, 0x00, 0x60, 0x00,
  0xC1, 0x80, 0x01, 0x00, 0x03, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x40, 0x00, 0xC0, 0x00, 0x81, 0x00, 0x03, 0x00, 0x02,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0C, 0x0F,
  0xFF, 0x00, 0x30, 0xF0, 0x0E, 0x00, 0x87, 0x00, 0x1C, 0x06, 0x30, 0x00,
  0x30, 0x19, 0x80, 0x00, 0x60, 0x6C, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x02,
  0x05, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0x80, 0x78, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0x83, 0xFF, 0x80, 0x03, 0x1E, 0x01, 0xC0, 0x06, 0x70, 0x01,
  0xC0, 0x09, 0x80, 0x01, 0x80, 0x16, 0x00, 0x01, 0x80, 0x78, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x03, 0xC0, 0x00, 0x18, 0x07, 0x80, 0x00, 0x60, 0x0D, 0x80, 0x01,
  0xC0, 0x19, 0xC0, 0x0E, 0x00, 0x21, 0xE0, 0x78, 0x00, 0x40, 0xFF, 0xC0,
  0x01, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0xC0, 0x3C,
  0x03, 0x84, 0x03, 0x80, 0x06, 0x60, 0x38, 0x00, 0x1B, 0x03, 0x80, 0x00,
  0x58, 0x18, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x07, 0x80, 0x80, 0x00, 0x7C, 0x06, 0x00, 0x06, 0x40, 0x18,
  0x00, 0xE2, 0x00, 0x70, 0x3E, 0x30, 0x01, 0xFF, 0xC1, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0xC0, 0x3F, 0xFC, 0x18, 0x1E, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x0D, 0x80, 0xC0,
  0x00, 0xCC, 0x07, 0x00, 0x1C, 0x60, 0x1E, 0x07, 0xC2, 0x00, 0x3F, 0xF8,
  0x30, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x80, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x70,
  0x00, 0x6C, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x0C, 0xC0, 0x03,
  0xC0, 0x03, 0x30, 0x00, 0xB0, 0x00, 0x8C, 0x00, 0x6C, 0x00, 0x63, 0x00,
  0x1B, 0x00, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0x30, 0x03, 0x10, 0x03, 0x04,
  0x01, 0x84, 0x00, 0x81, 0x00, 0x61, 0x00, 0x60, 0x40, 0x10, 0x60, 0x18,
  0x10, 0x0C, 0x18, 0x0C, 0x06, 0x03, 0x06, 0x03, 0x01, 0x81, 0x81, 0x80,
  0x80, 0x60, 0x60, 0x60, 0x60, 0x18, 0x10, 0x18, 0x18, 0x06, 0x0C, 0x06,
  0x0C, 0x01, 0x82, 0x01, 0x83, 0x00, 0x61, 0x80, 0x60, 0x80, 0x18, 0x60,
  0x08, 0x60, 0x06, 0x30, 0x02, 0x18, 0x01, 0x8C, 0x00, 0x8C, 0x00, 0x62,
  0x00, 0x23, 0x00, 0x19, 0x80, 0x08, 0x80, 0x06, 0x60, 0x02, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x04, 0x1C, 0x3C, 0x00, 0x01,
  0x86, 0x01, 0xC0, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0x00, 0x63, 0x00, 0x00, 0xC0, 0x1C, 0x60, 0x00,
  0x0E, 0x07, 0x08, 0x00, 0x00, 0xFF, 0x82, 0x00, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph RobotoMono_ThinItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 10, 46, 38, 14, -46 },
  { 59, 12, 13, 38, 16, -49 },
  { 79, 38, 46, 38, 1, -46 },
  { 298, 31, 60, 38, 4, -53 },
  { 531, 31, 48, 38, 4, -47 },
  { 717, 32, 48, 38, 3, -47 },
  { 909, 4, 13, 38, 19, -49 },
  { 916, 20, 67, 38, 11, -52 },
  { 1084, 19, 66, 38, 6, -51 },
  { 1241, 27, 25, 38, 9, -46 },
  { 1326, 31, 33, 38, 4, -38 },
  { 1454, 7, 13, 38, 8, -5 },
  { 1466, 22, 2, 38, 8, -22 },
  { 1472, 4, 4, 38, 15, -4 },
  { 1474, 30, 50, 38, 5, -46 },
  { 1662, 30, 48, 38, 5, -47 },
  { 1842, 17, 46, 38, 10, -46 },
  { 1940, 30, 47, 38, 2, -47 },
  { 2117, 31, 48, 38, 2, -47 },
  { 2303, 31, 46, 38, 2, -46 },
  { 2482, 31, 47, 38, 6, -46 },
  { 2665, 28, 48, 38, 4, -47 },
  { 2833, 29, 46, 38, 8, -46 },
  { 3000, 32, 48, 38, 4, -47 },
  { 3192, 28, 48, 38, 6, -47 },
  { 3360, 9, 32, 38, 17, -32 },
  { 3396, 13, 40, 38, 13, -32 },
  { 3461, 29, 26, 38, 5, -34 },
  { 3556, 30, 14, 38, 4, -28 },
  { 3609, 29, 26, 38, 4, -34 },
  { 3704, 24, 47, 38, 10, -47 },
  { 3845, 37, 47, 38, 1, -47 },
  { 4063, 32, 46, 38, 0, -46 },
  { 4247, 32, 46, 38, 3, -46 },
  { 4431, 32, 48, 38, 4, -47 },
  { 4623, 33, 46, 38, 3, -46 },
  { 4813, 34, 46, 38, 3, -46 },
  { 5009, 33, 46, 38, 4, -46 },
  { 5199, 32, 48, 38, 4, -47 },
  { 5391, 35, 46, 38, 2, -46 },
  { 5593, 33, 46, 38, 3, -46 },
  { 5783, 34, 47, 38, 2, -46 },
  { 5983, 35, 46, 38, 4, -46 },
  { 6185, 26, 46, 38, 4, -46 },
  { 6335, 36, 46, 38, 2, -46 },
  { 6542, 35, 46, 38, 2, -46 },
  { 6744, 31, 48, 38, 4, -47 },
  { 6930, 33, 46, 38, 4, -46 },
  { 7120, 33, 55, 38, 3, -47 },
  { 7347, 32, 46, 38, 4, -46 },
  { 7531, 32, 48, 38, 4, -47 },
  { 7723, 31, 46, 38, 8, -46 },
  { 7902, 33, 47, 38, 4, -46 },
  { 8096, 32, 46, 38, 7, -46 },
  { 8280, 33, 46, 38, 7, -46 },
  { 8470, 38, 46, 38, 1, -46 },
  { 8689, 32, 46, 38, 7, -46 },
  { 8873, 34, 46, 38, 1, -46 },
  { 9069, 19, 63, 38, 10, -53 },
  { 9219, 12, 50, 38, 13, -46 },
  { 9294, 19, 63, 38, 9, -53 },
  { 9444, 22, 25, 38, 8, -46 },
  { 9513, 27, 2, 38, 2, 0 },
  { 9520, 6, 8, 38, 20, -48 },
  { 9526, 30, 36, 38, 3, -35 },
  { 9661, 29, 50, 38, 4, -49 },
  { 9843, 28, 36, 38, 5, -35 },
  { 9969, 31, 50, 38, 5, -49 },
  { 10163, 29, 36, 38, 4, -35 },
  { 10294, 30, 49, 38, 9, -49 },
  { 10478, 31, 49, 38, 3, -35 },
  { 10668, 30, 49, 38, 3, -49 },
  { 10852, 26, 46, 38, 4, -46 },
  { 11002, 30, 61, 38, 0, -47 },
  { 11231, 30, 49, 38, 5, -49 },
  { 11415, 26, 49, 38, 4, -49 },
  { 11575, 38, 35, 38, -1, -35 },
  { 11742, 30, 35, 38, 3, -35 },
  { 11874, 30, 36, 38, 4, -35 },
  { 12009, 31, 48, 38, 1, -35 },
  { 12195, 29, 48, 38, 5, -35 },
  { 12369, 27, 35, 38, 9, -35 },
  { 12488, 29, 36, 38, 5, -35 },
  { 12619, 24, 45, 38, 8, -44 },
  { 12754, 29, 35, 38, 5, -34 },
  { 12881, 31, 34, 38, 6, -34 },
  { 13013, 34, 34, 38, 5, -34 },
  { 13158, 34, 34, 38, 2, -34 },
  { 13303, 39, 48, 38, -1, -34 },
  { 13537, 34, 34, 38, 1, -34 },
  { 13682, 25, 65, 38, 10, -51 },
  { 13886, 10, 55, 38, 14, -46 },
  { 13955, 25, 65, 38, 5, -51 },
  { 14159, 35, 11, 38, 1, -25 },
};

const GFXfont RobotoMono_ThinItalic65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic65pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_THINITALIC65PT7B_H_
