#ifndef _ROBOTOMONO_THINITALIC35PT7B_H_
#define _ROBOTOMONO_THINITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x80, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x45, 0x14, 0x61, 0x8A,
  0x28, 0x80, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x40,
  0x80, 0x02, 0x04, 0x00, 0x20, 0x40, 0x01, 0x02, 0x03, 0xFF, 0xFF, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x20,
  0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x04, 0x08, 0x07, 0xFF,
  0xFE, 0x01, 0x02, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00,
  0x40, 0x80, 0x02, 0x04, 0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x1F, 0x80, 0x30, 0x20, 0x20, 0x08, 0x20, 0x04, 0x10,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40,
  0x04, 0x10, 0x06, 0x0C, 0x06, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x20,
  0x68, 0x10, 0x24, 0x08, 0x22, 0x04, 0x21, 0x02, 0x10, 0x82, 0x10, 0x21,
  0x10, 0x1F, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x7C,
  0x04, 0x62, 0x04, 0x20, 0x82, 0x20, 0x42, 0x10, 0x22, 0x08, 0x12, 0x04,
  0x09, 0x02, 0x09, 0x01, 0x04, 0x00, 0x84, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x01, 0x04, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x20, 0x04, 0x20, 0x02, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0xD0, 0x00, 0xC8, 0x00, 0xC2, 0x02, 0x40, 0x82, 0x40, 0x41, 0x40, 0x10,
  0xA0, 0x04, 0x90, 0x02, 0x48, 0x00, 0xC4, 0x00, 0x61, 0x00, 0x50, 0xC0,
  0xC4, 0x1F, 0x81, 0x00, 0x69, 0x24, 0xA0, 0x00, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x40, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x07, 0x84, 0x71, 0xDE, 0x00,
  0xC0, 0x05, 0x00, 0x32, 0x01, 0x8C, 0x0C, 0x10, 0x60, 0x21, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xC0, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x11, 0x12, 0x24, 0xC0, 0xFF, 0xF0, 0xF0,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x06, 0x0C, 0x08, 0x06,
  0x10, 0x02, 0x10, 0x02, 0x20, 0x01, 0x20, 0x03, 0x40, 0x05, 0x40, 0x09,
  0x40, 0x11, 0x40, 0x62, 0x80, 0xC2, 0x81, 0x02, 0x82, 0x02, 0x84, 0x02,
  0x88, 0x02, 0x90, 0x04, 0xA0, 0x04, 0xC0, 0x04, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x10, 0x40, 0x20, 0x60, 0x40, 0x3F, 0x80, 0x01, 0x07, 0x39, 0xC1,
  0x81, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x01, 0xF8, 0x06,
  0x06, 0x0C, 0x02, 0x08, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x01,
  0xFC, 0x01, 0x81, 0x01, 0x00, 0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x42, 0x00, 0x21, 0x00, 0x20,
  0x40, 0x60, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x88, 0x00, 0x84,
  0x00, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0xC0, 0x40, 0xC0, 0x40, 0x40,
  0x20, 0x40, 0x10, 0x40, 0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x07,
  0xFF, 0x82, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x60, 0x0B, 0x8C, 0x06, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x82, 0x00, 0x41, 0x00, 0x40,
  0x40, 0x40, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x47, 0xE1,
  0x20, 0x22, 0x80, 0x26, 0x00, 0x28, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x24, 0x00, 0x48, 0x01, 0x18, 0x04,
  0x18, 0x10, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x81, 0x00,
  0x41, 0x00, 0x10, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10,
  0x01, 0x08, 0x01, 0x82, 0x01, 0x80, 0xC3, 0x00, 0x3F, 0x00, 0x40, 0x60,
  0xC0, 0x08, 0x40, 0x04, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x21, 0x00, 0x30, 0x40, 0x30, 0x1F, 0xE0, 0x00,
  0x03, 0xF0, 0x18, 0x10, 0x60, 0x10, 0x80, 0x12, 0x00, 0x24, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x68, 0x01, 0x48, 0x05, 0x08, 0x32, 0x0F, 0x84, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x7C, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x10,
  0x20, 0x40, 0x82, 0x08, 0x00, 0x00, 0x02, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x0F, 0xC3, 0x02, 0x60, 0x14, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00, 0x38, 0x10, 0x0C, 0x01,
  0x02, 0x00, 0x10, 0x80, 0x02, 0x30, 0x70, 0x44, 0x31, 0x89, 0x0C, 0x21,
  0x21, 0x04, 0x28, 0x40, 0x85, 0x08, 0x10, 0xA2, 0x04, 0x18, 0x40, 0x83,
  0x08, 0x10, 0x61, 0x04, 0x14, 0x40, 0x82, 0x88, 0x30, 0x51, 0x06, 0x12,
  0x11, 0x44, 0x43, 0xC7, 0x88, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10, 0x00, 0x84, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10,
  0x04, 0x08, 0x02, 0x08, 0x01, 0x07, 0xFF, 0x84, 0x00, 0x42, 0x00, 0x22,
  0x00, 0x11, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x80, 0x00, 0x80, 0x0F,
  0xF8, 0x04, 0x03, 0x02, 0x00, 0xC2, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x02, 0x10, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x07,
  0x03, 0xFF, 0x81, 0x00, 0x60, 0x80, 0x08, 0x80, 0x04, 0x40, 0x01, 0x20,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x24, 0x00, 0x22, 0x00, 0x21,
  0x00, 0x60, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x41,
  0x00, 0x21, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x44,
  0x00, 0x42, 0x00, 0x61, 0x80, 0x60, 0x60, 0x60, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x04, 0x06, 0x04, 0x00, 0x82, 0x00, 0x21, 0x00, 0x10, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20,
  0x01, 0x10, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42, 0x00, 0xC1,
  0x01, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFC, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFC, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0x81, 0x01, 0x00, 0x41, 0x00, 0x31, 0x00, 0x08, 0x80, 0x04,
  0x80, 0x02, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x03, 0xFD, 0x00, 0x02, 0x80, 0x01, 0x40,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x22, 0x00, 0x10, 0x80, 0x10,
  0x60, 0x30, 0x0F, 0xE0, 0x00, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00,
  0x84, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02,
  0x10, 0x00, 0x42, 0x00, 0x10, 0x40, 0x02, 0x10, 0x00, 0x43, 0xFF, 0xF8,
  0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04, 0x10, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x40, 0x04, 0x10, 0x02,
  0x04, 0x01, 0x80, 0x80, 0xC0, 0x1F, 0xC0, 0x00, 0x08, 0x00, 0x21, 0x00,
  0x08, 0x20, 0x06, 0x04, 0x01, 0x81, 0x00, 0x60, 0x20, 0x18, 0x04, 0x06,
  0x00, 0x81, 0x80, 0x10, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x11, 0x80,
  0x02, 0x50, 0x00, 0x51, 0x00, 0x0C, 0x20, 0x01, 0x02, 0x00, 0x40, 0x60,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x00, 0x80, 0x80, 0x08,
  0x20, 0x01, 0x04, 0x00, 0x10, 0x80, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x20, 0x00, 0xFF, 0xFC, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x03, 0x85,
  0x00, 0x50, 0xA0, 0x12, 0x14, 0x02, 0x84, 0x80, 0x90, 0x90, 0x12, 0x11,
  0x04, 0x42, 0x21, 0x88, 0x44, 0x22, 0x08, 0x88, 0x42, 0x11, 0x08, 0x41,
  0x41, 0x08, 0x28, 0x21, 0x06, 0x04, 0x20, 0xC1, 0x04, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x82, 0x00,
  0x10, 0x80, 0x02, 0x00, 0x08, 0x00, 0x21, 0x80, 0x04, 0x30, 0x00, 0x85,
  0x00, 0x20, 0xA0, 0x04, 0x24, 0x00, 0x84, 0x40, 0x10, 0x88, 0x02, 0x10,
  0x80, 0x42, 0x10, 0x10, 0x42, 0x02, 0x10, 0x20, 0x42, 0x04, 0x08, 0x40,
  0x81, 0x08, 0x08, 0x21, 0x01, 0x08, 0x20, 0x11, 0x08, 0x02, 0x21, 0x00,
  0x44, 0x20, 0x04, 0x84, 0x00, 0x90, 0x80, 0x14, 0x10, 0x01, 0x84, 0x00,
  0x30, 0x80, 0x02, 0x00, 0x01, 0xFC, 0x01, 0x83, 0x01, 0x00, 0x41, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x41, 0x80, 0x40, 0x60, 0x40, 0x1F, 0xC0, 0x00, 0x0F, 0xFC,
  0x02, 0x00, 0xC0, 0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x42, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x04, 0x20, 0x06, 0x08, 0x0E, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x81, 0x01,
  0x00, 0x41, 0x00, 0x21, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x90,
  0x00, 0x48, 0x00, 0x42, 0x00, 0x61, 0x00, 0x60, 0x40, 0x60, 0x1F, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x0F,
  0xF8, 0x04, 0x03, 0x02, 0x00, 0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x88, 0x00, 0xC4, 0x00,
  0x42, 0x00, 0xC1, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x10, 0x20,
  0x08, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x62, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x02, 0x00, 0x01, 0xFC, 0x03, 0x01, 0x03, 0x00, 0x41,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48,
  0x00, 0x26, 0x00, 0x11, 0x00, 0x10, 0x40, 0x30, 0x1F, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04,
  0x40, 0x02, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x10, 0x40, 0x04, 0x10, 0x02, 0x06, 0x01, 0x00, 0xC0, 0x80, 0x1F,
  0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x20, 0x08, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x03, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x10, 0x80, 0x08, 0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x90,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x80, 0x80, 0x60, 0x20,
  0x28, 0x08, 0x0A, 0x06, 0x02, 0x81, 0x81, 0x20, 0x90, 0x48, 0x24, 0x12,
  0x09, 0x04, 0x84, 0x42, 0x21, 0x10, 0x88, 0x44, 0x22, 0x21, 0x10, 0x88,
  0x44, 0x22, 0x11, 0x09, 0x04, 0x82, 0x41, 0x20, 0x90, 0x48, 0x28, 0x14,
  0x0A, 0x05, 0x02, 0x81, 0x40, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x00, 0x08, 0x00, 0x30, 0x80, 0x02, 0x04, 0x00,
  0x40, 0x40, 0x08, 0x02, 0x01, 0x80, 0x20, 0x10, 0x01, 0x02, 0x00, 0x10,
  0x40, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x90, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0A, 0x00, 0x00, 0xA0, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00,
  0x40, 0x80, 0x04, 0x08, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x20,
  0x60, 0x02, 0x04, 0x00, 0x10, 0x80, 0x01, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0x90, 0x00, 0x88, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x40, 0x80, 0x60, 0x20,
  0x20, 0x10, 0x20, 0x08, 0x20, 0x02, 0x10, 0x01, 0x10, 0x00, 0x90, 0x00,
  0x28, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xFC, 0x00, 0x81, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0x08, 0x18, 0x07, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0xF8, 0x00, 0x00, 0x80, 0x1C, 0x01, 0x40, 0x24, 0x02, 0x40, 0x44,
  0x04, 0x20, 0x82, 0x10, 0x21, 0x02, 0x20, 0x12, 0x01, 0x40, 0x1C, 0x01,
  0xFF, 0xFC, 0x91, 0x22, 0x00, 0xF0, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x02,
  0x20, 0x02, 0x20, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x0F, 0xFE,
  0x38, 0x02, 0x60, 0x02, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x14, 0x40, 0x64, 0x3F, 0x84, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0xF0, 0x13, 0x08,
  0x1C, 0x04, 0x18, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x01,
  0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x08, 0xC0, 0x10, 0xB0, 0x20, 0x8F, 0xC0, 0x01, 0xE0,
  0x0C, 0x30, 0x60, 0x31, 0x80, 0x22, 0x00, 0x48, 0x00, 0x50, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x01,
  0x20, 0x02, 0x40, 0x0C, 0x40, 0x10, 0xC0, 0xC0, 0x7E, 0x00, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x03, 0xC2, 0x0C, 0x32, 0x10, 0x0A, 0x20, 0x06, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x30, 0x40, 0x50,
  0x3F, 0x90, 0x00, 0xF0, 0x03, 0x0C, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x01,
  0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x7F, 0xFF, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x0C,
  0x10, 0x18, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x71, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF8, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0xF0,
  0x01, 0x86, 0x41, 0x80, 0xA1, 0x00, 0x30, 0x80, 0x10, 0x80, 0x08, 0x40,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84, 0x00, 0x42,
  0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x30, 0x0C, 0x08, 0x0A,
  0x03, 0xF9, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x61, 0x80,
  0x20, 0x60, 0x60, 0x0F, 0xE0, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x70, 0x13, 0x04,
  0x14, 0x02, 0x28, 0x02, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0xFE, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x01, 0x10, 0x03, 0x08, 0x02, 0x04, 0x02, 0x02, 0x06, 0x01,
  0x06, 0x00, 0x84, 0x00, 0x8C, 0x00, 0x4C, 0x00, 0x2B, 0x00, 0x18, 0x80,
  0x08, 0x20, 0x04, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0x80,
  0x20, 0x40, 0x08, 0x60, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x03, 0xFF, 0xF0, 0x03, 0xC3, 0xC1, 0xC6, 0x42, 0x28, 0x28, 0x13,
  0x03, 0x01, 0x20, 0x20, 0x12, 0x02, 0x01, 0x20, 0x20, 0x22, 0x02, 0x02,
  0x40, 0x20, 0x24, 0x02, 0x02, 0x40, 0x40, 0x24, 0x04, 0x02, 0x40, 0x40,
  0x44, 0x04, 0x04, 0x80, 0x40, 0x48, 0x08, 0x04, 0x80, 0x80, 0x48, 0x08,
  0x04, 0x80, 0x80, 0x80, 0x00, 0x78, 0x13, 0x0C, 0x14, 0x02, 0x28, 0x02,
  0x30, 0x02, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x04,
  0x10, 0x02, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x40, 0x0C, 0x40, 0x18, 0x20, 0x30, 0x1F, 0xC0, 0x00, 0x78, 0x09, 0x84,
  0x0E, 0x02, 0x0C, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x60, 0x04, 0x60, 0x08, 0x58, 0x10, 0x4F, 0xE0, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x03, 0xC0, 0x18, 0x64, 0x60, 0x29, 0x00, 0x32, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x20, 0x02, 0x40, 0x0C, 0xC0, 0x30, 0x80, 0xA0, 0xFE, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x7C, 0x46, 0x01, 0x60, 0x0A, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xF0, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20, 0x18, 0x1F,
  0xE0, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x10, 0x01, 0x00, 0x0F, 0xC0,
  0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x20, 0x06, 0x40, 0x14, 0x40, 0x50, 0x7F, 0x20, 0x80, 0x00,
  0xC0, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x44, 0x00, 0x41, 0x00, 0x20, 0x80,
  0x20, 0x40, 0x10, 0x20, 0x10, 0x08, 0x18, 0x04, 0x08, 0x02, 0x08, 0x01,
  0x04, 0x00, 0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x80, 0xE0, 0x60, 0x28, 0x18, 0x0A, 0x06, 0x04,
  0x82, 0x41, 0x20, 0x90, 0x88, 0x44, 0x22, 0x11, 0x08, 0x84, 0x44, 0x22,
  0x11, 0x08, 0x84, 0x82, 0x41, 0x20, 0x90, 0x48, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x81, 0x40, 0x40, 0x20, 0x10, 0x08, 0x00, 0x10, 0x00, 0x42, 0x00,
  0x20, 0xC0, 0x10, 0x10, 0x0C, 0x02, 0x06, 0x00, 0x83, 0x00, 0x11, 0x80,
  0x06, 0xC0, 0x00, 0xA0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x02,
  0x10, 0x01, 0x04, 0x00, 0x80, 0x80, 0x40, 0x30, 0x20, 0x04, 0x18, 0x00,
  0x8C, 0x00, 0x30, 0x08, 0x00, 0x00, 0x40, 0x00, 0x42, 0x00, 0x04, 0x08,
  0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x20, 0x18, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x01, 0x80, 0x10, 0x08, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10,
  0x40, 0x00, 0xC4, 0x00, 0x02, 0x20, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x70, 0x03, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x00, 0x1E, 0x00, 0x2C, 0x30, 0x09, 0x03, 0x01, 0x40, 0x30,
  0x48, 0x01, 0xF0,
};

const GFXglyph RobotoMono_ThinItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 6, 25, 21, 7, -25 },
  { 20, 6, 7, 21, 9, -26 },
  { 26, 21, 25, 21, 0, -25 },
  { 92, 17, 32, 21, 2, -28 },
  { 160, 17, 25, 21, 2, -25 },
  { 214, 17, 25, 21, 2, -25 },
  { 268, 3, 7, 21, 10, -26 },
  { 271, 11, 36, 21, 6, -28 },
  { 321, 11, 36, 21, 3, -28 },
  { 371, 14, 14, 21, 5, -25 },
  { 396, 17, 19, 21, 2, -21 },
  { 437, 4, 7, 21, 4, -3 },
  { 441, 12, 1, 21, 4, -12 },
  { 443, 2, 2, 21, 8, -2 },
  { 444, 16, 27, 21, 3, -25 },
  { 498, 16, 25, 21, 3, -25 },
  { 548, 8, 25, 21, 6, -25 },
  { 573, 16, 25, 21, 1, -25 },
  { 623, 17, 25, 21, 1, -25 },
  { 677, 17, 25, 21, 1, -25 },
  { 731, 17, 25, 21, 3, -25 },
  { 785, 15, 25, 21, 2, -25 },
  { 832, 16, 25, 21, 4, -25 },
  { 882, 17, 25, 21, 2, -25 },
  { 936, 15, 25, 21, 3, -25 },
  { 983, 5, 17, 21, 9, -17 },
  { 994, 7, 21, 21, 7, -17 },
  { 1013, 15, 14, 21, 3, -18 },
  { 1040, 17, 8, 21, 2, -15 },
  { 1057, 16, 13, 21, 2, -18 },
  { 1083, 12, 25, 21, 6, -25 },
  { 1121, 19, 25, 21, 1, -25 },
  { 1181, 17, 25, 21, 0, -25 },
  { 1235, 17, 25, 21, 2, -25 },
  { 1289, 17, 25, 21, 2, -25 },
  { 1343, 17, 25, 21, 2, -25 },
  { 1397, 18, 25, 21, 2, -25 },
  { 1454, 18, 25, 21, 2, -25 },
  { 1511, 17, 25, 21, 2, -25 },
  { 1565, 19, 25, 21, 1, -25 },
  { 1625, 17, 25, 21, 2, -25 },
  { 1679, 18, 25, 21, 1, -25 },
  { 1736, 19, 25, 21, 2, -25 },
  { 1796, 14, 25, 21, 2, -25 },
  { 1840, 19, 25, 21, 1, -25 },
  { 1900, 19, 25, 21, 1, -25 },
  { 1960, 17, 25, 21, 2, -25 },
  { 2014, 18, 25, 21, 2, -25 },
  { 2071, 17, 30, 21, 2, -25 },
  { 2135, 17, 25, 21, 2, -25 },
  { 2189, 17, 25, 21, 2, -25 },
  { 2243, 17, 25, 21, 4, -25 },
  { 2297, 18, 25, 21, 2, -25 },
  { 2354, 17, 25, 21, 4, -25 },
  { 2408, 18, 25, 21, 4, -25 },
  { 2465, 20, 25, 21, 1, -25 },
  { 2528, 17, 25, 21, 4, -25 },
  { 2582, 18, 25, 21, 1, -25 },
  { 2639, 11, 33, 21, 5, -28 },
  { 2685, 7, 27, 21, 7, -25 },
  { 2709, 10, 33, 21, 5, -28 },
  { 2751, 12, 14, 21, 4, -25 },
  { 2772, 14, 1, 21, 1, 0 },
  { 2774, 3, 5, 21, 11, -26 },
  { 2776, 16, 19, 21, 2, -19 },
  { 2814, 16, 26, 21, 2, -26 },
  { 2866, 15, 19, 21, 3, -19 },
  { 2902, 16, 26, 21, 3, -26 },
  { 2954, 16, 19, 21, 2, -19 },
  { 2992, 16, 27, 21, 5, -27 },
  { 3046, 17, 26, 21, 1, -19 },
  { 3102, 16, 26, 21, 2, -26 },
  { 3154, 14, 25, 21, 2, -25 },
  { 3198, 16, 32, 21, 0, -25 },
  { 3262, 17, 26, 21, 2, -26 },
  { 3318, 14, 26, 21, 2, -26 },
  { 3364, 20, 19, 21, 0, -19 },
  { 3412, 16, 19, 21, 2, -19 },
  { 3450, 16, 19, 21, 2, -19 },
  { 3488, 16, 26, 21, 1, -19 },
  { 3540, 15, 26, 21, 3, -19 },
  { 3589, 14, 19, 21, 5, -19 },
  { 3623, 16, 19, 21, 2, -19 },
  { 3661, 12, 23, 21, 5, -23 },
  { 3696, 15, 18, 21, 3, -18 },
  { 3730, 17, 19, 21, 3, -19 },
  { 3771, 18, 18, 21, 3, -18 },
  { 3812, 18, 19, 21, 1, -19 },
  { 3855, 21, 26, 21, -1, -19 },
  { 3924, 18, 18, 21, 1, -18 },
  { 3965, 14, 35, 21, 5, -27 },
  { 4027, 6, 30, 21, 7, -25 },
  { 4050, 13, 35, 21, 3, -27 },
  { 4107, 19, 5, 21, 1, -13 },
};

const GFXfont RobotoMono_ThinItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic35pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_THINITALIC35PT7B_H_
