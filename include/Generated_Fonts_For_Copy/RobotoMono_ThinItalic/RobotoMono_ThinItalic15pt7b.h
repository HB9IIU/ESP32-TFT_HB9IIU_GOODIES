#ifndef _ROBOTOMONO_THINITALIC15PT7B_H_
#define _ROBOTOMONO_THINITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x08, 0xBB, 0x00, 0x09, 0x04, 0x82, 0x4F, 0xF1, 0x20,
  0x90, 0x91, 0xFE, 0x24, 0x24, 0x12, 0x00, 0x08, 0x38, 0x8A, 0x14, 0x08,
  0x0E, 0x02, 0x03, 0x06, 0x12, 0xC2, 0x04, 0x00, 0x61, 0x26, 0x55, 0x2E,
  0x82, 0x09, 0x95, 0x53, 0x24, 0x30, 0x18, 0x49, 0x12, 0x43, 0x04, 0x14,
  0xC5, 0x8B, 0x0B, 0xE8, 0xE0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xC0, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x44, 0x22, 0x13, 0x00, 0x10,
  0x4D, 0x4E, 0x31, 0x20, 0x08, 0x20, 0x40, 0x8F, 0xE2, 0x08, 0x10, 0xE0,
  0xF8, 0x80, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04,
  0x00, 0x1C, 0x45, 0x0A, 0x18, 0xF2, 0x68, 0xE1, 0x85, 0x09, 0xE0, 0x17,
  0x91, 0x11, 0x22, 0x22, 0x20, 0x1C, 0x45, 0x08, 0x10, 0x20, 0x82, 0x08,
  0x20, 0x83, 0xF8, 0x1E, 0x21, 0x41, 0x01, 0x02, 0x1C, 0x02, 0x02, 0x82,
  0x82, 0x7C, 0x02, 0x06, 0x06, 0x0A, 0x12, 0x22, 0x44, 0xFF, 0x04, 0x04,
  0x04, 0x1F, 0x20, 0x20, 0x40, 0x78, 0x44, 0x02, 0x02, 0x82, 0x84, 0x78,
  0x0C, 0xC4, 0x10, 0xFA, 0x18, 0x61, 0x86, 0x17, 0x80, 0xFE, 0x08, 0x10,
  0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x1C, 0x45, 0x0A, 0x14, 0x27,
  0x91, 0x41, 0x83, 0x09, 0xE0, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x51, 0x1E,
  0x04, 0x11, 0xC0, 0x40, 0x08, 0x20, 0x00, 0x14, 0x80, 0x06, 0x31, 0x86,
  0x03, 0x01, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x40, 0x60, 0x30, 0x73, 0x18,
  0x00, 0x39, 0x18, 0x41, 0x08, 0x42, 0x08, 0x00, 0x04, 0x00, 0x0F, 0x08,
  0x4B, 0x2A, 0x55, 0x2D, 0x26, 0x93, 0x4A, 0xBE, 0x40, 0x1F, 0x00, 0x04,
  0x18, 0x30, 0x91, 0x24, 0x48, 0x9F, 0x42, 0x86, 0x08, 0x3C, 0x85, 0x0A,
  0x14, 0x4F, 0x21, 0x41, 0x83, 0x0B, 0xE0, 0x1C, 0x45, 0x0C, 0x18, 0x10,
  0x20, 0x41, 0x85, 0x09, 0xE0, 0x7C, 0x85, 0x0A, 0x18, 0x30, 0x60, 0xC1,
  0x85, 0x0B, 0xE0, 0x3F, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x80, 0x80, 0x80,
  0x80, 0xFC, 0x3F, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1C, 0x45, 0x0C, 0x08, 0x10, 0x27, 0xC1, 0x83, 0x09, 0xE0, 0x20,
  0x90, 0x48, 0x48, 0x24, 0x13, 0xF9, 0x04, 0x82, 0x42, 0x41, 0x20, 0x80,
  0x3E, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x43, 0xF0, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x85, 0x13, 0xC0, 0x41, 0x42, 0x44, 0x48,
  0x50, 0xA0, 0x50, 0x88, 0x88, 0x84, 0x82, 0x41, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0x41, 0x42, 0x42, 0x66, 0xAA, 0xAA, 0xB2, 0x92,
  0x82, 0x84, 0x84, 0x41, 0x41, 0x62, 0xA2, 0x92, 0x92, 0x92, 0x8A, 0x8C,
  0x8C, 0x84, 0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0,
  0x3C, 0x42, 0x41, 0x41, 0x42, 0x46, 0x78, 0x80, 0x80, 0x80, 0x80, 0x1C,
  0xC5, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0x40, 0x40, 0x3C,
  0x85, 0x0A, 0x14, 0x30, 0xBE, 0x44, 0x85, 0x0A, 0x10, 0x3C, 0x85, 0x0A,
  0x04, 0x07, 0x01, 0x01, 0x83, 0x09, 0xE0, 0xFE, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x00, 0x41, 0x41, 0x41, 0x82, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x84, 0x78, 0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x28, 0x60,
  0xC1, 0x00, 0x93, 0x26, 0x4D, 0x9B, 0x5A, 0xB5, 0x4C, 0x89, 0x22, 0x40,
  0x20, 0x90, 0x84, 0x42, 0x40, 0xC0, 0x40, 0x50, 0x28, 0x22, 0x21, 0x20,
  0x80, 0x83, 0x0A, 0x12, 0x45, 0x0A, 0x08, 0x10, 0x40, 0x81, 0x00, 0x3F,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFE, 0x39, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x70, 0x92, 0x44, 0x92, 0x44, 0x90,
  0x38, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x70, 0x11, 0x8C, 0x94,
  0xC4, 0xFC, 0xC0, 0x3C, 0x84, 0x09, 0xD4, 0x50, 0xA1, 0x7E, 0x40, 0x81,
  0x03, 0xE4, 0x30, 0x60, 0xC1, 0x85, 0x0B, 0xE0, 0x3C, 0x86, 0x0C, 0x08,
  0x10, 0x21, 0x3C, 0x02, 0x04, 0x09, 0xF4, 0x30, 0x61, 0x42, 0x85, 0x09,
  0xE0, 0x3C, 0x86, 0x0F, 0xF8, 0x10, 0x21, 0x3C, 0x1E, 0x40, 0x87, 0xE2,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x3E, 0x86, 0x0C, 0x28, 0x50, 0xA1,
  0x3C, 0x04, 0x13, 0xC0, 0x40, 0x81, 0x03, 0xE4, 0x30, 0x60, 0xC2, 0x85,
  0x0A, 0x10, 0x08, 0x00, 0x1E, 0x08, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x02,
  0x00, 0x00, 0xE0, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x1E, 0x00,
  0x20, 0x81, 0x02, 0x14, 0xCA, 0x18, 0x28, 0x91, 0x12, 0x10, 0x38, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x7F, 0x49, 0x89, 0x89, 0x89,
  0x89, 0x91, 0x91, 0x7C, 0x86, 0x0C, 0x18, 0x50, 0xA1, 0x42, 0x3C, 0x86,
  0x0C, 0x18, 0x30, 0x61, 0x3C, 0x3E, 0x45, 0x0A, 0x14, 0x28, 0x50, 0xBE,
  0x81, 0x02, 0x00, 0x3E, 0x86, 0x0C, 0x28, 0x50, 0xA1, 0x3C, 0x04, 0x10,
  0x20, 0x5D, 0x84, 0x20, 0x82, 0x08, 0x20, 0x3C, 0x85, 0x01, 0x80, 0xC0,
  0xA1, 0x3C, 0x21, 0x3E, 0x42, 0x21, 0x08, 0x43, 0x80, 0x42, 0x86, 0x0C,
  0x18, 0x50, 0xA1, 0x3E, 0x83, 0x05, 0x12, 0x24, 0x85, 0x0C, 0x10, 0x91,
  0x91, 0x92, 0xAA, 0xAC, 0xCC, 0xC8, 0x88, 0x21, 0x22, 0x14, 0x08, 0x18,
  0x24, 0x24, 0xC2, 0x40, 0xA0, 0x88, 0x84, 0x42, 0x41, 0x20, 0x60, 0x20,
  0x10, 0x10, 0x30, 0x00, 0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE,
  0x04, 0x21, 0x04, 0x10, 0x82, 0x30, 0x40, 0x82, 0x10, 0x40, 0x83, 0x00,
  0x24, 0xA4, 0x92, 0x52, 0x48, 0x20, 0x40, 0x82, 0x08, 0x20, 0x81, 0x08,
  0x41, 0x04, 0x10, 0x8C, 0x00, 0x71, 0x89, 0x86,
};

const GFXglyph RobotoMono_ThinItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 11, 9, 3, -11 },
  { 4, 3, 3, 9, 4, -11 },
  { 6, 9, 11, 9, 0, -11 },
  { 19, 7, 14, 9, 1, -12 },
  { 32, 7, 11, 9, 1, -11 },
  { 42, 7, 11, 9, 1, -11 },
  { 52, 1, 3, 9, 4, -11 },
  { 53, 4, 15, 9, 3, -12 },
  { 61, 5, 15, 9, 1, -12 },
  { 71, 6, 6, 9, 2, -11 },
  { 76, 7, 8, 9, 1, -9 },
  { 83, 1, 3, 9, 2, -1 },
  { 84, 5, 1, 9, 2, -5 },
  { 85, 1, 1, 9, 3, -1 },
  { 86, 7, 12, 9, 1, -11 },
  { 97, 7, 11, 9, 1, -11 },
  { 107, 4, 11, 9, 2, -11 },
  { 113, 7, 11, 9, 0, -11 },
  { 123, 8, 11, 9, 0, -11 },
  { 134, 8, 11, 9, 0, -11 },
  { 145, 8, 11, 9, 1, -11 },
  { 156, 6, 11, 9, 1, -11 },
  { 165, 7, 11, 9, 2, -11 },
  { 175, 7, 11, 9, 1, -11 },
  { 185, 7, 11, 9, 1, -11 },
  { 195, 2, 7, 9, 4, -7 },
  { 197, 3, 9, 9, 3, -7 },
  { 201, 7, 6, 9, 1, -8 },
  { 207, 7, 4, 9, 1, -7 },
  { 211, 7, 6, 9, 1, -8 },
  { 217, 6, 11, 9, 2, -11 },
  { 226, 9, 11, 9, 0, -11 },
  { 239, 7, 11, 9, 0, -11 },
  { 249, 7, 11, 9, 1, -11 },
  { 259, 7, 11, 9, 1, -11 },
  { 269, 7, 11, 9, 1, -11 },
  { 279, 8, 11, 9, 1, -11 },
  { 290, 8, 11, 9, 1, -11 },
  { 301, 7, 11, 9, 1, -11 },
  { 311, 9, 11, 9, 0, -11 },
  { 324, 7, 11, 9, 1, -11 },
  { 334, 7, 11, 9, 1, -11 },
  { 344, 8, 11, 9, 1, -11 },
  { 355, 6, 11, 9, 1, -11 },
  { 364, 8, 11, 9, 1, -11 },
  { 375, 8, 11, 9, 1, -11 },
  { 386, 7, 11, 9, 1, -11 },
  { 396, 8, 11, 9, 1, -11 },
  { 407, 7, 13, 9, 1, -11 },
  { 419, 7, 11, 9, 1, -11 },
  { 429, 7, 11, 9, 1, -11 },
  { 439, 7, 11, 9, 2, -11 },
  { 449, 8, 11, 9, 1, -11 },
  { 460, 7, 11, 9, 2, -11 },
  { 470, 7, 11, 9, 2, -11 },
  { 480, 9, 11, 9, 0, -11 },
  { 493, 7, 11, 9, 2, -11 },
  { 503, 8, 11, 9, 0, -11 },
  { 514, 5, 14, 9, 2, -12 },
  { 523, 3, 12, 9, 3, -11 },
  { 528, 5, 14, 9, 2, -12 },
  { 537, 5, 6, 9, 2, -11 },
  { 541, 6, 1, 9, 1, 0 },
  { 542, 1, 2, 9, 5, -11 },
  { 543, 7, 8, 9, 1, -8 },
  { 550, 7, 11, 9, 1, -11 },
  { 560, 7, 8, 9, 1, -8 },
  { 567, 7, 11, 9, 1, -11 },
  { 577, 7, 8, 9, 1, -8 },
  { 584, 7, 11, 9, 2, -11 },
  { 594, 7, 11, 9, 1, -8 },
  { 604, 7, 11, 9, 1, -11 },
  { 614, 6, 11, 9, 1, -11 },
  { 623, 7, 14, 9, 0, -11 },
  { 636, 7, 11, 9, 1, -11 },
  { 646, 6, 11, 9, 1, -11 },
  { 655, 8, 8, 9, 0, -8 },
  { 663, 7, 8, 9, 1, -8 },
  { 670, 7, 8, 9, 1, -8 },
  { 677, 7, 11, 9, 0, -8 },
  { 687, 7, 11, 9, 1, -8 },
  { 697, 6, 8, 9, 2, -8 },
  { 703, 7, 8, 9, 1, -8 },
  { 710, 5, 10, 9, 2, -10 },
  { 717, 7, 8, 9, 1, -8 },
  { 724, 7, 8, 9, 1, -8 },
  { 731, 8, 8, 9, 1, -8 },
  { 739, 8, 8, 9, 0, -8 },
  { 747, 9, 11, 9, 0, -8 },
  { 760, 8, 8, 9, 0, -8 },
  { 768, 6, 15, 9, 2, -12 },
  { 780, 3, 13, 9, 3, -11 },
  { 785, 6, 15, 9, 1, -12 },
  { 797, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_ThinItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic15pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_THINITALIC15PT7B_H_
