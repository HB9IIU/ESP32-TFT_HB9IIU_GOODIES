#ifndef _ROBOTOMONO_THINITALIC48PT7B_H_
#define _ROBOTOMONO_THINITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30,
  0x30, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x21,
  0x90, 0xD8, 0x4C, 0x24, 0x12, 0x09, 0x0C, 0x84, 0xC2, 0x41, 0x00, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0xC1, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x02,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x06, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xFC, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x0C,
  0x04, 0x00, 0x08, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x21,
  0x80, 0x00, 0x42, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x08, 0x00, 0x03,
  0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x81, 0x00, 0x02, 0x01, 0x00, 0x1C, 0x03, 0x80, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x61,
  0x00, 0x01, 0x01, 0x00, 0x06, 0x02, 0x00, 0x08, 0x04, 0x03, 0x10, 0x08,
  0x04, 0x60, 0x10, 0x18, 0x80, 0x20, 0x61, 0x00, 0x40, 0x82, 0x01, 0x82,
  0x04, 0x02, 0x0C, 0x08, 0x0C, 0x10, 0x18, 0x10, 0x40, 0x18, 0xC1, 0x80,
  0x1F, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x0F, 0x80, 0x18, 0x61, 0x80, 0x60, 0x81, 0x00,
  0x82, 0x01, 0x03, 0x04, 0x02, 0x0C, 0x18, 0x04, 0x10, 0x20, 0x08, 0x40,
  0x40, 0x31, 0x80, 0x80, 0x62, 0x01, 0x00, 0x88, 0x02, 0x01, 0x30, 0x04,
  0x06, 0x00, 0x08, 0x18, 0x00, 0x08, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0x20, 0x00, 0x80, 0x20, 0x01, 0x80, 0x20, 0x01, 0x00, 0x20, 0x01, 0x00,
  0x20, 0x01, 0x00, 0x60, 0x01, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x01,
  0x80, 0x01, 0x82, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x98, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x08, 0x03, 0x18, 0x0C, 0x02, 0x30, 0x04, 0x02, 0x20, 0x02,
  0x06, 0x60, 0x03, 0x04, 0x40, 0x01, 0x04, 0x40, 0x00, 0x8C, 0x40, 0x00,
  0xD8, 0x40, 0x00, 0x50, 0x40, 0x00, 0x30, 0x40, 0x00, 0x70, 0x60, 0x00,
  0xD0, 0x30, 0x03, 0x98, 0x18, 0x06, 0x0C, 0x07, 0xF8, 0x06, 0x25, 0xB4,
  0x92, 0xD0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0xC0, 0x60, 0x7F, 0x04, 0x3C, 0x1E, 0x4E, 0x00, 0x3F,
  0x00, 0x00, 0xC0, 0x00, 0x1A, 0x00, 0x03, 0x30, 0x00, 0x61, 0x00, 0x0C,
  0x08, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xC6, 0x21,
  0x18, 0x8C, 0x44, 0x00, 0xFF, 0xFF, 0x5F, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x06, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x10, 0x10, 0x00, 0x60, 0x80, 0x00, 0x86, 0x00, 0x02,
  0x10, 0x00, 0x08, 0xC0, 0x00, 0x72, 0x00, 0x03, 0xC8, 0x00, 0x1B, 0x60,
  0x00, 0xCD, 0x80, 0x06, 0x24, 0x00, 0x30, 0x90, 0x01, 0x02, 0x40, 0x08,
  0x0B, 0x00, 0xC0, 0x2C, 0x06, 0x01, 0xA0, 0x30, 0x04, 0x81, 0x80, 0x12,
  0x0C, 0x00, 0x48, 0x40, 0x01, 0x22, 0x00, 0x0C, 0xB0, 0x00, 0x23, 0x80,
  0x00, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x02,
  0x0C, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x20, 0x06, 0x00, 0xE0, 0x70, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x07, 0x21, 0xC2, 0xE0, 0x28, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x81,
  0x00, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00, 0x04, 0x30, 0x00, 0x08, 0x20,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x60, 0x30,
  0x00, 0x40, 0x40, 0x00, 0xC1, 0x80, 0x00, 0x82, 0x00, 0x01, 0x0C, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x13, 0x00, 0x00, 0x26, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00,
  0x06, 0x18, 0x00, 0x08, 0x10, 0x00, 0x20, 0x10, 0x01, 0x80, 0x18, 0x0E,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x68, 0x00, 0x00, 0x48, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x08, 0x00, 0x03, 0x18, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08,
  0x10, 0x00, 0x10, 0x10, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x20, 0x01, 0x80, 0x20, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x40, 0x30, 0x00, 0x40, 0x20, 0x00,
  0x40, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x09, 0xFF, 0x00, 0x1F, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00,
  0x40, 0x40, 0x00, 0x80, 0x20, 0x01, 0x80, 0x30, 0x03, 0x00, 0x18, 0x0E,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x07, 0x80,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x7F, 0x80, 0x8E, 0x07, 0x04, 0x80, 0x0C, 0x78, 0x00,
  0x22, 0x80, 0x01, 0x98, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x60,
  0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00,
  0xA0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x20, 0x00, 0x21, 0x80,
  0x03, 0x04, 0x00, 0x30, 0x30, 0x03, 0x00, 0xE0, 0x70, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x40,
  0xC0, 0x00, 0xC1, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00, 0x41, 0x80,
  0x01, 0x01, 0x00, 0x06, 0x01, 0x80, 0x30, 0x01, 0xC1, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0x06, 0x00, 0x70, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x02,
  0x18, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x09, 0x80, 0x00, 0x12,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x01, 0x98, 0x00, 0x02, 0x10,
  0x00, 0x08, 0x30, 0x00, 0x30, 0x30, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x03, 0x01, 0x80, 0xE0, 0x04,
  0x08, 0x00, 0x61, 0x00, 0x02, 0x30, 0x00, 0x32, 0x00, 0x01, 0x60, 0x00,
  0x14, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x40,
  0x00, 0x64, 0x00, 0x0A, 0x60, 0x03, 0x23, 0x00, 0x66, 0x1C, 0x38, 0x40,
  0x7E, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x38, 0x30, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x10, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x03, 0xFE, 0x03, 0x01, 0x83, 0x00, 0x62, 0x00, 0x13, 0x00,
  0x0D, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x06, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x04, 0x06, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x18, 0x20, 0x3F, 0x03, 0x0C, 0x0C, 0x30, 0x21, 0x03, 0x02,
  0x04, 0x60, 0xC0, 0x40, 0x88, 0x10, 0x08, 0x13, 0x04, 0x02, 0x02, 0x40,
  0x80, 0x40, 0xD8, 0x20, 0x08, 0x1B, 0x04, 0x03, 0x02, 0x41, 0x80, 0x40,
  0x48, 0x20, 0x08, 0x0B, 0x04, 0x01, 0x03, 0x60, 0x80, 0x60, 0x68, 0x10,
  0x08, 0x09, 0x06, 0x03, 0x01, 0x20, 0xC0, 0x60, 0x44, 0x18, 0x14, 0x08,
  0x81, 0x04, 0x82, 0x18, 0x21, 0x90, 0xC3, 0x03, 0xC1, 0xF0, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x02, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x88, 0x00, 0x03, 0x18, 0x00, 0x04, 0x10,
  0x00, 0x18, 0x20, 0x00, 0x20, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x00,
  0x06, 0x02, 0x00, 0x08, 0x06, 0x00, 0x30, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x10, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0x80, 0x01, 0x03, 0xFF, 0xFE, 0x04, 0x00, 0x04, 0x18, 0x00,
  0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x31, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x04,
  0x03, 0xFF, 0xC0, 0x02, 0x00, 0x70, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x04,
  0x02, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x08, 0x00, 0x30, 0x08, 0x01, 0xC0,
  0x0F, 0xFF, 0x80, 0x18, 0x00, 0xE0, 0x10, 0x00, 0x30, 0x10, 0x00, 0x18,
  0x10, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x30, 0x00, 0x04, 0x30, 0x00, 0x04,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0,
  0x40, 0x07, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x81,
  0x00, 0x01, 0x84, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x09, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x32, 0x00, 0x00, 0x46,
  0x00, 0x01, 0x84, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0x38, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x02, 0x00, 0xE0, 0x02, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x04, 0x00, 0x04, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10,
  0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x40,
  0x00, 0x30, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x40,
  0x07, 0x00, 0xC0, 0x3C, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x20, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0x80, 0xC0, 0x0C, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x84, 0x00, 0x01,
  0x18, 0x00, 0x02, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x01,
  0xFF, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x66, 0x00, 0x00, 0x84, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x18, 0x00, 0x04, 0x10, 0x00, 0x18, 0x10, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00,
  0x18, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x1F,
  0xFF, 0xFE, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10,
  0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03,
  0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x40, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x20, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x40,
  0x00, 0x20, 0x10, 0x00, 0x10, 0x04, 0x00, 0x18, 0x01, 0x00, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00, 0xC0,
  0x00, 0x80, 0x60, 0x00, 0x20, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x43, 0x00, 0x00, 0x11, 0xE0, 0x00, 0x04,
  0x88, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x30, 0x08, 0x00,
  0x08, 0x03, 0x00, 0x02, 0x00, 0x40, 0x00, 0x80, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x40, 0x04, 0x00, 0x18, 0x01, 0x00, 0x02, 0x00, 0x40,
  0x00, 0xC0, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x14, 0x00, 0x0A, 0x05, 0x00, 0x06, 0x81, 0x60, 0x01, 0x20,
  0x48, 0x00, 0xD8, 0x32, 0x00, 0x64, 0x08, 0x80, 0x11, 0x02, 0x20, 0x0C,
  0x40, 0x8C, 0x02, 0x10, 0x21, 0x01, 0x84, 0x08, 0x40, 0x43, 0x06, 0x10,
  0x30, 0x81, 0x04, 0x18, 0x20, 0x41, 0x84, 0x08, 0x10, 0x23, 0x02, 0x04,
  0x08, 0x81, 0x83, 0x02, 0x60, 0x60, 0xC0, 0x90, 0x10, 0x20, 0x38, 0x04,
  0x08, 0x06, 0x01, 0x02, 0x01, 0x00, 0x40, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x08, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x02, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x41, 0x40, 0x00, 0x20, 0xA0, 0x00, 0x10, 0x50, 0x00, 0x18, 0x24,
  0x00, 0x08, 0x32, 0x00, 0x04, 0x11, 0x80, 0x02, 0x08, 0x40, 0x01, 0x04,
  0x20, 0x01, 0x82, 0x08, 0x00, 0xC1, 0x04, 0x00, 0x41, 0x82, 0x00, 0x20,
  0x80, 0x80, 0x10, 0x40, 0x40, 0x08, 0x20, 0x30, 0x0C, 0x10, 0x08, 0x06,
  0x08, 0x04, 0x02, 0x0C, 0x01, 0x01, 0x04, 0x00, 0x80, 0x82, 0x00, 0x40,
  0x41, 0x00, 0x10, 0x60, 0x80, 0x08, 0x20, 0xC0, 0x06, 0x10, 0x40, 0x01,
  0x08, 0x20, 0x00, 0x84, 0x10, 0x00, 0x22, 0x08, 0x00, 0x13, 0x04, 0x00,
  0x09, 0x06, 0x00, 0x02, 0x82, 0x00, 0x01, 0x41, 0x00, 0x00, 0xE0, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x81,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x06, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x09, 0x80, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0x58, 0x00,
  0x00, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00, 0x02,
  0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00, 0x00, 0x22, 0x00, 0x00, 0x46,
  0x00, 0x01, 0x04, 0x00, 0x06, 0x08, 0x00, 0x08, 0x18, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0x00, 0x1C, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x40, 0x00, 0x30, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02,
  0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x60, 0x00, 0x10, 0x30, 0x00,
  0x18, 0x10, 0x00, 0x18, 0x08, 0x00, 0x30, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x02, 0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x20, 0x00, 0x80, 0x30, 0x03,
  0x00, 0x18, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x10, 0x00, 0x60, 0x20, 0x00,
  0x60, 0x40, 0x00, 0x40, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x86, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00, 0x21,
  0x80, 0x00, 0x42, 0x00, 0x01, 0x04, 0x00, 0x06, 0x08, 0x00, 0x18, 0x10,
  0x00, 0x60, 0x20, 0x03, 0x00, 0xFF, 0xFC, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x60, 0x01,
  0x80, 0x80, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x06, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x30, 0x00, 0x18, 0x40, 0x00, 0x10, 0x80, 0x00, 0x31,
  0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x38,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x04, 0x00, 0x06, 0x08, 0x00, 0x02,
  0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x30,
  0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x30,
  0x00, 0x04, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0xC0,
  0x00, 0x10, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0x40,
  0x00, 0x60, 0x40, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x18, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x24, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x18, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x40, 0x80, 0x00,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x02, 0x00, 0x18, 0x04, 0x00, 0x20,
  0x08, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x60, 0x08, 0x00,
  0x40, 0x30, 0x00, 0x80, 0x40, 0x01, 0x01, 0x80, 0x02, 0x02, 0x00, 0x04,
  0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x10, 0x80, 0x00, 0x21,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x08,
  0x01, 0xC0, 0x0C, 0x00, 0xA0, 0x06, 0x00, 0x50, 0x03, 0x00, 0x28, 0x03,
  0x80, 0x24, 0x01, 0x40, 0x12, 0x00, 0xA0, 0x09, 0x00, 0xD0, 0x08, 0xC0,
  0x48, 0x04, 0x60, 0x26, 0x02, 0x30, 0x33, 0x03, 0x18, 0x11, 0x81, 0x0C,
  0x08, 0xC0, 0x86, 0x0C, 0x60, 0xC3, 0x04, 0x30, 0x41, 0x82, 0x18, 0x20,
  0xC3, 0x04, 0x30, 0x61, 0x02, 0x10, 0x31, 0x81, 0x08, 0x18, 0xC0, 0x84,
  0x0C, 0x40, 0x44, 0x06, 0x60, 0x22, 0x03, 0x20, 0x11, 0x01, 0x90, 0x09,
  0x80, 0xD8, 0x04, 0x80, 0x68, 0x02, 0x40, 0x34, 0x01, 0x60, 0x16, 0x00,
  0xA0, 0x0A, 0x00, 0x50, 0x05, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00,
  0x80, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x06, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x02, 0x01, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x04, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x08, 0x02, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x62, 0x00, 0x00, 0x86, 0x00, 0x02, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x10, 0x18, 0x00, 0x40, 0x30, 0x01, 0x80, 0x20, 0x02,
  0x00, 0x60, 0x08, 0x00, 0x40, 0x30, 0x00, 0x80, 0x40, 0x01, 0x01, 0x00,
  0x01, 0x06, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x04, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x14, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x00,
  0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08,
  0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x01, 0xFC, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x03, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x78, 0x00, 0x48, 0x00,
  0xC8, 0x00, 0x88, 0x01, 0x0C, 0x03, 0x0C, 0x02, 0x04, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x06, 0x08, 0x02, 0x10, 0x02, 0x30, 0x02, 0x20, 0x03, 0x60,
  0x03, 0x40, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x8C, 0x46, 0x23, 0x10,
  0x00, 0x3F, 0x00, 0x07, 0xDE, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0,
  0x01, 0x8C, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0x03, 0xC0,
  0x08, 0x70, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x01, 0x20,
  0x00, 0x09, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x72, 0x00, 0x05,
  0x88, 0x00, 0xCC, 0x70, 0x1C, 0x60, 0xFF, 0x83, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x07, 0xC0, 0x11, 0xF7, 0x80, 0x98, 0x06, 0x05, 0x00, 0x10,
  0x70, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x18, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x60, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24,
  0x00, 0x03, 0x20, 0x00, 0x1B, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00,
  0x64, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x18, 0x00, 0x18, 0xE0,
  0x01, 0x85, 0x80, 0x18, 0x27, 0x03, 0x81, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xDE, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x04,
  0x00, 0x0C, 0x60, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x09, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x0C,
  0x80, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x20, 0x80, 0x02, 0x02, 0x00,
  0x60, 0x0C, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x3E, 0x04, 0x00, 0xF7, 0x8C, 0x03, 0x80, 0xCC, 0x06, 0x00,
  0x28, 0x0C, 0x00, 0x38, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18, 0x10, 0x00,
  0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x60, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00,
  0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00,
  0x60, 0x40, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x20, 0x01, 0xC0, 0x30, 0x03,
  0x40, 0x18, 0x0C, 0xC0, 0x0F, 0xF8, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xEF,
  0x00, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x04, 0x00, 0x18, 0x20, 0x00, 0x21,
  0x80, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x34, 0x00,
  0x00, 0x9F, 0xFF, 0xFE, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x70, 0x0C, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F,
  0xF0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xF7, 0x8C, 0x07, 0x01, 0x98, 0x18, 0x01,
  0xA0, 0x60, 0x01, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x82, 0x00,
  0x02, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x38, 0x0C, 0x00, 0xD0, 0x0C, 0x06,
  0x20, 0x0F, 0xF8, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x40, 0x00, 0x80, 0xC0, 0x02, 0x00,
  0xC0, 0x18, 0x00, 0xE0, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x7C, 0x01, 0x0F, 0x3C, 0x0C, 0x60, 0x18, 0x32, 0x00, 0x20,
  0x90, 0x00, 0xC2, 0x80, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80,
  0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00, 0x00,
  0x84, 0x00, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x22, 0x00, 0x01, 0x88,
  0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00,
  0x04, 0x40, 0x00, 0x31, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x30, 0x00, 0x08,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x08, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x81,
  0x80, 0x0C, 0x02, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x10,
  0x18, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x0C, 0x00, 0x02, 0x30,
  0x00, 0x04, 0xF0, 0x00, 0x0E, 0x20, 0x00, 0x38, 0x20, 0x00, 0x60, 0x60,
  0x00, 0x80, 0x60, 0x01, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x04, 0x00, 0xC0,
  0x18, 0x00, 0x80, 0x20, 0x00, 0x80, 0x40, 0x01, 0x80, 0x80, 0x01, 0x81,
  0x00, 0x01, 0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x4E, 0xE1, 0xEE, 0x05, 0x01, 0x30, 0x20, 0xE0, 0x16, 0x01, 0x0C, 0x01,
  0xC0, 0x10, 0xC0, 0x18, 0x01, 0x08, 0x01, 0x80, 0x10, 0x80, 0x10, 0x01,
  0x08, 0x01, 0x00, 0x31, 0x80, 0x10, 0x02, 0x10, 0x01, 0x00, 0x21, 0x00,
  0x30, 0x02, 0x10, 0x02, 0x00, 0x21, 0x00, 0x20, 0x02, 0x30, 0x02, 0x00,
  0x63, 0x00, 0x20, 0x04, 0x20, 0x02, 0x00, 0x42, 0x00, 0x60, 0x04, 0x20,
  0x04, 0x00, 0x42, 0x00, 0x40, 0x04, 0x60, 0x04, 0x00, 0xC4, 0x00, 0x40,
  0x08, 0x40, 0x04, 0x00, 0x84, 0x00, 0xC0, 0x08, 0x40, 0x08, 0x00, 0x8C,
  0x00, 0x80, 0x18, 0x00, 0x07, 0xC0, 0x10, 0xF3, 0xC0, 0xC6, 0x01, 0x83,
  0x60, 0x02, 0x09, 0x00, 0x0C, 0x28, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00,
  0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x02,
  0x10, 0x00, 0x08, 0x40, 0x00, 0x23, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20,
  0x00, 0x18, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x60, 0x00,
  0x11, 0x00, 0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x23,
  0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xDF, 0x00, 0x38, 0x06, 0x01,
  0x80, 0x0C, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x63, 0x00, 0x00, 0x88, 0x00,
  0x02, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0xC0, 0x00,
  0x61, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x0E, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x04, 0x7D, 0xE0, 0x09, 0x80, 0x60,
  0x34, 0x00, 0x40, 0x50, 0x00, 0xC0, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x82,
  0x00, 0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40,
  0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x0C, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00,
  0xC1, 0x00, 0x01, 0x06, 0x00, 0x04, 0x0A, 0x00, 0x18, 0x16, 0x00, 0x60,
  0x27, 0x03, 0x80, 0x43, 0xFC, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xDE, 0x30, 0x38, 0x0C, 0xC1, 0x80, 0x1A, 0x0C, 0x00,
  0x38, 0x20, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x10,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00,
  0x00, 0xC4, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x06, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x80, 0x03, 0x02,
  0x00, 0x1C, 0x0C, 0x00, 0xD0, 0x18, 0x0C, 0x40, 0x1F, 0xE3, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0xF0, 0x41, 0xF1, 0x0C, 0x70, 0x00, 0xCC, 0x00,
  0x09, 0x00, 0x00, 0xA0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xEF,
  0x80, 0x30, 0x03, 0x01, 0x80, 0x06, 0x08, 0x00, 0x08, 0x20, 0x00, 0x31,
  0x80, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x86, 0x00, 0x06, 0x08, 0x00,
  0x30, 0x18, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x03, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x40, 0x00, 0x32, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x60, 0x00, 0x32, 0x00, 0x01,
  0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x31,
  0x00, 0x01, 0x8C, 0x00, 0x1C, 0x20, 0x01, 0xC1, 0x80, 0x1A, 0x06, 0x03,
  0x10, 0x1F, 0xF1, 0x80, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x19, 0x80, 0x00,
  0x23, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x08,
  0x18, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x30, 0x01, 0x00, 0x40, 0x03, 0x01, 0x00, 0x02,
  0x06, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00, 0x11,
  0x80, 0x00, 0x26, 0x00, 0x00, 0x68, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x01, 0xA0, 0x0E,
  0x00, 0x90, 0x05, 0x00, 0x48, 0x06, 0x80, 0x64, 0x02, 0x40, 0x22, 0x01,
  0x20, 0x31, 0x01, 0x90, 0x10, 0x80, 0x88, 0x08, 0x40, 0xC4, 0x0C, 0x30,
  0x42, 0x04, 0x18, 0x21, 0x86, 0x0C, 0x20, 0xC2, 0x06, 0x10, 0x61, 0x03,
  0x18, 0x11, 0x81, 0x88, 0x08, 0x80, 0x4C, 0x04, 0x40, 0x24, 0x02, 0x60,
  0x12, 0x01, 0x20, 0x0A, 0x00, 0xB0, 0x05, 0x00, 0x50, 0x03, 0x80, 0x28,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x01, 0x81, 0x00, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x08, 0x01, 0x80, 0x06, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x41, 0x80,
  0x00, 0x31, 0x80, 0x00, 0x09, 0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00, 0x40, 0x40,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x40, 0x04, 0x00, 0x06, 0x00, 0x30, 0x00, 0x20, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x01, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xB8, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x46, 0x1C, 0x00, 0x33, 0x01, 0x80, 0x09, 0x80, 0x30, 0x06, 0x40,
  0x06, 0x01, 0x10, 0x00, 0xC1, 0x8C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xC0,
};

const GFXglyph RobotoMono_ThinItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 34, 28, 10, -34 },
  { 35, 9, 10, 28, 12, -36 },
  { 47, 28, 34, 28, 1, -34 },
  { 166, 23, 44, 28, 3, -39 },
  { 293, 23, 36, 28, 3, -35 },
  { 397, 24, 35, 28, 2, -35 },
  { 502, 3, 10, 28, 14, -36 },
  { 506, 15, 49, 28, 8, -38 },
  { 598, 14, 49, 28, 5, -38 },
  { 684, 20, 18, 28, 7, -34 },
  { 729, 23, 25, 28, 3, -28 },
  { 801, 5, 10, 28, 6, -4 },
  { 808, 16, 1, 28, 6, -16 },
  { 810, 3, 3, 28, 11, -3 },
  { 812, 22, 37, 28, 4, -34 },
  { 914, 22, 35, 28, 4, -35 },
  { 1011, 12, 34, 28, 8, -34 },
  { 1062, 23, 35, 28, 1, -35 },
  { 1163, 23, 35, 28, 1, -35 },
  { 1264, 24, 34, 28, 1, -34 },
  { 1366, 24, 34, 28, 4, -34 },
  { 1468, 21, 36, 28, 3, -35 },
  { 1563, 21, 34, 28, 6, -34 },
  { 1653, 23, 35, 28, 3, -35 },
  { 1754, 20, 35, 28, 5, -35 },
  { 1842, 7, 24, 28, 12, -24 },
  { 1863, 9, 30, 28, 10, -24 },
  { 1897, 21, 19, 28, 4, -25 },
  { 1947, 22, 11, 28, 3, -21 },
  { 1978, 21, 19, 28, 3, -25 },
  { 2028, 17, 35, 28, 8, -35 },
  { 2103, 27, 34, 28, 1, -34 },
  { 2218, 23, 34, 28, 0, -34 },
  { 2316, 24, 34, 28, 2, -34 },
  { 2418, 23, 36, 28, 3, -35 },
  { 2522, 24, 34, 28, 2, -34 },
  { 2624, 24, 34, 28, 3, -34 },
  { 2726, 25, 34, 28, 3, -34 },
  { 2833, 23, 36, 28, 3, -35 },
  { 2937, 25, 34, 28, 2, -34 },
  { 3044, 25, 34, 28, 2, -34 },
  { 3151, 24, 35, 28, 2, -34 },
  { 3256, 26, 34, 28, 3, -34 },
  { 3367, 19, 34, 28, 3, -34 },
  { 3448, 26, 34, 28, 2, -34 },
  { 3559, 25, 34, 28, 2, -34 },
  { 3666, 23, 35, 28, 3, -35 },
  { 3767, 25, 34, 28, 3, -34 },
  { 3874, 24, 41, 28, 3, -35 },
  { 3997, 23, 34, 28, 3, -34 },
  { 4095, 24, 35, 28, 3, -35 },
  { 4200, 23, 34, 28, 6, -34 },
  { 4298, 24, 34, 28, 3, -34 },
  { 4400, 23, 34, 28, 6, -34 },
  { 4498, 25, 34, 28, 5, -34 },
  { 4605, 28, 34, 28, 1, -34 },
  { 4724, 23, 34, 28, 6, -34 },
  { 4822, 25, 34, 28, 1, -34 },
  { 4929, 15, 46, 28, 7, -39 },
  { 5016, 9, 37, 28, 10, -34 },
  { 5058, 14, 46, 28, 7, -39 },
  { 5139, 16, 19, 28, 6, -34 },
  { 5177, 19, 1, 28, 2, 0 },
  { 5180, 4, 7, 28, 15, -36 },
  { 5184, 21, 27, 28, 3, -26 },
  { 5255, 21, 36, 28, 3, -36 },
  { 5350, 21, 26, 28, 3, -26 },
  { 5419, 24, 36, 28, 3, -36 },
  { 5527, 22, 26, 28, 3, -26 },
  { 5599, 22, 37, 28, 7, -37 },
  { 5701, 23, 36, 28, 2, -26 },
  { 5805, 22, 36, 28, 2, -36 },
  { 5904, 19, 34, 28, 3, -34 },
  { 5985, 22, 44, 28, 0, -34 },
  { 6106, 23, 36, 28, 3, -36 },
  { 6210, 19, 36, 28, 3, -36 },
  { 6296, 28, 26, 28, -1, -26 },
  { 6387, 22, 26, 28, 2, -26 },
  { 6459, 22, 26, 28, 3, -26 },
  { 6531, 23, 36, 28, 1, -26 },
  { 6635, 22, 36, 28, 3, -26 },
  { 6734, 20, 26, 28, 6, -26 },
  { 6799, 22, 26, 28, 3, -26 },
  { 6871, 18, 33, 28, 6, -32 },
  { 6946, 21, 25, 28, 4, -25 },
  { 7012, 23, 25, 28, 4, -25 },
  { 7084, 25, 25, 28, 4, -25 },
  { 7163, 25, 25, 28, 1, -25 },
  { 7242, 29, 35, 28, -1, -25 },
  { 7369, 24, 25, 28, 1, -25 },
  { 7444, 19, 47, 28, 7, -37 },
  { 7556, 8, 40, 28, 10, -34 },
  { 7596, 18, 47, 28, 4, -37 },
  { 7702, 26, 8, 28, 1, -18 },
};

const GFXfont RobotoMono_ThinItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic48pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_THINITALIC48PT7B_H_
