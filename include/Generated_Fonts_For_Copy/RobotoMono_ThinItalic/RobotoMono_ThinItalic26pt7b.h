#ifndef _ROBOTOMONO_THINITALIC26PT7B_H_
#define _ROBOTOMONO_THINITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x44, 0x00, 0x00, 0x06,
  0x00, 0x99, 0x99, 0x99, 0x00, 0x84, 0x02, 0x08, 0x04, 0x20, 0x08, 0x40,
  0x20, 0x83, 0xFE, 0xC0, 0x84, 0x02, 0x08, 0x04, 0x20, 0x08, 0x40, 0x21,
  0x00, 0x42, 0x0F, 0xFF, 0x82, 0x10, 0x04, 0x20, 0x08, 0x40, 0x21, 0x00,
  0x42, 0x00, 0x00, 0x80, 0x10, 0x03, 0xC0, 0xC2, 0x10, 0x12, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x80, 0x28, 0x02, 0x80, 0x44, 0x08, 0x37, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x30, 0x04, 0x80, 0x84, 0x08, 0x42, 0x84, 0x48, 0x48, 0x88,
  0x89, 0x90, 0x62, 0x00, 0x20, 0x04, 0x00, 0x8E, 0x11, 0x11, 0x21, 0x22,
  0x14, 0x21, 0xC2, 0x10, 0x22, 0x01, 0xC0, 0x03, 0x80, 0x22, 0x02, 0x08,
  0x10, 0x40, 0x84, 0x04, 0x20, 0x22, 0x01, 0x60, 0x04, 0x00, 0x60, 0x04,
  0x80, 0x42, 0x14, 0x10, 0xA0, 0x4A, 0x02, 0x50, 0x0C, 0x80, 0x62, 0x05,
  0x0F, 0xC4, 0xFC, 0x02, 0x04, 0x10, 0x41, 0x04, 0x08, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x04, 0x01, 0x00, 0x43, 0x13, 0x37,
  0x03, 0x01, 0x40, 0x88, 0x41, 0x20, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x24, 0xA8, 0xFF, 0x80, 0xC0, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x03, 0x80, 0xC4, 0x10, 0x22, 0x01, 0x20, 0x14, 0x03, 0x40,
  0x54, 0x09, 0x81, 0x18, 0x21, 0x84, 0x29, 0x82, 0xA0, 0x2C, 0x02, 0x80,
  0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x0E, 0xEA, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x07,
  0x00, 0x84, 0x10, 0x22, 0x01, 0x40, 0x14, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x00, 0xFF, 0xC0, 0x03, 0xC0, 0xC2, 0x10, 0x12, 0x01, 0x20, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0xC0, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x20,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x00, 0x20, 0x06,
  0x00, 0xA0, 0x12, 0x02, 0x20, 0x22, 0x04, 0x40, 0x84, 0x10, 0x42, 0x04,
  0x40, 0x44, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x0F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x88, 0x07,
  0x18, 0x20, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x40, 0x12, 0x01,
  0x08, 0x08, 0x40, 0x81, 0xF8, 0x00, 0x00, 0x40, 0x60, 0x30, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0xFC, 0xA0, 0x58, 0x0A, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x14, 0x02, 0x80, 0x88, 0x20, 0xF8, 0x00, 0xFF, 0xF0, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0x01, 0xE0, 0x30, 0x82, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x22,
  0x02, 0x08, 0x20, 0x3E, 0x06, 0x18, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00,
  0x50, 0x02, 0x40, 0x23, 0x02, 0x07, 0xE0, 0x0F, 0x02, 0x10, 0x81, 0x20,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0A, 0x03, 0x20, 0xA3,
  0xE4, 0x01, 0x00, 0x20, 0x08, 0x02, 0x01, 0x83, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x44, 0x22,
  0x00, 0x00, 0x10, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x70,
  0x30, 0x18, 0x0C, 0x02, 0x00, 0x00, 0x0E, 0x0C, 0x64, 0x09, 0x01, 0x80,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x01, 0x80, 0x80, 0x40, 0x10, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x18, 0x60, 0x80, 0x84,
  0x01, 0x21, 0xC4, 0x88, 0x94, 0x44, 0x52, 0x11, 0x88, 0x46, 0x41, 0x19,
  0x08, 0x64, 0x22, 0x90, 0x8A, 0x46, 0x29, 0x2B, 0x23, 0x10, 0x80, 0x01,
  0x01, 0x03, 0xF8, 0x00, 0x00, 0x40, 0x06, 0x00, 0x28, 0x02, 0x40, 0x12,
  0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x40, 0x82, 0x04, 0x20, 0x21,
  0xFF, 0x10, 0x08, 0x80, 0x48, 0x02, 0x40, 0x0C, 0x00, 0x40, 0x1F, 0xE0,
  0x80, 0x84, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x44, 0x04, 0x3F,
  0xC1, 0x01, 0x10, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04,
  0x80, 0x47, 0xFC, 0x00, 0x03, 0x80, 0xC6, 0x10, 0x12, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x02, 0x80, 0x28, 0x04, 0x80, 0x84, 0x18, 0x3E, 0x00, 0x1F, 0xE0, 0x80,
  0x84, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x90, 0x08, 0x81,
  0x87, 0xF0, 0x00, 0x1F, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xE0, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x3F,
  0xF9, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x7F, 0xC2, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x03, 0x80, 0xC6, 0x10, 0x12, 0x01, 0x40,
  0x14, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x83, 0xC8, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x24, 0x04, 0x3F, 0x80, 0x10, 0x04,
  0x40, 0x12, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02,
  0x3F, 0xF1, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x02,
  0x20, 0x08, 0x80, 0x22, 0x00, 0x80, 0x1F, 0xF8, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x07, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x40, 0x12, 0x01,
  0x10, 0x08, 0x40, 0x81, 0xF8, 0x00, 0x20, 0x0C, 0x80, 0x42, 0x02, 0x08,
  0x10, 0x20, 0x81, 0x0C, 0x04, 0x40, 0x12, 0x00, 0x58, 0x01, 0x90, 0x04,
  0x20, 0x20, 0x80, 0x81, 0x02, 0x02, 0x08, 0x08, 0x20, 0x10, 0x80, 0x42,
  0x00, 0x80, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F,
  0xF0, 0x10, 0x0C, 0x60, 0x32, 0x81, 0x4A, 0x05, 0x28, 0x28, 0xA1, 0x22,
  0x44, 0x89, 0x22, 0x44, 0x89, 0x14, 0x44, 0x51, 0x10, 0x84, 0x40, 0x11,
  0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x80, 0x10, 0x04, 0x40,
  0x12, 0x80, 0x8A, 0x02, 0x24, 0x08, 0x90, 0x22, 0x20, 0x88, 0x82, 0x42,
  0x11, 0x04, 0x44, 0x11, 0x10, 0x44, 0x40, 0x92, 0x02, 0x48, 0x06, 0x20,
  0x18, 0x80, 0x62, 0x00, 0x80, 0x07, 0x80, 0x84, 0x10, 0x22, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x1F, 0xE1,
  0x00, 0x88, 0x02, 0x40, 0x12, 0x00, 0x90, 0x05, 0x00, 0x48, 0x02, 0x40,
  0x23, 0xFE, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x21, 0x82, 0x02, 0x20, 0x12, 0x00,
  0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0A, 0x00, 0x48, 0x04, 0x40, 0x21, 0x06, 0x07, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x1F, 0xE0, 0x80, 0x84, 0x02, 0x20, 0x11, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x02, 0x20, 0x21, 0xFE, 0x08, 0x20, 0x81, 0x04,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x04, 0x40, 0x24, 0x01, 0x00, 0x03, 0xC0,
  0x61, 0x84, 0x02, 0x20, 0x12, 0x00, 0x90, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x0A, 0x00, 0x50, 0x02,
  0x40, 0x21, 0x03, 0x07, 0xE0, 0xFF, 0xF8, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x20,
  0x09, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x50, 0x02,
  0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10,
  0x10, 0x41, 0x01, 0xF0, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x24, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84, 0x10, 0x41, 0x02, 0x20, 0x22,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x01, 0x00, 0x10, 0x00, 0x82, 0x0C,
  0x10, 0x61, 0x85, 0x0C, 0x28, 0xA1, 0x45, 0x12, 0x28, 0x92, 0x44, 0x92,
  0x24, 0x92, 0x28, 0x91, 0x44, 0x8A, 0x28, 0x61, 0x43, 0x06, 0x10, 0x20,
  0x81, 0x04, 0x08, 0x00, 0x10, 0x01, 0x08, 0x02, 0x08, 0x04, 0x04, 0x08,
  0x04, 0x08, 0x02, 0x10, 0x02, 0x20, 0x01, 0x40, 0x01, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x02, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x20, 0x10, 0x20,
  0x20, 0x10, 0x40, 0x10, 0xC0, 0x08, 0x80, 0x0C, 0x00, 0x90, 0x08, 0x80,
  0x44, 0x04, 0x10, 0x40, 0x82, 0x04, 0x20, 0x12, 0x00, 0xA0, 0x05, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x1F, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xF0, 0x84, 0x10, 0x84, 0x21,
  0x04, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10, 0x42, 0x10, 0x80, 0x0E, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0xF0, 0x02, 0x03, 0x02, 0x41,
  0x21, 0x10, 0x88, 0x82, 0x81, 0x40, 0xC0, 0x40, 0xFF, 0xC0, 0x94, 0x07,
  0xC0, 0x82, 0x10, 0x12, 0x01, 0x00, 0x10, 0x01, 0x07, 0xF1, 0x81, 0x60,
  0x24, 0x02, 0x80, 0x28, 0x06, 0x40, 0xA3, 0xF2, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x17, 0xC2, 0x82, 0x30, 0x12, 0x01, 0x20,
  0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x04, 0x60,
  0x89, 0xF0, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x01, 0x40, 0x24, 0x08, 0x7E, 0x00, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F, 0x91, 0x06, 0x20, 0x24,
  0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x0C, 0x41, 0x43, 0xE8, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x03, 0x00,
  0x7F, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x0C, 0x7E, 0x00,
  0x00, 0xF0, 0x60, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0xFF, 0x81, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x07, 0xD0, 0x83, 0x10, 0x12, 0x01,
  0x20, 0x14, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x06,
  0x20, 0xA1, 0xF4, 0x00, 0x40, 0x04, 0x00, 0x88, 0x10, 0x62, 0x01, 0xC0,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x23, 0xC2, 0xC2,
  0x30, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x02,
  0x40, 0x24, 0x02, 0x80, 0x28, 0x02, 0x01, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0xC0, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x12, 0x06, 0x20, 0x82, 0x10, 0x46,
  0x04, 0x80, 0x58, 0x06, 0x40, 0x44, 0x08, 0x20, 0x81, 0x08, 0x10, 0x80,
  0x88, 0x04, 0x1F, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x43, 0xFF, 0x2F, 0x3C, 0x62, 0x84, 0x82, 0x0A, 0x04, 0x14, 0x10,
  0x28, 0x20, 0x90, 0x41, 0x20, 0x82, 0x41, 0x05, 0x02, 0x0A, 0x08, 0x14,
  0x10, 0x48, 0x20, 0x90, 0x41, 0x00, 0x23, 0xC2, 0xC2, 0x30, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x80, 0x28, 0x02, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x04, 0x20, 0xC1, 0xF0,
  0x0B, 0xE0, 0xA0, 0x86, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x24,
  0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x45, 0x04, 0x27, 0xC1, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x00, 0x0F, 0xA2, 0x0C, 0x80, 0xA0,
  0x14, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x64,
  0x14, 0x7D, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x13, 0xE4,
  0x80, 0xA0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x00, 0x0F, 0x86, 0x0C, 0x80, 0xA0, 0x14,
  0x00, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x28, 0x08,
  0xFE, 0x00, 0x04, 0x01, 0x00, 0x83, 0xFF, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x40, 0x0F, 0x00,
  0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x41, 0x47, 0xE8, 0x80, 0x0A, 0x00,
  0x90, 0x08, 0x80, 0x44, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x21, 0x00,
  0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x04, 0x00, 0x82, 0x0C, 0x10, 0x61,
  0x83, 0x0C, 0x28, 0xA1, 0x44, 0x8A, 0x24, 0x92, 0x24, 0x91, 0x45, 0x0A,
  0x28, 0x51, 0x43, 0x04, 0x18, 0x20, 0x80, 0x20, 0x08, 0x80, 0x84, 0x08,
  0x10, 0x80, 0x48, 0x02, 0x80, 0x0C, 0x00, 0x40, 0x05, 0x00, 0x44, 0x04,
  0x20, 0x40, 0x84, 0x02, 0x40, 0x10, 0x20, 0x02, 0x40, 0x08, 0x40, 0x10,
  0x80, 0x41, 0x00, 0x82, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x08,
  0x80, 0x12, 0x00, 0x28, 0x00, 0x50, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x40, 0x20, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x12, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88,
  0x88, 0x88, 0x80, 0x0C, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x10, 0x04, 0x00, 0xC0, 0x60, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x60, 0x20, 0x00,
  0x38, 0x05, 0x10, 0x28, 0x20, 0xA0, 0x7C,
};

const GFXglyph RobotoMono_ThinItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 4, 6, 15, 7, -20 },
  { 16, 15, 18, 15, 0, -18 },
  { 50, 12, 24, 15, 2, -21 },
  { 86, 12, 19, 15, 2, -19 },
  { 115, 13, 19, 15, 1, -19 },
  { 146, 1, 6, 15, 8, -20 },
  { 147, 7, 27, 15, 5, -21 },
  { 171, 8, 27, 15, 2, -21 },
  { 198, 10, 10, 15, 4, -18 },
  { 211, 12, 13, 15, 2, -15 },
  { 231, 3, 5, 15, 3, -2 },
  { 233, 9, 1, 15, 3, -9 },
  { 235, 2, 1, 15, 6, -1 },
  { 236, 12, 20, 15, 2, -18 },
  { 266, 12, 19, 15, 2, -19 },
  { 295, 7, 18, 15, 4, -18 },
  { 311, 12, 19, 15, 1, -19 },
  { 340, 12, 19, 15, 1, -19 },
  { 369, 12, 18, 15, 1, -18 },
  { 396, 13, 18, 15, 2, -18 },
  { 426, 11, 19, 15, 2, -19 },
  { 453, 12, 18, 15, 3, -18 },
  { 480, 13, 19, 15, 1, -19 },
  { 511, 11, 19, 15, 3, -19 },
  { 538, 3, 12, 15, 7, -12 },
  { 543, 5, 15, 15, 5, -12 },
  { 553, 12, 11, 15, 2, -14 },
  { 570, 12, 5, 15, 2, -11 },
  { 578, 11, 11, 15, 2, -14 },
  { 594, 10, 19, 15, 4, -19 },
  { 618, 14, 19, 15, 1, -19 },
  { 652, 13, 18, 15, 0, -18 },
  { 682, 13, 18, 15, 1, -18 },
  { 712, 12, 19, 15, 2, -19 },
  { 741, 13, 18, 15, 1, -18 },
  { 771, 14, 18, 15, 1, -18 },
  { 803, 13, 18, 15, 2, -18 },
  { 833, 12, 19, 15, 2, -19 },
  { 862, 14, 18, 15, 1, -18 },
  { 894, 13, 18, 15, 1, -18 },
  { 924, 13, 18, 15, 1, -18 },
  { 954, 14, 18, 15, 2, -18 },
  { 986, 10, 18, 15, 2, -18 },
  { 1009, 14, 18, 15, 1, -18 },
  { 1041, 14, 18, 15, 1, -18 },
  { 1073, 12, 19, 15, 2, -19 },
  { 1102, 13, 18, 15, 2, -18 },
  { 1132, 13, 22, 15, 1, -19 },
  { 1168, 13, 18, 15, 1, -18 },
  { 1198, 13, 19, 15, 1, -19 },
  { 1229, 13, 18, 15, 3, -18 },
  { 1259, 13, 18, 15, 2, -18 },
  { 1289, 12, 19, 15, 3, -19 },
  { 1318, 13, 18, 15, 3, -18 },
  { 1348, 16, 19, 15, 0, -19 },
  { 1386, 13, 19, 15, 3, -19 },
  { 1417, 13, 18, 15, 1, -18 },
  { 1447, 8, 25, 15, 4, -21 },
  { 1472, 5, 21, 15, 5, -19 },
  { 1486, 7, 25, 15, 4, -21 },
  { 1508, 9, 10, 15, 3, -18 },
  { 1520, 10, 1, 15, 1, 0 },
  { 1522, 2, 3, 15, 8, -19 },
  { 1523, 12, 14, 15, 1, -14 },
  { 1544, 12, 20, 15, 1, -20 },
  { 1574, 11, 14, 15, 2, -14 },
  { 1594, 12, 20, 15, 2, -20 },
  { 1624, 11, 14, 15, 2, -14 },
  { 1644, 12, 20, 15, 4, -20 },
  { 1674, 12, 20, 15, 1, -14 },
  { 1704, 12, 20, 15, 1, -20 },
  { 1734, 10, 19, 15, 2, -19 },
  { 1758, 12, 25, 15, 0, -19 },
  { 1796, 12, 20, 15, 2, -20 },
  { 1826, 10, 20, 15, 2, -20 },
  { 1851, 15, 14, 15, 0, -14 },
  { 1878, 12, 14, 15, 1, -14 },
  { 1899, 12, 14, 15, 1, -14 },
  { 1920, 13, 19, 15, 0, -14 },
  { 1951, 11, 19, 15, 2, -14 },
  { 1978, 11, 14, 15, 3, -14 },
  { 1998, 11, 14, 15, 2, -14 },
  { 2018, 10, 17, 15, 3, -17 },
  { 2040, 12, 14, 15, 2, -14 },
  { 2061, 13, 14, 15, 2, -14 },
  { 2084, 13, 14, 15, 2, -14 },
  { 2107, 13, 14, 15, 1, -14 },
  { 2130, 15, 20, 15, 0, -14 },
  { 2168, 13, 14, 15, 1, -14 },
  { 2191, 10, 26, 15, 4, -20 },
  { 2224, 4, 21, 15, 6, -18 },
  { 2235, 10, 26, 15, 2, -20 },
  { 2268, 14, 4, 15, 1, -10 },
};

const GFXfont RobotoMono_ThinItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic26pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_THINITALIC26PT7B_H_
