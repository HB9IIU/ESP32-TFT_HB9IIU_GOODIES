#ifndef _ROBOTOMONO_THINITALIC10PT7B_H_
#define _ROBOTOMONO_THINITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xE0, 0x14, 0xA7, 0xCA, 0xF9, 0x45, 0x00, 0x25, 0x98,
  0x61, 0x9B, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x3A, 0x4C, 0xC5, 0xC5, 0xE0,
  0xE0, 0x2A, 0x49, 0x24, 0x90, 0x44, 0x92, 0x49, 0x50, 0x27, 0xD9, 0x20,
  0x22, 0xF4, 0x40, 0xC0, 0xF0, 0x80, 0x11, 0x22, 0x44, 0x88, 0x79, 0x9F,
  0x99, 0xE0, 0xD5, 0x68, 0x7A, 0x42, 0x22, 0x23, 0xC0, 0x7A, 0x42, 0x60,
  0xC7, 0xC0, 0x08, 0x8A, 0x9F, 0x88, 0x40, 0x7A, 0x38, 0x21, 0x4B, 0x80,
  0x78, 0xE9, 0x99, 0xE0, 0xF8, 0x84, 0x44, 0x22, 0x00, 0x7C, 0x64, 0xC9,
  0x4B, 0xC0, 0x79, 0x99, 0x71, 0xE0, 0x88, 0x40, 0xA0, 0x3C, 0x43, 0xFF,
  0xC3, 0x68, 0xF4, 0xA8, 0x20, 0x3D, 0x5A, 0xF5, 0xD6, 0xA7, 0x00, 0x11,
  0x8A, 0x97, 0xC6, 0x20, 0xF9, 0x9E, 0x99, 0xE0, 0x74, 0x61, 0x08, 0x4B,
  0x80, 0x79, 0x14, 0x51, 0x8A, 0x2F, 0x00, 0xFC, 0x21, 0xE8, 0x43, 0x80,
  0xFC, 0x21, 0xE8, 0x42, 0x00, 0x74, 0x61, 0x49, 0x4B, 0xC0, 0x45, 0x14,
  0x5E, 0x8A, 0x28, 0x80, 0x3C, 0x41, 0x08, 0x20, 0x8F, 0x00, 0x08, 0x42,
  0x10, 0xC7, 0xC0, 0x8C, 0xA9, 0x8A, 0x52, 0x40, 0x88, 0x88, 0x88, 0xF0,
  0x45, 0x34, 0x9D, 0xAA, 0x28, 0x80, 0x45, 0x16, 0x56, 0x9A, 0x28, 0x80,
  0x79, 0x99, 0x99, 0xE0, 0xFC, 0x63, 0xE8, 0x42, 0x00, 0x74, 0x63, 0x18,
  0xCB, 0x84, 0xF9, 0x9D, 0xA9, 0x90, 0x74, 0x60, 0xC1, 0x4B, 0xC0, 0xF9,
  0x08, 0x44, 0x21, 0x00, 0x8C, 0x63, 0x29, 0x4B, 0x80, 0x8C, 0x65, 0x26,
  0x21, 0x00, 0xAD, 0x7B, 0xEB, 0x52, 0x80, 0x44, 0xA3, 0x04, 0x31, 0x28,
  0x80, 0x8C, 0x94, 0xC4, 0x21, 0x00, 0x78, 0x44, 0x42, 0x23, 0xE0, 0x6A,
  0xAA, 0xA0, 0xAA, 0x55, 0x24, 0x92, 0x49, 0x58, 0x26, 0x59, 0xF0, 0x80,
  0xF1, 0xF9, 0xE0, 0x88, 0xE9, 0x99, 0x9E, 0xF8, 0x89, 0xE0, 0x08, 0x5B,
  0x29, 0x4A, 0x5C, 0xF9, 0xE8, 0xF0, 0x19, 0x3C, 0x84, 0x21, 0x08, 0x7A,
  0x63, 0x17, 0x0B, 0xC0, 0x42, 0x14, 0xD4, 0xA6, 0x31, 0x2C, 0x22, 0x24,
  0xF0, 0x09, 0x04, 0x21, 0x08, 0x44, 0xE0, 0x48, 0x89, 0xEC, 0xA9, 0x62,
  0x22, 0x22, 0x4F, 0xFE, 0x5A, 0x69, 0xA8, 0x7A, 0x53, 0x18, 0x80, 0xF9,
  0x99, 0xE0, 0x7A, 0x53, 0x1F, 0x42, 0x00, 0xF9, 0x99, 0xE1, 0x20, 0x7A,
  0x21, 0x08, 0x00, 0xF8, 0x61, 0xF0, 0x2B, 0x44, 0x44, 0x60, 0x99, 0x99,
  0xE0, 0x8C, 0xA8, 0x84, 0x00, 0xAF, 0x6D, 0x4A, 0x00, 0x4C, 0xC2, 0x14,
  0x88, 0x45, 0x25, 0x0C, 0x20, 0x8C, 0x00, 0x78, 0x88, 0x8F, 0x80, 0x29,
  0x29, 0x24, 0x88, 0x55, 0xAA, 0x42, 0x22, 0x23, 0x24, 0x48, 0x66, 0x60,
};

const GFXglyph RobotoMono_ThinItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 1, 3, 6, 3, -8 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 4, 7, 6, 1, -7 },
  { 19, 5, 7, 6, 0, -7 },
  { 24, 1, 3, 6, 3, -8 },
  { 25, 3, 10, 6, 2, -8 },
  { 29, 3, 10, 6, 1, -8 },
  { 33, 5, 4, 6, 1, -7 },
  { 36, 4, 5, 6, 1, -6 },
  { 39, 1, 2, 6, 1, -1 },
  { 40, 4, 1, 6, 1, -4 },
  { 41, 1, 1, 6, 2, -1 },
  { 42, 4, 8, 6, 1, -7 },
  { 46, 4, 7, 6, 1, -7 },
  { 50, 2, 7, 6, 2, -7 },
  { 52, 5, 7, 6, 0, -7 },
  { 57, 5, 7, 6, 0, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 1, -7 },
  { 72, 4, 7, 6, 1, -7 },
  { 76, 5, 7, 6, 1, -7 },
  { 81, 5, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 1, 5, 6, 3, -5 },
  { 91, 2, 6, 6, 2, -5 },
  { 93, 4, 4, 6, 1, -5 },
  { 95, 4, 2, 6, 1, -4 },
  { 96, 4, 4, 6, 1, -5 },
  { 98, 3, 7, 6, 2, -7 },
  { 101, 6, 7, 6, 0, -7 },
  { 107, 5, 7, 6, 0, -7 },
  { 112, 4, 7, 6, 1, -7 },
  { 116, 5, 7, 6, 1, -7 },
  { 121, 6, 7, 6, 0, -7 },
  { 127, 5, 7, 6, 1, -7 },
  { 132, 5, 7, 6, 1, -7 },
  { 137, 5, 7, 6, 1, -7 },
  { 142, 6, 7, 6, 0, -7 },
  { 148, 6, 7, 6, 0, -7 },
  { 154, 5, 7, 6, 0, -7 },
  { 159, 5, 7, 6, 1, -7 },
  { 164, 4, 7, 6, 1, -7 },
  { 168, 6, 7, 6, 0, -7 },
  { 174, 6, 7, 6, 0, -7 },
  { 180, 4, 7, 6, 1, -7 },
  { 184, 5, 7, 6, 1, -7 },
  { 189, 5, 8, 6, 1, -7 },
  { 194, 4, 7, 6, 1, -7 },
  { 198, 5, 7, 6, 1, -7 },
  { 203, 5, 7, 6, 1, -7 },
  { 208, 5, 7, 6, 1, -7 },
  { 213, 5, 7, 6, 1, -7 },
  { 218, 5, 7, 6, 1, -7 },
  { 223, 6, 7, 6, 0, -7 },
  { 229, 5, 7, 6, 1, -7 },
  { 234, 5, 7, 6, 0, -7 },
  { 239, 2, 10, 6, 2, -8 },
  { 242, 2, 8, 6, 2, -7 },
  { 244, 3, 10, 6, 1, -8 },
  { 248, 4, 4, 6, 1, -7 },
  { 250, 4, 1, 6, 0, 0 },
  { 251, 1, 1, 6, 3, -7 },
  { 252, 4, 5, 6, 1, -5 },
  { 255, 4, 8, 6, 1, -8 },
  { 259, 4, 5, 6, 1, -5 },
  { 262, 5, 8, 6, 1, -8 },
  { 267, 4, 5, 6, 1, -5 },
  { 270, 5, 8, 6, 1, -8 },
  { 275, 5, 7, 6, 0, -5 },
  { 280, 5, 8, 6, 0, -8 },
  { 285, 4, 7, 6, 1, -7 },
  { 289, 5, 9, 6, 0, -7 },
  { 295, 4, 8, 6, 1, -8 },
  { 299, 4, 8, 6, 1, -8 },
  { 303, 6, 5, 6, 0, -5 },
  { 307, 5, 5, 6, 0, -5 },
  { 311, 4, 5, 6, 1, -5 },
  { 314, 5, 7, 6, 0, -5 },
  { 319, 4, 7, 6, 1, -5 },
  { 323, 5, 5, 6, 1, -5 },
  { 327, 4, 5, 6, 1, -5 },
  { 330, 4, 7, 6, 1, -7 },
  { 334, 4, 5, 6, 1, -5 },
  { 337, 5, 5, 6, 1, -5 },
  { 341, 5, 5, 6, 1, -5 },
  { 345, 6, 5, 6, 0, -5 },
  { 349, 6, 7, 6, 0, -5 },
  { 355, 5, 5, 6, 0, -5 },
  { 359, 3, 10, 6, 2, -8 },
  { 363, 2, 8, 6, 2, -7 },
  { 365, 4, 10, 6, 1, -8 },
  { 370, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_ThinItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic10pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_THINITALIC10PT7B_H_
