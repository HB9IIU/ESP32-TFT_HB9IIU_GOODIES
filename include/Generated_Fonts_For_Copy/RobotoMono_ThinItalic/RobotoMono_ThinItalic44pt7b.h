#ifndef _ROBOTOMONO_THINITALIC44PT7B_H_
#define _ROBOTOMONO_THINITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x21, 0x61, 0x63, 0x43, 0x42, 0x42, 0x42,
  0xC2, 0x86, 0x00, 0x04, 0x02, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01, 0x00,
  0x01, 0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0x40, 0x00, 0x40, 0x60,
  0x00, 0x60, 0x20, 0x00, 0x20, 0x10, 0x0F, 0xFF, 0xFF, 0xC0, 0x18, 0x08,
  0x00, 0x08, 0x04, 0x00, 0x04, 0x06, 0x00, 0x04, 0x02, 0x00, 0x02, 0x01,
  0x00, 0x01, 0x01, 0x80, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0xC0,
  0x40, 0x00, 0x40, 0x20, 0x00, 0x20, 0x30, 0x07, 0xFF, 0xFF, 0xC0, 0x10,
  0x08, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x00, 0x02,
  0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xE0, 0x00, 0x3D, 0xE0, 0x06, 0x01, 0x80, 0x60, 0x04,
  0x06, 0x00, 0x10, 0x20, 0x00, 0x82, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80,
  0x00, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x11, 0x00, 0x00, 0xC8, 0x00, 0x04, 0x60, 0x00, 0x21, 0x00, 0x01,
  0x08, 0x00, 0x18, 0x60, 0x01, 0x81, 0x00, 0x18, 0x06, 0x03, 0x80, 0x1F,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xFC, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x80, 0x04, 0x04,
  0x02, 0x60, 0x20, 0x32, 0x01, 0x03, 0x10, 0x08, 0x10, 0x80, 0x41, 0x04,
  0x06, 0x18, 0x20, 0x20, 0x81, 0x03, 0x08, 0x0C, 0x30, 0xC0, 0x37, 0x04,
  0x00, 0xE0, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x20, 0xF8, 0x03, 0x0C, 0x60, 0x10, 0xC1, 0x01, 0x04, 0x04, 0x18, 0x40,
  0x20, 0x82, 0x01, 0x08, 0x10, 0x08, 0x80, 0x80, 0xCC, 0x0C, 0x04, 0x40,
  0x60, 0x24, 0x03, 0x03, 0x00, 0x08, 0x10, 0x00, 0x61, 0x00, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x01,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x20, 0x02, 0x01,
  0x80, 0x08, 0x0C, 0x00, 0x20, 0x60, 0x00, 0x43, 0x00, 0x01, 0x18, 0x00,
  0x06, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x60, 0x00, 0x10,
  0x80, 0x00, 0x83, 0x00, 0xC4, 0x04, 0x02, 0x20, 0x08, 0x08, 0x80, 0x30,
  0x64, 0x00, 0x41, 0x10, 0x00, 0x84, 0x40, 0x03, 0x23, 0x00, 0x05, 0x8C,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0x40, 0x01, 0xC0, 0x80, 0x18, 0x81, 0x80,
  0xC3, 0x03, 0xFC, 0x06, 0x69, 0x24, 0xB4, 0x80, 0x00, 0x08, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x20,
  0x10, 0x1F, 0x04, 0x3C, 0x79, 0x78, 0x03, 0xF0, 0x00, 0x30, 0x00, 0x16,
  0x00, 0x08, 0x80, 0x04, 0x10, 0x02, 0x06, 0x01, 0x00, 0x80, 0xC0, 0x10,
  0x60, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0xF0, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x11, 0x32, 0x24, 0x48, 0xFF, 0xFE, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x38, 0x01, 0x80, 0xC0, 0x30, 0x02, 0x06, 0x00, 0x20, 0xC0, 0x01, 0x08,
  0x00, 0x11, 0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x03, 0x20, 0x00, 0xD2,
  0x00, 0x19, 0x20, 0x03, 0x12, 0x00, 0x61, 0x60, 0x08, 0x14, 0x01, 0x01,
  0x40, 0x20, 0x34, 0x0C, 0x02, 0x41, 0x80, 0x2C, 0x30, 0x02, 0xC6, 0x00,
  0x28, 0x80, 0x06, 0x90, 0x00, 0x4A, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00,
  0x08, 0x40, 0x01, 0x84, 0x00, 0x10, 0x60, 0x02, 0x02, 0x00, 0x40, 0x18,
  0x18, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x74, 0x39, 0x1C, 0x2C, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x18, 0x06, 0x00, 0x40, 0x60, 0x01,
  0x06, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x03, 0xDE, 0x00, 0x70, 0x08, 0x06, 0x00, 0x20, 0x60, 0x01,
  0x82, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x98,
  0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x01,
  0x86, 0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x38, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x12,
  0x00, 0x01, 0x10, 0x00, 0x10, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x40, 0x01,
  0x82, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x08, 0x04, 0x00, 0xC0, 0x60,
  0x0C, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x40, 0x04, 0x06, 0x00,
  0x20, 0x60, 0x03, 0x06, 0x00, 0x10, 0x3F, 0xFF, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF8,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x21, 0xE0, 0x01, 0x7F, 0xE0, 0x0E, 0x01, 0x80, 0x40, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x10, 0x00, 0x10,
  0x80, 0x00, 0x84, 0x00, 0x08, 0x10, 0x00, 0x40, 0x80, 0x04, 0x02, 0x00,
  0x40, 0x18, 0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x08, 0x02,
  0x3F, 0xE0, 0x4C, 0x06, 0x16, 0x00, 0x63, 0x80, 0x06, 0x60, 0x00, 0x48,
  0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0xD0, 0x00, 0x13, 0x00, 0x06, 0x20,
  0x00, 0x86, 0x00, 0x20, 0x40, 0x0C, 0x06, 0x06, 0x00, 0x7F, 0x80, 0xFF,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60,
  0x60, 0x01, 0x06, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x04, 0x30, 0x00, 0x20, 0x80, 0x02, 0x06,
  0x00, 0x20, 0x18, 0x06, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x70, 0x0C,
  0x06, 0x00, 0x30, 0x60, 0x00, 0x86, 0x00, 0x02, 0x20, 0x00, 0x12, 0x00,
  0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x11,
  0x00, 0x01, 0x84, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x38, 0x01, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x1C, 0x06, 0x06, 0x00, 0x61, 0x80,
  0x04, 0x20, 0x00, 0x8C, 0x00, 0x09, 0x00, 0x01, 0x60, 0x00, 0x28, 0x00,
  0x05, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00,
  0x1A, 0x00, 0x03, 0x40, 0x00, 0xCC, 0x00, 0x28, 0x80, 0x0D, 0x08, 0x02,
  0x60, 0xC3, 0x88, 0x0F, 0xC1, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0xF0, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x10, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0x38, 0x18, 0x04, 0x30, 0x02, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x08, 0x18, 0x00, 0x04,
  0x18, 0x0F, 0x02, 0x08, 0x18, 0xC1, 0x8C, 0x18, 0x30, 0xC4, 0x18, 0x10,
  0x66, 0x08, 0x08, 0x32, 0x08, 0x04, 0x1B, 0x04, 0x04, 0x09, 0x04, 0x02,
  0x04, 0x82, 0x01, 0x02, 0x41, 0x01, 0x81, 0x61, 0x00, 0x81, 0xA0, 0x80,
  0x40, 0x90, 0x40, 0x60, 0x48, 0x20, 0x30, 0x64, 0x10, 0x30, 0x22, 0x08,
  0x18, 0x11, 0x04, 0x16, 0x10, 0x83, 0x31, 0x30, 0x60, 0xF0, 0x70, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x70, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x40, 0x00, 0x11, 0x00, 0x00,
  0xC4, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x03, 0x06,
  0x00, 0x08, 0x08, 0x00, 0x60, 0x20, 0x01, 0x00, 0x80, 0x0C, 0x02, 0x00,
  0x20, 0x08, 0x01, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x80,
  0x04, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x04,
  0x18, 0x00, 0x18, 0x40, 0x00, 0x23, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20,
  0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x80, 0x18,
  0x03, 0x80, 0x40, 0x03, 0x01, 0x00, 0x06, 0x04, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x40, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x01, 0x02, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x40, 0x06, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x83, 0x00, 0x03,
  0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x60, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x04, 0x10, 0x00,
  0x30, 0x40, 0x03, 0x81, 0x00, 0x38, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xDC, 0x00, 0x60, 0x18, 0x06, 0x00, 0x40, 0x40, 0x01, 0x06,
  0x00, 0x08, 0x20, 0x00, 0x62, 0x00, 0x01, 0x10, 0x00, 0x09, 0x00, 0x00,
  0x48, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x90, 0x00,
  0x0C, 0x80, 0x00, 0x44, 0x00, 0x06, 0x30, 0x00, 0x20, 0x80, 0x03, 0x06,
  0x00, 0x30, 0x10, 0x03, 0x00, 0x60, 0x70, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x10, 0x03, 0x00, 0x40, 0x06, 0x01, 0x00, 0x04, 0x04, 0x00, 0x18,
  0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00,
  0x11, 0x00, 0x00, 0x44, 0x00, 0x03, 0x30, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00,
  0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x18,
  0x10, 0x00, 0xC0, 0x80, 0x0E, 0x02, 0x00, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0xDC, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00, 0x0C,
  0x60, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x09, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x0F, 0xFD, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x64, 0x00, 0x02, 0x30, 0x00, 0x10, 0x80, 0x00, 0x86, 0x00, 0x0C,
  0x18, 0x00, 0xC0, 0x60, 0x1C, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x01, 0x02,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08,
  0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x18,
  0x00, 0x04, 0x1F, 0xFF, 0xFC, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x30, 0x00, 0x08, 0x20, 0x00, 0x18, 0x20,
  0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x60,
  0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x20, 0xC0, 0x00, 0x20, 0x07, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x10, 0x10, 0x00, 0xC0,
  0x60, 0x06, 0x00, 0xC0, 0x60, 0x00, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x07,
  0x04, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x30, 0x08, 0x00, 0x60,
  0x08, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x08, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x10, 0x08, 0x00, 0x10, 0x10, 0x00, 0x10, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x11, 0x80, 0x00, 0x23, 0x80, 0x00, 0x26, 0x40, 0x00, 0x2C, 0x40, 0x00,
  0x38, 0x20, 0x00, 0x20, 0x30, 0x00, 0x20, 0x10, 0x00, 0x40, 0x08, 0x00,
  0x40, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x40, 0x02, 0x00,
  0xC0, 0x01, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0x40, 0x80, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xFE,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x28, 0x70, 0x00, 0xD0,
  0xB0, 0x01, 0x21, 0x20, 0x06, 0x82, 0x40, 0x09, 0x04, 0x80, 0x32, 0x09,
  0x00, 0x44, 0x31, 0x01, 0x08, 0x42, 0x02, 0x30, 0x84, 0x08, 0x41, 0x08,
  0x30, 0x82, 0x10, 0x41, 0x0C, 0x11, 0x82, 0x10, 0x22, 0x04, 0x20, 0x48,
  0x18, 0x40, 0x90, 0x20, 0x81, 0x40, 0x41, 0x01, 0x80, 0x86, 0x02, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20,
  0x80, 0x00, 0x43, 0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x08, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x38, 0x00, 0x18, 0x50, 0x00, 0x20, 0x90, 0x00, 0x41, 0x20, 0x00, 0x82,
  0x60, 0x01, 0x04, 0x40, 0x02, 0x10, 0x80, 0x0C, 0x20, 0x80, 0x10, 0x41,
  0x00, 0x20, 0x82, 0x00, 0x41, 0x02, 0x00, 0x82, 0x04, 0x01, 0x08, 0x0C,
  0x06, 0x10, 0x08, 0x08, 0x20, 0x10, 0x10, 0x40, 0x10, 0x20, 0x80, 0x20,
  0x43, 0x00, 0x40, 0x84, 0x00, 0x43, 0x08, 0x00, 0x84, 0x10, 0x01, 0x88,
  0x20, 0x01, 0x10, 0x40, 0x02, 0x21, 0x80, 0x02, 0x42, 0x00, 0x05, 0x04,
  0x00, 0x0A, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xBC, 0x00, 0x60, 0x10, 0x06, 0x00, 0x40, 0x40,
  0x03, 0x06, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x09,
  0x00, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00,
  0x0D, 0x00, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x14, 0x00, 0x00, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00,
  0x90, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x04, 0x30, 0x00, 0x60, 0x80,
  0x02, 0x04, 0x00, 0x20, 0x10, 0x02, 0x00, 0x60, 0x60, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x10, 0x01, 0xC0, 0x40, 0x01, 0x81, 0x00, 0x02, 0x0C,
  0x00, 0x0C, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00,
  0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0xC4, 0x00, 0x02, 0x10, 0x00, 0x18,
  0x40, 0x00, 0xC1, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x20, 0x07, 0x80, 0xFF,
  0xF0, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFB, 0x80, 0x03, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x20, 0x00, 0x80, 0x80, 0x01, 0x03, 0x00, 0x01, 0x04, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02,
  0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00, 0x00, 0x36, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x04, 0x60, 0x00, 0x08, 0x40,
  0x00, 0x30, 0x80, 0x00, 0x41, 0x00, 0x01, 0x03, 0x00, 0x06, 0x02, 0x00,
  0x18, 0x02, 0x00, 0x60, 0x02, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x80, 0x20, 0x06, 0x03, 0x00, 0x08,
  0x10, 0x00, 0x60, 0x80, 0x01, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x21, 0x00,
  0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x20, 0x00, 0x21,
  0x00, 0x02, 0x08, 0x00, 0x30, 0x80, 0x03, 0x04, 0x00, 0x20, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x08, 0x02, 0x00, 0xC0, 0x08, 0x04, 0x00, 0x40, 0x20,
  0x03, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x03, 0x06, 0x00, 0x08,
  0x20, 0x00, 0x41, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x62, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF7, 0x80, 0x1C, 0x03, 0x00, 0xC0,
  0x06, 0x06, 0x00, 0x08, 0x10, 0x00, 0x30, 0x80, 0x00, 0x42, 0x00, 0x01,
  0x08, 0x00, 0x04, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x11, 0x00,
  0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x20, 0x00, 0x40, 0xC0, 0x02,
  0x01, 0xC0, 0x30, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x42,
  0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00,
  0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02,
  0x30, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x83, 0x00, 0x06, 0x04, 0x00, 0x10, 0x10, 0x00,
  0xC0, 0x20, 0x06, 0x00, 0x60, 0x60, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xB0, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x10, 0x60, 0x00, 0x81, 0x00, 0x0C,
  0x08, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x20, 0x10, 0x03, 0x00, 0xC0,
  0x10, 0x02, 0x01, 0x80, 0x10, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x82, 0x00, 0x04, 0x10, 0x00, 0x21, 0x00, 0x01, 0x08,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x0A, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40,
  0x68, 0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x04, 0x40, 0x88,
  0x11, 0x02, 0x20, 0xC4, 0x08, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x61,
  0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82, 0x30, 0x42, 0x08, 0x81, 0x18,
  0x22, 0x04, 0x40, 0x98, 0x11, 0x02, 0x40, 0x4C, 0x09, 0x01, 0xA0, 0x2C,
  0x06, 0x80, 0xA0, 0x1A, 0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x07,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x20, 0x08, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x01, 0x81, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x20, 0x00, 0x80, 0x10,
  0x00, 0xC0, 0x04, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x01, 0x80, 0x40, 0x00,
  0x40, 0x60, 0x00, 0x30, 0x60, 0x00, 0x08, 0x20, 0x00, 0x06, 0x20, 0x00,
  0x01, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x12, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x40,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x01,
  0x00, 0x04, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x04, 0x00, 0x18, 0x06, 0x00,
  0x04, 0x02, 0x00, 0x03, 0x02, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x08, 0xC0, 0x00, 0xC2, 0x00, 0x04,
  0x10, 0x00, 0x40, 0xC0, 0x06, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00, 0xC0,
  0x30, 0x02, 0x01, 0x00, 0x10, 0x10, 0x00, 0xC1, 0x00, 0x02, 0x18, 0x00,
  0x10, 0x80, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x14, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x3F,
  0x00, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x20,
  0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x04,
  0x04, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01,
  0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x60, 0x03,
  0x80, 0x0A, 0x00, 0x68, 0x01, 0x30, 0x08, 0x40, 0x21, 0x01, 0x04, 0x0C,
  0x18, 0x20, 0x21, 0x80, 0x84, 0x02, 0x20, 0x08, 0x80, 0x34, 0x00, 0x70,
  0x01, 0x80, 0x04, 0xFF, 0xFF, 0x80, 0xC2, 0x18, 0x43, 0x0C, 0x00, 0x0E,
  0x00, 0x0F, 0xF8, 0x03, 0x00, 0x40, 0x60, 0x02, 0x0C, 0x00, 0x30, 0x80,
  0x01, 0x18, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x0F, 0xFE, 0x07, 0x80, 0x21, 0xC0, 0x02, 0x30, 0x00, 0x22,
  0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0xCC, 0x00, 0x1C,
  0x40, 0x03, 0x46, 0x00, 0x6C, 0x30, 0x1C, 0xC1, 0xFF, 0x0C, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x08,
  0xFF, 0x80, 0x98, 0x0C, 0x0A, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x21,
  0x80, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x32, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x06, 0x20, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00,
  0x10, 0x50, 0x03, 0x04, 0xC0, 0xC0, 0xC7, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0xE0, 0x0C, 0x06, 0x02, 0x00, 0x20, 0x80, 0x06, 0x20, 0x00, 0x4C,
  0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0xC6, 0x00, 0x30, 0x40,
  0x0C, 0x06, 0x03, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x01, 0x80, 0x80, 0x7F, 0x8C, 0x0E,
  0x02, 0x40, 0xC0, 0x0A, 0x04, 0x00, 0x30, 0x40, 0x01, 0x86, 0x00, 0x0C,
  0x20, 0x00, 0x63, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x60, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84,
  0x00, 0x04, 0x30, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x18, 0x20, 0x01,
  0x80, 0x80, 0x14, 0x02, 0x03, 0x20, 0x0F, 0xE1, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xF0, 0x03, 0x01, 0x80, 0x40, 0x04, 0x08, 0x00, 0x61, 0x00, 0x02,
  0x30, 0x00, 0x22, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00, 0x02, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x83, 0x00, 0x30, 0x18, 0x0E, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0xE0, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xF8, 0xC0, 0xE0, 0x24, 0x0C, 0x00, 0xA0, 0x40,
  0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x21,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00,
  0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x43, 0x00, 0x02, 0x08,
  0x00, 0x30, 0x40, 0x01, 0x82, 0x00, 0x18, 0x08, 0x01, 0x40, 0x20, 0x32,
  0x00, 0xFF, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x40, 0x02, 0x01, 0x00, 0x20, 0x06, 0x06, 0x00,
  0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x60, 0x08, 0x7D, 0xC0, 0x8C, 0x06, 0x09, 0x00, 0x20,
  0xA0, 0x03, 0x1C, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x11, 0x00, 0x03, 0x30, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x06, 0x60, 0x00, 0x44, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x0C, 0x80,
  0x00, 0x80, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x42, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0x80, 0x18, 0x0C, 0x01,
  0x80, 0x40, 0x18, 0x02, 0x01, 0x00, 0x10, 0x30, 0x00, 0x83, 0x00, 0x04,
  0x30, 0x00, 0x66, 0x00, 0x02, 0x78, 0x00, 0x16, 0x40, 0x00, 0xC1, 0x00,
  0x04, 0x0C, 0x00, 0x20, 0x20, 0x03, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80,
  0x18, 0x04, 0x00, 0x40, 0x20, 0x03, 0x01, 0x00, 0x0C, 0x18, 0x00, 0x20,
  0x80, 0x00, 0x80, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x1C, 0x0D, 0xFC, 0x3B, 0x85, 0x83, 0x60, 0x43,
  0x80, 0xE0, 0x31, 0x80, 0x60, 0x08, 0x80, 0x30, 0x04, 0x40, 0x10, 0x02,
  0x60, 0x08, 0x03, 0x20, 0x04, 0x01, 0x10, 0x02, 0x00, 0x88, 0x02, 0x00,
  0x44, 0x01, 0x00, 0x22, 0x00, 0x80, 0x12, 0x00, 0x40, 0x11, 0x00, 0x20,
  0x08, 0x80, 0x30, 0x04, 0x40, 0x10, 0x02, 0x20, 0x08, 0x01, 0x10, 0x04,
  0x01, 0x90, 0x02, 0x00, 0x88, 0x01, 0x00, 0x44, 0x01, 0x80, 0x22, 0x00,
  0x80, 0x11, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00, 0x87, 0xBC, 0x08, 0xC0,
  0x60, 0x90, 0x02, 0x0A, 0x00, 0x31, 0x40, 0x01, 0x18, 0x00, 0x11, 0x80,
  0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x33, 0x00, 0x02, 0x20,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x60, 0x00, 0x66,
  0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04,
  0xC0, 0x00, 0xC8, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0xE0,
  0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x46,
  0x00, 0x03, 0x20, 0x00, 0x1B, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00,
  0x34, 0x00, 0x01, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x06, 0x40,
  0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0xC0, 0x01, 0x82, 0x00, 0x18,
  0x18, 0x01, 0x80, 0x60, 0x38, 0x00, 0xFF, 0x00, 0x02, 0x0E, 0x00, 0x23,
  0xFE, 0x01, 0x30, 0x18, 0x0A, 0x00, 0x60, 0x60, 0x01, 0x02, 0x00, 0x08,
  0x30, 0x00, 0x61, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00,
  0x02, 0x10, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x42,
  0x00, 0x02, 0x10, 0x00, 0x31, 0x80, 0x01, 0x08, 0x00, 0x18, 0x60, 0x00,
  0x83, 0x00, 0x08, 0x14, 0x00, 0x80, 0x98, 0x18, 0x0C, 0x7F, 0x80, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xE3, 0x07, 0x01, 0x20, 0xC0, 0x0A, 0x08, 0x00, 0x61,
  0x00, 0x06, 0x30, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x00, 0x8C, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00,
  0x18, 0x40, 0x03, 0x02, 0x00, 0x50, 0x10, 0x19, 0x00, 0xFE, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x82, 0x0F, 0xB0, 0x8C, 0x00, 0x64, 0x00, 0x16, 0x00, 0x05, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x06, 0x00, 0xC0,
  0xC0, 0x06, 0x18, 0x00, 0x21, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x40, 0x00, 0x86, 0x00, 0x10, 0x30,
  0x06, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x31,
  0x00, 0x02, 0x30, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02,
  0x20, 0x00, 0x62, 0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00,
  0x44, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00,
  0x18, 0x40, 0x01, 0x84, 0x00, 0x28, 0x20, 0x05, 0x03, 0x01, 0x90, 0x1F,
  0xE1, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00,
  0xC6, 0x00, 0x04, 0x10, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x20, 0x30,
  0x03, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x80, 0x80,
  0x04, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x06, 0x00, 0x0C, 0x20, 0x00, 0x23,
  0x00, 0x01, 0x10, 0x00, 0x0D, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x10, 0x03, 0x80, 0x60, 0x0B, 0x00, 0xC0, 0x12,
  0x01, 0xC0, 0x64, 0x05, 0x80, 0x88, 0x0B, 0x01, 0x10, 0x32, 0x06, 0x20,
  0x44, 0x08, 0x40, 0x88, 0x30, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x18,
  0x43, 0x04, 0x20, 0x84, 0x08, 0xC1, 0x18, 0x11, 0x02, 0x20, 0x22, 0x04,
  0x40, 0x48, 0x0D, 0x80, 0x90, 0x1A, 0x01, 0x60, 0x14, 0x02, 0x80, 0x30,
  0x05, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x60, 0x08, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x10, 0x18, 0x00, 0x30, 0x60, 0x00, 0x21, 0x80, 0x00, 0x26, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x0C, 0x80, 0x00, 0x31, 0x80, 0x00, 0xC1, 0x00, 0x03, 0x01, 0x00, 0x0C,
  0x03, 0x00, 0x30, 0x02, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00, 0x30, 0x04, 0x00,
  0x04, 0x00, 0xC0, 0x01, 0x80, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x30, 0x03, 0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x08, 0x06,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x02,
  0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0x30, 0x60, 0x02, 0x60, 0x10, 0x06, 0x40, 0x08,
  0x04, 0xC0, 0x04, 0x08, 0x80, 0x03, 0xF0,
};

const GFXglyph RobotoMono_ThinItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 31, 26, 9, -31 },
  { 29, 8, 9, 26, 11, -33 },
  { 38, 25, 31, 26, 1, -31 },
  { 135, 21, 40, 26, 3, -36 },
  { 240, 21, 32, 26, 3, -32 },
  { 324, 22, 32, 26, 2, -32 },
  { 412, 3, 9, 26, 13, -33 },
  { 416, 13, 45, 26, 8, -35 },
  { 490, 13, 45, 26, 4, -35 },
  { 564, 18, 17, 26, 6, -31 },
  { 603, 21, 23, 26, 3, -26 },
  { 664, 4, 8, 26, 6, -3 },
  { 668, 15, 1, 26, 5, -15 },
  { 670, 3, 2, 26, 10, -2 },
  { 671, 19, 34, 26, 4, -31 },
  { 752, 20, 32, 26, 3, -32 },
  { 832, 11, 31, 26, 7, -31 },
  { 875, 21, 32, 26, 1, -32 },
  { 959, 21, 32, 26, 1, -32 },
  { 1043, 21, 31, 26, 1, -31 },
  { 1125, 21, 31, 26, 4, -31 },
  { 1207, 19, 32, 26, 3, -32 },
  { 1283, 19, 31, 26, 6, -31 },
  { 1357, 21, 32, 26, 3, -32 },
  { 1441, 19, 32, 26, 4, -32 },
  { 1517, 6, 21, 26, 11, -21 },
  { 1533, 8, 26, 26, 9, -21 },
  { 1559, 19, 17, 26, 4, -23 },
  { 1600, 20, 10, 26, 3, -19 },
  { 1625, 19, 17, 26, 3, -23 },
  { 1666, 16, 32, 26, 7, -32 },
  { 1730, 25, 32, 26, 1, -32 },
  { 1830, 22, 31, 26, 0, -31 },
  { 1916, 22, 31, 26, 2, -31 },
  { 2002, 21, 32, 26, 3, -32 },
  { 2086, 22, 31, 26, 2, -31 },
  { 2172, 23, 31, 26, 2, -31 },
  { 2262, 22, 31, 26, 3, -31 },
  { 2348, 21, 32, 26, 3, -32 },
  { 2432, 24, 31, 26, 1, -31 },
  { 2525, 22, 31, 26, 2, -31 },
  { 2611, 22, 31, 26, 2, -31 },
  { 2697, 24, 31, 26, 3, -31 },
  { 2790, 17, 31, 26, 3, -31 },
  { 2856, 23, 31, 26, 2, -31 },
  { 2946, 23, 31, 26, 2, -31 },
  { 3036, 21, 32, 26, 3, -32 },
  { 3120, 22, 31, 26, 3, -31 },
  { 3206, 23, 38, 26, 2, -32 },
  { 3316, 21, 31, 26, 3, -31 },
  { 3398, 22, 32, 26, 2, -32 },
  { 3486, 22, 31, 26, 5, -31 },
  { 3572, 22, 31, 26, 3, -31 },
  { 3658, 21, 31, 26, 5, -31 },
  { 3740, 22, 31, 26, 5, -31 },
  { 3826, 25, 31, 26, 1, -31 },
  { 3923, 21, 31, 26, 5, -31 },
  { 4005, 23, 31, 26, 1, -31 },
  { 4095, 13, 43, 26, 7, -36 },
  { 4165, 8, 34, 26, 9, -31 },
  { 4199, 13, 43, 26, 6, -36 },
  { 4269, 14, 17, 26, 6, -31 },
  { 4299, 17, 1, 26, 2, 0 },
  { 4302, 5, 6, 26, 13, -33 },
  { 4306, 20, 24, 26, 2, -24 },
  { 4366, 20, 33, 26, 2, -33 },
  { 4449, 19, 24, 26, 3, -24 },
  { 4506, 21, 33, 26, 3, -33 },
  { 4593, 20, 24, 26, 3, -24 },
  { 4653, 21, 33, 26, 6, -33 },
  { 4740, 21, 33, 26, 2, -24 },
  { 4827, 20, 33, 26, 2, -33 },
  { 4910, 17, 31, 26, 3, -31 },
  { 4976, 20, 40, 26, 0, -31 },
  { 5076, 21, 33, 26, 3, -33 },
  { 5163, 17, 33, 26, 3, -33 },
  { 5234, 25, 24, 26, 0, -24 },
  { 5309, 20, 24, 26, 2, -24 },
  { 5369, 21, 24, 26, 2, -24 },
  { 5432, 21, 33, 26, 1, -24 },
  { 5519, 20, 33, 26, 3, -24 },
  { 5602, 18, 24, 26, 6, -24 },
  { 5656, 20, 24, 26, 3, -24 },
  { 5716, 16, 30, 26, 6, -30 },
  { 5776, 20, 23, 26, 3, -23 },
  { 5834, 21, 23, 26, 4, -23 },
  { 5895, 23, 23, 26, 3, -23 },
  { 5962, 23, 23, 26, 1, -23 },
  { 6029, 27, 32, 26, -1, -23 },
  { 6137, 22, 23, 26, 1, -23 },
  { 6201, 17, 43, 26, 7, -34 },
  { 6293, 7, 37, 26, 9, -31 },
  { 6326, 17, 43, 26, 4, -34 },
  { 6418, 24, 7, 26, 1, -17 },
};

const GFXfont RobotoMono_ThinItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic44pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_THINITALIC44PT7B_H_
