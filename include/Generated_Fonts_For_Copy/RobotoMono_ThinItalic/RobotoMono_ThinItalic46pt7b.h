#ifndef _ROBOTOMONO_THINITALIC46PT7B_H_
#define _ROBOTOMONO_THINITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x83, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x61, 0x43, 0x43, 0x42, 0x42, 0xC2,
  0x82, 0x86, 0x86, 0x84, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x40, 0x20, 0x00, 0x10, 0x08, 0x00, 0x08, 0x06, 0x00, 0x02, 0x01, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x40, 0x30, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x02,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00, 0x10,
  0x0C, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00,
  0x20, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x20, 0x10, 0x03, 0xFF, 0xFF, 0xF0, 0x06, 0x03,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x20, 0x00, 0x20, 0x18, 0x00, 0x08,
  0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40, 0x20, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0x81, 0x80, 0x18, 0x03, 0x00,
  0xC0, 0x06, 0x06, 0x00, 0x08, 0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x20, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x40, 0x80,
  0x03, 0x03, 0x00, 0x18, 0x06, 0x01, 0x80, 0x07, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x63, 0x00, 0x02, 0x04, 0x00, 0x18, 0x18, 0x00, 0x40,
  0x20, 0x13, 0x00, 0x80, 0x88, 0x06, 0x06, 0x20, 0x18, 0x10, 0x80, 0x40,
  0x82, 0x01, 0x06, 0x08, 0x0C, 0x30, 0x20, 0x20, 0x80, 0xC1, 0x84, 0x01,
  0x8C, 0x30, 0x03, 0xC0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x0E, 0x00, 0x30, 0xFE, 0x01, 0x86, 0x08, 0x04, 0x10,
  0x30, 0x20, 0x80, 0x41, 0x82, 0x01, 0x04, 0x18, 0x04, 0x20, 0x40, 0x11,
  0x81, 0x00, 0xC4, 0x04, 0x02, 0x20, 0x10, 0x09, 0x80, 0x40, 0x60, 0x01,
  0x81, 0x00, 0x02, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xC3,
  0x00, 0x03, 0x01, 0x00, 0x04, 0x02, 0x00, 0x10, 0x06, 0x00, 0x20, 0x0C,
  0x00, 0xC0, 0x10, 0x01, 0x80, 0x20, 0x03, 0x00, 0x80, 0x06, 0x03, 0x00,
  0x04, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x18, 0x80, 0x00, 0x16, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x30,
  0x40, 0x08, 0xC0, 0xC0, 0x21, 0x00, 0x80, 0x44, 0x00, 0x80, 0x98, 0x01,
  0x83, 0x20, 0x01, 0x04, 0x40, 0x01, 0x18, 0x80, 0x03, 0x21, 0x00, 0x02,
  0xC2, 0x00, 0x03, 0x04, 0x00, 0x0E, 0x0C, 0x00, 0x34, 0x0C, 0x00, 0xC4,
  0x0C, 0x06, 0x0C, 0x0F, 0xF8, 0x0C, 0x55, 0x7A, 0xA0, 0x00, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x40, 0x20,
  0x2F, 0x86, 0x1F, 0x0E, 0x4F, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x1A,
  0x00, 0x03, 0x10, 0x00, 0x61, 0x80, 0x0C, 0x08, 0x01, 0x80, 0x40, 0x10,
  0x06, 0x02, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x11, 0x11,
  0x32, 0x24, 0xC8, 0x7F, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x83,
  0x80, 0x18, 0x02, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x18, 0x10, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0xE3, 0x00,
  0x06, 0x88, 0x00, 0x32, 0x20, 0x01, 0x88, 0x80, 0x0C, 0x22, 0x00, 0x40,
  0x98, 0x02, 0x02, 0x40, 0x30, 0x19, 0x01, 0x80, 0x64, 0x0C, 0x01, 0x10,
  0x60, 0x04, 0x43, 0x00, 0x13, 0x10, 0x00, 0x4C, 0x80, 0x03, 0x34, 0x00,
  0x08, 0xE0, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x20,
  0x60, 0x01, 0x80, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x10, 0x07, 0x03, 0xA0, 0xE2, 0x38, 0x2C, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x83, 0x80, 0x18, 0x03,
  0x00, 0xC0, 0x04, 0x06, 0x00, 0x08, 0x10, 0x00, 0x20, 0x80, 0x00, 0x82,
  0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xC1, 0xC0, 0x1C, 0x01, 0x80, 0xC0, 0x02, 0x02, 0x00,
  0x0C, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x4C, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x40, 0x80, 0x03, 0x03, 0x00, 0x18,
  0x07, 0x01, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00, 0x09, 0x00, 0x00, 0x32, 0x00,
  0x00, 0xC4, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x10, 0x40, 0x00,
  0x60, 0x80, 0x01, 0x81, 0x00, 0x06, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x20,
  0x10, 0x00, 0x80, 0x20, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x30, 0x01,
  0x00, 0x40, 0x06, 0x01, 0x00, 0x08, 0x04, 0x00, 0x10, 0x18, 0x00, 0x20,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x4F, 0xF8, 0x01, 0xE0, 0x18, 0x06, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x42, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x40, 0x01,
  0x81, 0x80, 0x0C, 0x02, 0x00, 0x60, 0x06, 0x03, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x01, 0x00, 0x21, 0xFF, 0x02, 0x70, 0x18, 0x6C,
  0x00, 0xC5, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x04, 0xC0, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x01,
  0x86, 0x00, 0x10, 0x30, 0x06, 0x01, 0x80, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0x81, 0x80, 0x18, 0x01, 0x00, 0xC0, 0x02, 0x06, 0x00, 0x0C,
  0x10, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x80, 0x60, 0x0C, 0x00, 0x71, 0xE0, 0x01, 0xFE, 0x00, 0x1C, 0x06, 0x00,
  0xC0, 0x04, 0x04, 0x00, 0x08, 0x20, 0x00, 0x31, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03,
  0x20, 0x00, 0x08, 0xC0, 0x00, 0x61, 0x00, 0x03, 0x06, 0x00, 0x18, 0x06,
  0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x06, 0x00,
  0xC0, 0xC0, 0x06, 0x08, 0x00, 0x21, 0x00, 0x03, 0x30, 0x00, 0x12, 0x00,
  0x01, 0x20, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40,
  0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x66,
  0x00, 0x0E, 0x20, 0x01, 0xA3, 0x00, 0x32, 0x18, 0x0E, 0x40, 0x7F, 0x84,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x3F, 0x00, 0x00, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x8C, 0x00, 0x01, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x08, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x07, 0x06, 0x00, 0xC2, 0x00,
  0x22, 0x00, 0x1B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x87, 0x80, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x60,
  0x00, 0x08, 0x10, 0x1F, 0x03, 0x0C, 0x1C, 0x70, 0xC6, 0x0C, 0x08, 0x11,
  0x02, 0x02, 0x04, 0xC1, 0x00, 0x81, 0x20, 0x40, 0x60, 0xC8, 0x20, 0x10,
  0x36, 0x08, 0x04, 0x09, 0x06, 0x01, 0x02, 0x41, 0x00, 0x80, 0x90, 0x40,
  0x20, 0x2C, 0x10, 0x08, 0x1A, 0x0C, 0x06, 0x04, 0x82, 0x01, 0x01, 0x20,
  0x80, 0xC0, 0xC8, 0x20, 0x30, 0x22, 0x08, 0x14, 0x18, 0x83, 0x09, 0x0C,
  0x30, 0x6C, 0x3E, 0x0C, 0x0C, 0x06, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x50, 0x00, 0x03, 0x40, 0x00, 0x09, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x08, 0x00, 0x0C, 0x20, 0x00, 0x20, 0x80, 0x01, 0x82, 0x00, 0x04, 0x08,
  0x00, 0x30, 0x20, 0x00, 0x80, 0xC0, 0x06, 0x01, 0x00, 0x10, 0x04, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x01, 0x00, 0x40, 0x06, 0x03, 0x00,
  0x18, 0x08, 0x00, 0x20, 0x7F, 0xFF, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x08,
  0x20, 0x00, 0x20, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x10, 0x00, 0x04, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x08, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x60, 0x00,
  0xC0, 0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04,
  0x18, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x40, 0x80, 0x01, 0x81,
  0x00, 0x06, 0x02, 0x00, 0x38, 0x0C, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x20,
  0x01, 0xC0, 0x40, 0x00, 0xC0, 0x80, 0x00, 0x81, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00,
  0x30, 0x80, 0x00, 0x43, 0x00, 0x01, 0x84, 0x00, 0x02, 0x08, 0x00, 0x08,
  0x10, 0x00, 0x60, 0x20, 0x07, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0x83, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x30,
  0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0xC0, 0x00,
  0x12, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x80, 0x00, 0x22, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x10,
  0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x06, 0x03, 0x00, 0x30, 0x06, 0x03,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x10, 0x01,
  0x80, 0x20, 0x00, 0x80, 0x40, 0x00, 0x80, 0x80, 0x01, 0x81, 0x00, 0x01,
  0x06, 0x00, 0x03, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88,
  0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x11, 0x80,
  0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00,
  0x0C, 0x60, 0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00, 0x02,
  0x04, 0x00, 0x08, 0x08, 0x00, 0x20, 0x30, 0x01, 0x80, 0x40, 0x1E, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x83, 0x80, 0x18,
  0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00,
  0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xA0, 0x00, 0x06,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80,
  0x00, 0x32, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x20, 0x80, 0x01, 0x83, 0x00, 0x0C, 0x06, 0x01, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01,
  0x04, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02,
  0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x06,
  0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04,
  0x10, 0x00, 0x0C, 0x3F, 0xFF, 0xF8, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08,
  0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x10,
  0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10,
  0xC0, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20,
  0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC2,
  0x00, 0x01, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x60, 0x08,
  0x01, 0x80, 0x1C, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x01, 0x82,
  0x00, 0x01, 0x81, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x01, 0x00,
  0x04, 0x03, 0x00, 0x02, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x43, 0x00, 0x00, 0x23, 0x80, 0x00, 0x13, 0x40,
  0x00, 0x13, 0x30, 0x00, 0x0A, 0x08, 0x00, 0x06, 0x02, 0x00, 0x02, 0x01,
  0x80, 0x01, 0x00, 0x40, 0x01, 0x80, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x80, 0x10, 0x00, 0x40, 0x08, 0x00, 0x10, 0x0C,
  0x00, 0x0C, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x01, 0x81, 0xC0, 0x01, 0xC0, 0xA0, 0x00, 0xA0, 0x50, 0x00, 0xD0, 0x68,
  0x00, 0x48, 0x34, 0x00, 0x6C, 0x13, 0x00, 0x24, 0x08, 0x80, 0x32, 0x04,
  0x40, 0x31, 0x02, 0x20, 0x10, 0x83, 0x10, 0x18, 0xC1, 0x0C, 0x08, 0x60,
  0x82, 0x0C, 0x20, 0x41, 0x04, 0x10, 0x20, 0x84, 0x08, 0x10, 0x42, 0x04,
  0x18, 0x22, 0x06, 0x08, 0x0B, 0x02, 0x04, 0x05, 0x01, 0x02, 0x03, 0x80,
  0x81, 0x01, 0x80, 0x40, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00,
  0x01, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01,
  0x07, 0x00, 0x01, 0x0D, 0x00, 0x03, 0x09, 0x00, 0x02, 0x08, 0x80, 0x02,
  0x08, 0x80, 0x02, 0x08, 0x80, 0x02, 0x08, 0x40, 0x06, 0x18, 0x40, 0x04,
  0x10, 0x60, 0x04, 0x10, 0x20, 0x04, 0x10, 0x20, 0x04, 0x10, 0x10, 0x04,
  0x10, 0x10, 0x0C, 0x30, 0x10, 0x08, 0x20, 0x08, 0x08, 0x20, 0x08, 0x08,
  0x20, 0x0C, 0x08, 0x20, 0x04, 0x08, 0x20, 0x04, 0x18, 0x60, 0x02, 0x10,
  0x40, 0x02, 0x10, 0x40, 0x02, 0x10, 0x40, 0x01, 0x10, 0x40, 0x01, 0x10,
  0x40, 0x01, 0xB0, 0x80, 0x00, 0xA0, 0x80, 0x00, 0xA0, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x03, 0x83, 0x00,
  0x18, 0x02, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x18, 0x30, 0x00, 0x20, 0x80,
  0x00, 0x86, 0x00, 0x03, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x60, 0x00, 0x05, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0,
  0x00, 0x02, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00,
  0x06, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x0C,
  0x80, 0x00, 0x22, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40,
  0x01, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x04, 0x00, 0x18, 0x04, 0x00,
  0x0C, 0x04, 0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x10, 0x00, 0x60, 0x10, 0x01, 0xC0, 0x3F, 0xFF, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x70, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x20, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x60, 0x00, 0x20, 0x20, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x40, 0x07, 0x01, 0x00, 0x04,
  0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x41, 0x00, 0x03, 0x04, 0x00, 0x18, 0x30, 0x00, 0xC0,
  0x80, 0x0C, 0x03, 0xFF, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x18, 0x06, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x01, 0x00, 0x04,
  0x04, 0x00, 0x18, 0x10, 0x00, 0x20, 0xC0, 0x00, 0x82, 0x00, 0x03, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x18, 0x80, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x00,
  0xE0, 0xE0, 0x06, 0x00, 0x60, 0x18, 0x00, 0x60, 0x60, 0x00, 0x60, 0x80,
  0x00, 0x43, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x86, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x04, 0x00,
  0x30, 0x06, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40,
  0x00, 0x11, 0x80, 0x00, 0x62, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x31, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x08, 0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80,
  0x00, 0x21, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x02, 0x00, 0x06, 0x04, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x0F, 0xF0,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90, 0x00, 0x02,
  0x40, 0x00, 0x11, 0x00, 0x00, 0x46, 0x00, 0x02, 0x18, 0x00, 0x08, 0x20,
  0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x01,
  0x80, 0xC0, 0x04, 0x01, 0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x40, 0x10, 0x01, 0x00, 0xC0, 0x06, 0x02, 0x00, 0x08, 0x18, 0x00, 0x20,
  0x40, 0x00, 0x81, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x31, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x30, 0x00, 0x04, 0x80, 0x00, 0x16, 0x00, 0x00,
  0x50, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x80, 0x10, 0x03, 0x80,
  0x10, 0x02, 0x80, 0x10, 0x02, 0x80, 0x38, 0x06, 0x80, 0x38, 0x04, 0x80,
  0x78, 0x04, 0x80, 0x58, 0x04, 0x80, 0x58, 0x08, 0x80, 0xC8, 0x08, 0x80,
  0x88, 0x08, 0x80, 0x88, 0x10, 0x81, 0x88, 0x10, 0x81, 0x08, 0x10, 0x81,
  0x08, 0x30, 0x83, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x60, 0x86,
  0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0xC0, 0x8C, 0x08, 0x80, 0x88,
  0x08, 0x80, 0x88, 0x08, 0x80, 0x98, 0x09, 0x00, 0x90, 0x09, 0x00, 0xB0,
  0x09, 0x00, 0xA0, 0x0A, 0x00, 0xA0, 0x0A, 0x00, 0xA0, 0x0A, 0x00, 0xC0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x30, 0x30, 0x00, 0x18, 0x04, 0x00, 0x04,
  0x01, 0x00, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x00, 0x40, 0x10, 0x00, 0x18, 0x08, 0x00, 0x02, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x40, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x20,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x40, 0x00, 0x08,
  0x08, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x00, 0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x04,
  0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x05, 0x00, 0x00, 0x34, 0x00, 0x00, 0x98, 0x00, 0x04, 0x20, 0x00,
  0x30, 0x80, 0x01, 0x83, 0x00, 0x04, 0x04, 0x00, 0x30, 0x10, 0x01, 0x80,
  0x60, 0x04, 0x00, 0x80, 0x20, 0x02, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x10,
  0x20, 0x00, 0x41, 0x80, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00, 0x09, 0x80,
  0x00, 0x14, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x3F, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x40, 0x20,
  0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x03, 0xF8, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x01, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x01,
  0x40, 0x06, 0x80, 0x09, 0x00, 0x22, 0x00, 0x46, 0x01, 0x04, 0x06, 0x08,
  0x08, 0x10, 0x30, 0x30, 0x40, 0x21, 0x00, 0x42, 0x00, 0x88, 0x01, 0xB0,
  0x03, 0x40, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xC0, 0xC4, 0x62, 0x31, 0x00,
  0x0F, 0x00, 0x07, 0xDE, 0x00, 0x60, 0x18, 0x04, 0x00, 0x20, 0x40, 0x01,
  0x84, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x07, 0x00, 0x08,
  0x60, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0xC4, 0x00, 0x0E, 0x20, 0x00, 0xF1, 0x80, 0x0D, 0x86,
  0x03, 0x8C, 0x1F, 0xF0, 0x60, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x3C, 0x00, 0x8F, 0x78, 0x1B,
  0x80, 0xC1, 0x60, 0x06, 0x1C, 0x00, 0x21, 0x80, 0x02, 0x10, 0x00, 0x31,
  0x00, 0x01, 0x30, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01,
  0x20, 0x00, 0x12, 0x00, 0x03, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x64, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08, 0xC0, 0x01, 0x8E, 0x00,
  0x30, 0xB0, 0x06, 0x09, 0x80, 0xC0, 0x87, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0x78, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x21, 0x80, 0x01,
  0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x82, 0x00, 0x18, 0x30, 0x03, 0x01, 0x80, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0xF0, 0x20, 0x0F, 0xF8, 0xC0, 0x30,
  0x09, 0x00, 0xC0, 0x0A, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x10, 0x00,
  0x30, 0x60, 0x00, 0x60, 0x80, 0x00, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41,
  0x80, 0x00, 0x83, 0x00, 0x01, 0x06, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x18, 0x10, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x30, 0x06, 0x80, 0x30,
  0x39, 0x00, 0x3F, 0xC6, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xBC, 0x00, 0xE0,
  0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x0C, 0x00, 0x08, 0x40, 0x00, 0x46,
  0x00, 0x02, 0x20, 0x00, 0x1A, 0x00, 0x00, 0x90, 0x00, 0x04, 0xFF, 0xFF,
  0xEC, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x60, 0x40, 0x06, 0x01, 0x80, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x3C, 0x10, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFE, 0x30, 0x18, 0x04, 0xC0, 0xC0, 0x0A, 0x06,
  0x00, 0x38, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00,
  0x10, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10,
  0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00, 0x21, 0x80,
  0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20, 0x00, 0xC0, 0xC0, 0x07,
  0x01, 0x80, 0x34, 0x03, 0x03, 0x90, 0x07, 0xF8, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x20, 0x10, 0x01, 0x00, 0x60, 0x18, 0x00, 0x73, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x03, 0xE0, 0x18, 0x7B, 0xC0, 0x8C, 0x03, 0x04,
  0xC0, 0x08, 0x28, 0x00, 0x61, 0x80, 0x01, 0x0C, 0x00, 0x08, 0xC0, 0x00,
  0x46, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C, 0xC0,
  0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x0C,
  0x40, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00,
  0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x30, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x04,
  0x1C, 0x00, 0x3F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x43,
  0x00, 0x06, 0x08, 0x00, 0x30, 0x20, 0x03, 0x00, 0x80, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x03, 0x00, 0x04, 0x18, 0x00,
  0x11, 0x80, 0x00, 0x4E, 0x00, 0x03, 0x6C, 0x00, 0x0A, 0x10, 0x00, 0x30,
  0x60, 0x00, 0x80, 0xC0, 0x02, 0x01, 0x00, 0x08, 0x02, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x10, 0x04, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x81,
  0x00, 0x02, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0F, 0xFF,
  0xFC, 0x00, 0xF0, 0x0E, 0x02, 0xF7, 0x1E, 0xE1, 0x60, 0x4C, 0x08, 0x70,
  0x0E, 0x03, 0x18, 0x03, 0x00, 0x44, 0x00, 0x80, 0x11, 0x00, 0x20, 0x04,
  0x40, 0x18, 0x03, 0x30, 0x06, 0x00, 0x88, 0x01, 0x00, 0x22, 0x00, 0x40,
  0x08, 0x80, 0x10, 0x02, 0x20, 0x04, 0x00, 0x88, 0x03, 0x00, 0x64, 0x00,
  0x80, 0x11, 0x00, 0x20, 0x04, 0x40, 0x08, 0x01, 0x10, 0x02, 0x00, 0x44,
  0x00, 0x80, 0x13, 0x00, 0x60, 0x0C, 0x80, 0x10, 0x02, 0x20, 0x04, 0x00,
  0x88, 0x01, 0x00, 0x22, 0x00, 0x40, 0x08, 0x80, 0x30, 0x06, 0x00, 0x00,
  0x0F, 0x80, 0x61, 0xEF, 0x02, 0x30, 0x0C, 0x13, 0x00, 0x20, 0xA0, 0x01,
  0x86, 0x00, 0x04, 0x70, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80,
  0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x08,
  0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x18, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88,
  0x00, 0x08, 0xC0, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x0F, 0xBC, 0x00, 0xC0,
  0x30, 0x08, 0x00, 0xC0, 0x80, 0x02, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44,
  0x00, 0x02, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80,
  0x00, 0x34, 0x00, 0x01, 0x20, 0x00, 0x19, 0x00, 0x00, 0x84, 0x00, 0x08,
  0x30, 0x00, 0xC0, 0x80, 0x1C, 0x03, 0x01, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x08, 0xF7, 0x80, 0x6C, 0x03, 0x01, 0x60, 0x04, 0x07, 0x00,
  0x08, 0x18, 0x00, 0x20, 0x40, 0x00, 0xC3, 0x00, 0x01, 0x0C, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00,
  0x41, 0x00, 0x01, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0xE0, 0x03, 0x02,
  0xC0, 0x18, 0x09, 0x80, 0xC0, 0x23, 0xFC, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0xF8, 0xC0, 0xC0, 0x24, 0x0C, 0x00, 0xA0, 0xC0, 0x07, 0x0C, 0x00,
  0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00, 0x23, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x33, 0x00, 0x01,
  0x18, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80,
  0x01, 0x84, 0x00, 0x18, 0x30, 0x01, 0xC0, 0xC0, 0x1A, 0x03, 0x03, 0x90,
  0x0F, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x04, 0x07, 0xE1, 0x07, 0xCC, 0x23, 0x80, 0x04, 0xC0,
  0x00, 0xB0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xBE, 0x01, 0xC0, 0x18, 0x18,
  0x00, 0x60, 0x80, 0x01, 0x0C, 0x00, 0x0C, 0x40, 0x00, 0x62, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x09, 0x80, 0x00, 0x4C, 0x00, 0x04, 0x20, 0x00,
  0x61, 0x80, 0x06, 0x07, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x01,
  0xFF, 0xFF, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0xF0, 0x30, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x32, 0x00,
  0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x00, 0x48,
  0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08,
  0x80, 0x01, 0x88, 0x00, 0x38, 0xC0, 0x07, 0x84, 0x00, 0xD0, 0x60, 0x39,
  0x01, 0xFE, 0x10, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x64, 0x00, 0x01, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x20, 0x80, 0x01, 0x82, 0x00, 0x04, 0x0C, 0x00,
  0x20, 0x10, 0x01, 0x80, 0x40, 0x04, 0x01, 0x00, 0x30, 0x06, 0x00, 0x80,
  0x08, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0x80, 0x03, 0x06, 0x00, 0x04,
  0x10, 0x00, 0x10, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x90, 0x00, 0x02, 0xC0,
  0x00, 0x0A, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x14, 0x03, 0x80, 0x28, 0x05, 0x00, 0x90,
  0x1A, 0x01, 0x20, 0x24, 0x06, 0x40, 0x4C, 0x08, 0x81, 0x18, 0x11, 0x02,
  0x30, 0x62, 0x0C, 0x20, 0x84, 0x10, 0x43, 0x08, 0x20, 0x84, 0x10, 0x81,
  0x08, 0x31, 0x02, 0x30, 0x66, 0x04, 0x40, 0xC8, 0x09, 0x81, 0xB0, 0x12,
  0x03, 0x40, 0x24, 0x02, 0x80, 0x58, 0x06, 0x00, 0xA0, 0x0C, 0x01, 0x40,
  0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x06,
  0x03, 0x00, 0x0C, 0x01, 0x00, 0x18, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x23, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x62, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x00, 0x03, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x18, 0x00, 0x60, 0x30, 0x00, 0x20,
  0x20, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x40, 0x20, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x10, 0x01, 0x00, 0x03, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x08, 0x00, 0x08, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x9E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x02, 0x04,
  0x18, 0x30, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08,
  0x10, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x88, 0x30, 0x00, 0x88,
  0x04, 0x00, 0x4C, 0x01, 0x00, 0x64, 0x00, 0x60, 0x66, 0x00, 0x18, 0x62,
  0x00, 0x07, 0xC0,
};

const GFXglyph RobotoMono_ThinItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 33, 27, 10, -33 },
  { 30, 8, 10, 27, 12, -35 },
  { 40, 26, 33, 27, 1, -33 },
  { 148, 22, 42, 27, 3, -37 },
  { 264, 22, 33, 27, 3, -33 },
  { 355, 23, 33, 27, 2, -33 },
  { 450, 2, 10, 27, 14, -35 },
  { 453, 14, 47, 27, 8, -36 },
  { 536, 14, 47, 27, 4, -36 },
  { 619, 20, 18, 27, 6, -33 },
  { 664, 22, 24, 27, 3, -27 },
  { 730, 4, 10, 27, 6, -4 },
  { 735, 16, 2, 27, 5, -16 },
  { 739, 2, 3, 27, 11, -3 },
  { 740, 21, 36, 27, 4, -33 },
  { 835, 22, 33, 27, 3, -33 },
  { 926, 12, 33, 27, 7, -33 },
  { 976, 22, 33, 27, 1, -33 },
  { 1067, 22, 33, 27, 1, -33 },
  { 1158, 23, 33, 27, 1, -33 },
  { 1253, 22, 33, 27, 4, -33 },
  { 1344, 20, 33, 27, 3, -33 },
  { 1427, 20, 33, 27, 6, -33 },
  { 1510, 22, 33, 27, 3, -33 },
  { 1601, 20, 33, 27, 4, -33 },
  { 1684, 6, 23, 27, 12, -23 },
  { 1702, 9, 29, 27, 9, -23 },
  { 1735, 20, 18, 27, 4, -24 },
  { 1780, 21, 10, 27, 3, -20 },
  { 1807, 20, 18, 27, 3, -24 },
  { 1852, 17, 33, 27, 7, -33 },
  { 1923, 26, 33, 27, 1, -33 },
  { 2031, 22, 33, 27, 0, -33 },
  { 2122, 23, 33, 27, 2, -33 },
  { 2217, 22, 33, 27, 3, -33 },
  { 2308, 23, 33, 27, 2, -33 },
  { 2403, 24, 33, 27, 2, -33 },
  { 2502, 23, 33, 27, 3, -33 },
  { 2597, 22, 34, 27, 3, -33 },
  { 2691, 24, 33, 27, 2, -33 },
  { 2790, 24, 33, 27, 2, -33 },
  { 2889, 23, 33, 27, 2, -33 },
  { 2984, 25, 33, 27, 3, -33 },
  { 3088, 18, 33, 27, 3, -33 },
  { 3163, 25, 33, 27, 2, -33 },
  { 3267, 24, 33, 27, 2, -33 },
  { 3366, 22, 33, 27, 3, -33 },
  { 3457, 24, 33, 27, 3, -33 },
  { 3556, 24, 39, 27, 2, -33 },
  { 3673, 22, 33, 27, 3, -33 },
  { 3764, 23, 33, 27, 2, -33 },
  { 3859, 22, 33, 27, 6, -33 },
  { 3950, 23, 33, 27, 3, -33 },
  { 4045, 22, 33, 27, 5, -33 },
  { 4136, 24, 33, 27, 5, -33 },
  { 4235, 26, 33, 27, 1, -33 },
  { 4343, 22, 33, 27, 5, -33 },
  { 4434, 24, 33, 27, 1, -33 },
  { 4533, 14, 44, 27, 7, -37 },
  { 4610, 9, 36, 27, 9, -33 },
  { 4651, 13, 44, 27, 7, -37 },
  { 4723, 15, 18, 27, 6, -33 },
  { 4757, 18, 1, 27, 2, 0 },
  { 4760, 4, 6, 27, 14, -34 },
  { 4763, 21, 25, 27, 2, -25 },
  { 4829, 20, 35, 27, 3, -35 },
  { 4917, 20, 25, 27, 3, -25 },
  { 4980, 23, 35, 27, 3, -35 },
  { 5081, 21, 25, 27, 3, -25 },
  { 5147, 22, 35, 27, 6, -35 },
  { 5244, 22, 35, 27, 2, -25 },
  { 5341, 21, 35, 27, 2, -35 },
  { 5433, 18, 33, 27, 3, -33 },
  { 5508, 21, 43, 27, 0, -33 },
  { 5621, 22, 35, 27, 3, -35 },
  { 5718, 18, 35, 27, 3, -35 },
  { 5797, 26, 25, 27, 0, -25 },
  { 5879, 21, 25, 27, 2, -25 },
  { 5945, 21, 25, 27, 3, -25 },
  { 6011, 22, 34, 27, 1, -25 },
  { 6105, 21, 34, 27, 3, -25 },
  { 6195, 19, 25, 27, 6, -25 },
  { 6255, 21, 25, 27, 3, -25 },
  { 6321, 17, 31, 27, 6, -31 },
  { 6387, 20, 24, 27, 4, -24 },
  { 6447, 22, 24, 27, 4, -24 },
  { 6513, 23, 24, 27, 4, -24 },
  { 6582, 24, 24, 27, 1, -24 },
  { 6654, 28, 34, 27, -1, -24 },
  { 6773, 23, 24, 27, 1, -24 },
  { 6842, 18, 46, 27, 7, -36 },
  { 6946, 7, 39, 27, 10, -33 },
  { 6981, 18, 46, 27, 4, -36 },
  { 7085, 25, 7, 27, 1, -17 },
};

const GFXfont RobotoMono_ThinItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic46pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_THINITALIC46PT7B_H_
