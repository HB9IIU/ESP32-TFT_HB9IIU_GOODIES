#ifndef _ROBOTOMONO_THINITALIC67PT7B_H_
#define _ROBOTOMONO_THINITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x30, 0x33, 0x03, 0x30, 0x33,
  0x02, 0x20, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x64, 0x04, 0xC0, 0xCC,
  0x0C, 0xC0, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x02, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x08, 0x20, 0x03, 0x00, 0x0C, 0x60, 0x03,
  0x00, 0x18, 0x60, 0x03, 0x00, 0x30, 0x40, 0x03, 0x00, 0x70, 0xC0, 0x03,
  0x00, 0x60, 0xC0, 0x03, 0x00, 0xC0, 0xC0, 0x02, 0x01, 0x80, 0xC0, 0x06,
  0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x60, 0x38, 0x18, 0x00, 0x30, 0x70,
  0x30, 0x00, 0x1F, 0xE0, 0x30, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x03, 0xF8, 0x00, 0x0C,
  0x07, 0x9C, 0x00, 0x18, 0x0E, 0x06, 0x00, 0x18, 0x18, 0x03, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x30, 0x01, 0x00, 0xC0,
  0x60, 0x01, 0x01, 0x80, 0x60, 0x03, 0x03, 0x80, 0x60, 0x03, 0x03, 0x00,
  0x40, 0x03, 0x06, 0x00, 0x40, 0x03, 0x0C, 0x00, 0xC0, 0x03, 0x0C, 0x00,
  0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x30, 0x00, 0xC0, 0x06, 0x10, 0x00,
  0x40, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x40, 0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x30, 0x60, 0x06, 0x00, 0x18, 0x60, 0x03,
  0x00, 0x18, 0x60, 0x00, 0xC0, 0x0C, 0x30, 0x00, 0x30, 0x06, 0x30, 0x00,
  0x18, 0x06, 0x18, 0x00, 0x06, 0x03, 0x18, 0x00, 0x01, 0x01, 0x8C, 0x00,
  0x00, 0xC1, 0x86, 0x00, 0x00, 0x30, 0xC3, 0x00, 0x00, 0x18, 0xC1, 0x80,
  0x00, 0x06, 0xE0, 0xC0, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x6C, 0x06, 0x00, 0x00, 0xE6, 0x01,
  0x80, 0x00, 0xE1, 0x80, 0x70, 0x01, 0xC0, 0x60, 0x1E, 0x07, 0xC0, 0x30,
  0x03, 0xFF, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x33, 0x32, 0x66,
  0x66, 0x4C, 0xCC, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x20, 0x07, 0xF8, 0x02, 0x03, 0xF1, 0xF0,
  0x60, 0xF8, 0x03, 0xE6, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x07,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x30, 0x41,
  0x83, 0x06, 0x18, 0x30, 0xC3, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x23, 0x9C, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xE1, 0x00, 0x00,
  0x03, 0xC6, 0x00, 0x00, 0x1D, 0x8C, 0x00, 0x00, 0x73, 0x10, 0x00, 0x01,
  0xC6, 0x60, 0x00, 0x06, 0x0C, 0xC0, 0x00, 0x18, 0x11, 0x80, 0x00, 0x60,
  0x23, 0x00, 0x01, 0x80, 0xC4, 0x00, 0x0E, 0x01, 0x98, 0x00, 0x38, 0x03,
  0x30, 0x00, 0xE0, 0x06, 0x60, 0x03, 0x00, 0x08, 0xC0, 0x0C, 0x00, 0x31,
  0x80, 0x30, 0x00, 0x62, 0x00, 0xC0, 0x00, 0xCC, 0x07, 0x00, 0x01, 0x98,
  0x1C, 0x00, 0x03, 0x30, 0x70, 0x00, 0x04, 0x61, 0x80, 0x00, 0x18, 0xC6,
  0x00, 0x00, 0x31, 0x98, 0x00, 0x00, 0x63, 0x60, 0x00, 0x01, 0x87, 0x80,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0xFB, 0x03, 0xC3, 0x0F, 0x02, 0x3C, 0x02, 0xE0, 0x06, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x38, 0x00, 0x40, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x80, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x0F, 0xF0, 0x00, 0x04, 0x7F, 0xFC, 0x00, 0x05,
  0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x7F, 0xE0,
  0x06, 0x0F, 0xEF, 0xC0, 0x31, 0xE0, 0x07, 0x01, 0x1C, 0x00, 0x1C, 0x19,
  0x80, 0x00, 0x70, 0xD8, 0x00, 0x01, 0x85, 0x80, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xF0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0E, 0x40, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x16, 0x60,
  0x00, 0x03, 0x63, 0x00, 0x00, 0xE4, 0x18, 0x00, 0x1C, 0xC1, 0xC0, 0x07,
  0x0C, 0x0F, 0x03, 0xE0, 0x80, 0x3F, 0xF8, 0x18, 0x00, 0x3C, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0x01, 0xC1, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0x10,
  0x01, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFB, 0xF0, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x30, 0x1C, 0x00, 0xFC, 0x00,
  0xC0, 0x60, 0x0F, 0xFC, 0x03, 0x03, 0x00, 0x70, 0x38, 0x0C, 0x0C, 0x03,
  0x00, 0x60, 0x30, 0x60, 0x18, 0x01, 0x00, 0xC1, 0x80, 0xC0, 0x04, 0x03,
  0x0C, 0x03, 0x00, 0x30, 0x0C, 0x30, 0x18, 0x00, 0xC0, 0x31, 0x80, 0x60,
  0x02, 0x00, 0xC6, 0x03, 0x00, 0x18, 0x03, 0x10, 0x0C, 0x00, 0x60, 0x0C,
  0xC0, 0x60, 0x01, 0x80, 0x23, 0x01, 0x80, 0x04, 0x01, 0x8C, 0x06, 0x00,
  0x30, 0x06, 0x60, 0x10, 0x00, 0xC0, 0x19, 0x80, 0xC0, 0x02, 0x00, 0x66,
  0x03, 0x00, 0x18, 0x01, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x40, 0x20, 0x01,
  0x80, 0x31, 0x00, 0x80, 0x0C, 0x00, 0x84, 0x06, 0x00, 0x30, 0x06, 0x30,
  0x18, 0x01, 0xC0, 0x18, 0xC0, 0x60, 0x0F, 0x00, 0xC3, 0x01, 0x80, 0x2C,
  0x03, 0x0C, 0x02, 0x01, 0xB0, 0x18, 0x10, 0x0C, 0x0C, 0x40, 0xE0, 0x60,
  0x30, 0xE1, 0x87, 0x01, 0x80, 0x7F, 0x07, 0xF8, 0x06, 0x00, 0xF0, 0x07,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x7C, 0x00, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x06, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x38, 0x10, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x02, 0x00, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x38, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x98, 0x00,
  0x1F, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x80, 0x20, 0x00, 0x00,
  0x38, 0x01, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x00, 0x08, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x00, 0x08, 0x07, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x01, 0x86, 0xC0,
  0x00, 0x00, 0x0C, 0xE3, 0x00, 0x00, 0x00, 0x4E, 0x18, 0x00, 0x00, 0x02,
  0xE0, 0x60, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x1A, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1A, 0x00,
  0x00, 0x36, 0x01, 0x20, 0x00, 0x03, 0x60, 0x33, 0x00, 0x00, 0x66, 0x03,
  0x30, 0x00, 0x0E, 0x40, 0x33, 0x00, 0x00, 0xCC, 0x03, 0x10, 0x00, 0x18,
  0xC0, 0x31, 0x00, 0x01, 0x8C, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x61, 0x80,
  0x03, 0x08, 0x06, 0x18, 0x00, 0x60, 0x80, 0x60, 0x80, 0x0C, 0x18, 0x06,
  0x08, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x18, 0x18, 0x04, 0x0C, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x30, 0x10, 0x0C, 0x04, 0x03, 0x01, 0x00, 0xC0, 0x40,
  0x60, 0x30, 0x0C, 0x06, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0xC0, 0x30, 0x08,
  0x06, 0x18, 0x03, 0x01, 0x80, 0x21, 0x80, 0x20, 0x18, 0x02, 0x30, 0x06,
  0x01, 0x80, 0x33, 0x00, 0x60, 0x18, 0x03, 0x60, 0x06, 0x01, 0x00, 0x3C,
  0x00, 0x60, 0x10, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x00, 0x40, 0x30,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xB0, 0x00, 0x00, 0x20, 0x0B, 0x00,
  0x00, 0x02, 0x01, 0x90, 0x00, 0x00, 0x60, 0x19, 0x80, 0x00, 0x06, 0x01,
  0x88, 0x00, 0x00, 0x60, 0x18, 0xC0, 0x00, 0x06, 0x01, 0x0C, 0x00, 0x00,
  0x40, 0x10, 0x40, 0x00, 0x04, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x60,
  0x00, 0x0C, 0x03, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x30, 0x00, 0x0C, 0x02,
  0x01, 0x00, 0x00, 0x80, 0x20, 0x18, 0x00, 0x08, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x08, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x0C,
  0x00, 0x18, 0x04, 0x00, 0x40, 0x01, 0x00, 0x40, 0x06, 0x00, 0x10, 0x0C,
  0x00, 0x20, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x80, 0x01, 0x00, 0x30, 0x08, 0x00, 0x18, 0x02, 0x01, 0x80, 0x01,
  0x80, 0x20, 0x18, 0x00, 0x08, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x18,
  0x00, 0x04, 0x06, 0x01, 0x00, 0x00, 0x60, 0x60, 0x10, 0x00, 0x06, 0x04,
  0x03, 0x00, 0x00, 0x20, 0xC0, 0x30, 0x00, 0x03, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0xC0, 0x30, 0x00, 0x01, 0x0C, 0x02, 0x00, 0x00, 0x18, 0x80, 0x20,
  0x00, 0x00, 0x88, 0x06, 0x00, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x00, 0xD8,
  0x06, 0x00, 0x00, 0x05, 0x80, 0x60, 0x00, 0x00, 0x78, 0x04, 0x00, 0x00,
  0x07, 0x00, 0x40, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0x00, 0x01, 0xF0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x01, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x78,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x10, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x78, 0x00, 0x18, 0x00,
  0x0B, 0x00, 0x03, 0x00, 0x03, 0x60, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x1E,
  0x00, 0x09, 0x80, 0x03, 0xC0, 0x03, 0x30, 0x00, 0x58, 0x00, 0x66, 0x00,
  0x1B, 0x00, 0x08, 0xC0, 0x03, 0x60, 0x01, 0x18, 0x00, 0x4C, 0x00, 0x63,
  0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x30, 0x01, 0x0C, 0x00, 0x46, 0x00,
  0x61, 0x80, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x01, 0x06, 0x00, 0xC3,
  0x00, 0x60, 0xC0, 0x18, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x03, 0x00,
  0xC1, 0x80, 0x60, 0x60, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x01, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01,
  0x00, 0xC0, 0xC0, 0x60, 0x20, 0x18, 0x18, 0x04, 0x0C, 0x03, 0x02, 0x00,
  0x81, 0x80, 0x60, 0xC0, 0x10, 0x20, 0x0C, 0x18, 0x02, 0x0C, 0x01, 0x82,
  0x00, 0x41, 0x80, 0x30, 0xC0, 0x08, 0x20, 0x06, 0x18, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x06, 0x20, 0x03, 0x18, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x03, 0x20, 0x01, 0x98, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x32, 0x00, 0x01, 0x8C, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x04, 0x00, 0x30,
  0x18, 0x00, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x06, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0xC1, 0x81, 0x83, 0x03, 0x02, 0x06, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0x01, 0xE0, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0F, 0x0C,
  0x00, 0x00, 0x7C, 0x38, 0x00, 0x03, 0xB0, 0x60, 0x00, 0x38, 0xC0, 0xC0,
  0x03, 0xC3, 0x01, 0xE0, 0x7C, 0x0C, 0x03, 0xFF, 0xC0, 0x30, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xC0, 0x00, 0x83,
  0xFF, 0xC0, 0x06, 0x1C, 0x03, 0xC0, 0x19, 0xC0, 0x03, 0x80, 0x6E, 0x00,
  0x06, 0x01, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x82, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x03, 0x01, 0x60, 0x00, 0x18, 0x0C, 0xC0, 0x00, 0xC0, 0x33, 0x80,
  0x0E, 0x00, 0xC3, 0xC0, 0xF0, 0x03, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x01, 0xC0, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xF0, 0x0C, 0x00, 0x3F, 0xFC, 0x0C, 0x00, 0x78, 0x07,
  0x08, 0x00, 0xE0, 0x03, 0x98, 0x01, 0x80, 0x00, 0xD8, 0x03, 0x00, 0x00,
  0xD8, 0x06, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x07, 0x80, 0x30, 0x00, 0x0D, 0x00, 0x38, 0x00, 0x3B,
  0x00, 0x1C, 0x00, 0x73, 0x00, 0x0F, 0x03, 0xC3, 0x00, 0x03, 0xFF, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x03, 0x00, 0x1E, 0x01, 0xC2,
  0x00, 0x38, 0x00, 0xE6, 0x00, 0x60, 0x00, 0x36, 0x00, 0xC0, 0x00, 0x36,
  0x01, 0x80, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x03, 0x40, 0x0E, 0x00, 0x0E, 0x40,
  0x07, 0x00, 0x1C, 0xC0, 0x03, 0xC0, 0xF0, 0xC0, 0x00, 0xFF, 0xC0, 0xC0,
  0x00, 0x1C, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x1F, 0xE0, 0x01, 0x80, 0xFF, 0xF0, 0x03, 0x07,
  0x80, 0x70, 0x06, 0x1C, 0x00, 0x70, 0x08, 0xE0, 0x00, 0x60, 0x13, 0x80,
  0x00, 0x60, 0x64, 0x00, 0x00, 0xC0, 0xD0, 0x00, 0x00, 0x81, 0xE0, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xE1, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0E, 0x02,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x40, 0x70, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x0C, 0xEC, 0x00,
  0x00, 0x1F, 0x0C, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x3F, 0xF0, 0x3F, 0xF0, 0x0D, 0xE0,
  0x71, 0xE0, 0x70, 0x17, 0x00, 0x67, 0x00, 0x60, 0x2C, 0x00, 0x5C, 0x00,
  0x40, 0x70, 0x00, 0xF0, 0x00, 0xC1, 0xC0, 0x01, 0xC0, 0x01, 0x83, 0x80,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x10, 0x00, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x00, 0x20, 0xC0,
  0x00, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x83, 0x00, 0x03, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x00, 0x04, 0x08, 0x00, 0x08, 0x00, 0x08, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x82, 0x00, 0x02, 0x00, 0x02, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x18, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0xC1,
  0x00, 0x01, 0x00, 0x01, 0x02, 0x00, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x40, 0x00, 0x60, 0x80, 0x00, 0x80, 0x00, 0x81, 0x00, 0x01,
  0x00, 0x01, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x06, 0x03, 0xFF, 0xC0, 0x0C, 0x1E, 0x01, 0xC0, 0x18, 0x60, 0x01, 0xC0,
  0x23, 0x80, 0x01, 0x80, 0x4C, 0x00, 0x01, 0x81, 0xB0, 0x00, 0x03, 0x03,
  0x40, 0x00, 0x06, 0x07, 0x80, 0x00, 0x04, 0x0E, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x41, 0xFF, 0xE0,
  0x00, 0xC3, 0x80, 0x78, 0x00, 0xCE, 0x00, 0x18, 0x00, 0xDC, 0x00, 0x0C,
  0x00, 0xF0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x02,
  0x01, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x60, 0x1B, 0x00, 0x00, 0xC0,
  0x1B, 0x80, 0x01, 0x80, 0x19, 0xC0, 0x07, 0x00, 0x18, 0x78, 0x3E, 0x00,
  0x10, 0x3F, 0xF8, 0x00, 0x10, 0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x30, 0x07, 0x80, 0x70, 0x80,
  0x38, 0x00, 0xE6, 0x01, 0x80, 0x01, 0xD8, 0x0C, 0x00, 0x03, 0x60, 0x60,
  0x00, 0x07, 0x83, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x03, 0x40,
  0x38, 0x00, 0x39, 0x00, 0x70, 0x01, 0xCC, 0x00, 0xF0, 0x3C, 0x30, 0x00,
  0xFF, 0xC0, 0xC0, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x30, 0x1F, 0xFF, 0x03, 0x07, 0xC0, 0x00, 0x20, 0xE0, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x0F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xE0, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x41, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xD8, 0x0C,
  0x00, 0x0E, 0x60, 0x18, 0x00, 0xF1, 0x00, 0x38, 0x1F, 0x0C, 0x00, 0x7F,
  0xF0, 0x30, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x08, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x1B, 0x00,
  0x07, 0x00, 0x03, 0x60, 0x00, 0xF0, 0x00, 0xCC, 0x00, 0x16, 0x00, 0x19,
  0x80, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0xC2, 0x00, 0x33, 0x00,
  0x18, 0x40, 0x06, 0x60, 0x06, 0x08, 0x00, 0x8C, 0x00, 0xC1, 0x80, 0x31,
  0x80, 0x18, 0x30, 0x06, 0x30, 0x06, 0x06, 0x01, 0x86, 0x00, 0xC0, 0xC0,
  0x30, 0xC0, 0x30, 0x18, 0x0C, 0x08, 0x06, 0x03, 0x01, 0x81, 0x00, 0xC0,
  0x60, 0x20, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC1,
  0x80, 0x30, 0x60, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x03, 0x08, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x30, 0x00, 0x98, 0x00, 0x4C, 0x00,
  0x13, 0x00, 0x09, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x58, 0x00, 0x2C,
  0x00, 0x0A, 0x00, 0x05, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xDF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0B, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x30, 0xFB, 0xE0, 0x00, 0x06, 0x1C, 0x07, 0x00, 0x00, 0x63,
  0x80, 0x18, 0x00, 0x06, 0x30, 0x00, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x00,
  0x0C, 0x40, 0x00, 0x30, 0x01, 0x8C, 0x00, 0x01, 0xC0, 0x70, 0xC0, 0x00,
  0x0F, 0x1E, 0x08, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
};

const GFXglyph RobotoMono_ThinItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 11, 48, 39, 14, -48 },
  { 67, 12, 13, 39, 17, -50 },
  { 87, 39, 48, 39, 1, -48 },
  { 321, 31, 61, 39, 5, -54 },
  { 558, 32, 49, 39, 4, -48 },
  { 754, 33, 49, 39, 3, -48 },
  { 957, 4, 13, 39, 20, -50 },
  { 964, 20, 68, 39, 12, -53 },
  { 1134, 20, 68, 39, 6, -53 },
  { 1304, 28, 26, 39, 9, -48 },
  { 1395, 32, 34, 39, 4, -39 },
  { 1531, 7, 13, 39, 8, -5 },
  { 1543, 23, 2, 39, 8, -23 },
  { 1549, 5, 4, 39, 15, -4 },
  { 1552, 30, 52, 39, 6, -48 },
  { 1747, 31, 49, 39, 5, -48 },
  { 1937, 16, 48, 39, 11, -48 },
  { 2033, 31, 48, 39, 2, -48 },
  { 2219, 32, 49, 39, 2, -48 },
  { 2415, 32, 48, 39, 2, -48 },
  { 2607, 32, 49, 39, 6, -48 },
  { 2803, 29, 49, 39, 4, -48 },
  { 2981, 30, 48, 39, 8, -48 },
  { 3161, 33, 49, 39, 4, -48 },
  { 3364, 28, 49, 39, 7, -48 },
  { 3536, 9, 33, 39, 17, -33 },
  { 3574, 13, 41, 39, 13, -33 },
  { 3641, 30, 26, 39, 5, -35 },
  { 3739, 31, 15, 39, 5, -29 },
  { 3798, 30, 26, 39, 4, -35 },
  { 3896, 24, 48, 39, 11, -48 },
  { 4040, 38, 48, 39, 1, -48 },
  { 4268, 33, 48, 39, 0, -48 },
  { 4466, 33, 48, 39, 3, -48 },
  { 4664, 33, 49, 39, 4, -48 },
  { 4867, 34, 48, 39, 3, -48 },
  { 5071, 34, 48, 39, 4, -48 },
  { 5275, 34, 48, 39, 4, -48 },
  { 5479, 33, 49, 39, 4, -48 },
  { 5682, 36, 48, 39, 2, -48 },
  { 5898, 34, 48, 39, 3, -48 },
  { 6102, 34, 49, 39, 3, -48 },
  { 6311, 37, 48, 39, 4, -48 },
  { 6533, 27, 48, 39, 4, -48 },
  { 6695, 36, 48, 39, 3, -48 },
  { 6911, 36, 48, 39, 2, -48 },
  { 7127, 32, 49, 39, 4, -48 },
  { 7323, 35, 48, 39, 4, -48 },
  { 7533, 34, 57, 39, 3, -48 },
  { 7776, 33, 48, 39, 4, -48 },
  { 7974, 33, 49, 39, 4, -48 },
  { 8177, 33, 48, 39, 8, -48 },
  { 8375, 34, 49, 39, 4, -48 },
  { 8584, 32, 48, 39, 8, -48 },
  { 8776, 35, 48, 39, 7, -48 },
  { 8986, 39, 48, 39, 1, -48 },
  { 9220, 32, 48, 39, 8, -48 },
  { 9412, 35, 48, 39, 2, -48 },
  { 9622, 20, 64, 39, 10, -54 },
  { 9782, 12, 52, 39, 14, -48 },
  { 9860, 19, 64, 39, 10, -54 },
  { 10012, 22, 26, 39, 9, -48 },
  { 10084, 28, 2, 39, 2, 0 },
  { 10091, 7, 9, 39, 20, -50 },
  { 10099, 30, 37, 39, 4, -36 },
  { 10238, 30, 51, 39, 4, -50 },
  { 10430, 29, 37, 39, 5, -36 },
  { 10565, 32, 51, 39, 5, -50 },
  { 10769, 30, 37, 39, 4, -36 },
  { 10908, 32, 51, 39, 9, -51 },
  { 11112, 32, 50, 39, 3, -36 },
  { 11312, 31, 50, 39, 3, -50 },
  { 11506, 27, 48, 39, 4, -48 },
  { 11668, 30, 62, 39, 0, -48 },
  { 11901, 31, 50, 39, 5, -50 },
  { 12095, 27, 50, 39, 4, -50 },
  { 12264, 39, 36, 39, -1, -36 },
  { 12440, 31, 36, 39, 3, -36 },
  { 12580, 31, 37, 39, 4, -36 },
  { 12724, 32, 50, 39, 1, -36 },
  { 12924, 30, 50, 39, 5, -36 },
  { 13112, 28, 36, 39, 9, -36 },
  { 13238, 30, 37, 39, 5, -36 },
  { 13377, 24, 46, 39, 9, -45 },
  { 13515, 30, 36, 39, 5, -35 },
  { 13650, 32, 35, 39, 6, -35 },
  { 13790, 35, 35, 39, 5, -35 },
  { 13944, 35, 35, 39, 2, -35 },
  { 14098, 40, 49, 39, -1, -35 },
  { 14343, 35, 35, 39, 1, -35 },
  { 14497, 26, 66, 39, 10, -52 },
  { 14712, 11, 57, 39, 14, -48 },
  { 14791, 25, 66, 39, 6, -52 },
  { 14998, 36, 11, 39, 2, -25 },
};

const GFXfont RobotoMono_ThinItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic67pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_THINITALIC67PT7B_H_
