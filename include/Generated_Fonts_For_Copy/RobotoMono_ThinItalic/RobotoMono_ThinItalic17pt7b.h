#ifndef _ROBOTOMONO_THINITALIC17PT7B_H_
#define _ROBOTOMONO_THINITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x5A, 0x82, 0x76, 0xD0, 0x04, 0x81, 0x20, 0x88, 0xFF, 0x09,
  0x04, 0x41, 0x20, 0x48, 0xFF, 0x89, 0x04, 0x41, 0x20, 0x04, 0x04, 0x1A,
  0x21, 0x41, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x82, 0x82, 0x6C, 0x10,
  0x10, 0x70, 0x91, 0x92, 0x94, 0xA4, 0x48, 0x12, 0x15, 0x29, 0x49, 0x89,
  0x0E, 0x1C, 0x22, 0x22, 0x24, 0x28, 0x30, 0x50, 0x89, 0x85, 0x82, 0x86,
  0x79, 0xF0, 0x18, 0x88, 0x84, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08,
  0x20, 0x30, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x11, 0x08, 0x80,
  0x08, 0x13, 0x59, 0xC2, 0x88, 0x90, 0x00, 0x08, 0x08, 0x08, 0x08, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x58, 0xFC, 0x80, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x1E, 0x21, 0x41, 0x43,
  0x45, 0x89, 0x91, 0xA1, 0xC2, 0x82, 0x84, 0x78, 0x3D, 0x11, 0x22, 0x22,
  0x22, 0x44, 0x1F, 0x21, 0x41, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0xFF, 0x1F, 0x10, 0x48, 0x20, 0x10, 0x10, 0x70, 0x48, 0x02, 0x01,
  0x40, 0x90, 0x87, 0x80, 0x01, 0x01, 0x81, 0x41, 0x20, 0x90, 0x90, 0x88,
  0x84, 0xFF, 0x81, 0x00, 0x80, 0x80, 0x3F, 0x40, 0x40, 0x40, 0x78, 0x84,
  0x02, 0x02, 0x02, 0x84, 0x84, 0xF8, 0x0E, 0x20, 0x82, 0x07, 0xC8, 0x60,
  0xC1, 0x83, 0x06, 0x13, 0xC0, 0xFF, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x1F, 0x21, 0x41, 0x41, 0x41, 0x3E, 0x62,
  0x81, 0x81, 0x81, 0x82, 0x7C, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x61, 0xBD,
  0x04, 0x10, 0x67, 0x00, 0x20, 0x00, 0x04, 0x10, 0x00, 0x00, 0x04, 0x48,
  0x03, 0x0C, 0x30, 0xC0, 0x30, 0x0C, 0x02, 0x7F, 0x00, 0xFE, 0x40, 0x38,
  0x04, 0x03, 0x0C, 0x70, 0x80, 0x7A, 0x18, 0x41, 0x08, 0x42, 0x10, 0x40,
  0x00, 0x10, 0x0F, 0x84, 0x12, 0x65, 0x25, 0x52, 0x64, 0x99, 0x26, 0x8A,
  0xA4, 0xA6, 0xC4, 0x00, 0xF8, 0x02, 0x06, 0x06, 0x0A, 0x0A, 0x11, 0x11,
  0x21, 0x3F, 0x41, 0x41, 0x81, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x7E, 0x42,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0x1E, 0x21, 0x41, 0x41, 0x80, 0x80, 0x80,
  0x80, 0x81, 0x82, 0x82, 0x7C, 0x7E, 0x41, 0x41, 0x41, 0x41, 0x41, 0x81,
  0x81, 0x81, 0x82, 0x84, 0xF8, 0x3F, 0xA0, 0x10, 0x08, 0x04, 0x03, 0xF1,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xC0, 0x3F, 0x90, 0x10, 0x08, 0x04,
  0x03, 0xF1, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x21, 0x41,
  0x40, 0x80, 0x80, 0x8E, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x40, 0xA0, 0x50,
  0x28, 0x24, 0x17, 0xFA, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90, 0x40, 0x3F,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x82, 0x84, 0x78, 0x20,
  0xA0, 0x90, 0x88, 0x84, 0x82, 0x81, 0xC1, 0x10, 0x84, 0x42, 0x20, 0x90,
  0x20, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x07, 0xF0,
  0x20, 0xB0, 0xD8, 0xAC, 0x65, 0x54, 0xAA, 0x65, 0x22, 0x81, 0x41, 0x20,
  0x90, 0x40, 0x40, 0xB0, 0x58, 0x2A, 0x25, 0x14, 0x8A, 0x25, 0x12, 0x85,
  0x43, 0x20, 0x90, 0x40, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x84, 0x78, 0x3F, 0x10, 0x50, 0x28, 0x14, 0x0A, 0x09, 0xF8,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x21, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x04, 0x06, 0x3E, 0x41, 0x41, 0x41,
  0x41, 0x42, 0x7C, 0x84, 0x84, 0x84, 0x82, 0x82, 0x3E, 0x41, 0x41, 0x40,
  0x60, 0x18, 0x04, 0x02, 0x01, 0x81, 0x82, 0x7C, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0xA0, 0x50, 0x28,
  0x24, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x21, 0x0F, 0x00, 0x81, 0x81,
  0x82, 0x82, 0x84, 0x44, 0x48, 0x48, 0x50, 0x50, 0x60, 0x20, 0x88, 0xC8,
  0xA6, 0x55, 0x2A, 0xA5, 0x53, 0x29, 0x98, 0xCC, 0x46, 0x22, 0x11, 0x00,
  0x20, 0x44, 0x21, 0x10, 0x24, 0x0A, 0x01, 0x00, 0xC0, 0x48, 0x12, 0x08,
  0x84, 0x12, 0x04, 0x81, 0x82, 0x42, 0x44, 0x48, 0x28, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x3F, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x20, 0x10, 0x10, 0x1F, 0xE0, 0x39, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x42, 0x10, 0xC0, 0x84, 0x44, 0x44, 0x22, 0x22, 0x21, 0x10, 0x18,
  0x42, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x08, 0x84, 0xE0, 0x08, 0x62,
  0x8A, 0x46, 0x18, 0x40, 0xFC, 0xA4, 0x3E, 0x41, 0x01, 0x01, 0x7E, 0x82,
  0x82, 0x86, 0xFA, 0x20, 0x20, 0x40, 0x40, 0x7E, 0x42, 0x41, 0x41, 0x81,
  0x82, 0x82, 0x84, 0xF8, 0x3E, 0x41, 0x41, 0x80, 0x80, 0x80, 0x82, 0x82,
  0x7C, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x41, 0x82, 0x82, 0x82, 0x82,
  0x86, 0x7A, 0x3E, 0x41, 0x41, 0xFF, 0x80, 0x80, 0x80, 0x82, 0x7C, 0x0F,
  0x10, 0x10, 0x10, 0xEE, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x3D, 0x43, 0x41, 0x82, 0x82, 0x82, 0x82, 0x86, 0x7A, 0x04, 0x04, 0x88,
  0x70, 0x20, 0x20, 0x40, 0x40, 0x5E, 0x61, 0x41, 0x41, 0x81, 0x82, 0x82,
  0x82, 0x82, 0x04, 0x00, 0x01, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x20, 0x47,
  0xF0, 0x01, 0x00, 0x00, 0x1E, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x10, 0xE0, 0x20, 0x20, 0x20, 0x20, 0x41, 0x46, 0x48,
  0x50, 0x70, 0x48, 0x88, 0x84, 0x82, 0x3C, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x8F, 0xE0, 0x7B, 0x91, 0x14, 0x46, 0x11, 0x88,
  0xA2, 0x28, 0x8A, 0x22, 0x88, 0x80, 0x5E, 0x61, 0x41, 0x41, 0x82, 0x82,
  0x82, 0x82, 0x82, 0x3E, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C,
  0x3F, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x40, 0x80, 0x80,
  0x3D, 0x43, 0x41, 0x82, 0x82, 0x82, 0x82, 0x86, 0x7A, 0x04, 0x04, 0x04,
  0x5E, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x80, 0x3E, 0x41, 0x40, 0x60,
  0x1C, 0x02, 0x02, 0x82, 0x7C, 0x10, 0x4E, 0xC8, 0x20, 0x82, 0x08, 0x41,
  0x03, 0x80, 0x41, 0x41, 0x41, 0x41, 0x82, 0x82, 0x82, 0x86, 0x7A, 0x81,
  0x82, 0x84, 0x84, 0x88, 0x48, 0x50, 0x60, 0x20, 0x88, 0xC4, 0x66, 0x53,
  0x2A, 0x55, 0x32, 0x98, 0x88, 0x44, 0x00, 0x20, 0x88, 0x84, 0x81, 0x80,
  0x80, 0xA0, 0x48, 0x44, 0xC1, 0x00, 0x40, 0x48, 0x22, 0x08, 0x84, 0x22,
  0x04, 0x81, 0x40, 0x50, 0x08, 0x04, 0x01, 0x00, 0x80, 0xC0, 0x00, 0x3F,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x00, 0x0C, 0x41,
  0x08, 0x20, 0x82, 0x10, 0x81, 0x04, 0x10, 0x41, 0x04, 0x08, 0x10, 0x55,
  0x56, 0xAA, 0xA0, 0x18, 0x10, 0x10, 0x20, 0x41, 0x02, 0x02, 0x06, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x10, 0xC0, 0x78, 0x61, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 3, 4, 10, 4, -13 },
  { 6, 10, 12, 10, 0, -12 },
  { 21, 8, 16, 10, 1, -14 },
  { 37, 8, 12, 10, 1, -12 },
  { 49, 8, 12, 10, 1, -12 },
  { 61, 1, 4, 10, 5, -13 },
  { 62, 5, 17, 10, 3, -13 },
  { 73, 5, 17, 10, 2, -13 },
  { 84, 7, 7, 10, 2, -12 },
  { 91, 8, 9, 10, 1, -10 },
  { 100, 2, 3, 10, 2, -1 },
  { 101, 6, 1, 10, 2, -6 },
  { 102, 1, 1, 10, 4, -1 },
  { 103, 8, 13, 10, 1, -12 },
  { 116, 8, 12, 10, 1, -12 },
  { 128, 4, 12, 10, 3, -12 },
  { 134, 8, 12, 10, 0, -12 },
  { 146, 9, 12, 10, 0, -12 },
  { 160, 9, 12, 10, 0, -12 },
  { 174, 8, 12, 10, 2, -12 },
  { 186, 7, 12, 10, 1, -12 },
  { 197, 8, 12, 10, 2, -12 },
  { 209, 8, 12, 10, 1, -12 },
  { 221, 7, 12, 10, 2, -12 },
  { 232, 3, 8, 10, 4, -8 },
  { 235, 4, 10, 10, 3, -8 },
  { 240, 8, 7, 10, 1, -9 },
  { 247, 8, 3, 10, 1, -7 },
  { 250, 8, 7, 10, 1, -9 },
  { 257, 6, 12, 10, 3, -12 },
  { 266, 10, 12, 10, 0, -12 },
  { 281, 8, 12, 10, 0, -12 },
  { 293, 8, 12, 10, 1, -12 },
  { 305, 8, 12, 10, 1, -12 },
  { 317, 8, 12, 10, 1, -12 },
  { 329, 9, 12, 10, 1, -12 },
  { 343, 9, 12, 10, 1, -12 },
  { 357, 8, 12, 10, 1, -12 },
  { 369, 9, 12, 10, 1, -12 },
  { 383, 8, 12, 10, 1, -12 },
  { 395, 8, 12, 10, 1, -12 },
  { 407, 9, 12, 10, 1, -12 },
  { 421, 7, 12, 10, 1, -12 },
  { 432, 9, 12, 10, 1, -12 },
  { 446, 9, 12, 10, 1, -12 },
  { 460, 8, 12, 10, 1, -12 },
  { 472, 9, 12, 10, 1, -12 },
  { 486, 8, 14, 10, 1, -12 },
  { 500, 8, 12, 10, 1, -12 },
  { 512, 8, 12, 10, 1, -12 },
  { 524, 8, 12, 10, 2, -12 },
  { 536, 9, 12, 10, 1, -12 },
  { 550, 8, 12, 10, 2, -12 },
  { 562, 9, 12, 10, 2, -12 },
  { 576, 10, 12, 10, 0, -12 },
  { 591, 8, 12, 10, 2, -12 },
  { 603, 9, 12, 10, 0, -12 },
  { 617, 5, 17, 10, 3, -14 },
  { 628, 4, 13, 10, 3, -12 },
  { 635, 5, 17, 10, 2, -14 },
  { 646, 6, 7, 10, 2, -12 },
  { 652, 6, 1, 10, 1, 0 },
  { 653, 2, 3, 10, 5, -13 },
  { 654, 8, 9, 10, 1, -9 },
  { 663, 8, 13, 10, 1, -13 },
  { 676, 8, 9, 10, 1, -9 },
  { 685, 8, 13, 10, 1, -13 },
  { 698, 8, 9, 10, 1, -9 },
  { 707, 8, 13, 10, 2, -13 },
  { 720, 8, 13, 10, 1, -9 },
  { 733, 8, 13, 10, 1, -13 },
  { 746, 7, 12, 10, 1, -12 },
  { 757, 8, 16, 10, 0, -12 },
  { 773, 8, 13, 10, 1, -13 },
  { 786, 7, 13, 10, 1, -13 },
  { 798, 10, 9, 10, 0, -9 },
  { 810, 8, 9, 10, 1, -9 },
  { 819, 8, 9, 10, 1, -9 },
  { 828, 8, 12, 10, 0, -9 },
  { 840, 8, 12, 10, 1, -9 },
  { 852, 7, 9, 10, 2, -9 },
  { 860, 8, 9, 10, 1, -9 },
  { 869, 6, 11, 10, 2, -11 },
  { 878, 8, 9, 10, 1, -9 },
  { 887, 8, 9, 10, 2, -9 },
  { 896, 9, 9, 10, 1, -9 },
  { 907, 9, 9, 10, 0, -9 },
  { 918, 10, 13, 10, 0, -9 },
  { 935, 9, 9, 10, 0, -9 },
  { 946, 6, 17, 10, 3, -13 },
  { 959, 2, 14, 10, 4, -12 },
  { 963, 7, 17, 10, 1, -13 },
  { 978, 10, 2, 10, 0, -6 },
};

const GFXfont RobotoMono_ThinItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic17pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_THINITALIC17PT7B_H_
