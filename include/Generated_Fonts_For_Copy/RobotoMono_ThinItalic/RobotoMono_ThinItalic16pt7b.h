#ifndef _ROBOTOMONO_THINITALIC16PT7B_H_
#define _ROBOTOMONO_THINITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x92, 0x02, 0x00, 0xB6, 0x80, 0x04, 0x82, 0x40, 0x94,
  0xDE, 0x12, 0x04, 0x82, 0x23, 0xFC, 0x24, 0x11, 0x04, 0x80, 0x04, 0x0C,
  0x32, 0x41, 0x41, 0x40, 0x20, 0x1C, 0x02, 0x02, 0x82, 0x82, 0x6C, 0x10,
  0x10, 0x60, 0x90, 0x92, 0x94, 0x94, 0x68, 0x10, 0x27, 0x29, 0x49, 0x89,
  0x0E, 0x18, 0x24, 0x24, 0x24, 0x28, 0x10, 0x70, 0x89, 0x8A, 0x86, 0x84,
  0x7A, 0xE0, 0x08, 0x88, 0x84, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08,
  0x40, 0x22, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x80, 0x11, 0x25,
  0xF1, 0x84, 0x88, 0x80, 0x08, 0x08, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x58, 0xF8, 0x80, 0x03, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0x80, 0x1C, 0x22, 0x41, 0x41, 0x47, 0x89, 0x92, 0xA2, 0xC2,
  0x82, 0x84, 0x78, 0x79, 0x22, 0x22, 0x24, 0x44, 0x40, 0x0C, 0x33, 0x21,
  0x41, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x0E, 0x11, 0x21,
  0x41, 0x01, 0x02, 0x1C, 0x02, 0x01, 0x82, 0x82, 0x7C, 0x03, 0x05, 0x0A,
  0x0A, 0x12, 0x22, 0x42, 0xFF, 0x04, 0x04, 0x04, 0x3F, 0x20, 0x20, 0x40,
  0x7C, 0x02, 0x02, 0x02, 0x82, 0x84, 0x78, 0x06, 0x30, 0x82, 0x05, 0x8C,
  0xA0, 0xC1, 0x83, 0x06, 0x13, 0xC0, 0xFE, 0x08, 0x10, 0x40, 0x82, 0x08,
  0x10, 0x40, 0x82, 0x00, 0x0C, 0x32, 0x41, 0x41, 0x41, 0x22, 0x3C, 0x42,
  0x82, 0x82, 0x82, 0x7C, 0x39, 0x18, 0x61, 0x86, 0x18, 0x67, 0x64, 0x21,
  0x38, 0x40, 0x02, 0x20, 0x00, 0x02, 0x50, 0x06, 0x73, 0x03, 0x01, 0x80,
  0x80, 0x7E, 0x00, 0x07, 0xF0, 0x60, 0x30, 0x18, 0x63, 0x18, 0x00, 0x36,
  0x62, 0x10, 0x88, 0x88, 0x40, 0x01, 0x00, 0x1F, 0x90, 0x53, 0xAA, 0x55,
  0x2D, 0x16, 0x93, 0x49, 0x9B, 0x20, 0x0F, 0x00, 0x04, 0x0A, 0x0A, 0x0A,
  0x12, 0x12, 0x22, 0x3E, 0x41, 0x41, 0x81, 0x7E, 0x41, 0x41, 0x42, 0x44,
  0xBC, 0x82, 0x82, 0x82, 0x82, 0xFC, 0x1C, 0x22, 0x41, 0x41, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x82, 0x84, 0x78, 0x7E, 0x41, 0x41, 0x41, 0x41, 0x81,
  0x81, 0x82, 0x82, 0x84, 0xF8, 0x7F, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x80,
  0x80, 0x80, 0x80, 0xFC, 0x7F, 0x40, 0x40, 0x40, 0x40, 0x7E, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1C, 0x22, 0x41, 0x41, 0x80, 0x80, 0x80, 0x8E, 0x82,
  0x82, 0x82, 0x7C, 0x41, 0x41, 0x41, 0x41, 0x81, 0xFE, 0x82, 0x82, 0x82,
  0x82, 0x82, 0x3F, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFC, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x84, 0x84, 0xF8,
  0x41, 0xA1, 0x11, 0x09, 0x05, 0x03, 0x81, 0x21, 0x10, 0x84, 0x42, 0x20,
  0x80, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x0F, 0xC0, 0x41, 0x63,
  0x63, 0x65, 0xA5, 0x99, 0x92, 0x82, 0x82, 0x82, 0x82, 0x41, 0x61, 0x61,
  0x51, 0x91, 0x92, 0x8A, 0x8A, 0x86, 0x84, 0x84, 0x1C, 0x22, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x78, 0x3F, 0x41, 0x41, 0x41,
  0x41, 0x7E, 0x40, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x22, 0x41, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x08, 0x04, 0x7E, 0x41, 0x41,
  0x41, 0x42, 0x74, 0x88, 0x84, 0x84, 0x84, 0x82, 0x1C, 0x22, 0x41, 0x41,
  0x40, 0x30, 0x0C, 0x02, 0x02, 0x82, 0x82, 0x7C, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x41, 0x41, 0x41, 0x41, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x83, 0x82, 0x84, 0x84, 0x88, 0x88,
  0x48, 0x50, 0x50, 0x60, 0x40, 0x91, 0x91, 0xB2, 0xB2, 0xAA, 0xCC, 0xCC,
  0x8C, 0x88, 0x88, 0x88, 0x20, 0xC4, 0x41, 0x10, 0x28, 0x0C, 0x02, 0x01,
  0x40, 0x48, 0x22, 0x10, 0x88, 0x10, 0x83, 0x82, 0x44, 0x48, 0x50, 0x30,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x3F, 0x80, 0x19, 0x08, 0x42, 0x10, 0x88, 0x42,
  0x10, 0x84, 0x23, 0x80, 0x91, 0x24, 0x91, 0x24, 0x90, 0x18, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x84, 0x42, 0x13, 0x80, 0x11, 0x4A, 0x94, 0xC4, 0xFC,
  0xC0, 0x1C, 0xC5, 0x08, 0x13, 0xF8, 0x60, 0xC2, 0xFC, 0x20, 0x81, 0x02,
  0xE6, 0x28, 0x50, 0xC1, 0x83, 0x06, 0x17, 0xC0, 0x1C, 0x45, 0x0C, 0x08,
  0x10, 0x20, 0xC2, 0x78, 0x01, 0x01, 0x01, 0x1D, 0x22, 0x42, 0x82, 0x82,
  0x82, 0x82, 0x84, 0x7C, 0x1C, 0x45, 0x0C, 0x1F, 0xD0, 0x20, 0x40, 0x7C,
  0x0F, 0x10, 0x20, 0xFC, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x1C, 0x45, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x7C, 0x08, 0x17, 0xC0, 0x40,
  0x81, 0x02, 0xE6, 0x28, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x20, 0x04, 0x07,
  0x02, 0x08, 0x21, 0x04, 0x10, 0x4F, 0xC0, 0x02, 0x00, 0x70, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x9E, 0x00, 0x20, 0x20, 0x40, 0x41,
  0x46, 0x48, 0x50, 0x60, 0x90, 0x88, 0x84, 0x84, 0x3C, 0x10, 0x82, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x3F, 0x3B, 0x22, 0x52, 0x31, 0x18, 0x8C, 0x46,
  0x23, 0x12, 0x91, 0x00, 0x1C, 0xC5, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84,
  0x1C, 0xC5, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x78, 0x0E, 0x31, 0x21, 0x21,
  0x41, 0x41, 0x41, 0x42, 0x7C, 0x80, 0x80, 0x80, 0x1C, 0x45, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0x7C, 0x08, 0x10, 0x20, 0x0E, 0xE1, 0x02, 0x04, 0x10,
  0x20, 0x40, 0x80, 0x1C, 0xC5, 0x0A, 0x03, 0x80, 0x80, 0xC1, 0x7C, 0x10,
  0x8F, 0xC8, 0x20, 0x82, 0x10, 0x41, 0x03, 0x80, 0x42, 0x86, 0x0C, 0x18,
  0x30, 0x61, 0x3E, 0x81, 0x42, 0x42, 0x44, 0x28, 0x28, 0x30, 0x20, 0x89,
  0xCC, 0xA6, 0x55, 0x4A, 0xA6, 0x61, 0x11, 0x08, 0x21, 0x89, 0x05, 0x01,
  0x01, 0x40, 0xA0, 0x89, 0x82, 0x40, 0x90, 0x88, 0x44, 0x42, 0x20, 0xA0,
  0x60, 0x10, 0x10, 0x10, 0x38, 0x00, 0x3F, 0x81, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xFE, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08, 0x60, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x0C, 0x00, 0x24, 0x94, 0x92, 0x49, 0x48, 0x18, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x03, 0x08, 0x20, 0x40, 0x81, 0x04, 0x30, 0x00,
  0x70, 0xC6, 0x40, 0xC0,
};

const GFXglyph RobotoMono_ThinItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 3, 3, 9, 4, -12 },
  { 8, 10, 11, 9, 0, -11 },
  { 22, 8, 15, 9, 1, -13 },
  { 37, 8, 12, 9, 1, -12 },
  { 49, 8, 12, 9, 1, -12 },
  { 61, 1, 3, 9, 5, -12 },
  { 62, 5, 17, 9, 3, -13 },
  { 73, 4, 17, 9, 2, -13 },
  { 82, 7, 6, 9, 2, -11 },
  { 88, 8, 8, 9, 1, -9 },
  { 96, 2, 3, 9, 2, -1 },
  { 97, 5, 1, 9, 2, -6 },
  { 98, 1, 1, 9, 4, -1 },
  { 99, 8, 12, 9, 1, -11 },
  { 111, 8, 12, 9, 1, -12 },
  { 123, 4, 11, 9, 3, -11 },
  { 129, 8, 12, 9, 0, -12 },
  { 141, 8, 12, 9, 0, -12 },
  { 153, 8, 11, 9, 0, -11 },
  { 164, 8, 11, 9, 1, -11 },
  { 175, 7, 12, 9, 1, -12 },
  { 186, 7, 11, 9, 2, -11 },
  { 196, 8, 12, 9, 1, -12 },
  { 208, 6, 12, 9, 2, -12 },
  { 217, 2, 8, 9, 4, -8 },
  { 219, 3, 10, 9, 3, -8 },
  { 223, 7, 6, 9, 1, -8 },
  { 229, 7, 4, 9, 1, -7 },
  { 233, 7, 6, 9, 1, -8 },
  { 239, 5, 12, 9, 3, -12 },
  { 247, 9, 11, 9, 0, -11 },
  { 260, 8, 11, 9, 0, -11 },
  { 271, 8, 11, 9, 1, -11 },
  { 282, 8, 12, 9, 1, -12 },
  { 294, 8, 11, 9, 1, -11 },
  { 305, 8, 11, 9, 1, -11 },
  { 316, 8, 11, 9, 1, -11 },
  { 327, 8, 12, 9, 1, -12 },
  { 339, 8, 11, 9, 1, -11 },
  { 350, 8, 11, 9, 1, -11 },
  { 361, 8, 11, 9, 1, -11 },
  { 372, 9, 11, 9, 1, -11 },
  { 385, 6, 11, 9, 1, -11 },
  { 394, 8, 11, 9, 1, -11 },
  { 405, 8, 11, 9, 1, -11 },
  { 416, 8, 12, 9, 1, -12 },
  { 428, 8, 11, 9, 1, -11 },
  { 439, 8, 14, 9, 1, -12 },
  { 453, 8, 11, 9, 1, -11 },
  { 464, 8, 12, 9, 1, -12 },
  { 476, 8, 11, 9, 2, -11 },
  { 487, 8, 11, 9, 1, -11 },
  { 498, 8, 11, 9, 2, -11 },
  { 509, 8, 11, 9, 2, -11 },
  { 520, 10, 11, 9, 0, -11 },
  { 534, 8, 11, 9, 2, -11 },
  { 545, 9, 11, 9, 0, -11 },
  { 558, 5, 15, 9, 2, -13 },
  { 568, 3, 12, 9, 3, -11 },
  { 573, 5, 15, 9, 2, -13 },
  { 583, 5, 6, 9, 2, -11 },
  { 587, 6, 1, 9, 1, 0 },
  { 588, 1, 2, 9, 5, -12 },
  { 589, 7, 9, 9, 1, -9 },
  { 597, 7, 12, 9, 1, -12 },
  { 608, 7, 9, 9, 1, -9 },
  { 616, 8, 12, 9, 1, -12 },
  { 628, 7, 9, 9, 1, -9 },
  { 636, 8, 12, 9, 2, -12 },
  { 648, 7, 12, 9, 1, -9 },
  { 659, 7, 12, 9, 1, -12 },
  { 670, 6, 11, 9, 1, -11 },
  { 679, 7, 14, 9, 0, -11 },
  { 692, 8, 12, 9, 1, -12 },
  { 704, 6, 12, 9, 1, -12 },
  { 713, 9, 9, 9, 0, -9 },
  { 724, 7, 9, 9, 1, -9 },
  { 732, 7, 9, 9, 1, -9 },
  { 740, 8, 12, 9, 0, -9 },
  { 752, 7, 12, 9, 1, -9 },
  { 763, 7, 9, 9, 2, -9 },
  { 771, 7, 9, 9, 1, -9 },
  { 779, 6, 11, 9, 2, -11 },
  { 788, 7, 8, 9, 1, -8 },
  { 795, 8, 8, 9, 1, -8 },
  { 803, 9, 8, 9, 1, -8 },
  { 812, 9, 8, 9, 0, -8 },
  { 821, 9, 11, 9, 0, -8 },
  { 834, 9, 8, 9, 0, -8 },
  { 843, 7, 15, 9, 2, -12 },
  { 857, 3, 13, 9, 3, -11 },
  { 862, 7, 15, 9, 1, -12 },
  { 876, 9, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_ThinItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic16pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_THINITALIC16PT7B_H_
