#ifndef _ROBOTOMONO_THINITALIC21PT7B_H_
#define _ROBOTOMONO_THINITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x22, 0x44, 0x40, 0x00, 0xC0, 0x55, 0x99, 0x90,
  0x02, 0x10, 0x22, 0x02, 0x20, 0x44, 0x3F, 0xF0, 0x44, 0x08, 0x80, 0x88,
  0x08, 0x81, 0x10, 0xFF, 0xE2, 0x10, 0x22, 0x02, 0x20, 0x42, 0x00, 0x01,
  0x00, 0x80, 0xD8, 0x41, 0x20, 0x48, 0x12, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x02, 0x00, 0xA0, 0x28, 0x09, 0x04, 0x36, 0x02, 0x00, 0x80, 0x38,
  0x12, 0x08, 0x8E, 0x22, 0x89, 0x22, 0x87, 0x20, 0x10, 0x09, 0x84, 0x91,
  0x24, 0x91, 0x44, 0x51, 0x10, 0x38, 0x0F, 0x04, 0x21, 0x08, 0x44, 0x12,
  0x05, 0x00, 0x80, 0x60, 0x24, 0x11, 0x18, 0x26, 0x06, 0x81, 0xA0, 0x67,
  0xE4, 0x5A, 0x80, 0x04, 0x21, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x40, 0x80, 0x10, 0x20, 0x81, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x42,
  0x00, 0x08, 0x04, 0x02, 0x1D, 0x71, 0xC0, 0xC0, 0x90, 0x84, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x56, 0x80, 0xFF, 0x80, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x1F, 0x10,
  0x50, 0x28, 0x18, 0x1C, 0x16, 0x13, 0x11, 0x90, 0xD0, 0x70, 0x50, 0x28,
  0x24, 0x11, 0xF0, 0x0C, 0xDC, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x00, 0x1F, 0x10, 0x50, 0x28, 0x10, 0x08, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0xFC, 0x1F, 0x08, 0x22, 0x05,
  0x01, 0x00, 0x40, 0x20, 0x10, 0x78, 0x01, 0x00, 0x20, 0x0A, 0x02, 0x81,
  0x20, 0x47, 0xE0, 0x00, 0x80, 0x60, 0x28, 0x12, 0x05, 0x02, 0x41, 0x10,
  0x84, 0x41, 0x20, 0x4F, 0xFC, 0x08, 0x02, 0x00, 0x80, 0x20, 0x1F, 0xC8,
  0x02, 0x00, 0x80, 0x20, 0x13, 0x07, 0x20, 0x04, 0x00, 0x80, 0x20, 0x0A,
  0x04, 0x81, 0x20, 0x87, 0xC0, 0x03, 0x86, 0x04, 0x04, 0x02, 0x02, 0xF1,
  0x86, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x08, 0xF8, 0xFF, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x02, 0x00, 0x0F, 0x82, 0x08, 0x80, 0x90, 0x12, 0x04, 0x40, 0x84,
  0x20, 0xF8, 0x20, 0x88, 0x0A, 0x01, 0x40, 0x28, 0x08, 0x83, 0x0F, 0x80,
  0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x43, 0x1E, 0x80,
  0x40, 0x40, 0x20, 0x61, 0xC0, 0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x00, 0x24, 0x44, 0x80, 0x01, 0x83, 0x06, 0x0C, 0x08, 0x03, 0x80, 0x30,
  0x06, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x01, 0xC1, 0x81, 0x83, 0x80, 0x3E, 0x41, 0x41, 0x81, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x00, 0x00, 0x00, 0x60, 0x07, 0xE0, 0x81,
  0x10, 0x12, 0x39, 0x24, 0x94, 0x89, 0x48, 0x95, 0x09, 0x91, 0x19, 0x11,
  0x93, 0x29, 0xDC, 0x40, 0x04, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x40, 0x28,
  0x0A, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10, 0x44, 0x13, 0xFC, 0x81, 0x40,
  0x50, 0x18, 0x04, 0x1F, 0x88, 0x12, 0x04, 0x81, 0x20, 0x50, 0x14, 0x09,
  0xFC, 0x40, 0x90, 0x14, 0x06, 0x01, 0x80, 0xA0, 0x4F, 0xE0, 0x0F, 0x82,
  0x08, 0x81, 0x10, 0x14, 0x02, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x01, 0x40, 0x48, 0x08, 0x82, 0x0F, 0x80, 0x3F, 0x04, 0x10, 0x81, 0x10,
  0x24, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x48,
  0x11, 0x04, 0x3F, 0x00, 0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x03, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F,
  0xC0, 0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x01, 0xFC,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F, 0x82,
  0x08, 0x81, 0x20, 0x14, 0x00, 0x80, 0x10, 0x04, 0x00, 0x87, 0xD0, 0x0A,
  0x01, 0x40, 0x28, 0x08, 0x81, 0x0F, 0xC0, 0x20, 0x24, 0x04, 0x80, 0xA0,
  0x14, 0x04, 0x80, 0x90, 0x13, 0xFE, 0x40, 0x50, 0x0A, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x20, 0x20, 0x1F, 0xE0, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x3F,
  0xC0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x0A, 0x02, 0x81, 0x20, 0x87, 0xC0, 0x20, 0x32, 0x04, 0x20,
  0x82, 0x10, 0x22, 0x02, 0x40, 0x48, 0x05, 0x80, 0x64, 0x04, 0x40, 0x42,
  0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0x40, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x03, 0xFE,
  0x20, 0x24, 0x0C, 0xC1, 0x98, 0x55, 0x0A, 0xA2, 0x92, 0x92, 0x52, 0x4C,
  0x48, 0x8A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20, 0x20, 0x24, 0x04,
  0xC0, 0xA8, 0x14, 0x84, 0x90, 0x92, 0x12, 0x22, 0x44, 0x50, 0x4A, 0x0A,
  0x41, 0x48, 0x19, 0x03, 0x20, 0x20, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0x90, 0x43,
  0xE0, 0x1F, 0x84, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x12, 0x04,
  0x7F, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x0F, 0x82,
  0x08, 0x81, 0x20, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x48, 0x08, 0x82, 0x0F, 0x80, 0x10, 0x01, 0x00, 0x20, 0x1F,
  0x88, 0x12, 0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x06, 0x7E, 0x10, 0x84,
  0x11, 0x04, 0x81, 0x20, 0x28, 0x08, 0x0F, 0x82, 0x08, 0x80, 0x90, 0x12,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x40, 0x28, 0x08,
  0x81, 0x0F, 0xC0, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x20, 0x24,
  0x04, 0x80, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A,
  0x02, 0x40, 0x48, 0x08, 0x82, 0x0F, 0x80, 0x80, 0x60, 0x14, 0x05, 0x02,
  0x40, 0x90, 0x44, 0x11, 0x08, 0x22, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0C,
  0x01, 0x00, 0x84, 0x30, 0x86, 0x10, 0xC6, 0x28, 0xC5, 0x28, 0xA5, 0x24,
  0xA4, 0xA4, 0x94, 0x62, 0x8C, 0x61, 0x8C, 0x21, 0x04, 0x20, 0x80, 0x10,
  0x18, 0x80, 0x82, 0x08, 0x10, 0x80, 0x48, 0x02, 0x40, 0x0C, 0x00, 0x40,
  0x05, 0x00, 0x48, 0x02, 0x40, 0x21, 0x02, 0x08, 0x20, 0x23, 0x01, 0x00,
  0x80, 0x68, 0x09, 0x02, 0x20, 0x82, 0x10, 0x44, 0x09, 0x00, 0xA0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x1F, 0xE0, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xE0, 0x1C, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x38, 0x88, 0x44, 0x44,
  0x42, 0x22, 0x22, 0x11, 0x11, 0x1C, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x38, 0x08, 0x30, 0x51, 0x22,
  0x48, 0xA0, 0xC1, 0xFF, 0x94, 0x1F, 0x88, 0x24, 0x04, 0x01, 0x00, 0x8F,
  0xE4, 0x0A, 0x02, 0x80, 0xA0, 0xC7, 0xC8, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0F, 0xC2, 0x09, 0x01, 0x40, 0x50, 0x14, 0x05, 0x02, 0x40, 0xA0,
  0x4C, 0x12, 0xF8, 0x3E, 0x20, 0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0x81, 0x41, 0x1F, 0x00, 0x00, 0x40, 0x10, 0x08, 0x02, 0x08, 0x8D, 0xA4,
  0x1A, 0x02, 0x81, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x21, 0xF8,
  0x1F, 0x08, 0x24, 0x05, 0x01, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x63, 0xE0, 0x07, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x1F, 0x48,
  0x34, 0x05, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0x90, 0x43, 0xF0,
  0x04, 0x01, 0x20, 0x87, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x22, 0x0B,
  0x65, 0x04, 0x81, 0x40, 0x50, 0x14, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A,
  0x02, 0x03, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x80, 0x43, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x0F, 0x80, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x12, 0x18, 0x88, 0x24, 0x16, 0x06, 0x81, 0x10, 0x44, 0x10, 0x84,
  0x12, 0x02, 0x1F, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x21, 0xFF, 0x5F, 0xF6, 0x21, 0x42,
  0x14, 0x21, 0x42, 0x18, 0x41, 0x84, 0x28, 0x42, 0x84, 0x28, 0x42, 0x84,
  0x20, 0x2F, 0x94, 0x22, 0x05, 0x01, 0x40, 0x50, 0x24, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x10, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x02, 0x80, 0x90, 0x43, 0xE0, 0x1F, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48,
  0x12, 0x05, 0x01, 0x40, 0x98, 0x25, 0xF1, 0x00, 0x40, 0x20, 0x08, 0x00,
  0x3E, 0xA0, 0xE0, 0x30, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x1F,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x4F, 0xA8, 0x18, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1F, 0x88, 0x12, 0x04, 0x80, 0x10,
  0x03, 0x80, 0x18, 0x02, 0x80, 0x90, 0x23, 0xF0, 0x10, 0x20, 0x47, 0xF2,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x07, 0x80, 0x40, 0xC0, 0x60,
  0x30, 0x18, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x1F, 0x80, 0x80, 0x60,
  0x28, 0x11, 0x04, 0x42, 0x10, 0x84, 0x40, 0x90, 0x28, 0x0C, 0x01, 0x00,
  0x88, 0x62, 0x19, 0x46, 0x52, 0x94, 0xA9, 0x4A, 0x53, 0x14, 0xC6, 0x21,
  0x88, 0x40, 0x60, 0x64, 0x10, 0x44, 0x05, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x90, 0x21, 0x08, 0x22, 0x02, 0x00, 0x20, 0x12, 0x02, 0x20, 0x21, 0x04,
  0x10, 0x41, 0x08, 0x11, 0x00, 0x90, 0x0A, 0x00, 0xA0, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x00, 0x03, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x11, 0x12, 0x22, 0x22, 0x22, 0x44,
  0x44, 0x44, 0x88, 0x18, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x02, 0x03, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x40, 0x80,
  0x38, 0x14, 0x41, 0x83, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 4, 5, 12, 5, -16 },
  { 12, 12, 15, 12, 0, -15 },
  { 35, 10, 19, 12, 1, -17 },
  { 59, 10, 15, 12, 1, -15 },
  { 78, 10, 15, 12, 1, -15 },
  { 97, 2, 5, 12, 6, -16 },
  { 99, 6, 22, 12, 4, -17 },
  { 116, 6, 22, 12, 2, -17 },
  { 133, 9, 8, 12, 3, -15 },
  { 142, 10, 11, 12, 1, -12 },
  { 156, 2, 5, 12, 3, -2 },
  { 158, 8, 1, 12, 2, -7 },
  { 159, 1, 1, 12, 5, -1 },
  { 160, 9, 16, 12, 2, -15 },
  { 178, 9, 15, 12, 2, -15 },
  { 195, 6, 15, 12, 3, -15 },
  { 207, 9, 15, 12, 1, -15 },
  { 224, 10, 15, 12, 1, -15 },
  { 243, 10, 15, 12, 1, -15 },
  { 262, 10, 15, 12, 2, -15 },
  { 281, 9, 15, 12, 1, -15 },
  { 298, 9, 15, 12, 3, -15 },
  { 315, 11, 15, 12, 1, -15 },
  { 336, 9, 15, 12, 2, -15 },
  { 353, 3, 10, 12, 5, -10 },
  { 357, 4, 13, 12, 4, -10 },
  { 364, 9, 8, 12, 2, -11 },
  { 373, 10, 5, 12, 1, -9 },
  { 380, 10, 8, 12, 1, -11 },
  { 390, 8, 15, 12, 3, -15 },
  { 405, 12, 15, 12, 0, -15 },
  { 428, 10, 15, 12, 0, -15 },
  { 447, 10, 15, 12, 1, -15 },
  { 466, 11, 15, 12, 1, -15 },
  { 487, 11, 15, 12, 1, -15 },
  { 508, 11, 15, 12, 1, -15 },
  { 529, 11, 15, 12, 1, -15 },
  { 550, 11, 15, 12, 1, -15 },
  { 571, 11, 15, 12, 1, -15 },
  { 592, 11, 15, 12, 1, -15 },
  { 613, 10, 15, 12, 1, -15 },
  { 632, 12, 15, 12, 1, -15 },
  { 655, 9, 15, 12, 1, -15 },
  { 672, 11, 15, 12, 1, -15 },
  { 693, 11, 15, 12, 1, -15 },
  { 714, 10, 15, 12, 1, -15 },
  { 733, 11, 15, 12, 1, -15 },
  { 754, 11, 18, 12, 1, -15 },
  { 779, 10, 15, 12, 1, -15 },
  { 798, 11, 15, 12, 1, -15 },
  { 819, 10, 15, 12, 3, -15 },
  { 838, 11, 15, 12, 1, -15 },
  { 859, 10, 15, 12, 2, -15 },
  { 878, 11, 15, 12, 2, -15 },
  { 899, 13, 15, 12, 0, -15 },
  { 924, 11, 15, 12, 2, -15 },
  { 945, 11, 15, 12, 0, -15 },
  { 966, 6, 20, 12, 3, -17 },
  { 981, 4, 16, 12, 4, -15 },
  { 989, 6, 20, 12, 3, -17 },
  { 1004, 7, 8, 12, 3, -15 },
  { 1011, 8, 1, 12, 1, 0 },
  { 1012, 2, 3, 12, 6, -16 },
  { 1013, 10, 11, 12, 1, -11 },
  { 1027, 10, 16, 12, 1, -16 },
  { 1047, 9, 11, 12, 2, -11 },
  { 1060, 10, 16, 12, 2, -16 },
  { 1080, 10, 11, 12, 1, -11 },
  { 1094, 10, 16, 12, 3, -16 },
  { 1114, 10, 15, 12, 1, -11 },
  { 1133, 10, 16, 12, 1, -16 },
  { 1153, 9, 15, 12, 1, -15 },
  { 1170, 10, 19, 12, 0, -15 },
  { 1194, 10, 16, 12, 1, -16 },
  { 1214, 9, 16, 12, 1, -16 },
  { 1232, 12, 11, 12, 0, -11 },
  { 1249, 10, 11, 12, 1, -11 },
  { 1263, 10, 11, 12, 1, -11 },
  { 1277, 10, 15, 12, 0, -11 },
  { 1296, 9, 15, 12, 2, -11 },
  { 1313, 9, 11, 12, 3, -11 },
  { 1326, 10, 11, 12, 1, -11 },
  { 1340, 7, 14, 12, 3, -14 },
  { 1353, 9, 11, 12, 2, -11 },
  { 1366, 10, 11, 12, 2, -11 },
  { 1380, 10, 11, 12, 2, -11 },
  { 1394, 11, 11, 12, 1, -11 },
  { 1410, 12, 15, 12, 0, -11 },
  { 1433, 11, 11, 12, 0, -11 },
  { 1449, 8, 21, 12, 3, -16 },
  { 1470, 4, 18, 12, 4, -15 },
  { 1479, 8, 21, 12, 2, -16 },
  { 1500, 12, 3, 12, 0, -8 },
};

const GFXfont RobotoMono_ThinItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic21pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_THINITALIC21PT7B_H_
