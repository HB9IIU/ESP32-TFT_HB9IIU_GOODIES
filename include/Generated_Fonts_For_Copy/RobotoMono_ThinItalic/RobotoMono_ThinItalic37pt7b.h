#ifndef _ROBOTOMONO_THINITALIC37PT7B_H_
#define _ROBOTOMONO_THINITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x22, 0x85, 0x0A,
  0x14, 0x48, 0x91, 0x42, 0x00, 0x08, 0x10, 0x00, 0x40, 0x40, 0x01, 0x02,
  0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81, 0x00, 0x04, 0x04, 0x03,
  0xFF, 0xFF, 0x00, 0x40, 0x80, 0x02, 0x02, 0x00, 0x08, 0x10, 0x00, 0x20,
  0x40, 0x01, 0x01, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x80, 0x80,
  0x02, 0x04, 0x00, 0x08, 0x10, 0x0F, 0xFF, 0xFE, 0x01, 0x02, 0x00, 0x04,
  0x08, 0x00, 0x20, 0x20, 0x00, 0x81, 0x00, 0x06, 0x04, 0x00, 0x10, 0x30,
  0x00, 0x40, 0x80, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x38, 0xE0, 0x30, 0x18, 0x20, 0x04, 0x30, 0x03, 0x10, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x03, 0x20,
  0x01, 0x08, 0x01, 0x02, 0x03, 0x00, 0xFF, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x02, 0x08, 0x01,
  0x02, 0x00, 0x40, 0x81, 0x90, 0x20, 0xC8, 0x08, 0x22, 0x02, 0x10, 0x81,
  0x08, 0x20, 0x42, 0x04, 0x21, 0x01, 0xF0, 0x80, 0x10, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x1C, 0x01, 0x08, 0x80, 0x84, 0x10, 0x42, 0x04,
  0x10, 0x81, 0x08, 0x20, 0x44, 0x10, 0x13, 0x04, 0x04, 0x81, 0x02, 0x60,
  0x40, 0x80, 0x08, 0x40, 0x03, 0xE0, 0x00, 0x20, 0x00, 0x76, 0x00, 0x30,
  0x40, 0x08, 0x10, 0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x30,
  0x04, 0x18, 0x01, 0x0C, 0x00, 0x66, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x88, 0x00, 0x43, 0x00, 0x20, 0x40, 0x58, 0x08, 0x24, 0x02,
  0x0A, 0x00, 0x46, 0x80, 0x09, 0x20, 0x02, 0xC8, 0x00, 0x62, 0x00, 0x18,
  0x40, 0x1A, 0x08, 0x0C, 0x41, 0xFC, 0x18, 0x55, 0x6A, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80,
  0x82, 0x71, 0x0F, 0x1D, 0x70, 0x03, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08,
  0x40, 0x10, 0x20, 0x20, 0x30, 0x60, 0x10, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x24, 0x94, 0xA4, 0xFF, 0xF8, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x01, 0xCE,
  0x01, 0x80, 0x81, 0x00, 0x21, 0x80, 0x10, 0x80, 0x08, 0x80, 0x02, 0x40,
  0x03, 0x20, 0x02, 0xA0, 0x02, 0x50, 0x02, 0x28, 0x06, 0x24, 0x06, 0x14,
  0x04, 0x0A, 0x04, 0x05, 0x04, 0x02, 0x84, 0x01, 0x44, 0x01, 0x2C, 0x00,
  0x9C, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x40,
  0x10, 0x10, 0x30, 0x07, 0xF0, 0x00, 0x01, 0x83, 0x4E, 0x38, 0x28, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x00, 0x70, 0x00, 0xC7, 0x01, 0x80, 0xC1, 0x80, 0x20, 0x80, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x40, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x73, 0x80, 0x20, 0x10, 0x10, 0x02, 0x08, 0x00, 0x86, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x21, 0x00, 0x18, 0x60, 0x0C, 0x0C, 0x06, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x34, 0x00, 0x19, 0x00, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x08, 0x00, 0x82, 0x00, 0x60, 0x80, 0x10, 0x20,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0xC0, 0x10, 0x20,
  0x04, 0x10, 0x01, 0x0F, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0xFF,
  0xC1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x10, 0x01, 0x73, 0x80, 0x60,
  0x30, 0x30, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x10, 0x01, 0x04,
  0x00, 0xC1, 0x80, 0x60, 0x30, 0x30, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x23, 0xF8, 0x2C, 0x04, 0x50, 0x02, 0x60,
  0x02, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0x20, 0x08, 0x10,
  0x30, 0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x79, 0xC0,
  0x30, 0x18, 0x10, 0x03, 0x0C, 0x00, 0x42, 0x00, 0x11, 0x80, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x20, 0x80, 0x08, 0x30, 0x0C, 0x06, 0x06,
  0x00, 0x7E, 0x00, 0x60, 0xC0, 0x60, 0x08, 0x20, 0x01, 0x18, 0x00, 0x44,
  0x00, 0x09, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x11, 0x00,
  0x08, 0x40, 0x04, 0x0C, 0x06, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x0C, 0x70,
  0x20, 0x30, 0x80, 0x22, 0x00, 0x28, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x02,
  0xA0, 0x0E, 0x60, 0x34, 0x37, 0x88, 0x10, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x01, 0xF0, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x80, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x73, 0x0C, 0x04, 0x40, 0x14, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xDE, 0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x60, 0x01, 0x06, 0x00,
  0x08, 0x60, 0xF0, 0x42, 0x08, 0x63, 0x30, 0x82, 0x09, 0x08, 0x10, 0x58,
  0x40, 0x84, 0x84, 0x08, 0x24, 0x20, 0x41, 0x42, 0x02, 0x0A, 0x10, 0x10,
  0x50, 0x81, 0x02, 0x84, 0x08, 0x24, 0x20, 0xC1, 0x21, 0x06, 0x11, 0x08,
  0x50, 0x88, 0x44, 0x88, 0x41, 0xC3, 0x83, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x60, 0x03, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20,
  0x01, 0x08, 0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x10, 0x04, 0x04, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x02, 0x04, 0x00, 0x83, 0xFF,
  0xE0, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x05,
  0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x10, 0x0F, 0xFC, 0x02, 0x00, 0xC0,
  0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0x3F, 0xF8,
  0x08, 0x01, 0x82, 0x00, 0x30, 0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC8, 0x00, 0x22, 0x00,
  0x30, 0x80, 0x18, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x71, 0x80, 0x30,
  0x10, 0x10, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x0A, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x10,
  0x20, 0x08, 0x04, 0x0C, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x02, 0x00, 0x80,
  0x80, 0x10, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x05, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00,
  0x60, 0x80, 0x60, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x03, 0xFF,
  0xE0, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xE0, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x79, 0x80, 0x30, 0x18, 0x10, 0x02, 0x08, 0x00, 0x46, 0x00, 0x11,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x01, 0xFE, 0x80, 0x00,
  0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x04, 0x20, 0x02, 0x04, 0x03, 0x00, 0xFF, 0x00, 0x04,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x04,
  0x10, 0x00, 0x41, 0x00, 0x04, 0x1F, 0xFF, 0xC2, 0x00, 0x04, 0x20, 0x00,
  0x42, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x84, 0x00,
  0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x0F, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x21, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x20, 0x80, 0x04, 0x10, 0x01,
  0x03, 0x00, 0x40, 0x30, 0x30, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x30, 0x80,
  0x06, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x01, 0x01, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x10, 0x80, 0x01,
  0x10, 0x00, 0x27, 0x80, 0x02, 0xC8, 0x00, 0x38, 0x40, 0x02, 0x04, 0x00,
  0x20, 0x20, 0x02, 0x03, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x40, 0x08,
  0x04, 0x00, 0x40, 0x40, 0x06, 0x04, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00,
  0x18, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0xFF, 0xFC, 0x04, 0x00, 0x30, 0x60, 0x03, 0x0A, 0x00, 0x50, 0xA0, 0x05,
  0x0A, 0x00, 0x90, 0xA0, 0x0A, 0x09, 0x01, 0x20, 0x90, 0x32, 0x11, 0x02,
  0x21, 0x10, 0x42, 0x11, 0x04, 0x21, 0x08, 0x84, 0x10, 0x88, 0x41, 0x09,
  0x04, 0x20, 0xB0, 0x42, 0x0A, 0x04, 0x20, 0x40, 0x42, 0x04, 0x08, 0x20,
  0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x10, 0x04, 0x00, 0x10, 0xC0, 0x01,
  0x0A, 0x00, 0x10, 0xA0, 0x02, 0x09, 0x00, 0x20, 0x90, 0x02, 0x09, 0x00,
  0x21, 0x08, 0x02, 0x10, 0x80, 0x21, 0x08, 0x04, 0x10, 0x40, 0x41, 0x04,
  0x04, 0x10, 0x20, 0x42, 0x02, 0x04, 0x20, 0x20, 0x42, 0x01, 0x08, 0x20,
  0x10, 0x82, 0x01, 0x08, 0x20, 0x08, 0x84, 0x00, 0x88, 0x40, 0x04, 0x84,
  0x00, 0x50, 0x40, 0x05, 0x04, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x10,
  0x00, 0x38, 0x00, 0x71, 0x80, 0x30, 0x10, 0x10, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x10,
  0x00, 0x84, 0x00, 0x61, 0x00, 0x10, 0x20, 0x08, 0x04, 0x0C, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x80, 0x10, 0x20, 0x01, 0x04, 0x00, 0x10, 0x80,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x08, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x10, 0x20, 0x1C, 0x0F, 0xFE,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x38, 0x00, 0x39, 0xC0, 0x08, 0x04, 0x02, 0x00,
  0x40, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x82, 0x00, 0x20,
  0x20, 0x08, 0x06, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x07, 0xFE, 0x02, 0x00, 0xC0,
  0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x21, 0x00, 0x08, 0x40, 0x04, 0x20, 0x06,
  0x08, 0x06, 0x03, 0xFE, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x04,
  0x00, 0x81, 0x00, 0x20, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x00, 0x40, 0x00, 0x38, 0x00, 0x71, 0xC0, 0x60,
  0x18, 0x30, 0x02, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x11, 0x00, 0x0C,
  0x60, 0x06, 0x0C, 0x03, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x10, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x00, 0x88, 0x00, 0x11, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01,
  0x01, 0x00, 0x40, 0x30, 0x30, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x50, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21,
  0x00, 0x10, 0x20, 0x04, 0x08, 0x02, 0x02, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x01, 0x02, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04, 0x10,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0A,
  0x03, 0x01, 0x40, 0x60, 0x28, 0x14, 0x05, 0x02, 0x81, 0x20, 0x50, 0x24,
  0x12, 0x04, 0x82, 0x41, 0x10, 0x48, 0x22, 0x11, 0x04, 0x42, 0x21, 0x08,
  0x44, 0x21, 0x10, 0x44, 0x22, 0x09, 0x04, 0x41, 0x20, 0x90, 0x24, 0x12,
  0x04, 0x82, 0x40, 0xA0, 0x50, 0x14, 0x0A, 0x02, 0x81, 0x40, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x81, 0x00, 0x08, 0x04, 0x00, 0x80, 0x20, 0x08, 0x00, 0x80,
  0xC0, 0x04, 0x04, 0x00, 0x10, 0x40, 0x00, 0x84, 0x00, 0x02, 0x60, 0x00,
  0x12, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x40,
  0x00, 0x12, 0x00, 0x01, 0x08, 0x00, 0x10, 0x40, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x80, 0x04, 0x0C, 0x00, 0x20,
  0x40, 0x01, 0x84, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00,
  0x10, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x02, 0x08, 0x00, 0x82, 0x00, 0x21, 0x00, 0x04, 0x80, 0x01,
  0x20, 0x00, 0x50, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7C, 0x00, 0x82, 0x08, 0x20,
  0x41, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x41, 0x02,
  0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E, 0x00, 0x01, 0x80, 0x18, 0x02,
  0x40, 0x24, 0x04, 0x40, 0x44, 0x08, 0x41, 0x82, 0x10, 0x22, 0x02, 0x20,
  0x24, 0x01, 0x40, 0x18, 0x01, 0xFF, 0xFE, 0xC4, 0x23, 0x00, 0xF8, 0x01,
  0x83, 0x03, 0x00, 0xC3, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x01, 0xFF, 0x83, 0x80, 0x46, 0x00, 0x26, 0x00,
  0x22, 0x00, 0x12, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x0E, 0x60, 0x0D, 0x18,
  0x09, 0x87, 0xF8, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0xF8, 0x09,
  0x82, 0x05, 0x00, 0x83, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x80, 0x04,
  0x40, 0x03, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x12, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x50, 0x04, 0x24,
  0x0C, 0x11, 0xFC, 0x00, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x04, 0x10, 0x02,
  0x20, 0x02, 0x60, 0x01, 0x40, 0x01, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x40, 0x18, 0x20, 0x20, 0x1F, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x01, 0xE1, 0x01, 0x86, 0x41, 0x80, 0x50, 0x40, 0x14, 0x20,
  0x02, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00,
  0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x30, 0x80, 0x08, 0x10, 0x06, 0x06, 0x06, 0x80, 0x7E, 0x20, 0x00,
  0xF8, 0x01, 0x83, 0x01, 0x00, 0xC1, 0x00, 0x21, 0x00, 0x09, 0x80, 0x04,
  0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xBF, 0xFF, 0xD0, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x03, 0x04, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0xFF,
  0xFC, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x81, 0x86, 0x41, 0x00,
  0xA1, 0x00, 0x51, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x40,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x0C, 0x40, 0x04, 0x10, 0x06, 0x0C, 0x0D, 0x01, 0xF8,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x80, 0x10, 0x60,
  0x30, 0x18, 0x30, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x78, 0x08, 0xC3, 0x04, 0x80, 0x42, 0x80, 0x22, 0x80, 0x11, 0x80, 0x04,
  0x80, 0x02, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x81, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x7E, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x01, 0x88, 0x01, 0x84, 0x01, 0x04, 0x01, 0x02, 0x03, 0x01,
  0x03, 0x00, 0x82, 0x00, 0x46, 0x00, 0x26, 0x00, 0x25, 0x00, 0x14, 0x80,
  0x0C, 0x20, 0x04, 0x08, 0x02, 0x06, 0x01, 0x01, 0x01, 0x00, 0x40, 0x80,
  0x30, 0x40, 0x08, 0x20, 0x02, 0x10, 0x00, 0x80, 0x07, 0xF8, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x07, 0xFF,
  0xF0, 0x13, 0xC1, 0xE0, 0xA1, 0x30, 0x86, 0x07, 0x02, 0x60, 0x30, 0x13,
  0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x02, 0x20, 0x20,
  0x12, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x01, 0x20,
  0x10, 0x11, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x01,
  0x20, 0x10, 0x11, 0x01, 0x00, 0x80, 0x10, 0x7C, 0x08, 0xC3, 0x05, 0x80,
  0x42, 0x80, 0x22, 0x80, 0x11, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10, 0x00,
  0x80, 0x00, 0xF8, 0x01, 0x86, 0x03, 0x00, 0x83, 0x00, 0x21, 0x00, 0x11,
  0x00, 0x05, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x0C, 0x80, 0x04, 0x40,
  0x04, 0x30, 0x04, 0x0C, 0x0C, 0x01, 0xFC, 0x00, 0x08, 0x7C, 0x04, 0xC1,
  0x02, 0x80, 0x41, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x28, 0x02, 0x16, 0x06,
  0x08, 0xFE, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE1, 0x06, 0x19,
  0x08, 0x05, 0x10, 0x05, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x40, 0x18, 0x60, 0x68, 0x1F, 0x88,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x10, 0x3E, 0x23, 0x80, 0x48, 0x00, 0xA0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF0, 0x0E, 0x0C, 0x18, 0x02,
  0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x0C, 0x60, 0x18, 0x3F, 0xE0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0xFC, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x07, 0xE0, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x0C, 0x40, 0x18, 0x60, 0x68, 0x3F, 0x88, 0x80, 0x00, 0x50, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x04, 0x60, 0x02, 0x08, 0x00, 0x82, 0x00, 0x40, 0x80,
  0x10, 0x10, 0x08, 0x04, 0x06, 0x01, 0x01, 0x00, 0x40, 0x80, 0x08, 0x20,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x22, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x80, 0x40, 0x30, 0x18, 0x06, 0x03, 0x01, 0x40,
  0x60, 0x28, 0x14, 0x09, 0x02, 0x81, 0x20, 0x90, 0x24, 0x12, 0x08, 0x82,
  0x41, 0x10, 0x84, 0x42, 0x10, 0x88, 0x44, 0x11, 0x08, 0x82, 0x41, 0x10,
  0x48, 0x14, 0x0A, 0x02, 0x81, 0x40, 0x60, 0x28, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x00, 0x18, 0x00, 0x21, 0x00, 0x08, 0x10, 0x02, 0x03,
  0x00, 0xC0, 0x20, 0x30, 0x06, 0x0C, 0x00, 0x43, 0x00, 0x04, 0xC0, 0x00,
  0xD0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x11, 0x00, 0x04,
  0x30, 0x01, 0x02, 0x00, 0x40, 0x20, 0x18, 0x06, 0x06, 0x00, 0x41, 0x80,
  0x04, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x20, 0x00, 0xC0, 0x40, 0x01, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0xC0, 0x02, 0x01, 0x00, 0x04, 0x04, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x48, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x12, 0x18, 0x02, 0x40, 0x40, 0x24, 0x02, 0x06, 0x80, 0x10, 0xC8,
  0x00, 0xF0,
};

const GFXglyph RobotoMono_ThinItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 7, 8, 22, 9, -28 },
  { 28, 22, 26, 22, 0, -26 },
  { 100, 17, 34, 22, 3, -30 },
  { 173, 18, 27, 22, 2, -27 },
  { 234, 18, 27, 22, 2, -27 },
  { 295, 2, 8, 22, 11, -28 },
  { 297, 11, 37, 22, 6, -29 },
  { 348, 11, 37, 22, 3, -29 },
  { 399, 16, 14, 22, 5, -26 },
  { 427, 18, 19, 22, 2, -22 },
  { 470, 3, 8, 22, 5, -3 },
  { 473, 13, 1, 22, 4, -13 },
  { 475, 2, 2, 22, 9, -2 },
  { 476, 17, 28, 22, 3, -26 },
  { 536, 17, 27, 22, 3, -27 },
  { 594, 9, 26, 22, 6, -26 },
  { 624, 17, 27, 22, 1, -27 },
  { 682, 18, 27, 22, 1, -27 },
  { 743, 18, 26, 22, 1, -26 },
  { 802, 18, 26, 22, 3, -26 },
  { 861, 16, 27, 22, 2, -27 },
  { 915, 16, 26, 22, 5, -26 },
  { 967, 18, 27, 22, 2, -27 },
  { 1028, 15, 27, 22, 4, -27 },
  { 1079, 5, 18, 22, 10, -18 },
  { 1091, 8, 23, 22, 7, -18 },
  { 1114, 16, 14, 22, 3, -19 },
  { 1142, 17, 8, 22, 3, -16 },
  { 1159, 17, 14, 22, 2, -19 },
  { 1189, 13, 27, 22, 6, -27 },
  { 1233, 21, 27, 22, 1, -27 },
  { 1304, 18, 26, 22, 0, -26 },
  { 1363, 18, 26, 22, 2, -26 },
  { 1422, 18, 27, 22, 2, -27 },
  { 1483, 18, 26, 22, 2, -26 },
  { 1542, 19, 26, 22, 2, -26 },
  { 1604, 19, 26, 22, 2, -26 },
  { 1666, 18, 27, 22, 2, -27 },
  { 1727, 20, 26, 22, 1, -26 },
  { 1792, 19, 26, 22, 2, -26 },
  { 1854, 19, 26, 22, 1, -26 },
  { 1916, 20, 26, 22, 2, -26 },
  { 1981, 15, 26, 22, 2, -26 },
  { 2030, 20, 26, 22, 1, -26 },
  { 2095, 20, 26, 22, 1, -26 },
  { 2160, 18, 27, 22, 2, -27 },
  { 2221, 19, 26, 22, 2, -26 },
  { 2283, 19, 32, 22, 2, -27 },
  { 2359, 18, 26, 22, 2, -26 },
  { 2418, 18, 27, 22, 2, -27 },
  { 2479, 18, 26, 22, 4, -26 },
  { 2538, 19, 26, 22, 2, -26 },
  { 2600, 18, 26, 22, 4, -26 },
  { 2659, 19, 26, 22, 4, -26 },
  { 2721, 21, 26, 22, 1, -26 },
  { 2790, 18, 26, 22, 4, -26 },
  { 2849, 19, 26, 22, 1, -26 },
  { 2911, 11, 36, 22, 6, -30 },
  { 2961, 6, 28, 22, 8, -26 },
  { 2982, 11, 36, 22, 5, -30 },
  { 3032, 12, 14, 22, 5, -26 },
  { 3053, 15, 1, 22, 1, 0 },
  { 3055, 4, 4, 22, 11, -27 },
  { 3057, 17, 20, 22, 2, -20 },
  { 3100, 17, 28, 22, 2, -28 },
  { 3160, 16, 20, 22, 3, -20 },
  { 3200, 18, 28, 22, 3, -28 },
  { 3263, 17, 20, 22, 2, -20 },
  { 3306, 17, 28, 22, 5, -28 },
  { 3366, 17, 28, 22, 2, -20 },
  { 3426, 17, 28, 22, 2, -28 },
  { 3486, 15, 26, 22, 2, -26 },
  { 3535, 17, 34, 22, 0, -26 },
  { 3608, 17, 28, 22, 3, -28 },
  { 3668, 15, 28, 22, 2, -28 },
  { 3721, 21, 20, 22, 0, -20 },
  { 3774, 17, 20, 22, 2, -20 },
  { 3817, 17, 20, 22, 2, -20 },
  { 3860, 17, 28, 22, 1, -20 },
  { 3920, 16, 28, 22, 3, -20 },
  { 3976, 15, 20, 22, 5, -20 },
  { 4014, 16, 20, 22, 3, -20 },
  { 4054, 13, 25, 22, 5, -25 },
  { 4095, 16, 20, 22, 3, -20 },
  { 4135, 18, 20, 22, 3, -20 },
  { 4180, 19, 20, 22, 3, -20 },
  { 4228, 19, 20, 22, 1, -20 },
  { 4276, 23, 28, 22, -1, -20 },
  { 4357, 19, 20, 22, 1, -20 },
  { 4405, 14, 37, 22, 6, -29 },
  { 4470, 6, 31, 22, 8, -26 },
  { 4494, 14, 37, 22, 3, -29 },
  { 4559, 20, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_ThinItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic37pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_THINITALIC37PT7B_H_
