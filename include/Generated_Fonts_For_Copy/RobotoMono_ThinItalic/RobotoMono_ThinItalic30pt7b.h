#ifndef _ROBOTOMONO_THINITALIC30PT7B_H_
#define _ROBOTOMONO_THINITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x80, 0x00,
  0x00, 0x8C, 0x00, 0x4C, 0x63, 0x19, 0x4A, 0x40, 0x00, 0x41, 0x00, 0x10,
  0x40, 0x04, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x41, 0x01, 0xFF, 0xFC,
  0x04, 0x10, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x10, 0x40, 0x04,
  0x10, 0x01, 0x04, 0x0F, 0xFF, 0xE0, 0x20, 0x80, 0x08, 0x20, 0x04, 0x10,
  0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x80, 0x00, 0x00, 0x40, 0x01, 0x00,
  0x0E, 0x01, 0xC4, 0x08, 0x08, 0x40, 0x11, 0x00, 0x44, 0x01, 0x20, 0x04,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x11, 0x00, 0x46, 0x06,
  0x07, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x00, 0x08, 0x00, 0x90, 0x04,
  0x20, 0x20, 0x82, 0x82, 0x12, 0x08, 0x48, 0x22, 0x21, 0x10, 0x84, 0x41,
  0xE2, 0x00, 0x10, 0x00, 0x80, 0x02, 0x30, 0x11, 0x30, 0x88, 0x42, 0x21,
  0x11, 0x04, 0x84, 0x14, 0x10, 0x50, 0x41, 0x01, 0x08, 0x03, 0xC0, 0x00,
  0x40, 0x06, 0x60, 0x10, 0x40, 0x20, 0x40, 0x81, 0x01, 0x02, 0x02, 0x08,
  0x02, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x48, 0x01, 0x10, 0x04,
  0x10, 0x48, 0x10, 0xA0, 0x22, 0x40, 0x24, 0x80, 0x51, 0x00, 0x62, 0x00,
  0xC2, 0x06, 0x83, 0xF0, 0x80, 0x56, 0xA8, 0x00, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x02, 0x00, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x1F,
  0x27, 0x07, 0xC0, 0x18, 0x01, 0x20, 0x11, 0x01, 0x04, 0x10, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x25, 0x29, 0x00, 0xFF, 0xC0, 0xB0, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x18, 0xC0, 0x80, 0x84, 0x02, 0x10, 0x04, 0x80,
  0x12, 0x00, 0xD0, 0x05, 0x40, 0x25, 0x01, 0x14, 0x08, 0x50, 0xC1, 0x84,
  0x0A, 0x20, 0x29, 0x00, 0xA8, 0x02, 0xC0, 0x12, 0x00, 0x48, 0x02, 0x10,
  0x08, 0x20, 0xC0, 0x7C, 0x00, 0x06, 0x37, 0x8C, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x00,
  0x01, 0x80, 0x18, 0xC0, 0x80, 0x84, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x18, 0x40, 0x80, 0x84, 0x01, 0x10, 0x04,
  0x80, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0E, 0x01, 0xF0,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01,
  0x10, 0x08, 0x40, 0x40, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x60, 0x02, 0x80,
  0x12, 0x00, 0x88, 0x02, 0x40, 0x11, 0x00, 0x84, 0x04, 0x10, 0x20, 0x41,
  0x01, 0x04, 0x08, 0x20, 0x21, 0x00, 0x8F, 0xFF, 0xC0, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x0F, 0xFC, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xC1, 0x80,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x20, 0x04, 0x80,
  0x22, 0x00, 0x88, 0x04, 0x10, 0x20, 0x3F, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x47, 0xC2, 0xC1,
  0x18, 0x04, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x14,
  0x00, 0xA0, 0x08, 0x80, 0x46, 0x04, 0x0F, 0xC0, 0xFF, 0xF8, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x30, 0x20,
  0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x48, 0x01, 0x10, 0x02, 0x20, 0x08,
  0x20, 0x20, 0x31, 0x80, 0x7F, 0x03, 0x01, 0x08, 0x01, 0x10, 0x02, 0x40,
  0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44, 0x00, 0x84, 0x06, 0x07, 0xF0,
  0x00, 0x01, 0x80, 0x63, 0x04, 0x04, 0x40, 0x24, 0x00, 0xA0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x24, 0x03, 0x30, 0x68,
  0x7C, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x3C,
  0x00, 0x23, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x08, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x41, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x20, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x03, 0x11, 0x81, 0x20, 0x28,
  0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0xE6, 0x01, 0x80, 0x81, 0x00, 0x21, 0x00, 0x10,
  0x87, 0x88, 0x84, 0x42, 0x84, 0x21, 0x44, 0x10, 0xA2, 0x08, 0xA2, 0x08,
  0x51, 0x04, 0x28, 0x82, 0x14, 0x42, 0x12, 0x21, 0x09, 0x11, 0x84, 0x89,
  0x44, 0x43, 0x1C, 0x20, 0x00, 0x08, 0x00, 0x02, 0x02, 0x00, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00,
  0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80,
  0x41, 0x00, 0x87, 0xFF, 0x08, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00, 0x12,
  0x00, 0x18, 0x00, 0x20, 0x1F, 0xF0, 0x40, 0x21, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x11, 0x03, 0x87, 0xFE, 0x10,
  0x04, 0x40, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48,
  0x02, 0x20, 0x10, 0xFF, 0x80, 0x01, 0xC0, 0x18, 0xC0, 0x80, 0x84, 0x01,
  0x10, 0x04, 0x80, 0x14, 0x00, 0x50, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x02, 0x80, 0x0A, 0x00,
  0x48, 0x01, 0x10, 0x08, 0x60, 0x40, 0x7E, 0x00, 0x0F, 0xF0, 0x08, 0x08,
  0x10, 0x04, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x01, 0x10, 0x01,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x10, 0x40, 0x20, 0x80, 0xC0,
  0xFF, 0x00, 0x1F, 0xFE, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0xFF, 0xC2, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xFF, 0xC2, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0,
  0x0C, 0x20, 0x20, 0x20, 0x80, 0x22, 0x00, 0x44, 0x00, 0x50, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x1F, 0xD0, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x82,
  0x02, 0x03, 0xF8, 0x00, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x3F, 0xFC, 0x20, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x0F, 0xFF,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x40, 0x04, 0x80, 0x11,
  0x00, 0x21, 0x00, 0x82, 0x02, 0x03, 0xF8, 0x00, 0x10, 0x03, 0x10, 0x04,
  0x10, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x20, 0x80, 0x21, 0x00,
  0x22, 0x00, 0x24, 0x00, 0x4A, 0x00, 0x72, 0x00, 0x41, 0x00, 0x40, 0x80,
  0x40, 0x80, 0x40, 0x40, 0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x08, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0x08, 0x01,
  0x18, 0x03, 0x14, 0x05, 0x14, 0x05, 0x14, 0x09, 0x14, 0x0A, 0x14, 0x12,
  0x22, 0x12, 0x22, 0x22, 0x22, 0x42, 0x22, 0x42, 0x22, 0x84, 0x41, 0x84,
  0x41, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x08, 0x08, 0x01, 0x18, 0x01, 0x14, 0x01, 0x14, 0x01,
  0x14, 0x02, 0x12, 0x02, 0x22, 0x02, 0x21, 0x02, 0x21, 0x02, 0x21, 0x02,
  0x20, 0x84, 0x20, 0x84, 0x40, 0x84, 0x40, 0x44, 0x40, 0x44, 0x40, 0x24,
  0x40, 0x28, 0x40, 0x28, 0x80, 0x18, 0x80, 0x18, 0x80, 0x08, 0x01, 0xC0,
  0x18, 0xC0, 0x80, 0x84, 0x01, 0x10, 0x04, 0x80, 0x14, 0x00, 0x50, 0x01,
  0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x02, 0x10, 0x08, 0x40, 0xC0, 0xFC,
  0x00, 0x1F, 0xF8, 0x20, 0x08, 0x40, 0x08, 0x80, 0x11, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x10, 0x80, 0x41, 0xFF, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x60, 0x20, 0x20, 0x80,
  0x22, 0x00, 0x44, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x22, 0x00, 0x42, 0x01, 0x04, 0x04, 0x07, 0xF0, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x1F, 0xF0, 0x40, 0x21, 0x00, 0x44,
  0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x44,
  0x02, 0x1F, 0xF0, 0x40, 0x81, 0x01, 0x04, 0x04, 0x10, 0x10, 0x80, 0x22,
  0x00, 0x88, 0x01, 0x20, 0x04, 0x80, 0x10, 0x01, 0xE0, 0x0C, 0x30, 0x20,
  0x30, 0x80, 0x22, 0x00, 0x44, 0x00, 0x48, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x84, 0x02, 0x07, 0xF8,
  0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x44,
  0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x41,
  0x00, 0x82, 0x06, 0x03, 0xF0, 0x00, 0x80, 0x06, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x04, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x80, 0x81, 0x01, 0x04, 0x02, 0x08, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00,
  0x12, 0x00, 0x28, 0x00, 0x50, 0x00, 0x40, 0x00, 0x80, 0x00, 0x81, 0x01,
  0x81, 0x02, 0x81, 0x02, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x84, 0x84,
  0x84, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0x90,
  0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x80, 0x80, 0x80, 0x08, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x10, 0x08,
  0x08, 0x02, 0x04, 0x00, 0x42, 0x00, 0x10, 0x80, 0x02, 0x40, 0x00, 0xA0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x41, 0x00, 0x10, 0x40, 0x08, 0x08, 0x04, 0x02, 0x02, 0x00, 0x40, 0x80,
  0x10, 0xC0, 0x02, 0x00, 0xC0, 0x06, 0x80, 0x09, 0x00, 0x21, 0x00, 0x82,
  0x01, 0x04, 0x04, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x12, 0x00, 0x24,
  0x00, 0x50, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xF0, 0x82, 0x04, 0x10, 0x41, 0x04, 0x08, 0x20,
  0x82, 0x08, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x40, 0x07,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x0F, 0x80, 0x02, 0x01, 0x40, 0x50,
  0x24, 0x09, 0x04, 0x21, 0x08, 0x82, 0x40, 0x90, 0x18, 0x04, 0xFF, 0xF0,
  0x89, 0x10, 0x07, 0xE0, 0xC0, 0x88, 0x02, 0x40, 0x12, 0x00, 0x80, 0x04,
  0x00, 0x21, 0xFE, 0x30, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x03, 0x40,
  0x2A, 0x02, 0x4F, 0xE4, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0xFC, 0x28, 0x11, 0x80, 0x88, 0x02, 0x40, 0x14,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0C, 0x00, 0xA0, 0x05, 0x00,
  0x4C, 0x02, 0x70, 0x62, 0x7C, 0x00, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40,
  0x14, 0x00, 0xA0, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x28, 0x01, 0x20, 0x10, 0x81, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x03, 0xE2, 0x08,
  0x28, 0x20, 0x30, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x01, 0x04, 0x02, 0x08,
  0x1C, 0x0F, 0xC8, 0x00, 0x07, 0xE0, 0x40, 0x84, 0x02, 0x40, 0x14, 0x00,
  0xA0, 0x06, 0x00, 0x3F, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x08, 0x81, 0x83, 0xF0, 0x00, 0x7C, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x3F, 0xF8, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03,
  0xE2, 0x08, 0x28, 0x20, 0x30, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x01, 0x04,
  0x02, 0x08, 0x1C, 0x0F, 0xC8, 0x00, 0x10, 0x00, 0x40, 0x00, 0x84, 0x02,
  0x04, 0x08, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x7C, 0x2C, 0x11, 0x80, 0x48, 0x02, 0xC0,
  0x14, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x14, 0x00, 0xA0, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x0F, 0xC0, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x01, 0x10, 0x18, 0x80, 0x82, 0x04, 0x08, 0x60,
  0x22, 0x00, 0x90, 0x05, 0xC0, 0x18, 0x80, 0x42, 0x01, 0x04, 0x04, 0x08,
  0x10, 0x20, 0x80, 0x42, 0x00, 0x88, 0x01, 0x00, 0x0F, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x2F, 0x8F, 0x18, 0x38, 0x48,
  0x10, 0x24, 0x08, 0x12, 0x04, 0x0A, 0x02, 0x05, 0x02, 0x02, 0x81, 0x02,
  0x40, 0x81, 0x20, 0x40, 0x90, 0x20, 0x50, 0x20, 0x28, 0x10, 0x24, 0x08,
  0x12, 0x04, 0x09, 0x02, 0x04, 0x11, 0xF0, 0x58, 0x21, 0x80, 0x44, 0x01,
  0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x20, 0x04, 0x07, 0xE0, 0x60,
  0x43, 0x00, 0x88, 0x02, 0x40, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x11, 0x00, 0x84, 0x04, 0x0F,
  0xE0, 0x13, 0xF0, 0x50, 0x21, 0x80, 0x84, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x90, 0x02, 0x40, 0x11,
  0x80, 0x46, 0x06, 0x17, 0xE0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x00, 0x07, 0xC4, 0x20, 0xA1, 0x01, 0x88, 0x02, 0x40,
  0x09, 0x00, 0x24, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x21, 0x00, 0x84, 0x0E, 0x0F, 0xC8, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x11, 0xF9, 0x30, 0x0A, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x07, 0xE0, 0x60,
  0x62, 0x00, 0x88, 0x01, 0x20, 0x00, 0x80, 0x01, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x80, 0x12, 0x00, 0x44, 0x02, 0x0F,
  0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x07, 0xC0, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02,
  0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x31, 0x00, 0x84, 0x0E, 0x0F, 0xC8, 0x80, 0x06, 0x00,
  0x28, 0x00, 0x90, 0x04, 0x40, 0x21, 0x00, 0x84, 0x04, 0x08, 0x10, 0x20,
  0x80, 0x82, 0x02, 0x10, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x02,
  0x00, 0x81, 0x01, 0x81, 0x82, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84,
  0x84, 0x44, 0x88, 0x44, 0x88, 0x48, 0x88, 0x48, 0x90, 0x50, 0x90, 0x50,
  0xA0, 0x60, 0xA0, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x10, 0x03, 0x10,
  0x04, 0x08, 0x08, 0x04, 0x10, 0x04, 0x20, 0x02, 0x60, 0x02, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x04, 0x40, 0x08, 0x20, 0x10, 0x20, 0x20,
  0x10, 0x40, 0x10, 0x80, 0x08, 0x20, 0x00, 0x88, 0x00, 0x44, 0x00, 0x42,
  0x00, 0x40, 0x80, 0x20, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x04, 0x10,
  0x02, 0x08, 0x01, 0x08, 0x00, 0x44, 0x00, 0x24, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x07, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFE, 0x00, 0x60,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x30, 0x03, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84,
  0x22, 0x10, 0x84, 0x21, 0x10, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x18, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x00, 0x3E, 0x01,
  0x41, 0x02, 0x80, 0x82, 0x80, 0x4C, 0x00, 0x30,
};

const GFXglyph RobotoMono_ThinItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 5, 21, 18, 6, -21 },
  { 15, 5, 7, 18, 8, -23 },
  { 20, 18, 21, 18, 0, -21 },
  { 68, 14, 27, 18, 2, -24 },
  { 116, 14, 22, 18, 2, -22 },
  { 155, 15, 22, 18, 1, -22 },
  { 197, 2, 7, 18, 9, -23 },
  { 199, 9, 31, 18, 5, -24 },
  { 234, 9, 31, 18, 3, -24 },
  { 269, 13, 11, 18, 4, -21 },
  { 287, 14, 16, 18, 2, -18 },
  { 315, 3, 6, 18, 4, -2 },
  { 318, 10, 1, 18, 4, -10 },
  { 320, 2, 2, 18, 7, -2 },
  { 321, 14, 23, 18, 2, -21 },
  { 362, 14, 22, 18, 2, -22 },
  { 401, 7, 21, 18, 5, -21 },
  { 420, 14, 22, 18, 1, -22 },
  { 459, 14, 22, 18, 1, -22 },
  { 498, 14, 21, 18, 1, -21 },
  { 535, 14, 21, 18, 3, -21 },
  { 572, 13, 22, 18, 2, -22 },
  { 608, 13, 21, 18, 4, -21 },
  { 643, 15, 22, 18, 2, -22 },
  { 685, 13, 22, 18, 3, -22 },
  { 721, 4, 15, 18, 8, -15 },
  { 729, 6, 19, 18, 6, -15 },
  { 744, 14, 12, 18, 2, -16 },
  { 765, 14, 7, 18, 2, -13 },
  { 778, 13, 12, 18, 2, -16 },
  { 798, 11, 22, 18, 5, -22 },
  { 829, 17, 22, 18, 1, -22 },
  { 876, 15, 21, 18, 0, -21 },
  { 916, 14, 21, 18, 2, -21 },
  { 953, 14, 22, 18, 2, -22 },
  { 992, 16, 21, 18, 1, -21 },
  { 1034, 15, 21, 18, 2, -21 },
  { 1074, 15, 21, 18, 2, -21 },
  { 1114, 15, 22, 18, 2, -22 },
  { 1156, 16, 21, 18, 1, -21 },
  { 1198, 16, 21, 18, 1, -21 },
  { 1240, 15, 21, 18, 1, -21 },
  { 1280, 16, 21, 18, 2, -21 },
  { 1322, 12, 21, 18, 2, -21 },
  { 1354, 16, 21, 18, 1, -21 },
  { 1396, 16, 21, 18, 1, -21 },
  { 1438, 14, 22, 18, 2, -22 },
  { 1477, 15, 21, 18, 2, -21 },
  { 1517, 15, 26, 18, 2, -22 },
  { 1566, 14, 21, 18, 2, -21 },
  { 1603, 15, 22, 18, 2, -22 },
  { 1645, 14, 21, 18, 4, -21 },
  { 1682, 15, 21, 18, 2, -21 },
  { 1722, 15, 21, 18, 3, -21 },
  { 1762, 16, 21, 18, 3, -21 },
  { 1804, 18, 21, 18, 0, -21 },
  { 1852, 15, 21, 18, 3, -21 },
  { 1892, 15, 21, 18, 1, -21 },
  { 1932, 8, 29, 18, 5, -24 },
  { 1961, 6, 23, 18, 6, -21 },
  { 1979, 9, 29, 18, 4, -24 },
  { 2012, 10, 11, 18, 4, -21 },
  { 2026, 12, 1, 18, 1, 0 },
  { 2028, 3, 4, 18, 9, -22 },
  { 2030, 13, 16, 18, 2, -16 },
  { 2056, 13, 23, 18, 2, -23 },
  { 2094, 13, 16, 18, 2, -16 },
  { 2120, 15, 23, 18, 2, -23 },
  { 2164, 13, 16, 18, 2, -16 },
  { 2190, 14, 23, 18, 4, -23 },
  { 2231, 15, 22, 18, 1, -16 },
  { 2273, 13, 23, 18, 2, -23 },
  { 2311, 12, 21, 18, 2, -21 },
  { 2343, 14, 27, 18, 0, -21 },
  { 2391, 14, 23, 18, 2, -23 },
  { 2432, 12, 23, 18, 2, -23 },
  { 2467, 17, 16, 18, 0, -16 },
  { 2501, 14, 16, 18, 1, -16 },
  { 2529, 14, 16, 18, 2, -16 },
  { 2557, 14, 22, 18, 1, -16 },
  { 2596, 14, 22, 18, 2, -16 },
  { 2635, 13, 16, 18, 4, -16 },
  { 2661, 14, 16, 18, 2, -16 },
  { 2689, 11, 20, 18, 4, -20 },
  { 2717, 14, 16, 18, 2, -16 },
  { 2745, 14, 16, 18, 3, -16 },
  { 2773, 16, 16, 18, 2, -16 },
  { 2805, 16, 16, 18, 1, -16 },
  { 2837, 17, 22, 18, 0, -16 },
  { 2884, 15, 16, 18, 1, -16 },
  { 2914, 11, 29, 18, 5, -23 },
  { 2954, 5, 25, 18, 6, -21 },
  { 2970, 11, 29, 18, 3, -23 },
  { 3010, 16, 5, 18, 1, -11 },
};

const GFXfont RobotoMono_ThinItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic30pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_THINITALIC30PT7B_H_
