#ifndef _ROBOTOMONO_THINITALIC13PT7B_H_
#define _ROBOTOMONO_THINITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0x80, 0xB6, 0x80, 0x0A, 0x12, 0x7F, 0x14, 0x24, 0x28,
  0xDE, 0x48, 0x50, 0x08, 0x66, 0x51, 0x41, 0x03, 0x02, 0x86, 0x2D, 0x08,
  0xE6, 0xAA, 0xB4, 0x20, 0xF5, 0x65, 0x1C, 0x39, 0x25, 0x08, 0x62, 0x59,
  0x62, 0xF4, 0xE0, 0x12, 0x44, 0x48, 0x88, 0x88, 0x84, 0x40, 0x21, 0x11,
  0x11, 0x11, 0x12, 0x24, 0x80, 0x25, 0x5C, 0xA9, 0x00, 0x10, 0x41, 0x3F,
  0x20, 0x82, 0x00, 0xE0, 0xF0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10,
  0x82, 0x00, 0x7D, 0x18, 0x67, 0xA7, 0x18, 0x62, 0xF0, 0x74, 0x92, 0x52,
  0x40, 0x3D, 0x10, 0x41, 0x08, 0x42, 0x10, 0xFC, 0x3C, 0x84, 0x08, 0x21,
  0x80, 0xA1, 0x42, 0x78, 0x04, 0x18, 0x51, 0x22, 0x48, 0xAE, 0x84, 0x08,
  0x3D, 0x04, 0x1E, 0x04, 0x10, 0x62, 0x70, 0x3A, 0x21, 0xF8, 0xC6, 0x31,
  0xF0, 0xF8, 0x44, 0x22, 0x21, 0x10, 0x80, 0x7D, 0x14, 0x51, 0x7A, 0x18,
  0x61, 0xF8, 0x7D, 0x18, 0x61, 0x85, 0xF0, 0x82, 0x70, 0x40, 0x08, 0x40,
  0x0A, 0x80, 0x0C, 0xCC, 0x18, 0x18, 0xFC, 0x0F, 0x80, 0xC0, 0xC0, 0xC4,
  0xE0, 0x7C, 0x42, 0x22, 0x20, 0x00, 0x40, 0x1E, 0x29, 0x55, 0xA5, 0xA9,
  0xAA, 0xBA, 0x84, 0x78, 0x08, 0x51, 0x49, 0x25, 0x17, 0xD1, 0x84, 0x7D,
  0x18, 0x62, 0xFA, 0x18, 0x62, 0xF0, 0x7D, 0x18, 0x60, 0x82, 0x08, 0x62,
  0xF0, 0x79, 0x18, 0x61, 0x86, 0x18, 0x62, 0xF0, 0x7D, 0x08, 0x20, 0xFA,
  0x08, 0x20, 0xF8, 0x7D, 0x04, 0x20, 0xFA, 0x08, 0x20, 0x80, 0x7D, 0x18,
  0x20, 0x9A, 0x18, 0x61, 0xF8, 0x22, 0x85, 0x0A, 0x17, 0xE8, 0x50, 0xC2,
  0x84, 0x7C, 0x41, 0x04, 0x20, 0x82, 0x08, 0xF8, 0x02, 0x04, 0x08, 0x10,
  0x20, 0xA1, 0x42, 0x78, 0x46, 0x91, 0x45, 0x06, 0x12, 0x24, 0x44, 0x84,
  0x42, 0x11, 0x08, 0x42, 0x10, 0xF8, 0x23, 0x62, 0x66, 0x56, 0x5A, 0x52,
  0x42, 0x82, 0x84, 0x22, 0xC5, 0x4A, 0x95, 0x29, 0x52, 0xC2, 0x84, 0x7D,
  0x18, 0x61, 0x86, 0x18, 0x62, 0xF0, 0x7C, 0x85, 0x0C, 0x2F, 0x90, 0x20,
  0x40, 0x80, 0x7D, 0x18, 0x61, 0x86, 0x18, 0x62, 0xF0, 0x40, 0x80, 0x7D,
  0x14, 0x61, 0xEA, 0x48, 0xA2, 0x88, 0x7E, 0x18, 0x10, 0x38, 0x10, 0x61,
  0xF8, 0xFC, 0x82, 0x08, 0x41, 0x04, 0x10, 0x40, 0x46, 0x18, 0x61, 0x86,
  0x18, 0x62, 0xF0, 0x83, 0x09, 0x12, 0x44, 0x8A, 0x14, 0x30, 0x20, 0x93,
  0x26, 0xCD, 0xAB, 0x5A, 0xB6, 0x44, 0x88, 0x23, 0x22, 0x14, 0x18, 0x10,
  0x18, 0x24, 0x44, 0x82, 0x82, 0x89, 0x22, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x3E, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0xFC, 0x32, 0x44, 0x44, 0x44,
  0x88, 0x88, 0xC0, 0xAA, 0xA5, 0x50, 0x31, 0x11, 0x22, 0x22, 0x22, 0x44,
  0xC0, 0x25, 0x59, 0x90, 0xFC, 0xC0, 0x7A, 0x10, 0x5E, 0x8A, 0x2F, 0x80,
  0x41, 0x04, 0x3E, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0x39, 0x18, 0x20, 0x82,
  0x2F, 0x00, 0x04, 0x10, 0x5F, 0x86, 0x18, 0xA2, 0x8B, 0xE0, 0x39, 0x18,
  0x7E, 0x82, 0x07, 0x80, 0x1C, 0x84, 0x3E, 0x41, 0x04, 0x10, 0x82, 0x00,
  0x7E, 0x18, 0x62, 0x8A, 0x2F, 0x82, 0x93, 0x80, 0x41, 0x04, 0x2E, 0xC6,
  0x18, 0x62, 0x8A, 0x20, 0x10, 0x1C, 0x21, 0x08, 0x84, 0xF8, 0x04, 0x03,
  0xC2, 0x08, 0x20, 0x82, 0x08, 0x41, 0x38, 0x41, 0x04, 0x11, 0x5A, 0x86,
  0x24, 0x92, 0x20, 0x70, 0x84, 0x21, 0x08, 0x44, 0x27, 0xC0, 0x76, 0x96,
  0x4C, 0x99, 0x32, 0x64, 0x80, 0xBB, 0x18, 0x61, 0x8A, 0x28, 0x80, 0x7A,
  0x18, 0x61, 0x86, 0x2F, 0x00, 0x7D, 0x14, 0x51, 0x45, 0x1F, 0xA0, 0x82,
  0x00, 0x7E, 0x18, 0x62, 0x8A, 0x2F, 0x82, 0x08, 0x40, 0x7A, 0x21, 0x08,
  0x42, 0x00, 0x7A, 0x14, 0x0C, 0x0A, 0x2F, 0x80, 0x24, 0xF4, 0x44, 0x48,
  0x70, 0x86, 0x18, 0x61, 0x8A, 0x2F, 0x80, 0x86, 0x18, 0x92, 0x51, 0x42,
  0x00, 0x93, 0x26, 0xD6, 0xAD, 0x91, 0x24, 0x00, 0x42, 0x48, 0x60, 0x82,
  0x88, 0xB1, 0x00, 0x41, 0x42, 0x44, 0x24, 0x28, 0x28, 0x10, 0x20, 0x20,
  0xC0, 0x7E, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x00, 0x19, 0x08, 0x42, 0x22,
  0x08, 0x42, 0x10, 0x82, 0x00, 0x55, 0xAA, 0xA8, 0x20, 0x84, 0x21, 0x08,
  0x22, 0x21, 0x08, 0x88, 0x00, 0x73, 0x1C,
};

const GFXglyph RobotoMono_ThinItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 3, 3, 8, 3, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 12, 8, 1, -11 },
  { 24, 6, 9, 8, 1, -9 },
  { 31, 6, 9, 8, 1, -9 },
  { 38, 1, 3, 8, 4, -10 },
  { 39, 4, 13, 8, 2, -10 },
  { 46, 4, 13, 8, 1, -10 },
  { 53, 5, 5, 8, 2, -9 },
  { 57, 6, 7, 8, 1, -8 },
  { 63, 1, 3, 8, 2, -1 },
  { 64, 4, 1, 8, 2, -5 },
  { 65, 1, 1, 8, 3, -1 },
  { 66, 6, 10, 8, 1, -9 },
  { 74, 6, 9, 8, 1, -9 },
  { 81, 3, 9, 8, 2, -9 },
  { 85, 6, 9, 8, 0, -9 },
  { 92, 7, 9, 8, 0, -9 },
  { 100, 7, 9, 8, 0, -9 },
  { 108, 6, 9, 8, 1, -9 },
  { 115, 5, 9, 8, 1, -9 },
  { 121, 5, 9, 8, 2, -9 },
  { 127, 6, 9, 8, 1, -9 },
  { 134, 6, 9, 8, 1, -9 },
  { 141, 2, 7, 8, 3, -7 },
  { 143, 2, 9, 8, 3, -7 },
  { 146, 6, 5, 8, 1, -7 },
  { 150, 6, 3, 8, 1, -6 },
  { 153, 6, 5, 8, 1, -7 },
  { 157, 5, 9, 8, 2, -9 },
  { 163, 8, 9, 8, 0, -9 },
  { 172, 6, 9, 8, 0, -9 },
  { 179, 6, 9, 8, 1, -9 },
  { 186, 6, 9, 8, 1, -9 },
  { 193, 6, 9, 8, 1, -9 },
  { 200, 6, 9, 8, 1, -9 },
  { 207, 6, 9, 8, 1, -9 },
  { 214, 6, 9, 8, 1, -9 },
  { 221, 7, 9, 8, 0, -9 },
  { 229, 6, 9, 8, 1, -9 },
  { 236, 7, 9, 8, 0, -9 },
  { 244, 7, 9, 8, 1, -9 },
  { 252, 5, 9, 8, 1, -9 },
  { 258, 8, 9, 8, 0, -9 },
  { 267, 7, 9, 8, 0, -9 },
  { 275, 6, 9, 8, 1, -9 },
  { 282, 7, 9, 8, 1, -9 },
  { 290, 6, 11, 8, 1, -9 },
  { 299, 6, 9, 8, 1, -9 },
  { 306, 6, 9, 8, 1, -9 },
  { 313, 6, 9, 8, 2, -9 },
  { 320, 6, 9, 8, 1, -9 },
  { 327, 7, 9, 8, 1, -9 },
  { 335, 7, 9, 8, 1, -9 },
  { 343, 8, 9, 8, 0, -9 },
  { 352, 7, 9, 8, 1, -9 },
  { 360, 7, 9, 8, 0, -9 },
  { 368, 4, 13, 8, 2, -11 },
  { 375, 2, 10, 8, 3, -9 },
  { 378, 4, 13, 8, 2, -11 },
  { 385, 4, 5, 8, 2, -9 },
  { 388, 6, 1, 8, 0, 0 },
  { 389, 1, 2, 8, 4, -10 },
  { 390, 6, 7, 8, 1, -7 },
  { 396, 6, 10, 8, 1, -10 },
  { 404, 6, 7, 8, 1, -7 },
  { 410, 6, 10, 8, 1, -10 },
  { 418, 6, 7, 8, 1, -7 },
  { 424, 6, 10, 8, 2, -10 },
  { 432, 6, 10, 8, 1, -7 },
  { 440, 6, 10, 8, 1, -10 },
  { 448, 5, 9, 8, 1, -9 },
  { 454, 6, 12, 8, 0, -9 },
  { 463, 6, 10, 8, 1, -10 },
  { 471, 5, 10, 8, 1, -10 },
  { 478, 7, 7, 8, 0, -7 },
  { 485, 6, 7, 8, 1, -7 },
  { 491, 6, 7, 8, 1, -7 },
  { 497, 6, 10, 8, 0, -7 },
  { 505, 6, 10, 8, 1, -7 },
  { 513, 5, 7, 8, 2, -7 },
  { 518, 6, 7, 8, 1, -7 },
  { 524, 4, 9, 8, 2, -9 },
  { 529, 6, 7, 8, 1, -7 },
  { 535, 6, 7, 8, 1, -7 },
  { 541, 7, 7, 8, 1, -7 },
  { 548, 7, 7, 8, 0, -7 },
  { 555, 8, 10, 8, 0, -7 },
  { 565, 7, 7, 8, 0, -7 },
  { 572, 5, 13, 8, 2, -10 },
  { 581, 2, 11, 8, 3, -9 },
  { 584, 5, 13, 8, 1, -10 },
  { 593, 7, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_ThinItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic13pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_THINITALIC13PT7B_H_
