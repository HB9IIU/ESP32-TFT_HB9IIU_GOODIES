#ifndef _ROBOTOMONO_THINITALIC68PT7B_H_
#define _ROBOTOMONO_THINITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0x30, 0x39, 0x81, 0x8C, 0x0C,
  0x60, 0x63, 0x03, 0x18, 0x18, 0x80, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x18, 0x80, 0x8C, 0x0C, 0x60, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0xC0, 0x02, 0x00, 0x18, 0x60, 0x01, 0x00, 0x18, 0x30, 0x01, 0x80,
  0x18, 0x10, 0x00, 0xC0, 0x1C, 0x18, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0x30,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x20, 0x06, 0x03, 0x00, 0x18, 0x06,
  0x03, 0x00, 0x0E, 0x06, 0x03, 0x00, 0x03, 0xDE, 0x03, 0x80, 0x00, 0xFE,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x1E, 0x00, 0x00, 0x60, 0x3F, 0xC0, 0x00, 0x60, 0x38, 0x30,
  0x00, 0x70, 0x38, 0x0C, 0x00, 0x30, 0x38, 0x06, 0x00, 0x30, 0x18, 0x01,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x04, 0x00,
  0x30, 0x18, 0x06, 0x00, 0x18, 0x1C, 0x03, 0x00, 0x0C, 0x0C, 0x01, 0x80,
  0x04, 0x0C, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x03, 0x06, 0x00, 0x20,
  0x01, 0x86, 0x00, 0x10, 0x00, 0x86, 0x00, 0x0C, 0x00, 0xC1, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0x40, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x9C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x18, 0x30,
  0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x06, 0x30, 0x00, 0x60, 0x03, 0x18,
  0x00, 0x18, 0x03, 0x18, 0x00, 0x06, 0x01, 0x8C, 0x00, 0x03, 0x01, 0xCC,
  0x00, 0x00, 0xC0, 0xC6, 0x00, 0x00, 0x30, 0xE3, 0x00, 0x00, 0x18, 0x61,
  0x80, 0x00, 0x06, 0x70, 0xC0, 0x00, 0x01, 0xB0, 0x60, 0x00, 0x00, 0xF0,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x3C, 0x06, 0x00, 0x00, 0x3E,
  0x03, 0x00, 0x00, 0x39, 0x80, 0xE0, 0x00, 0x70, 0xE0, 0x38, 0x00, 0xF0,
  0x30, 0x0F, 0x03, 0xE0, 0x0C, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x33, 0x33, 0x32, 0x66, 0x66, 0x4C, 0xCC, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x40, 0x03, 0x00, 0x13, 0x80, 0x18, 0x07, 0xEF, 0x80, 0xC1, 0xF8,
  0x0F, 0x84, 0x3E, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x07, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x0E, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x30, 0xC3, 0x0C,
  0x21, 0x86, 0x30, 0xC6, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x6F, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x0E, 0x8C, 0x00, 0x00, 0x39, 0x18, 0x00, 0x00, 0xE6, 0x20,
  0x00, 0x03, 0x0C, 0xC0, 0x00, 0x0C, 0x19, 0x80, 0x00, 0x30, 0x33, 0x00,
  0x00, 0xC0, 0x66, 0x00, 0x07, 0x00, 0xC8, 0x00, 0x1C, 0x01, 0x30, 0x00,
  0x70, 0x06, 0x60, 0x01, 0xC0, 0x0C, 0xC0, 0x06, 0x00, 0x19, 0x80, 0x18,
  0x00, 0x33, 0x00, 0x60, 0x00, 0x64, 0x01, 0x80, 0x00, 0x98, 0x0E, 0x00,
  0x03, 0x30, 0x38, 0x00, 0x06, 0x60, 0xE0, 0x00, 0x0C, 0xC3, 0x00, 0x00,
  0x19, 0x8C, 0x00, 0x00, 0x63, 0x30, 0x00, 0x00, 0xC6, 0xC0, 0x00, 0x01,
  0x8F, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x40, 0x3C, 0x60, 0x78, 0x30, 0xF0, 0x1B, 0xE0, 0x0D, 0x80, 0x04,
  0x80, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x08, 0x03, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0E, 0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x07, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x20,
  0x00, 0x03, 0x80, 0x10, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x87,
  0xFE, 0x00, 0x00, 0x9F, 0xC7, 0xC0, 0x00, 0x5C, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x80,
  0x03, 0x07, 0xFF, 0x80, 0x30, 0xF8, 0x0F, 0x01, 0x8E, 0x00, 0x1C, 0x09,
  0xC0, 0x00, 0x70, 0xDC, 0x00, 0x01, 0x87, 0x80, 0x00, 0x06, 0x28, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x05, 0x18, 0x00, 0x00, 0x78, 0x60, 0x00, 0x06, 0xC3,
  0x00, 0x00, 0xE6, 0x0C, 0x00, 0x0E, 0x20, 0x38, 0x01, 0xC3, 0x00, 0xF8,
  0xFC, 0x18, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81, 0xE0, 0xE0, 0x00, 0x00, 0x30,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x0E, 0x00,
  0xFF, 0x80, 0x60, 0x18, 0x03, 0x83, 0x80, 0x60, 0x60, 0x0C, 0x03, 0x00,
  0xC1, 0xC0, 0x30, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x0C, 0x03, 0x0E, 0x03,
  0x00, 0x10, 0x06, 0x18, 0x06, 0x00, 0x20, 0x0C, 0x30, 0x18, 0x00, 0xC0,
  0x10, 0xC0, 0x30, 0x01, 0x80, 0x21, 0x80, 0xC0, 0x02, 0x00, 0xC6, 0x01,
  0x80, 0x0C, 0x01, 0x8C, 0x02, 0x00, 0x18, 0x03, 0x18, 0x0C, 0x00, 0x30,
  0x06, 0x20, 0x18, 0x00, 0x40, 0x0C, 0xC0, 0x20, 0x01, 0x80, 0x31, 0x80,
  0xC0, 0x03, 0x00, 0x63, 0x01, 0x80, 0x06, 0x00, 0xC6, 0x03, 0x00, 0x18,
  0x01, 0x88, 0x06, 0x00, 0x30, 0x06, 0x10, 0x08, 0x00, 0xE0, 0x0C, 0x20,
  0x10, 0x01, 0xC0, 0x18, 0xC0, 0x20, 0x07, 0x00, 0x61, 0x80, 0x40, 0x0A,
  0x00, 0xC3, 0x00, 0x80, 0x34, 0x03, 0x02, 0x01, 0x00, 0xC8, 0x0E, 0x06,
  0x03, 0x03, 0x18, 0x38, 0x0C, 0x07, 0x1C, 0x30, 0xE0, 0x18, 0x07, 0xF0,
  0x3F, 0x80, 0x30, 0x03, 0x80, 0x3C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x07, 0xF0, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x07, 0xC0, 0x0C, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x70, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x30, 0x03, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x38, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30,
  0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xCC, 0x00, 0x0F, 0xFF, 0xE6, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x70,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00,
  0x08, 0x00, 0x70, 0x00, 0x00, 0x40, 0x07, 0x00, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0x30, 0xF8, 0x00, 0x00, 0x01, 0x8E, 0xE0, 0x00, 0x00, 0x0C, 0xE3,
  0x00, 0x00, 0x00, 0x6E, 0x0C, 0x00, 0x00, 0x02, 0xE0, 0x60, 0x00, 0x00,
  0x3C, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x1F, 0x01, 0xA0, 0x00, 0x01, 0xB0, 0x1B, 0x00, 0x00, 0x32, 0x01, 0xB0,
  0x00, 0x03, 0x60, 0x13, 0x00, 0x00, 0x66, 0x03, 0x30, 0x00, 0x06, 0x60,
  0x31, 0x00, 0x00, 0xC6, 0x03, 0x18, 0x00, 0x1C, 0x40, 0x31, 0x80, 0x01,
  0x84, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x21, 0x80, 0x03, 0x0C, 0x06, 0x08,
  0x00, 0x60, 0xC0, 0x60, 0xC0, 0x06, 0x0C, 0x06, 0x0C, 0x00, 0xC0, 0x80,
  0x60, 0xC0, 0x18, 0x18, 0x04, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x18, 0x0C, 0x06,
  0x06, 0x01, 0x00, 0xC0, 0x60, 0xC0, 0x30, 0x08, 0x02, 0x18, 0x03, 0x01,
  0x80, 0x31, 0x80, 0x30, 0x18, 0x03, 0x30, 0x03, 0x01, 0x80, 0x33, 0x00,
  0x30, 0x18, 0x03, 0x60, 0x02, 0x01, 0x80, 0x16, 0x00, 0x60, 0x10, 0x01,
  0xC0, 0x06, 0x03, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x00, 0x80, 0x38, 0x00, 0x00, 0x04, 0x01, 0xE0, 0x00,
  0x00, 0x60, 0x0D, 0x00, 0x00, 0x03, 0x00, 0x48, 0x00, 0x00, 0x18, 0x06,
  0x60, 0x00, 0x00, 0xC0, 0x31, 0x00, 0x00, 0x04, 0x01, 0x8C, 0x00, 0x00,
  0x20, 0x0C, 0x60, 0x00, 0x03, 0x00, 0x41, 0x00, 0x00, 0x18, 0x02, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x20, 0x00, 0x06, 0x01, 0x81, 0x80, 0x00, 0x20,
  0x0C, 0x0C, 0x00, 0x01, 0x00, 0x60, 0x20, 0x00, 0x18, 0x02, 0x01, 0x80,
  0x00, 0xC0, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x20, 0x00, 0x30, 0x0C,
  0x01, 0x80, 0x01, 0x00, 0x60, 0x04, 0x00, 0x18, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x10, 0x01, 0x80, 0x06, 0x00, 0x80, 0x04, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0x08, 0x03, 0x00, 0x04, 0x00, 0xC0,
  0x18, 0x00, 0x30, 0x06, 0x00, 0x80, 0x00, 0x80, 0x30, 0x04, 0x00, 0x06,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x03, 0x00, 0x00, 0x80, 0x40, 0x18,
  0x00, 0x06, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x30, 0x04, 0x00, 0x00, 0x81,
  0x80, 0x20, 0x00, 0x06, 0x0C, 0x03, 0x00, 0x00, 0x10, 0x40, 0x18, 0x00,
  0x00, 0xC2, 0x00, 0xC0, 0x00, 0x06, 0x30, 0x04, 0x00, 0x00, 0x11, 0x80,
  0x20, 0x00, 0x00, 0xCC, 0x03, 0x00, 0x00, 0x06, 0x60, 0x18, 0x00, 0x00,
  0x12, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x06, 0x00, 0x00, 0x03, 0x80, 0x20,
  0x00, 0x00, 0x1C, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x70, 0x00, 0x60, 0x00, 0x70, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x3F,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x03,
  0xF0, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x10, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80,
  0x04, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x10, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0A, 0x00, 0x07, 0x00, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00,
  0xF0, 0x00, 0x48, 0x00, 0x3C, 0x00, 0x12, 0x00, 0x1B, 0x00, 0x0C, 0x80,
  0x06, 0xC0, 0x03, 0x20, 0x01, 0x30, 0x00, 0x88, 0x00, 0xCC, 0x00, 0x62,
  0x00, 0x33, 0x00, 0x18, 0x80, 0x08, 0xC0, 0x04, 0x20, 0x06, 0x30, 0x03,
  0x08, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0x40,
  0x18, 0x20, 0x0C, 0x10, 0x06, 0x08, 0x02, 0x04, 0x01, 0x02, 0x01, 0x81,
  0x00, 0xC0, 0x80, 0x60, 0x60, 0x30, 0x20, 0x30, 0x18, 0x08, 0x08, 0x0C,
  0x06, 0x02, 0x02, 0x03, 0x01, 0x81, 0x80, 0x81, 0x80, 0x60, 0x60, 0x20,
  0x60, 0x18, 0x10, 0x08, 0x18, 0x06, 0x0C, 0x02, 0x0C, 0x01, 0x83, 0x00,
  0x83, 0x00, 0x60, 0x80, 0x20, 0xC0, 0x18, 0x60, 0x08, 0x60, 0x06, 0x18,
  0x02, 0x18, 0x01, 0x84, 0x00, 0x86, 0x00, 0x63, 0x00, 0x23, 0x00, 0x18,
  0xC0, 0x08, 0xC0, 0x06, 0x20, 0x02, 0x30, 0x01, 0x98, 0x00, 0x98, 0x00,
  0x66, 0x00, 0x26, 0x00, 0x19, 0x80, 0x09, 0x00, 0x06, 0xC0, 0x02, 0xC0,
  0x01, 0xB0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x02, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x18, 0x20,
  0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00,
  0x18, 0x02, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x10, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x01, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0x86, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x06, 0x07, 0x80, 0x00,
  0x10, 0x78, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x1E, 0x30, 0x00, 0x01, 0xD8, 0x60, 0x00, 0x0E, 0x41, 0x80, 0x00,
  0x71, 0x83, 0x80, 0x07, 0x0E, 0x07, 0x80, 0xF8, 0x38, 0x07, 0xFF, 0x00,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0xC0, 0xFF, 0xC0, 0x02, 0x0F, 0x07, 0x80, 0x08, 0xF0, 0x03,
  0x80, 0x67, 0x00, 0x06, 0x01, 0xB0, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x80, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x05, 0x80, 0x00,
  0x70, 0x33, 0x00, 0x03, 0x80, 0xC6, 0x00, 0x3C, 0x03, 0x0F, 0x03, 0xC0,
  0x0C, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x07, 0x80, 0x30, 0x00, 0x1F, 0xF8, 0x18, 0x00, 0x3E, 0x0F, 0x0C,
  0x00, 0x78, 0x01, 0xC6, 0x00, 0x70, 0x00, 0x73, 0x00, 0x70, 0x00, 0x19,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x3C, 0x00,
  0xC0, 0x00, 0x36, 0x00, 0x30, 0x00, 0x33, 0x00, 0x1C, 0x00, 0x71, 0x00,
  0x07, 0x81, 0xF1, 0x80, 0x00, 0xFF, 0xE0, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7C, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0x03, 0x00, 0x0F, 0x83, 0xC3, 0x00, 0x3C, 0x00,
  0xE3, 0x00, 0x70, 0x00, 0x73, 0x00, 0xE0, 0x00, 0x32, 0x00, 0xC0, 0x00,
  0x1E, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xE0, 0x08, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x07,
  0x60, 0x07, 0x00, 0x1C, 0x40, 0x03, 0xC0, 0xF8, 0xC0, 0x00, 0xFF, 0xE0,
  0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x7F, 0xE0, 0x03,
  0x03, 0xE0, 0xF0, 0x06, 0x1E, 0x00, 0x70, 0x0C, 0x70, 0x00, 0x70, 0x19,
  0x80, 0x00, 0x60, 0x26, 0x00, 0x00, 0x40, 0x58, 0x00, 0x00, 0xC1, 0xA0,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x0F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x03, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x06, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x08, 0x38, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0x18, 0xF8, 0x00, 0x00, 0x19, 0x98, 0x00, 0x00, 0x1F, 0x0C, 0x00,
  0x00, 0x1E, 0x06, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0C, 0xF0, 0xF0, 0xF0, 0x70, 0x1B, 0x80, 0x63, 0x80, 0x60, 0x2C, 0x00,
  0x6E, 0x00, 0x60, 0x70, 0x00, 0xF0, 0x00, 0xC0, 0xE0, 0x01, 0xE0, 0x01,
  0x83, 0x80, 0x03, 0x80, 0x01, 0x06, 0x00, 0x06, 0x00, 0x02, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x40, 0x00, 0x40, 0x00, 0x61, 0x80, 0x00, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x00, 0x01, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x10, 0x00, 0x18, 0x00, 0x18, 0x60, 0x00, 0x20, 0x00, 0x30, 0xC0,
  0x00, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x80, 0x00, 0x83, 0x00, 0x03, 0x00,
  0x03, 0x04, 0x00, 0x06, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x60, 0x00, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC0,
  0x00, 0x41, 0x80, 0x01, 0x80, 0x01, 0x82, 0x00, 0x03, 0x00, 0x03, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x60, 0x00, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x00, 0xC1,
  0x00, 0x01, 0x80, 0x01, 0x82, 0x00, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0x80, 0x0C,
  0x0F, 0x83, 0xC0, 0x18, 0x78, 0x01, 0xC0, 0x31, 0xC0, 0x01, 0x80, 0x66,
  0x00, 0x01, 0x80, 0x98, 0x00, 0x03, 0x03, 0x60, 0x00, 0x03, 0x06, 0x80,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x3F, 0xF0, 0x00, 0x10, 0x78, 0x3C, 0x00, 0x18, 0xE0, 0x03, 0x00,
  0x0C, 0xE0, 0x00, 0xC0, 0x06, 0xC0, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x1B, 0x00, 0x00, 0xE0, 0x0D,
  0xC0, 0x00, 0xE0, 0x06, 0x70, 0x01, 0xC0, 0x03, 0x0F, 0x03, 0xC0, 0x01,
  0x83, 0xFF, 0x80, 0x00, 0x80, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x30, 0x03, 0xE0,
  0xF0, 0xC0, 0x3C, 0x00, 0xE3, 0x01, 0xC0, 0x01, 0xCC, 0x0E, 0x00, 0x03,
  0x20, 0x30, 0x00, 0x07, 0x81, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x01, 0xE0, 0x30, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x66, 0x01, 0xC0, 0x07,
  0x10, 0x03, 0xC0, 0xF8, 0x40, 0x03, 0xFF, 0x83, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x30, 0x07, 0xFF, 0x03, 0x01, 0xF0,
  0x10, 0x30, 0x78, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x23, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x38, 0x00, 0x38, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0xE0, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x04, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x78, 0x18, 0x00,
  0x01, 0xA0, 0x18, 0x00, 0x06, 0xC0, 0x30, 0x00, 0x19, 0x80, 0x38, 0x00,
  0xE3, 0x00, 0x3C, 0x0F, 0x86, 0x00, 0x3F, 0xFC, 0x0C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0x60, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0D,
  0x80, 0x03, 0xC0, 0x03, 0x10, 0x00, 0xD8, 0x00, 0x62, 0x00, 0x1B, 0x00,
  0x0C, 0x60, 0x06, 0x60, 0x03, 0x0C, 0x00, 0xCC, 0x00, 0x61, 0x80, 0x18,
  0x80, 0x18, 0x30, 0x06, 0x10, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x60, 0xC0,
  0x30, 0x60, 0x18, 0x18, 0x06, 0x0C, 0x03, 0x03, 0x00, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x30, 0x30, 0x18, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80,
  0x60, 0xC0, 0x18, 0x20, 0x04, 0x18, 0x03, 0x0C, 0x00, 0x86, 0x00, 0x61,
  0x80, 0x10, 0xC0, 0x04, 0x60, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x66, 0x00,
  0x11, 0x00, 0x0C, 0xC0, 0x02, 0x60, 0x01, 0xB0, 0x00, 0x48, 0x00, 0x36,
  0x00, 0x0B, 0x00, 0x06, 0x80, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x87, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0x0E, 0x0F, 0x00, 0x00,
  0x31, 0x80, 0x38, 0x00, 0x06, 0x30, 0x01, 0xC0, 0x00, 0x67, 0x00, 0x0E,
  0x00, 0x0E, 0x60, 0x00, 0x70, 0x00, 0xCC, 0x00, 0x03, 0x80, 0x18, 0xC0,
  0x00, 0x1C, 0x03, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x80, 0x00, 0x03, 0xFC,
  0x00,
};

const GFXglyph RobotoMono_ThinItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 11, 48, 40, 14, -48 },
  { 67, 13, 14, 40, 17, -51 },
  { 90, 39, 48, 40, 1, -48 },
  { 324, 32, 62, 40, 5, -55 },
  { 572, 33, 50, 40, 4, -49 },
  { 779, 33, 50, 40, 3, -49 },
  { 986, 4, 14, 40, 20, -51 },
  { 993, 20, 70, 40, 12, -54 },
  { 1168, 21, 70, 40, 6, -54 },
  { 1352, 29, 26, 40, 9, -48 },
  { 1447, 33, 35, 40, 4, -40 },
  { 1592, 6, 13, 40, 9, -5 },
  { 1602, 23, 2, 40, 8, -23 },
  { 1608, 4, 4, 40, 16, -4 },
  { 1610, 30, 52, 40, 6, -48 },
  { 1805, 31, 50, 40, 5, -49 },
  { 1999, 17, 48, 40, 11, -48 },
  { 2101, 31, 49, 40, 2, -49 },
  { 2291, 33, 50, 40, 2, -49 },
  { 2498, 33, 48, 40, 2, -48 },
  { 2696, 33, 49, 40, 6, -48 },
  { 2899, 29, 50, 40, 4, -49 },
  { 3081, 30, 48, 40, 9, -48 },
  { 3261, 34, 50, 40, 4, -49 },
  { 3474, 29, 50, 40, 7, -49 },
  { 3656, 9, 33, 40, 18, -33 },
  { 3694, 13, 41, 40, 14, -33 },
  { 3761, 31, 26, 40, 5, -35 },
  { 3862, 31, 16, 40, 5, -30 },
  { 3924, 30, 27, 40, 4, -36 },
  { 4026, 25, 49, 40, 11, -49 },
  { 4180, 39, 50, 40, 1, -49 },
  { 4424, 33, 48, 40, 0, -48 },
  { 4622, 33, 48, 40, 4, -48 },
  { 4820, 33, 50, 40, 4, -49 },
  { 5027, 34, 48, 40, 3, -48 },
  { 5231, 35, 48, 40, 4, -48 },
  { 5441, 35, 48, 40, 4, -48 },
  { 5651, 33, 50, 40, 4, -49 },
  { 5858, 37, 48, 40, 2, -48 },
  { 6080, 35, 48, 40, 3, -48 },
  { 6290, 34, 49, 40, 3, -48 },
  { 6499, 37, 48, 40, 4, -48 },
  { 6721, 27, 48, 40, 4, -48 },
  { 6883, 36, 48, 40, 3, -48 },
  { 7099, 37, 48, 40, 2, -48 },
  { 7321, 33, 50, 40, 4, -49 },
  { 7528, 35, 48, 40, 4, -48 },
  { 7738, 34, 58, 40, 4, -49 },
  { 7985, 33, 48, 40, 4, -48 },
  { 8183, 34, 50, 40, 4, -49 },
  { 8396, 33, 48, 40, 8, -48 },
  { 8594, 35, 49, 40, 4, -48 },
  { 8809, 32, 48, 40, 8, -48 },
  { 9001, 34, 48, 40, 8, -48 },
  { 9205, 40, 48, 40, 1, -48 },
  { 9445, 33, 48, 40, 8, -48 },
  { 9643, 35, 48, 40, 2, -48 },
  { 9853, 19, 65, 40, 11, -55 },
  { 10008, 12, 52, 40, 14, -48 },
  { 10086, 20, 65, 40, 10, -55 },
  { 10249, 23, 26, 40, 9, -48 },
  { 10324, 28, 2, 40, 2, 0 },
  { 10331, 6, 9, 40, 21, -50 },
  { 10338, 30, 38, 40, 4, -37 },
  { 10481, 30, 52, 40, 4, -51 },
  { 10676, 29, 38, 40, 5, -37 },
  { 10814, 33, 52, 40, 5, -51 },
  { 11029, 31, 38, 40, 4, -37 },
  { 11177, 32, 52, 40, 9, -52 },
  { 11385, 32, 51, 40, 3, -37 },
  { 11589, 31, 51, 40, 3, -51 },
  { 11787, 27, 49, 40, 4, -49 },
  { 11953, 31, 64, 40, 0, -49 },
  { 12201, 32, 51, 40, 5, -51 },
  { 12405, 27, 51, 40, 4, -51 },
  { 12578, 39, 37, 40, -1, -37 },
  { 12759, 31, 37, 40, 3, -37 },
  { 12903, 31, 38, 40, 4, -37 },
  { 13051, 33, 51, 40, 1, -37 },
  { 13262, 30, 51, 40, 5, -37 },
  { 13454, 28, 37, 40, 9, -37 },
  { 13584, 30, 38, 40, 5, -37 },
  { 13727, 25, 47, 40, 9, -46 },
  { 13874, 31, 37, 40, 5, -36 },
  { 14018, 32, 36, 40, 6, -36 },
  { 14162, 35, 36, 40, 5, -36 },
  { 14320, 35, 36, 40, 2, -36 },
  { 14478, 41, 51, 40, -1, -36 },
  { 14740, 35, 36, 40, 1, -36 },
  { 14898, 26, 68, 40, 11, -53 },
  { 15119, 11, 57, 40, 14, -48 },
  { 15198, 26, 68, 40, 6, -53 },
  { 15419, 36, 11, 40, 2, -26 },
};

const GFXfont RobotoMono_ThinItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic68pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_THINITALIC68PT7B_H_
