#ifndef _ROBOTOMONO_THINITALIC52PT7B_H_
#define _ROBOTOMONO_THINITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0xE0, 0xC0, 0x20, 0xC8, 0x22, 0x09, 0x82, 0x61, 0x90, 0x64, 0x11, 0x04,
  0x41, 0x30, 0xCC, 0x30, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x02, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80,
  0x60, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x30,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x06, 0x00, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x0C, 0x03,
  0x00, 0x06, 0x02, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x1C,
  0x07, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x08, 0x00, 0x02, 0x06, 0x00, 0x02, 0x01, 0x00, 0x03,
  0x00, 0x80, 0x11, 0x00, 0x60, 0x18, 0x80, 0x20, 0x18, 0x40, 0x10, 0x08,
  0x60, 0x08, 0x0C, 0x30, 0x04, 0x0C, 0x18, 0x06, 0x0C, 0x0C, 0x02, 0x04,
  0x06, 0x03, 0x06, 0x01, 0x01, 0x06, 0x00, 0xC1, 0x82, 0x00, 0x3F, 0x83,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x81, 0xF8, 0x00, 0xC1, 0x86, 0x00,
  0xC1, 0x81, 0x80, 0x41, 0x80, 0x40, 0x60, 0x80, 0x20, 0x60, 0x40, 0x10,
  0x20, 0x60, 0x08, 0x20, 0x30, 0x04, 0x30, 0x10, 0x06, 0x30, 0x08, 0x03,
  0x10, 0x04, 0x01, 0x18, 0x02, 0x01, 0x88, 0x01, 0x00, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x08, 0x00, 0x30, 0x02, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x20,
  0x00, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x08, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x60,
  0x0C, 0x20, 0x08, 0x02, 0x10, 0x03, 0x00, 0x8C, 0x00, 0x40, 0x62, 0x00,
  0x08, 0x19, 0x80, 0x03, 0x04, 0x60, 0x00, 0x43, 0x10, 0x00, 0x19, 0x84,
  0x00, 0x03, 0x61, 0x00, 0x00, 0x70, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0F,
  0x03, 0x00, 0x06, 0x40, 0x60, 0x07, 0x18, 0x0C, 0x07, 0x03, 0x01, 0xFF,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x32, 0x22, 0x66, 0x44, 0x44, 0xC0, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x78, 0x04, 0x0F, 0x3C,
  0x30, 0xF0, 0x1E, 0xDE, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xD0,
  0x00, 0x06, 0x20, 0x00, 0x30, 0xC0, 0x01, 0x81, 0x80, 0x0C, 0x02, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0xC4, 0x21,
  0x18, 0x8C, 0xC4, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x0C, 0x02, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x18, 0x00, 0x03, 0x10, 0x00, 0x07, 0x10, 0x00, 0x0F, 0x30,
  0x00, 0x1B, 0x20, 0x00, 0x33, 0x20, 0x00, 0x63, 0x60, 0x00, 0xC2, 0x60,
  0x03, 0x02, 0x60, 0x06, 0x02, 0x40, 0x0C, 0x02, 0x40, 0x18, 0x06, 0x40,
  0x30, 0x06, 0xC0, 0x60, 0x04, 0xC0, 0xC0, 0x04, 0x81, 0x00, 0x04, 0x86,
  0x00, 0x0C, 0x8C, 0x00, 0x0C, 0x98, 0x00, 0x08, 0xB0, 0x00, 0x08, 0xE0,
  0x00, 0x18, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x20, 0x40,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x30, 0x03, 0x00, 0x1C,
  0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x03, 0xC0,
  0x76, 0x0E, 0x33, 0xC1, 0x70, 0x0A, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x70, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x10, 0x00, 0x18, 0x18, 0x00, 0x04, 0x18, 0x00, 0x02, 0x08, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x10, 0x20, 0x00, 0x18, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x10, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x03, 0x00, 0x80,
  0x01, 0x80, 0x20, 0x00, 0x40, 0x08, 0x00, 0x20, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x10, 0x03, 0x00, 0x04, 0x00, 0x80,
  0x01, 0x00, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x08, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x63, 0xFC, 0x00, 0x2F,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x08, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x81, 0x80, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x03, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x0F, 0xF0, 0x04, 0x78, 0x38, 0x19, 0x80, 0x18, 0x2C, 0x00, 0x18,
  0x70, 0x00, 0x11, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x26, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80,
  0x00, 0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x10, 0x00, 0x04, 0x30, 0x00, 0x18, 0x20, 0x00, 0x60, 0x60, 0x01,
  0x80, 0x60, 0x06, 0x00, 0x70, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x06, 0x00,
  0x0C, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x08, 0x10,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x08,
  0x30, 0x00, 0x06, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x03, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x08,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x30, 0x0F, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x0E,
  0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x21, 0x80, 0x00, 0x84,
  0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00, 0x16, 0x00, 0x00, 0x50, 0x00,
  0x01, 0x40, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x60,
  0x00, 0x28, 0x80, 0x01, 0xA3, 0x00, 0x0D, 0x86, 0x00, 0xC4, 0x0E, 0x1E,
  0x10, 0x0F, 0xE0, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xFC, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x70, 0x60, 0x00, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0xE0, 0x70, 0x30, 0x03, 0x0C, 0x00, 0x23, 0x00,
  0x06, 0x40, 0x00, 0xD8, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0x0E,
  0x00, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x06, 0x03,
  0xF8, 0x08, 0x60, 0x30, 0x60, 0x43, 0x03, 0x01, 0x02, 0x30, 0x30, 0x08,
  0x11, 0x83, 0x00, 0x80, 0x88, 0x10, 0x04, 0x04, 0xC1, 0x80, 0x20, 0x24,
  0x08, 0x03, 0x01, 0x60, 0x40, 0x10, 0x1B, 0x06, 0x00, 0x80, 0xD0, 0x20,
  0x0C, 0x04, 0x81, 0x00, 0x60, 0x24, 0x08, 0x02, 0x01, 0x60, 0xC0, 0x10,
  0x1B, 0x06, 0x01, 0x80, 0x98, 0x20, 0x0C, 0x04, 0x81, 0x00, 0xC0, 0x64,
  0x08, 0x0E, 0x02, 0x30, 0x60, 0xD0, 0x31, 0x83, 0x0C, 0xC3, 0x0C, 0x0D,
  0xC3, 0xF0, 0x20, 0x3C, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x08, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x04, 0x40, 0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0,
  0x40, 0x00, 0x40, 0x20, 0x00, 0x60, 0x10, 0x00, 0x20, 0x08, 0x00, 0x30,
  0x04, 0x00, 0x10, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0x40, 0x0C,
  0x00, 0x20, 0x04, 0x00, 0x10, 0x06, 0x00, 0x08, 0x02, 0x00, 0x04, 0x03,
  0x00, 0x03, 0x01, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x30, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x08, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x7C, 0x00, 0x80,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x20, 0x00, 0x08, 0x10,
  0x00, 0x06, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x30,
  0x20, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x70, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x02, 0x00, 0x06, 0x01, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x10, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x30, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x60,
  0x00, 0x38, 0x20, 0x00, 0x30, 0x10, 0x01, 0xF0, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08,
  0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x10, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x30, 0x08,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x60,
  0x1F, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30,
  0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x0C, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x60, 0x08, 0x00,
  0x18, 0x01, 0x00, 0x0E, 0x00, 0x20, 0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x40, 0x00, 0x08, 0x30, 0x00, 0x02,
  0x08, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x30, 0x01, 0xFF, 0xCC, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x07, 0x00, 0x38, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x01, 0x03, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60,
  0x08, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x70, 0x1C, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x10, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x03,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x20, 0x03, 0x00, 0x01, 0x00, 0x30, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x06, 0x6C,
  0x00, 0x00, 0x26, 0x30, 0x00, 0x01, 0x60, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x20, 0x03, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x08, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x18, 0x02, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x28, 0x00, 0x0E,
  0x02, 0x80, 0x01, 0xA0, 0x68, 0x00, 0x12, 0x06, 0xC0, 0x03, 0x20, 0x4C,
  0x00, 0x26, 0x04, 0x40, 0x06, 0x60, 0x44, 0x00, 0x44, 0x04, 0x40, 0x0C,
  0x40, 0xC6, 0x01, 0x84, 0x0C, 0x60, 0x10, 0x40, 0x82, 0x03, 0x0C, 0x08,
  0x20, 0x20, 0xC0, 0x82, 0x06, 0x08, 0x18, 0x30, 0x40, 0x81, 0x83, 0x0C,
  0x08, 0x18, 0x11, 0x80, 0x81, 0x01, 0x10, 0x18, 0x10, 0x13, 0x01, 0x81,
  0x01, 0xA0, 0x10, 0x30, 0x1E, 0x01, 0x03, 0x00, 0xC0, 0x10, 0x20, 0x0C,
  0x03, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x38, 0x00, 0x02, 0x06, 0x80,
  0x00, 0x20, 0x48, 0x00, 0x06, 0x04, 0x40, 0x00, 0x60, 0x44, 0x00, 0x04,
  0x04, 0x60, 0x00, 0x40, 0x42, 0x00, 0x04, 0x0C, 0x20, 0x00, 0x40, 0x83,
  0x00, 0x0C, 0x08, 0x10, 0x00, 0xC0, 0x81, 0x00, 0x08, 0x08, 0x08, 0x00,
  0x81, 0x80, 0x80, 0x08, 0x18, 0x0C, 0x00, 0x81, 0x00, 0x40, 0x18, 0x10,
  0x04, 0x01, 0x01, 0x00, 0x60, 0x10, 0x10, 0x02, 0x01, 0x03, 0x00, 0x20,
  0x10, 0x30, 0x01, 0x03, 0x02, 0x00, 0x10, 0x30, 0x20, 0x01, 0x82, 0x02,
  0x00, 0x08, 0x20, 0x20, 0x00, 0x82, 0x06, 0x00, 0x0C, 0x20, 0x60, 0x00,
  0x46, 0x04, 0x00, 0x04, 0x60, 0x40, 0x00, 0x24, 0x04, 0x00, 0x02, 0x40,
  0x40, 0x00, 0x34, 0x0C, 0x00, 0x01, 0x40, 0xC0, 0x00, 0x1C, 0x08, 0x00,
  0x01, 0xC0, 0x80, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1C, 0x0C,
  0x00, 0x38, 0x01, 0x00, 0x30, 0x00, 0x40, 0x30, 0x00, 0x30, 0x10, 0x00,
  0x08, 0x18, 0x00, 0x04, 0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x24, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x02,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0x84, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x20, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x60, 0x07, 0xC0,
  0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x10, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x04, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x08,
  0x00, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x3C,
  0x01, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1E, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x08, 0x30, 0x00, 0x02,
  0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x58, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x30, 0x00, 0x03, 0x04,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x40, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xE0,
  0x01, 0x00, 0x3C, 0x00, 0x80, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x20, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x08, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x18, 0x40, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x08,
  0x00, 0x04, 0x0C, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x1C, 0x01,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x20, 0x00, 0x80, 0x10, 0x00, 0x60, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x60, 0x40, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x07, 0x00,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x07, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08,
  0x10, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x30,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00,
  0x04, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x08, 0x00, 0x0C,
  0x04, 0x00, 0x04, 0x02, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x20,
  0x10, 0x00, 0x10, 0x18, 0x00, 0x08, 0x08, 0x00, 0x04, 0x0C, 0x00, 0x03,
  0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x08, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x80,
  0x14, 0x00, 0xA0, 0x05, 0x00, 0x68, 0x03, 0x40, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x64, 0x03, 0x20, 0x19, 0x00, 0x88, 0x04, 0x40, 0x22, 0x03, 0x10,
  0x18, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x18, 0x40, 0x42, 0x04,
  0x10, 0x30, 0x81, 0x04, 0x08, 0x20, 0xC1, 0x02, 0x08, 0x20, 0x41, 0x82,
  0x08, 0x10, 0x40, 0x86, 0x04, 0x10, 0x21, 0x01, 0x0C, 0x08, 0x40, 0x62,
  0x02, 0x30, 0x18, 0x80, 0x88, 0x06, 0x60, 0x22, 0x01, 0x90, 0x09, 0x80,
  0x64, 0x02, 0x40, 0x1B, 0x00, 0xB0, 0x06, 0x80, 0x2C, 0x01, 0xA0, 0x0A,
  0x00, 0x68, 0x02, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0xC0,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x60, 0x10, 0x00, 0x20, 0x0C, 0x00,
  0x30, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x10, 0x00, 0x20,
  0x18, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x26, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xFE, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x00, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x0C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00,
  0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C,
  0x06, 0x01, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x01, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x04, 0xC0, 0x06,
  0x60, 0x06, 0x10, 0x02, 0x08, 0x03, 0x04, 0x01, 0x03, 0x01, 0x80, 0x80,
  0x80, 0x40, 0xC0, 0x20, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x02, 0x20, 0x01,
  0x30, 0x00, 0xD0, 0x00, 0x78, 0x00, 0x10, 0xFF, 0xFF, 0xF8, 0x86, 0x10,
  0xC2, 0x18, 0x60, 0x00, 0x1F, 0xC0, 0x01, 0xFB, 0xE0, 0x06, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x60, 0x00, 0x41, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x8C,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0x81, 0xF0, 0x01, 0x0E, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x4C, 0x00, 0x01, 0x90, 0x00, 0x03, 0x20, 0x00, 0x0E, 0x60, 0x00, 0x38,
  0xC0, 0x00, 0xD0, 0xC0, 0x06, 0x20, 0xC0, 0x38, 0x40, 0xFF, 0xC0, 0x80,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0xFC, 0x00, 0xC7, 0x8E, 0x01, 0x98, 0x06, 0x02, 0x40, 0x02, 0x05, 0x00,
  0x06, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x08, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x31, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22,
  0x00, 0x00, 0xC4, 0x00, 0x01, 0x98, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40,
  0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x87, 0x80, 0x06, 0x0D, 0x80,
  0x18, 0x19, 0xC0, 0xE0, 0x20, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xC7, 0x80, 0x38, 0x03, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x08,
  0x20, 0x00, 0x31, 0x80, 0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x05, 0x80,
  0x00, 0x16, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x13, 0x00, 0x00, 0xC4, 0x00,
  0x02, 0x10, 0x00, 0x18, 0x20, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0xC0, 0x70,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xE0, 0xC0, 0x0F, 0x3C, 0x60, 0x1C,
  0x03, 0x30, 0x18, 0x00, 0xD0, 0x18, 0x00, 0x28, 0x18, 0x00, 0x1C, 0x08,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x01,
  0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x20, 0x60, 0x00, 0x30, 0x10, 0x00, 0x38, 0x0C, 0x00, 0x3C, 0x03, 0x00,
  0x36, 0x00, 0xC0, 0x72, 0x00, 0x3F, 0xE1, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x0C, 0x06,
  0x00, 0x04, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x02, 0x7F,
  0xFF, 0xFE, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x10, 0x10,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1E,
  0x78, 0xC0, 0x38, 0x06, 0x60, 0x30, 0x01, 0xA0, 0x30, 0x00, 0x50, 0x30,
  0x00, 0x38, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04,
  0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x70, 0x18, 0x00,
  0x78, 0x06, 0x00, 0x6C, 0x01, 0x80, 0xE4, 0x00, 0x7F, 0xC2, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x7F, 0x00, 0x83, 0xC7, 0x01, 0x0C,
  0x03, 0x02, 0x60, 0x03, 0x05, 0x80, 0x03, 0x1A, 0x00, 0x06, 0x38, 0x00,
  0x04, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x20, 0x00, 0x04, 0x40, 0x00, 0x08,
  0x80, 0x00, 0x11, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x10,
  0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x81, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x1C, 0x08, 0x00,
  0x30, 0x08, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x18, 0x06,
  0x00, 0x10, 0x0C, 0x00, 0x10, 0x38, 0x00, 0x10, 0x60, 0x00, 0x10, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x36, 0xC0, 0x00, 0x2C, 0x60, 0x00, 0x38, 0x20,
  0x00, 0x20, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x08, 0x00, 0x60, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x40, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x80, 0x00, 0x60, 0x80, 0x00,
  0x30, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x03, 0xF0,
  0x13, 0xDE, 0x3E, 0xE0, 0x58, 0x09, 0x80, 0xC1, 0xC0, 0x3C, 0x01, 0x06,
  0x00, 0xE0, 0x04, 0x30, 0x01, 0x80, 0x10, 0xC0, 0x0C, 0x00, 0x42, 0x00,
  0x30, 0x01, 0x08, 0x00, 0xC0, 0x04, 0x20, 0x02, 0x00, 0x31, 0x80, 0x08,
  0x00, 0xC6, 0x00, 0x20, 0x02, 0x10, 0x01, 0x80, 0x08, 0x40, 0x06, 0x00,
  0x21, 0x00, 0x10, 0x00, 0x84, 0x00, 0x40, 0x06, 0x30, 0x01, 0x00, 0x18,
  0xC0, 0x04, 0x00, 0x42, 0x00, 0x30, 0x01, 0x08, 0x00, 0xC0, 0x04, 0x20,
  0x02, 0x00, 0x10, 0x80, 0x08, 0x00, 0xC6, 0x00, 0x20, 0x03, 0x18, 0x00,
  0x80, 0x08, 0x40, 0x06, 0x00, 0x21, 0x00, 0x18, 0x00, 0x84, 0x00, 0x40,
  0x02, 0x30, 0x01, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x18, 0x78, 0xE0, 0x21,
  0x80, 0x60, 0x4C, 0x00, 0x60, 0xB0, 0x00, 0x43, 0x40, 0x00, 0xC7, 0x00,
  0x00, 0x8C, 0x00, 0x01, 0x18, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00,
  0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xF9, 0xE0, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x08, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x8F, 0x1C, 0x00,
  0x8C, 0x03, 0x00, 0x58, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x18, 0x00, 0x08,
  0x1C, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x02, 0x08, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x20, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x3C, 0x00, 0x30, 0x1B,
  0x00, 0x30, 0x08, 0xE0, 0x70, 0x04, 0x3F, 0xE0, 0x02, 0x01, 0x80, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xE7,
  0x8C, 0x0E, 0x01, 0x98, 0x30, 0x01, 0xA0, 0xC0, 0x01, 0x43, 0x00, 0x03,
  0x84, 0x00, 0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x11,
  0x80, 0x00, 0x22, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x20,
  0x00, 0x06, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00,
  0x00, 0xC4, 0x00, 0x01, 0x88, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00,
  0x18, 0x20, 0x00, 0x70, 0x60, 0x01, 0xE0, 0x60, 0x06, 0xC0, 0x60, 0x39,
  0x00, 0x7F, 0xC2, 0x00, 0x08, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xFC, 0x10, 0x7C, 0x20, 0xC7, 0x00, 0x03, 0x30, 0x00, 0x09,
  0x80, 0x00, 0x2C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xE7, 0xE0, 0x0C,
  0x00, 0xE0, 0x60, 0x00, 0x60, 0x80, 0x00, 0x43, 0x00, 0x00, 0xC4, 0x00,
  0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x03, 0x20, 0x00, 0x04, 0x60,
  0x00, 0x18, 0x40, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xE0, 0x0E, 0x00, 0x7F,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x02, 0x20, 0x00,
  0x0C, 0x40, 0x00, 0x18, 0x80, 0x00, 0x31, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x10, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x18,
  0x80, 0x00, 0x23, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x03, 0x10,
  0x00, 0x06, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00,
  0x00, 0x46, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x10, 0x00,
  0x38, 0x30, 0x00, 0xD0, 0x20, 0x03, 0x20, 0x70, 0x3C, 0xC0, 0x3F, 0xE1,
  0x80, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x10, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x08, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x04, 0x0C,
  0x00, 0x04, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x02, 0x30,
  0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x0C, 0x00, 0x78, 0x01, 0x80, 0x0B, 0x00,
  0x30, 0x03, 0x60, 0x0E, 0x00, 0x4C, 0x01, 0x40, 0x19, 0x80, 0x68, 0x03,
  0x30, 0x09, 0x80, 0x46, 0x03, 0x30, 0x18, 0xC0, 0x66, 0x02, 0x18, 0x08,
  0xC0, 0x41, 0x03, 0x18, 0x18, 0x20, 0x41, 0x02, 0x04, 0x18, 0x20, 0xC0,
  0x82, 0x04, 0x10, 0x10, 0x40, 0x82, 0x02, 0x18, 0x10, 0xC0, 0x42, 0x02,
  0x10, 0x08, 0xC0, 0x46, 0x01, 0x10, 0x08, 0x80, 0x26, 0x01, 0x90, 0x04,
  0x80, 0x36, 0x00, 0x90, 0x06, 0x80, 0x16, 0x00, 0xF0, 0x02, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x80,
  0x08, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x40, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x08, 0x00, 0x40, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80,
  0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0x18, 0x18, 0x00, 0x33, 0x00, 0xC0, 0x02,
  0x20, 0x06, 0x00, 0x66, 0x00, 0x30, 0x0C, 0x40, 0x01, 0x81, 0x8C, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1C, 0x00,
};

const GFXglyph RobotoMono_ThinItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 37, 31, 11, -37 },
  { 38, 10, 11, 31, 13, -39 },
  { 52, 30, 37, 31, 1, -37 },
  { 191, 24, 47, 31, 4, -42 },
  { 332, 25, 39, 31, 3, -38 },
  { 454, 26, 39, 31, 2, -38 },
  { 581, 4, 11, 31, 15, -39 },
  { 587, 16, 53, 31, 9, -41 },
  { 693, 15, 53, 31, 5, -41 },
  { 793, 22, 20, 31, 7, -37 },
  { 848, 25, 27, 31, 3, -31 },
  { 933, 5, 10, 31, 7, -4 },
  { 940, 18, 2, 31, 6, -18 },
  { 945, 3, 3, 31, 12, -3 },
  { 947, 24, 40, 31, 4, -37 },
  { 1067, 24, 39, 31, 4, -38 },
  { 1184, 13, 37, 31, 8, -37 },
  { 1245, 24, 37, 31, 1, -37 },
  { 1356, 25, 38, 31, 1, -37 },
  { 1475, 26, 37, 31, 1, -37 },
  { 1596, 25, 38, 31, 5, -37 },
  { 1715, 23, 38, 31, 3, -37 },
  { 1825, 23, 37, 31, 7, -37 },
  { 1932, 26, 38, 31, 3, -37 },
  { 2056, 22, 39, 31, 5, -38 },
  { 2164, 7, 25, 31, 13, -25 },
  { 2186, 10, 31, 31, 10, -25 },
  { 2225, 23, 20, 31, 4, -27 },
  { 2283, 24, 12, 31, 4, -23 },
  { 2319, 23, 20, 31, 3, -27 },
  { 2377, 19, 37, 31, 8, -37 },
  { 2465, 29, 37, 31, 1, -37 },
  { 2600, 25, 37, 31, 0, -37 },
  { 2716, 25, 37, 31, 3, -37 },
  { 2832, 26, 39, 31, 3, -38 },
  { 2959, 27, 37, 31, 2, -37 },
  { 3084, 27, 37, 31, 3, -37 },
  { 3209, 27, 37, 31, 3, -37 },
  { 3334, 26, 38, 31, 3, -37 },
  { 3458, 28, 37, 31, 2, -37 },
  { 3588, 26, 37, 31, 3, -37 },
  { 3709, 26, 38, 31, 2, -37 },
  { 3833, 29, 37, 31, 3, -37 },
  { 3968, 21, 37, 31, 3, -37 },
  { 4066, 28, 37, 31, 2, -37 },
  { 4196, 28, 37, 31, 2, -37 },
  { 4326, 25, 38, 31, 3, -37 },
  { 4445, 27, 37, 31, 3, -37 },
  { 4570, 26, 44, 31, 3, -37 },
  { 4713, 25, 37, 31, 3, -37 },
  { 4829, 26, 38, 31, 3, -37 },
  { 4953, 25, 37, 31, 6, -37 },
  { 5069, 27, 38, 31, 3, -37 },
  { 5198, 25, 37, 31, 6, -37 },
  { 5314, 26, 37, 31, 6, -37 },
  { 5435, 30, 37, 31, 1, -37 },
  { 5574, 25, 37, 31, 6, -37 },
  { 5690, 27, 37, 31, 1, -37 },
  { 5815, 15, 50, 31, 8, -42 },
  { 5909, 9, 40, 31, 11, -37 },
  { 5954, 15, 50, 31, 8, -42 },
  { 6048, 17, 20, 31, 7, -37 },
  { 6091, 21, 1, 31, 2, 0 },
  { 6094, 5, 7, 31, 16, -39 },
  { 6099, 23, 29, 31, 3, -28 },
  { 6183, 23, 40, 31, 3, -39 },
  { 6298, 22, 29, 31, 4, -28 },
  { 6378, 25, 40, 31, 4, -39 },
  { 6503, 24, 29, 31, 3, -28 },
  { 6590, 25, 40, 31, 7, -40 },
  { 6715, 25, 39, 31, 2, -28 },
  { 6837, 23, 39, 31, 3, -39 },
  { 6950, 21, 37, 31, 3, -37 },
  { 7048, 24, 48, 31, 0, -37 },
  { 7192, 24, 39, 31, 4, -39 },
  { 7309, 21, 39, 31, 3, -39 },
  { 7412, 30, 28, 31, -1, -28 },
  { 7517, 23, 28, 31, 3, -28 },
  { 7598, 24, 29, 31, 3, -28 },
  { 7685, 25, 39, 31, 1, -28 },
  { 7807, 23, 39, 31, 4, -28 },
  { 7920, 22, 28, 31, 7, -28 },
  { 7997, 23, 29, 31, 4, -28 },
  { 8081, 19, 36, 31, 7, -35 },
  { 8167, 23, 28, 31, 4, -27 },
  { 8248, 24, 28, 31, 5, -28 },
  { 8332, 27, 27, 31, 4, -27 },
  { 8424, 28, 28, 31, 1, -28 },
  { 8522, 31, 39, 31, -1, -28 },
  { 8674, 27, 27, 31, 1, -27 },
  { 8766, 20, 52, 31, 8, -41 },
  { 8896, 8, 44, 31, 11, -37 },
  { 8940, 20, 52, 31, 4, -41 },
  { 9070, 28, 9, 31, 1, -20 },
};

const GFXfont RobotoMono_ThinItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic52pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_THINITALIC52PT7B_H_
