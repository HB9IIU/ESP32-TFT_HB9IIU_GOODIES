#ifndef _ROBOTOMONO_THINITALIC22PT7B_H_
#define _ROBOTOMONO_THINITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x49, 0x40, 0x04, 0x99, 0xAA, 0xA0, 0x01, 0x10,
  0x10, 0x80, 0x88, 0x04, 0x40, 0x42, 0x1F, 0xEC, 0x11, 0x01, 0x08, 0x08,
  0x80, 0x44, 0x04, 0x21, 0xFF, 0xC1, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40,
  0x01, 0x00, 0x20, 0x1E, 0x04, 0x21, 0x02, 0x40, 0x48, 0x09, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0xA0, 0x12, 0x02, 0x40, 0x86,
  0xE0, 0x20, 0x04, 0x00, 0x38, 0x08, 0x81, 0x11, 0x42, 0x48, 0x49, 0x12,
  0x14, 0x81, 0x10, 0x04, 0x01, 0x38, 0x48, 0x89, 0x12, 0x22, 0x88, 0x50,
  0x90, 0x1C, 0x07, 0x01, 0x10, 0x42, 0x08, 0x41, 0x10, 0x24, 0x05, 0x00,
  0x40, 0x34, 0x08, 0x85, 0x08, 0xC1, 0x28, 0x15, 0x01, 0x10, 0x61, 0xF2,
  0x55, 0x80, 0x04, 0x21, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x80, 0x18, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x20, 0x41,
  0x04, 0x10, 0x00, 0x04, 0x02, 0x02, 0x19, 0x33, 0xE0, 0xC0, 0x90, 0x44,
  0x42, 0x00, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x41, 0xFF, 0xC1, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x56, 0x80, 0xFE, 0x80, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x04, 0x22, 0x05,
  0x01, 0x40, 0xE0, 0x58, 0x26, 0x11, 0x88, 0xA4, 0x2A, 0x0B, 0x02, 0x81,
  0x20, 0x48, 0x21, 0xF0, 0x04, 0x76, 0x61, 0x08, 0x20, 0x82, 0x08, 0x21,
  0x04, 0x10, 0x41, 0x04, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x40, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03, 0xFE,
  0x0F, 0x04, 0x32, 0x05, 0x01, 0x00, 0x40, 0x10, 0x08, 0x0C, 0x0F, 0x00,
  0x20, 0x08, 0x02, 0x80, 0xA0, 0x28, 0x11, 0xF8, 0x00, 0x40, 0x20, 0x18,
  0x0A, 0x04, 0x82, 0x20, 0x88, 0x44, 0x21, 0x10, 0x48, 0x13, 0xFF, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x1F, 0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x17, 0x83, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x48, 0x09, 0x02, 0x20,
  0xC3, 0xE0, 0x01, 0xC1, 0x80, 0x80, 0x40, 0x20, 0x08, 0x05, 0xF1, 0x82,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x90, 0x24, 0x10, 0xF8, 0xFF, 0xC0,
  0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x07, 0x81, 0x08, 0x40, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x10, 0xFC, 0x11, 0x84, 0x09, 0x01, 0x40, 0x28, 0x05,
  0x00, 0x90, 0x21, 0xF8, 0x0F, 0x0C, 0x24, 0x09, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x02, 0x80, 0x90, 0xE3, 0xC8, 0x04, 0x01, 0x00, 0x80, 0x41, 0xE0,
  0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x00, 0x00, 0x21, 0x10, 0x88,
  0x00, 0x01, 0xC3, 0x83, 0x03, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x60, 0x60, 0xE0, 0xC0, 0x00, 0x3C, 0x86, 0x0C, 0x10, 0x20, 0x41,
  0x04, 0x10, 0x40, 0x82, 0x00, 0x00, 0x00, 0x20, 0x03, 0xE0, 0x20, 0x82,
  0x02, 0x23, 0x12, 0x24, 0x92, 0x25, 0x22, 0x29, 0x11, 0x48, 0x8C, 0x84,
  0xA4, 0x45, 0x26, 0x48, 0xCC, 0x20, 0x01, 0x00, 0x07, 0xF0, 0x00, 0x80,
  0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0x42, 0x08, 0x42, 0x08,
  0x41, 0x17, 0xE2, 0x04, 0x80, 0x50, 0x0C, 0x01, 0x1F, 0x04, 0x18, 0x80,
  0x90, 0x12, 0x02, 0x40, 0x88, 0x13, 0xFC, 0x40, 0x88, 0x09, 0x01, 0x20,
  0x24, 0x05, 0x00, 0xA0, 0x67, 0xF0, 0x07, 0x81, 0x08, 0x40, 0x90, 0x14,
  0x02, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x28, 0x04,
  0x81, 0x10, 0x41, 0xF0, 0x1F, 0x04, 0x10, 0x81, 0x10, 0x12, 0x02, 0x40,
  0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x28, 0x09, 0x01, 0x20,
  0xC7, 0xE0, 0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03,
  0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x07, 0xFC,
  0x1F, 0xF1, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x5F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x07, 0x81, 0x08, 0x40, 0x90, 0x14, 0x02, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x7A, 0x01, 0x40, 0x28, 0x04, 0x80, 0x90, 0x21, 0xF8, 0x20, 0x12,
  0x01, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x27, 0xFA, 0x40, 0x44,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x1F, 0xE0,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x07, 0xFC, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x48, 0x09, 0x02, 0x20, 0x43, 0xF0, 0x10, 0x11, 0x02, 0x20, 0x42, 0x08,
  0x21, 0x02, 0x20, 0x24, 0x02, 0x80, 0x54, 0x06, 0x40, 0x42, 0x04, 0x10,
  0x41, 0x08, 0x08, 0x80, 0x88, 0x04, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0xFF,
  0x20, 0x13, 0x03, 0x30, 0x53, 0x06, 0x30, 0xA4, 0x8A, 0x49, 0x24, 0x92,
  0x4A, 0x24, 0xC4, 0x44, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08,
  0x20, 0x12, 0x01, 0x30, 0x23, 0x02, 0x28, 0x24, 0x82, 0x44, 0x24, 0x42,
  0x44, 0x44, 0x24, 0x82, 0x48, 0x24, 0x81, 0x48, 0x18, 0x80, 0x88, 0x08,
  0x07, 0x81, 0x08, 0x40, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80,
  0x30, 0x06, 0x01, 0x40, 0x28, 0x04, 0x81, 0x10, 0x41, 0xF0, 0x1F, 0x81,
  0x06, 0x10, 0x22, 0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x04, 0x41, 0x87,
  0xE0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x07, 0x83,
  0x08, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x28, 0x05, 0x01, 0x10, 0x41, 0xF0, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x1F, 0x82, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x12, 0x02,
  0x41, 0x8F, 0xC1, 0x04, 0x20, 0x84, 0x11, 0x01, 0x20, 0x24, 0x02, 0x07,
  0x83, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x28, 0x05, 0x00, 0x90, 0x21, 0xF8, 0xFF, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x84, 0x08, 0x41, 0x03, 0xE0, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x20,
  0x48, 0x22, 0x08, 0x44, 0x11, 0x04, 0x81, 0x20, 0x48, 0x14, 0x02, 0x00,
  0x80, 0x82, 0x18, 0x41, 0x84, 0x28, 0xA2, 0x8A, 0x28, 0xA4, 0x92, 0x49,
  0x24, 0x92, 0x8A, 0x28, 0xA2, 0x8A, 0x30, 0xC3, 0x0C, 0x30, 0x82, 0x08,
  0x20, 0x10, 0x08, 0x80, 0x82, 0x04, 0x10, 0x40, 0x44, 0x02, 0x40, 0x0A,
  0x00, 0x60, 0x02, 0x00, 0x28, 0x02, 0x20, 0x11, 0x01, 0x08, 0x10, 0x21,
  0x01, 0x18, 0x04, 0x80, 0x60, 0x18, 0x0A, 0x04, 0x42, 0x10, 0x84, 0x40,
  0xA0, 0x28, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x1F,
  0xF0, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFC, 0x0E,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x0F, 0x00, 0x88, 0x88, 0x88, 0x44, 0x44, 0x42,
  0x22, 0x22, 0x10, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x8F, 0x00, 0x08, 0x18,
  0x50, 0xA2, 0x44, 0x50, 0xC1, 0x82, 0xFF, 0x80, 0xA4, 0x0F, 0x04, 0x32,
  0x05, 0x01, 0x00, 0x43, 0xF3, 0x05, 0x01, 0x80, 0xA0, 0x28, 0x19, 0xFA,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x0B, 0xC3, 0x08, 0x81, 0x40, 0x50,
  0x14, 0x05, 0x01, 0x40, 0x50, 0x28, 0x0B, 0x04, 0xBE, 0x00, 0x1E, 0x10,
  0x90, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0xA0, 0x8F, 0x80,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x47, 0x92, 0x19, 0x02, 0x80, 0xA0,
  0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x12, 0x0C, 0x7D, 0x00, 0x0F, 0x04,
  0x22, 0x05, 0x01, 0x40, 0x5F, 0xF8, 0x02, 0x00, 0x80, 0x10, 0x04, 0x08,
  0xFC, 0x03, 0xC1, 0x00, 0x80, 0x40, 0x10, 0x3F, 0xC1, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x00, 0x0F,
  0x44, 0x32, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0x90, 0x24,
  0x18, 0xFA, 0x01, 0x00, 0x48, 0x21, 0x10, 0x38, 0x00, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x09, 0xE3, 0x84, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01,
  0x40, 0x50, 0x28, 0x0A, 0x02, 0x80, 0x80, 0x01, 0x00, 0x80, 0x00, 0x03,
  0xE0, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x11,
  0xFF, 0x00, 0x40, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x20, 0xF0, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x14,
  0x19, 0x08, 0x44, 0x12, 0x0B, 0x01, 0x40, 0x88, 0x21, 0x08, 0x22, 0x08,
  0x81, 0x00, 0x1F, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xFF, 0x80, 0x3C, 0xF2,
  0x31, 0x42, 0x14, 0x21, 0x42, 0x14, 0x21, 0x82, 0x18, 0x21, 0x84, 0x18,
  0x42, 0x84, 0x28, 0x42, 0x27, 0x8E, 0x16, 0x05, 0x01, 0x40, 0x50, 0x14,
  0x05, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x0F, 0x04, 0x22, 0x05, 0x01,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x24, 0x10, 0xF8, 0x17, 0x83,
  0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x48, 0x09,
  0x82, 0x2F, 0x84, 0x00, 0x80, 0x10, 0x04, 0x00, 0x1E, 0x90, 0xD0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x40, 0xA0, 0xCF, 0xA0, 0x10, 0x10,
  0x08, 0x04, 0x27, 0x9C, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x00, 0x1F, 0x10, 0x50, 0x28, 0x04, 0x01, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x60, 0x4F, 0xC0, 0x08, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20, 0x3C, 0x40, 0x50, 0x14,
  0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x31, 0xF4,
  0x80, 0x60, 0x18, 0x09, 0x02, 0x41, 0x10, 0x44, 0x20, 0x90, 0x24, 0x0A,
  0x01, 0x80, 0x40, 0x84, 0x30, 0x86, 0x31, 0x46, 0x29, 0x45, 0x29, 0x29,
  0x25, 0x28, 0xA5, 0x18, 0x42, 0x08, 0x41, 0x00, 0x20, 0x24, 0x08, 0x42,
  0x08, 0x80, 0xA0, 0x08, 0x01, 0x00, 0x50, 0x12, 0x04, 0x21, 0x02, 0x40,
  0x60, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x41, 0x04, 0x08, 0x20, 0x42,
  0x01, 0x10, 0x09, 0x00, 0x50, 0x02, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x00, 0x1F, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFE, 0x01,
  0x81, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x38, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x80, 0x20,
  0x24, 0x92, 0x52, 0x49, 0x29, 0x24, 0x92, 0x00, 0x18, 0x04, 0x04, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x03, 0x02, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x3C, 0x14, 0x21, 0x81, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 4, 5, 13, 6, -17 },
  { 10, 13, 16, 13, 0, -16 },
  { 36, 11, 20, 13, 1, -18 },
  { 64, 11, 16, 13, 1, -16 },
  { 86, 11, 16, 13, 1, -16 },
  { 108, 2, 5, 13, 6, -17 },
  { 110, 6, 22, 13, 4, -17 },
  { 127, 7, 22, 13, 2, -17 },
  { 147, 9, 9, 13, 3, -16 },
  { 158, 11, 11, 13, 1, -13 },
  { 174, 2, 5, 13, 3, -2 },
  { 176, 7, 1, 13, 3, -8 },
  { 177, 1, 1, 13, 5, -1 },
  { 178, 10, 17, 13, 2, -16 },
  { 200, 10, 16, 13, 2, -16 },
  { 220, 6, 16, 13, 3, -16 },
  { 232, 10, 16, 13, 1, -16 },
  { 252, 10, 16, 13, 1, -16 },
  { 272, 10, 16, 13, 1, -16 },
  { 292, 11, 16, 13, 2, -16 },
  { 314, 10, 16, 13, 1, -16 },
  { 334, 10, 16, 13, 3, -16 },
  { 354, 11, 16, 13, 1, -16 },
  { 376, 10, 16, 13, 2, -16 },
  { 396, 3, 10, 13, 6, -10 },
  { 400, 5, 13, 13, 4, -10 },
  { 409, 10, 8, 13, 2, -11 },
  { 419, 10, 5, 13, 2, -10 },
  { 426, 10, 9, 13, 1, -12 },
  { 438, 7, 16, 13, 4, -16 },
  { 452, 13, 16, 13, 0, -16 },
  { 478, 11, 16, 13, 0, -16 },
  { 500, 11, 16, 13, 1, -16 },
  { 522, 11, 16, 13, 1, -16 },
  { 544, 11, 16, 13, 1, -16 },
  { 566, 11, 16, 13, 1, -16 },
  { 588, 12, 16, 13, 1, -16 },
  { 612, 11, 16, 13, 1, -16 },
  { 634, 12, 16, 13, 1, -16 },
  { 658, 11, 16, 13, 1, -16 },
  { 680, 11, 16, 13, 1, -16 },
  { 702, 12, 16, 13, 1, -16 },
  { 726, 9, 16, 13, 1, -16 },
  { 744, 12, 16, 13, 1, -16 },
  { 768, 12, 16, 13, 1, -16 },
  { 792, 11, 16, 13, 1, -16 },
  { 814, 12, 16, 13, 1, -16 },
  { 838, 11, 19, 13, 1, -16 },
  { 865, 11, 16, 13, 1, -16 },
  { 887, 11, 16, 13, 1, -16 },
  { 909, 10, 16, 13, 3, -16 },
  { 929, 12, 16, 13, 1, -16 },
  { 953, 10, 16, 13, 3, -16 },
  { 973, 12, 16, 13, 2, -16 },
  { 997, 13, 16, 13, 0, -16 },
  { 1023, 10, 16, 13, 3, -16 },
  { 1043, 12, 16, 13, 0, -16 },
  { 1067, 7, 21, 13, 3, -18 },
  { 1086, 4, 17, 13, 5, -16 },
  { 1095, 7, 21, 13, 3, -18 },
  { 1114, 7, 9, 13, 3, -16 },
  { 1122, 9, 1, 13, 1, 0 },
  { 1124, 2, 3, 13, 7, -16 },
  { 1125, 10, 12, 13, 1, -12 },
  { 1140, 10, 17, 13, 1, -17 },
  { 1162, 9, 12, 13, 2, -12 },
  { 1176, 10, 17, 13, 2, -17 },
  { 1198, 10, 12, 13, 1, -12 },
  { 1213, 10, 17, 13, 3, -17 },
  { 1235, 10, 17, 13, 1, -12 },
  { 1257, 10, 17, 13, 1, -17 },
  { 1279, 9, 16, 13, 1, -16 },
  { 1297, 10, 21, 13, 0, -16 },
  { 1324, 10, 17, 13, 2, -17 },
  { 1346, 9, 17, 13, 1, -17 },
  { 1366, 12, 12, 13, 0, -12 },
  { 1384, 10, 12, 13, 1, -12 },
  { 1399, 10, 12, 13, 1, -12 },
  { 1414, 11, 16, 13, 0, -12 },
  { 1436, 9, 16, 13, 2, -12 },
  { 1454, 9, 12, 13, 3, -12 },
  { 1468, 9, 12, 13, 2, -12 },
  { 1482, 8, 15, 13, 3, -15 },
  { 1497, 10, 12, 13, 2, -12 },
  { 1512, 10, 12, 13, 2, -12 },
  { 1527, 11, 12, 13, 2, -12 },
  { 1544, 11, 12, 13, 1, -12 },
  { 1561, 13, 17, 13, 0, -12 },
  { 1589, 12, 12, 13, 0, -12 },
  { 1607, 9, 22, 13, 3, -17 },
  { 1632, 3, 19, 13, 5, -16 },
  { 1640, 8, 22, 13, 2, -17 },
  { 1662, 12, 3, 13, 0, -8 },
};

const GFXfont RobotoMono_ThinItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic22pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_THINITALIC22PT7B_H_
