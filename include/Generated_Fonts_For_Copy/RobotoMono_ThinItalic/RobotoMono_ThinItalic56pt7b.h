#ifndef _ROBOTOMONO_THINITALIC56PT7B_H_
#define _ROBOTOMONO_THINITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xE0, 0xC0, 0x30, 0x48, 0x32, 0x0C, 0x83, 0x60, 0xD8,
  0x26, 0x09, 0x06, 0x41, 0xB0, 0x6C, 0x10, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x08, 0x01, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x80, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x08, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x08, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04,
  0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x0E, 0x01, 0x80, 0x06, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x60, 0x60, 0x00, 0x08, 0x04, 0x00, 0x03, 0x00,
  0xC0, 0x10, 0x40, 0x18, 0x03, 0x18, 0x03, 0x00, 0x42, 0x00, 0x60, 0x18,
  0x40, 0x0C, 0x06, 0x08, 0x01, 0x01, 0x83, 0x00, 0x20, 0x20, 0x60, 0x0C,
  0x0C, 0x0C, 0x01, 0x83, 0x00, 0x80, 0x60, 0x40, 0x10, 0x08, 0x18, 0x03,
  0x03, 0x06, 0x00, 0x39, 0xC0, 0x80, 0x03, 0xE0, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x03, 0xC0, 0x00, 0x81, 0xFE, 0x00, 0x30, 0x60, 0x40, 0x0C, 0x18,
  0x0C, 0x03, 0x02, 0x00, 0x80, 0x60, 0xC0, 0x10, 0x18, 0x10, 0x02, 0x06,
  0x02, 0x00, 0x40, 0x80, 0xC0, 0x08, 0x30, 0x18, 0x01, 0x0C, 0x03, 0x00,
  0x61, 0x00, 0x40, 0x0C, 0x60, 0x08, 0x01, 0x18, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x08, 0x00, 0x02, 0x03, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x30,
  0x03, 0x18, 0x03, 0x00, 0x66, 0x00, 0x20, 0x08, 0x80, 0x06, 0x03, 0x30,
  0x00, 0x60, 0x64, 0x00, 0x04, 0x19, 0x80, 0x00, 0xC3, 0x30, 0x00, 0x08,
  0xC6, 0x00, 0x01, 0x98, 0xC0, 0x00, 0x1E, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x1F, 0x06, 0x00, 0x06, 0x20, 0x60, 0x01, 0x86,
  0x07, 0x01, 0xE0, 0x60, 0x3F, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x33,
  0x32, 0x22, 0x66, 0x44, 0xC0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x40, 0x0C, 0x03,
  0xF0, 0x10, 0x1E, 0x78, 0x21, 0xE0, 0x1E, 0x5E, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x07, 0x00,
  0x0C, 0x04, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x20, 0x82, 0x18, 0x61,
  0x0C, 0x61, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x07, 0x00, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x08, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x1C, 0x60, 0x00, 0x0F, 0x10, 0x00, 0x06, 0xCC, 0x00, 0x03, 0x33,
  0x00, 0x01, 0x8C, 0x80, 0x01, 0x83, 0x20, 0x00, 0xC0, 0x88, 0x00, 0x60,
  0x26, 0x00, 0x30, 0x09, 0x80, 0x18, 0x06, 0x60, 0x0C, 0x01, 0x90, 0x06,
  0x00, 0x64, 0x07, 0x00, 0x11, 0x03, 0x00, 0x04, 0xC1, 0x80, 0x01, 0x30,
  0xC0, 0x00, 0xCC, 0x60, 0x00, 0x33, 0x30, 0x00, 0x08, 0xD8, 0x00, 0x06,
  0x3C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x08, 0x10, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0E, 0xC0, 0xE2, 0x1E,
  0x09, 0xE0, 0x2C, 0x01, 0xA0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x20, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x07,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x10, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x08, 0x00,
  0x06, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x0C,
  0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x10,
  0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0x40, 0x60, 0x00, 0x18, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x63, 0xFC, 0x00, 0x09, 0xFB, 0xE0,
  0x01, 0xE0, 0x06, 0x00, 0x70, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x30, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x30, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x7F, 0x80, 0x31, 0xF1, 0xE0,
  0x11, 0x80, 0x18, 0x1B, 0x80, 0x06, 0x0F, 0x00, 0x01, 0x85, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x31, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0xC0, 0x00,
  0x02, 0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x08, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x04, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x03,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x30, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01,
  0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x0A, 0x30, 0x00, 0x36, 0x18, 0x00, 0x66,
  0x0C, 0x01, 0xC4, 0x07, 0x0F, 0x04, 0x03, 0xFC, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x28, 0x00, 0x00, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x70, 0x60, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x38, 0x38, 0x0E, 0x00, 0xC1, 0x80,
  0x06, 0x30, 0x00, 0x22, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x01, 0xC0,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xF1, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x02, 0x03, 0x00, 0x78, 0x02, 0x06, 0x01, 0xFE, 0x03, 0x06,
  0x03, 0x03, 0x03, 0x0C, 0x06, 0x03, 0x03, 0x0C, 0x0C, 0x02, 0x03, 0x18,
  0x18, 0x02, 0x03, 0x18, 0x18, 0x02, 0x03, 0x30, 0x30, 0x06, 0x02, 0x30,
  0x20, 0x04, 0x02, 0x20, 0x20, 0x04, 0x02, 0x60, 0x60, 0x0C, 0x06, 0x60,
  0x40, 0x0C, 0x06, 0x60, 0x40, 0x08, 0x06, 0x40, 0xC0, 0x08, 0x04, 0x40,
  0xC0, 0x18, 0x04, 0xC0, 0x80, 0x18, 0x0C, 0xC0, 0x80, 0x30, 0x0C, 0xC0,
  0x80, 0x30, 0x08, 0xC0, 0x80, 0x70, 0x18, 0xC0, 0x80, 0x70, 0x10, 0xC0,
  0x80, 0xB0, 0x30, 0xC0, 0x81, 0x90, 0x60, 0xC0, 0xC7, 0x18, 0xC0, 0x40,
  0x7C, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x08,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x08, 0x03, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x40, 0x04, 0x00, 0x18, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x80,
  0x30, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xE0, 0x30, 0x00,
  0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0C, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x18, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x08, 0x00, 0x06, 0x01,
  0x00, 0x03, 0x80, 0x20, 0x03, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0x80, 0x07,
  0x80, 0x30, 0x00, 0x1C, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x06, 0x04, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x30, 0x03,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x83, 0x80,
  0x01, 0x80, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x03, 0x81, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x40, 0x01, 0xC0, 0x02,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x04, 0x00,
  0x07, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x30,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xC4,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x0E,
  0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x02, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x06, 0x07, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0xE0, 0x08, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x00, 0x80, 0x00,
  0xC0, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x21, 0xC0, 0x00, 0x00,
  0x47, 0xC0, 0x00, 0x00, 0x98, 0x80, 0x00, 0x03, 0x61, 0x80, 0x00, 0x07,
  0x81, 0x80, 0x00, 0x0E, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x40, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x2C, 0x0D, 0x00, 0x01, 0xA0, 0x24, 0x00,
  0x0C, 0x80, 0x98, 0x00, 0x32, 0x02, 0x60, 0x01, 0x88, 0x19, 0x80, 0x06,
  0x60, 0x62, 0x00, 0x31, 0x81, 0x88, 0x00, 0x84, 0x04, 0x30, 0x06, 0x10,
  0x10, 0xC0, 0x10, 0x40, 0xC3, 0x00, 0xC3, 0x03, 0x04, 0x06, 0x0C, 0x0C,
  0x10, 0x18, 0x30, 0x20, 0x40, 0xC0, 0x80, 0x81, 0x82, 0x02, 0x02, 0x06,
  0x18, 0x08, 0x18, 0x08, 0x40, 0x60, 0x60, 0x23, 0x01, 0x81, 0x80, 0x98,
  0x06, 0x04, 0x03, 0x60, 0x10, 0x10, 0x07, 0x00, 0x40, 0x40, 0x18, 0x01,
  0x03, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x02, 0x02, 0xC0, 0x00, 0x08,
  0x09, 0x00, 0x00, 0x20, 0x26, 0x00, 0x01, 0x80, 0x88, 0x00, 0x06, 0x06,
  0x20, 0x00, 0x18, 0x18, 0xC0, 0x00, 0x40, 0x41, 0x00, 0x01, 0x01, 0x04,
  0x00, 0x04, 0x04, 0x18, 0x00, 0x30, 0x30, 0x20, 0x00, 0xC0, 0xC0, 0xC0,
  0x02, 0x03, 0x01, 0x00, 0x08, 0x08, 0x04, 0x00, 0x20, 0x20, 0x18, 0x00,
  0x80, 0x80, 0x20, 0x06, 0x06, 0x00, 0x80, 0x18, 0x18, 0x03, 0x00, 0x40,
  0x60, 0x04, 0x01, 0x01, 0x00, 0x18, 0x04, 0x04, 0x00, 0x20, 0x10, 0x10,
  0x00, 0x80, 0xC0, 0xC0, 0x03, 0x03, 0x03, 0x00, 0x04, 0x08, 0x08, 0x00,
  0x10, 0x20, 0x20, 0x00, 0x60, 0x80, 0x80, 0x00, 0x86, 0x02, 0x00, 0x03,
  0x18, 0x18, 0x00, 0x04, 0x60, 0x60, 0x00, 0x11, 0x01, 0x00, 0x00, 0x64,
  0x04, 0x00, 0x00, 0x90, 0x10, 0x00, 0x02, 0xC0, 0x40, 0x00, 0x0F, 0x03,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x06, 0x00, 0x60, 0x07, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x16, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x50, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x10, 0x00,
  0x06, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0x00, 0x03, 0x80,
  0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x10,
  0x00, 0x1E, 0x01, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x03,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x08, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0x30, 0x00, 0x30, 0x02,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x82, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x20, 0x00, 0x02, 0x04,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60,
  0x08, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x18, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x09, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x1E,
  0x00, 0x30, 0x00, 0xB0, 0x01, 0x80, 0x05, 0x80, 0x0C, 0x00, 0x6C, 0x00,
  0xE0, 0x02, 0x60, 0x05, 0x00, 0x13, 0x00, 0x28, 0x01, 0x98, 0x03, 0x40,
  0x0C, 0xC0, 0x13, 0x00, 0x46, 0x00, 0x98, 0x02, 0x30, 0x0C, 0xC0, 0x31,
  0x80, 0x46, 0x01, 0x0C, 0x02, 0x30, 0x08, 0x60, 0x31, 0x80, 0xC3, 0x01,
  0x0C, 0x04, 0x18, 0x18, 0x60, 0x20, 0xC0, 0xC3, 0x03, 0x06, 0x04, 0x18,
  0x10, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x10, 0x30, 0x60,
  0x61, 0x81, 0x82, 0x03, 0x0C, 0x04, 0x30, 0x18, 0x40, 0x21, 0x80, 0xC6,
  0x01, 0x08, 0x06, 0x30, 0x08, 0x40, 0x31, 0x00, 0x46, 0x01, 0x98, 0x02,
  0x20, 0x0C, 0xC0, 0x11, 0x00, 0x64, 0x00, 0x98, 0x03, 0x60, 0x04, 0x80,
  0x1B, 0x00, 0x24, 0x00, 0xD0, 0x01, 0x60, 0x07, 0x80, 0x0A, 0x00, 0x38,
  0x00, 0x50, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x02, 0x00, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x10, 0x01,
  0x80, 0x00, 0x18, 0x01, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x04,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x10,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x04, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x40, 0x06, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x0C, 0x00, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x04, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06,
  0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03, 0x20, 0x00, 0x44, 0x00, 0x18,
  0x80, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x20, 0x04, 0x04, 0x01, 0x80,
  0xC0, 0x20, 0x18, 0x0C, 0x01, 0x03, 0x00, 0x20, 0x60, 0x06, 0x18, 0x00,
  0xC2, 0x00, 0x18, 0xC0, 0x01, 0x10, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0xFF, 0xFF, 0xFE, 0xC3, 0x08, 0x61, 0x0C, 0x20, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x1E, 0x00, 0x38, 0x01, 0x80, 0x70, 0x00, 0x60, 0x30, 0x00,
  0x10, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x06, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x1C, 0x60, 0x00, 0x1A, 0x18, 0x00, 0x19, 0x0E, 0x00, 0x39,
  0x83, 0x80, 0x70, 0xC0, 0x7F, 0xE0, 0x60, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0xFE, 0x00, 0x21, 0xE1, 0xC0, 0x11, 0x80, 0x30, 0x0B, 0x00, 0x0C,
  0x0F, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x40,
  0x00, 0x06, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03, 0x18, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x80, 0x01, 0x81, 0x60, 0x01, 0xC0,
  0x98, 0x01, 0xC0, 0xC7, 0x03, 0x80, 0x61, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x70, 0x01, 0xC0, 0x1C, 0x03, 0x00,
  0x04, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00,
  0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00,
  0x08, 0x60, 0x00, 0x18, 0x20, 0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x0E, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x03, 0xFC, 0x18, 0x01, 0xF1, 0xC3, 0x00, 0x70, 0x0E,
  0x60, 0x18, 0x00, 0x48, 0x06, 0x00, 0x05, 0x01, 0x80, 0x00, 0xE0, 0x20,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x0C, 0x04,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x34, 0x00, 0x80, 0x0C,
  0x80, 0x1C, 0x07, 0x10, 0x00, 0xFF, 0x86, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x02, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x0E,
  0x03, 0x00, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x60, 0x07, 0xC7, 0x0C, 0x01, 0xC0, 0x39, 0x80, 0x60, 0x01, 0x20, 0x18,
  0x00, 0x14, 0x06, 0x00, 0x03, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x20, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x18, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0xD8, 0x03, 0x00, 0x32, 0x00, 0x70, 0x1C, 0x40, 0x03,
  0xFE, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x38, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x7F, 0x80,
  0x20, 0xF0, 0xE0, 0x10, 0xC0, 0x18, 0x19, 0xC0, 0x06, 0x0D, 0x80, 0x01,
  0x04, 0x80, 0x00, 0xC2, 0x80, 0x00, 0x61, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x10, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x60,
  0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08,
  0xC0, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x3D, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x40, 0x00, 0x70, 0x10, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x20,
  0x06, 0x00, 0x08, 0x03, 0x00, 0x02, 0x03, 0x80, 0x01, 0x81, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0xE0, 0x00, 0x04, 0x70, 0x00, 0x01, 0x36, 0x00,
  0x00, 0xD8, 0xC0, 0x00, 0x38, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x80, 0x18, 0x00, 0x20, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x00, 0x18,
  0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x01,
  0xFF, 0xFF, 0xFC, 0x02, 0x3F, 0x80, 0xFC, 0x03, 0x38, 0xE1, 0xE7, 0x01,
  0x30, 0x19, 0x80, 0xC0, 0xB0, 0x0D, 0x80, 0x20, 0x70, 0x03, 0x80, 0x10,
  0x30, 0x01, 0x80, 0x0C, 0x30, 0x00, 0x80, 0x04, 0x18, 0x00, 0x40, 0x02,
  0x0C, 0x00, 0x60, 0x01, 0x04, 0x00, 0x30, 0x00, 0x82, 0x00, 0x18, 0x00,
  0x41, 0x00, 0x08, 0x00, 0x61, 0x80, 0x04, 0x00, 0x30, 0xC0, 0x02, 0x00,
  0x10, 0x60, 0x03, 0x00, 0x08, 0x20, 0x01, 0x80, 0x04, 0x10, 0x00, 0x80,
  0x06, 0x08, 0x00, 0x40, 0x03, 0x0C, 0x00, 0x20, 0x01, 0x86, 0x00, 0x10,
  0x00, 0x82, 0x00, 0x18, 0x00, 0x41, 0x00, 0x0C, 0x00, 0x20, 0x80, 0x04,
  0x00, 0x30, 0x40, 0x02, 0x00, 0x18, 0x60, 0x01, 0x00, 0x08, 0x30, 0x00,
  0x80, 0x04, 0x10, 0x00, 0xC0, 0x02, 0x08, 0x00, 0x60, 0x01, 0x04, 0x00,
  0x20, 0x01, 0x86, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x07, 0xF8, 0x02, 0x0F,
  0x0E, 0x01, 0x0C, 0x01, 0x81, 0x98, 0x00, 0x60, 0xD8, 0x00, 0x10, 0x58,
  0x00, 0x0C, 0x28, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x08, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x02, 0x30, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x04, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x1E, 0x00,
  0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0x83,
  0xF8, 0x00, 0x21, 0xE3, 0xC0, 0x04, 0xE0, 0x0C, 0x00, 0xB0, 0x00, 0xC0,
  0x3C, 0x00, 0x08, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x18, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x20,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x03, 0x80,
  0x01, 0x80, 0x50, 0x00, 0x60, 0x19, 0x80, 0x18, 0x03, 0x1C, 0x0E, 0x00,
  0x61, 0xFF, 0x80, 0x08, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0x80, 0x7C, 0x70, 0xC0,
  0x70, 0x0E, 0x60, 0x60, 0x01, 0x20, 0x60, 0x00, 0x50, 0x60, 0x00, 0x38,
  0x20, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x46, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x19, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x04, 0x60, 0x00,
  0x02, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x38, 0x30,
  0x00, 0x1C, 0x0C, 0x00, 0x36, 0x03, 0x00, 0x32, 0x01, 0xC0, 0x71, 0x00,
  0x3F, 0xE0, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x03, 0xFE, 0x18, 0x1F, 0x0C, 0x30, 0xE0, 0x00, 0x67,
  0x00, 0x00, 0x98, 0x00, 0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0xE0, 0x03, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x20, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x19, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x1E, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x38,
  0x00, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20,
  0x00, 0x02, 0x10, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x02, 0x10, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x30, 0x40, 0x00, 0x38, 0x30, 0x00, 0x34, 0x08, 0x00,
  0x36, 0x06, 0x00, 0x33, 0x01, 0xC0, 0xF1, 0x80, 0x7F, 0xE0, 0x80, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x01, 0x00,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x02, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0x20, 0x05,
  0x80, 0x11, 0x00, 0x2C, 0x01, 0x88, 0x03, 0x60, 0x0C, 0x40, 0x11, 0x00,
  0x42, 0x01, 0x88, 0x06, 0x10, 0x08, 0x40, 0x20, 0x80, 0xC2, 0x03, 0x04,
  0x06, 0x10, 0x18, 0x20, 0x20, 0x80, 0x81, 0x83, 0x04, 0x0C, 0x0C, 0x10,
  0x30, 0x40, 0x61, 0x81, 0x86, 0x03, 0x08, 0x0C, 0x30, 0x18, 0x40, 0x61,
  0x00, 0xC6, 0x03, 0x18, 0x06, 0x20, 0x08, 0x80, 0x33, 0x00, 0x4C, 0x01,
  0x90, 0x02, 0x60, 0x0D, 0x80, 0x12, 0x00, 0x2C, 0x00, 0xB0, 0x01, 0x40,
  0x05, 0x00, 0x0E, 0x00, 0x28, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x1C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x04, 0x38, 0xE0, 0x00, 0x11, 0x80, 0xE0, 0x00, 0xCC, 0x01, 0xC0, 0x02,
  0x20, 0x03, 0x80, 0x19, 0x80, 0x07, 0x00, 0xC4, 0x00, 0x0E, 0x06, 0x30,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoMono_ThinItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 8, 40, 33, 12, -40 },
  { 41, 10, 11, 33, 14, -42 },
  { 55, 32, 40, 33, 1, -40 },
  { 215, 26, 51, 33, 4, -45 },
  { 381, 27, 41, 33, 3, -40 },
  { 520, 27, 41, 33, 3, -40 },
  { 659, 4, 11, 33, 16, -42 },
  { 665, 16, 57, 33, 10, -44 },
  { 779, 17, 57, 33, 5, -44 },
  { 901, 23, 22, 33, 8, -40 },
  { 965, 27, 29, 33, 3, -33 },
  { 1063, 6, 11, 33, 7, -4 },
  { 1072, 19, 2, 33, 7, -19 },
  { 1077, 3, 3, 33, 13, -3 },
  { 1079, 25, 43, 33, 5, -40 },
  { 1214, 26, 41, 33, 4, -40 },
  { 1348, 14, 40, 33, 9, -40 },
  { 1418, 26, 40, 33, 1, -40 },
  { 1548, 28, 41, 33, 1, -40 },
  { 1692, 27, 40, 33, 2, -40 },
  { 1827, 27, 41, 33, 5, -40 },
  { 1966, 25, 41, 33, 3, -40 },
  { 2095, 25, 40, 33, 7, -40 },
  { 2220, 28, 41, 33, 3, -40 },
  { 2364, 24, 41, 33, 5, -40 },
  { 2487, 8, 27, 33, 14, -27 },
  { 2514, 11, 34, 33, 11, -27 },
  { 2561, 24, 22, 33, 5, -29 },
  { 2627, 26, 13, 33, 4, -25 },
  { 2670, 25, 22, 33, 3, -29 },
  { 2739, 20, 40, 33, 9, -40 },
  { 2839, 32, 40, 33, 1, -40 },
  { 2999, 27, 40, 33, 0, -40 },
  { 3134, 27, 40, 33, 3, -40 },
  { 3269, 27, 41, 33, 4, -40 },
  { 3408, 29, 40, 33, 2, -40 },
  { 3553, 29, 40, 33, 3, -40 },
  { 3698, 29, 40, 33, 3, -40 },
  { 3843, 28, 41, 33, 3, -40 },
  { 3987, 30, 40, 33, 2, -40 },
  { 4137, 28, 40, 33, 3, -40 },
  { 4277, 29, 41, 33, 2, -40 },
  { 4426, 31, 40, 33, 3, -40 },
  { 4581, 22, 40, 33, 4, -40 },
  { 4691, 30, 40, 33, 2, -40 },
  { 4841, 30, 40, 33, 2, -40 },
  { 4991, 26, 41, 33, 4, -40 },
  { 5125, 28, 40, 33, 4, -40 },
  { 5265, 28, 47, 33, 3, -40 },
  { 5430, 28, 40, 33, 3, -40 },
  { 5570, 28, 41, 33, 3, -40 },
  { 5714, 27, 40, 33, 7, -40 },
  { 5849, 28, 41, 33, 4, -40 },
  { 5993, 27, 40, 33, 6, -40 },
  { 6128, 29, 40, 33, 6, -40 },
  { 6273, 32, 40, 33, 1, -40 },
  { 6433, 27, 40, 33, 6, -40 },
  { 6568, 30, 40, 33, 1, -40 },
  { 6718, 16, 55, 33, 9, -46 },
  { 6828, 10, 43, 33, 12, -40 },
  { 6882, 16, 55, 33, 8, -46 },
  { 6992, 19, 22, 33, 7, -40 },
  { 7045, 23, 1, 33, 2, 0 },
  { 7048, 5, 7, 33, 17, -41 },
  { 7053, 25, 31, 33, 3, -30 },
  { 7150, 25, 43, 33, 3, -42 },
  { 7285, 24, 31, 33, 4, -30 },
  { 7378, 27, 43, 33, 4, -42 },
  { 7524, 25, 31, 33, 4, -30 },
  { 7621, 26, 43, 33, 8, -43 },
  { 7761, 27, 42, 33, 2, -30 },
  { 7903, 25, 42, 33, 3, -42 },
  { 8035, 23, 40, 33, 3, -40 },
  { 8150, 25, 52, 33, 0, -40 },
  { 8313, 26, 42, 33, 4, -42 },
  { 8450, 23, 42, 33, 3, -42 },
  { 8571, 33, 30, 33, -1, -30 },
  { 8695, 25, 30, 33, 3, -30 },
  { 8789, 26, 31, 33, 3, -30 },
  { 8890, 27, 41, 33, 1, -30 },
  { 9029, 25, 41, 33, 4, -30 },
  { 9158, 23, 30, 33, 8, -30 },
  { 9245, 25, 31, 33, 4, -30 },
  { 9342, 21, 39, 33, 7, -38 },
  { 9445, 25, 31, 33, 4, -30 },
  { 9542, 26, 30, 33, 5, -30 },
  { 9640, 29, 30, 33, 4, -30 },
  { 9749, 30, 30, 33, 1, -30 },
  { 9862, 34, 42, 33, -1, -30 },
  { 10041, 29, 30, 33, 1, -30 },
  { 10150, 21, 56, 33, 9, -44 },
  { 10297, 9, 47, 33, 12, -40 },
  { 10350, 21, 56, 33, 5, -44 },
  { 10497, 30, 9, 33, 1, -21 },
};

const GFXfont RobotoMono_ThinItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic56pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_THINITALIC56PT7B_H_
