#ifndef _ROBOTOMONO_THINITALIC70PT7B_H_
#define _ROBOTOMONO_THINITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x07, 0x00, 0xF0, 0x1C, 0x00, 0x30, 0x33,
  0x03, 0x30, 0x33, 0x03, 0x60, 0x36, 0x03, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x0C, 0xC0, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x61, 0x80, 0x06, 0x00, 0x38,
  0x60, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x60, 0x06, 0x06, 0x00, 0x18, 0x03,
  0x01, 0x00, 0x06, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x18, 0x03, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0xE0, 0x30, 0x00, 0x38, 0x70, 0x18, 0x00, 0x07, 0xF8, 0x06, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0xFE, 0x00, 0x01, 0x80, 0xFB, 0xC0, 0x00, 0xC0,
  0x70, 0x38, 0x00, 0x70, 0x38, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x07, 0x01, 0x80, 0x0C, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x80, 0x03, 0x06, 0x00, 0x60, 0x01, 0x83, 0x80, 0x18, 0x00,
  0x60, 0xC0, 0x06, 0x00, 0x18, 0x60, 0x01, 0x80, 0x0C, 0x30, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x41, 0xC0, 0x1C, 0x00, 0x30, 0xE0,
  0x03, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x03, 0x18, 0x00, 0x18, 0x01, 0x86,
  0x00, 0x03, 0x00, 0x63, 0x00, 0x00, 0x60, 0x18, 0xC0, 0x00, 0x18, 0x0C,
  0x60, 0x00, 0x03, 0x03, 0x18, 0x00, 0x00, 0x61, 0x86, 0x00, 0x00, 0x18,
  0x61, 0x80, 0x00, 0x03, 0x30, 0x60, 0x00, 0x00, 0xFC, 0x18, 0x00, 0x00,
  0x1E, 0x06, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x30, 0x00,
  0x00, 0xD8, 0x0E, 0x00, 0x00, 0xE3, 0x01, 0xC0, 0x00, 0x70, 0xE0, 0x38,
  0x00, 0x70, 0x18, 0x07, 0xC0, 0xF8, 0x03, 0x00, 0x7F, 0xF8, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0x33, 0x33, 0x26, 0x66, 0x64, 0xCC, 0xCC, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x01, 0xBC, 0x00, 0x80, 0x3E, 0xFC, 0x0C, 0x0F,
  0x80, 0xFC, 0x63, 0xE0, 0x00, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x0C, 0x18,
  0x61, 0xC3, 0x0C, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F,
  0xF7, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x1D, 0x18, 0x00, 0x00, 0x39, 0x18,
  0x00, 0x00, 0x73, 0x18, 0x00, 0x00, 0xC3, 0x18, 0x00, 0x01, 0x83, 0x30,
  0x00, 0x03, 0x03, 0x30, 0x00, 0x06, 0x03, 0x30, 0x00, 0x1C, 0x03, 0x30,
  0x00, 0x38, 0x03, 0x30, 0x00, 0x70, 0x06, 0x20, 0x00, 0xC0, 0x06, 0x60,
  0x01, 0x80, 0x06, 0x60, 0x03, 0x00, 0x06, 0x60, 0x06, 0x00, 0x06, 0x60,
  0x1C, 0x00, 0x04, 0x60, 0x38, 0x00, 0x0C, 0x40, 0x70, 0x00, 0x0C, 0xC0,
  0xE0, 0x00, 0x0C, 0xC1, 0x80, 0x00, 0x0C, 0xC3, 0x00, 0x00, 0x18, 0xC6,
  0x00, 0x00, 0x18, 0xDC, 0x00, 0x00, 0x18, 0xF8, 0x00, 0x00, 0x30, 0xF0,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xF8, 0x01, 0xF6, 0x01, 0xE1, 0x81, 0xE0, 0x63, 0xE0, 0x1B, 0xE0,
  0x04, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x08, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x18, 0x3F, 0xF0, 0x00, 0x06, 0x7F, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xF0, 0x02, 0x0F, 0x81, 0xE0, 0x18, 0xF0,
  0x01, 0xC0, 0x67, 0x00, 0x01, 0x81, 0x30, 0x00, 0x03, 0x0D, 0x80, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFB, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x78, 0x00, 0x30, 0x03, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E, 0x40,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x0D, 0x0C, 0x00,
  0x00, 0x6C, 0x30, 0x00, 0x03, 0x30, 0x60, 0x00, 0x38, 0xC0, 0xC0, 0x01,
  0xC6, 0x01, 0xC0, 0x3C, 0x18, 0x03, 0xFF, 0xE0, 0x60, 0x03, 0xFC, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC1, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x03, 0xE0, 0x06, 0x01, 0xC0, 0x0F, 0xF0,
  0x03, 0x01, 0x80, 0x3C, 0x1C, 0x03, 0x03, 0x00, 0x70, 0x0C, 0x03, 0x03,
  0x00, 0xE0, 0x0C, 0x03, 0x06, 0x01, 0xC0, 0x0C, 0x03, 0x06, 0x01, 0x80,
  0x08, 0x03, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x0C, 0x03, 0x00, 0x18, 0x03,
  0x18, 0x06, 0x00, 0x18, 0x03, 0x18, 0x06, 0x00, 0x10, 0x02, 0x18, 0x0C,
  0x00, 0x30, 0x06, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x30, 0x0C, 0x00, 0x20,
  0x06, 0x30, 0x18, 0x00, 0x60, 0x06, 0x20, 0x18, 0x00, 0x60, 0x04, 0x60,
  0x18, 0x00, 0x60, 0x0C, 0x60, 0x10, 0x00, 0x40, 0x0C, 0x60, 0x30, 0x00,
  0xC0, 0x0C, 0x60, 0x30, 0x00, 0xC0, 0x08, 0x60, 0x30, 0x01, 0xC0, 0x18,
  0x40, 0x30, 0x01, 0x80, 0x18, 0x40, 0x30, 0x03, 0x80, 0x30, 0xC0, 0x30,
  0x03, 0x80, 0x30, 0xC0, 0x30, 0x07, 0x80, 0x70, 0x40, 0x30, 0x0D, 0x80,
  0x60, 0x60, 0x30, 0x19, 0x80, 0xC0, 0x60, 0x10, 0x30, 0xC1, 0xC0, 0x60,
  0x1C, 0xE0, 0xFF, 0x80, 0x60, 0x0F, 0xC0, 0x7E, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0C, 0x00,
  0x1F, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x38, 0x08, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x00, 0x38, 0x04, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x07, 0x80,
  0x06, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0x84, 0x00,
  0x07, 0xFF, 0xF1, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x70,
  0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x08, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x02,
  0x0F, 0x00, 0x00, 0x00, 0x0C, 0x3B, 0x00, 0x00, 0x00, 0x18, 0xE7, 0x00,
  0x00, 0x00, 0x33, 0x86, 0x00, 0x00, 0x00, 0x6C, 0x06, 0x00, 0x00, 0x00,
  0xF0, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x1E, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x1B,
  0x00, 0x00, 0x19, 0x00, 0x6C, 0x00, 0x00, 0xEC, 0x01, 0x90, 0x00, 0x03,
  0x30, 0x04, 0x60, 0x00, 0x1C, 0xC0, 0x31, 0x80, 0x00, 0x63, 0x00, 0xC6,
  0x00, 0x03, 0x0C, 0x03, 0x18, 0x00, 0x0C, 0x20, 0x0C, 0x20, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x06, 0x0C,
  0x00, 0x70, 0x60, 0x18, 0x30, 0x01, 0x81, 0x80, 0x60, 0x40, 0x0C, 0x04,
  0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x10, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x81, 0xC0, 0x20,
  0x0C, 0x03, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0xC0, 0x18, 0x02, 0x00, 0xC6, 0x00, 0x60, 0x18, 0x01, 0x18, 0x01, 0x80,
  0x60, 0x06, 0xC0, 0x04, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x06, 0x00, 0x78,
  0x00, 0xC0, 0x10, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x02, 0x00,
  0xD0, 0x00, 0x00, 0x18, 0x03, 0x60, 0x00, 0x00, 0x60, 0x0D, 0x80, 0x00,
  0x01, 0x80, 0x22, 0x00, 0x00, 0x06, 0x00, 0x8C, 0x00, 0x00, 0x10, 0x06,
  0x30, 0x00, 0x00, 0x40, 0x18, 0x60, 0x00, 0x03, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x01, 0x82, 0x00, 0x00, 0x30, 0x04, 0x0C, 0x00, 0x00, 0xC0, 0x10,
  0x30, 0x00, 0x02, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x80,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x40, 0x00, 0x40, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x08, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x08,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x01, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x01, 0x00, 0x60, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x30, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x10, 0x00, 0x01, 0x03, 0x00,
  0x40, 0x00, 0x06, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x20, 0x0C, 0x00, 0x00,
  0x21, 0x80, 0x30, 0x00, 0x00, 0xC6, 0x00, 0xC0, 0x00, 0x03, 0x18, 0x02,
  0x00, 0x00, 0x06, 0x60, 0x08, 0x00, 0x00, 0x19, 0x00, 0x60, 0x00, 0x00,
  0x24, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x04, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x04, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x06, 0x80,
  0x00, 0xE0, 0x00, 0x68, 0x00, 0x0E, 0x00, 0x06, 0x80, 0x01, 0xE0, 0x00,
  0x48, 0x00, 0x1E, 0x00, 0x0C, 0x80, 0x01, 0x60, 0x00, 0xC8, 0x00, 0x36,
  0x00, 0x08, 0x80, 0x03, 0x60, 0x01, 0x88, 0x00, 0x26, 0x00, 0x18, 0x80,
  0x06, 0x60, 0x01, 0x08, 0x00, 0x66, 0x00, 0x30, 0x80, 0x04, 0x60, 0x03,
  0x08, 0x00, 0xC6, 0x00, 0x20, 0x80, 0x0C, 0x60, 0x06, 0x08, 0x01, 0x86,
  0x00, 0x60, 0x80, 0x18, 0x60, 0x04, 0x08, 0x01, 0x86, 0x00, 0xC0, 0x80,
  0x30, 0x60, 0x0C, 0x08, 0x03, 0x06, 0x00, 0xC0, 0x80, 0x30, 0x60, 0x08,
  0x08, 0x06, 0x06, 0x01, 0x80, 0x80, 0x60, 0x60, 0x18, 0x08, 0x06, 0x06,
  0x01, 0x00, 0x80, 0xC0, 0x20, 0x30, 0x08, 0x0C, 0x02, 0x03, 0x00, 0x80,
  0xC0, 0x20, 0x20, 0x08, 0x18, 0x03, 0x06, 0x00, 0x81, 0x80, 0x30, 0x60,
  0x0C, 0x18, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03,
  0x0C, 0x00, 0xC7, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x31, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x09, 0x80, 0x03,
  0x20, 0x00, 0x98, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0xB0,
  0x00, 0x34, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x40, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x20, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC1, 0x81, 0x83, 0x83, 0x03, 0x06, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xF0, 0x00,
  0x60, 0x3C, 0x00, 0x00, 0x81, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0xF8, 0xC0,
  0x00, 0x03, 0xA0, 0xC0, 0x00, 0x0E, 0xC1, 0xC0, 0x00, 0x71, 0x81, 0xC0,
  0x03, 0xC3, 0x01, 0xE0, 0x3E, 0x06, 0x00, 0xFF, 0xF0, 0x0C, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x3C, 0x00, 0x03, 0x03, 0xFF, 0x80, 0x06, 0x1F, 0x07,
  0x80, 0x0C, 0x70, 0x01, 0x80, 0x13, 0x80, 0x01, 0x80, 0x6E, 0x00, 0x01,
  0x80, 0xD8, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x03,
  0x01, 0x98, 0x00, 0x1C, 0x03, 0x1C, 0x00, 0x70, 0x06, 0x1F, 0x07, 0xC0,
  0x0C, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x0F, 0xFE, 0x06,
  0x00, 0x0F, 0x83, 0xC1, 0x80, 0x07, 0x00, 0x1C, 0x60, 0x03, 0x80, 0x03,
  0x18, 0x01, 0x80, 0x00, 0x64, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x30, 0x00, 0x06, 0xC0, 0x06, 0x00, 0x07, 0x20, 0x00, 0xC0, 0x07, 0x98,
  0x00, 0x1E, 0x0F, 0x86, 0x00, 0x03, 0xFF, 0x81, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0xC0, 0x03, 0xE0, 0xF0, 0x60, 0x03, 0x80, 0x0E, 0x30, 0x03, 0x80,
  0x03, 0x98, 0x03, 0x00, 0x00, 0xC8, 0x03, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x1E, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0xD8, 0x01, 0x80, 0x01, 0xC8, 0x00, 0x70, 0x03, 0xCC, 0x00, 0x1E, 0x0F,
  0x86, 0x00, 0x07, 0xFF, 0x03, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x03, 0x01,
  0xFF, 0xC0, 0x04, 0x0F, 0x81, 0xE0, 0x18, 0x38, 0x00, 0xE0, 0x30, 0xC0,
  0x00, 0xC0, 0x63, 0x00, 0x00, 0xC0, 0xCC, 0x00, 0x01, 0x81, 0xB0, 0x00,
  0x01, 0x82, 0xC0, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x81,
  0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x20, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0x08, 0x78, 0x00, 0x00, 0x0C, 0xEE, 0x00, 0x00, 0x06, 0xE3, 0x00,
  0x00, 0x03, 0xE0, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0x1C, 0x1C, 0x1E,
  0x0E, 0x03, 0x70, 0x06, 0x38, 0x07, 0x03, 0xE0, 0x06, 0x60, 0x03, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x80, 0x01, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x07, 0x00, 0x03, 0x00, 0x01, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x06, 0x00, 0x06, 0x00, 0x03, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x30, 0x00, 0x10, 0x00, 0x08, 0x30, 0x00, 0x10, 0x00, 0x18, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x20, 0x00, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x00, 0x10, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x40, 0x00, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0x80, 0xFF, 0xE0, 0x01, 0x03, 0xE0, 0x78, 0x03, 0x07, 0x00, 0x1C,
  0x03, 0x0C, 0x00, 0x0C, 0x03, 0x18, 0x00, 0x06, 0x03, 0x30, 0x00, 0x06,
  0x03, 0x60, 0x00, 0x03, 0x02, 0xC0, 0x00, 0x03, 0x07, 0x80, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x1F, 0xFC,
  0x00, 0x06, 0x1F, 0x07, 0x80, 0x01, 0x1E, 0x00, 0x70, 0x00, 0x4E, 0x00,
  0x06, 0x00, 0x37, 0x00, 0x00, 0xC0, 0x0F, 0x80, 0x00, 0x30, 0x03, 0xC0,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30,
  0x02, 0xC0, 0x00, 0x18, 0x01, 0x98, 0x00, 0x1C, 0x00, 0x63, 0x80, 0x0E,
  0x00, 0x18, 0x78, 0x1F, 0x00, 0x06, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x0C, 0x00, 0xF8, 0x3E, 0x18, 0x03, 0x80, 0x0E,
  0x30, 0x0E, 0x00, 0x0E, 0x60, 0x30, 0x00, 0x0C, 0x80, 0xC0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x43, 0x80, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x72,
  0x00, 0x70, 0x03, 0xC4, 0x00, 0x78, 0x3E, 0x18, 0x00, 0x7F, 0xF0, 0x30,
  0x00, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x06,
  0x00, 0xFF, 0xF0, 0x10, 0x1F, 0x80, 0x80, 0xC1, 0xE0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x78, 0x30, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x0D, 0x80, 0xE0, 0x00,
  0x73, 0x00, 0xE0, 0x03, 0xC6, 0x00, 0xF0, 0x3E, 0x0C, 0x00, 0x7F, 0xF0,
  0x30, 0x00, 0x1D, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x01,
  0xB0, 0x00, 0x18, 0x00, 0x0C, 0x80, 0x01, 0xE0, 0x00, 0xC6, 0x00, 0x0F,
  0x00, 0x06, 0x30, 0x00, 0xD8, 0x00, 0x21, 0x80, 0x06, 0xC0, 0x03, 0x0C,
  0x00, 0x66, 0x00, 0x18, 0x60, 0x03, 0x30, 0x01, 0x83, 0x00, 0x19, 0x80,
  0x0C, 0x18, 0x01, 0x8C, 0x00, 0x60, 0xC0, 0x0C, 0x60, 0x06, 0x06, 0x00,
  0xC3, 0x00, 0x30, 0x30, 0x06, 0x18, 0x03, 0x01, 0x80, 0x20, 0x40, 0x18,
  0x0C, 0x03, 0x02, 0x00, 0xC0, 0x60, 0x18, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x06,
  0x06, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x60,
  0xC0, 0x04, 0x18, 0x03, 0x0C, 0x00, 0x21, 0x80, 0x18, 0x60, 0x01, 0x8C,
  0x00, 0xC3, 0x00, 0x0C, 0x40, 0x06, 0x30, 0x00, 0x66, 0x00, 0x11, 0x80,
  0x03, 0x30, 0x00, 0x98, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00,
  0x26, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x18, 0x7C, 0xF8, 0x00, 0x00, 0xC7, 0x00, 0xE0, 0x00,
  0x06, 0x70, 0x03, 0x80, 0x00, 0x63, 0x00, 0x0E, 0x00, 0x03, 0x30, 0x00,
  0x38, 0x00, 0x31, 0x80, 0x00, 0xE0, 0x03, 0x98, 0x00, 0x03, 0x80, 0x38,
  0xC0, 0x00, 0x07, 0x03, 0x86, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00,
};

const GFXglyph RobotoMono_ThinItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 11, 50, 41, 15, -50 },
  { 70, 12, 15, 41, 18, -53 },
  { 93, 41, 50, 41, 1, -50 },
  { 350, 33, 64, 41, 5, -57 },
  { 614, 34, 51, 41, 4, -50 },
  { 831, 34, 51, 41, 3, -50 },
  { 1048, 4, 15, 41, 21, -53 },
  { 1056, 21, 71, 41, 12, -55 },
  { 1243, 20, 71, 41, 7, -55 },
  { 1421, 29, 27, 41, 10, -50 },
  { 1519, 34, 36, 41, 4, -41 },
  { 1672, 7, 14, 41, 9, -5 },
  { 1685, 24, 2, 41, 8, -24 },
  { 1691, 4, 4, 41, 16, -4 },
  { 1693, 31, 54, 41, 6, -50 },
  { 1903, 32, 51, 41, 5, -50 },
  { 2107, 18, 50, 41, 11, -50 },
  { 2220, 32, 50, 41, 2, -50 },
  { 2420, 34, 51, 41, 2, -50 },
  { 2637, 34, 50, 41, 2, -50 },
  { 2850, 34, 51, 41, 6, -50 },
  { 3067, 30, 51, 41, 4, -50 },
  { 3259, 31, 50, 41, 9, -50 },
  { 3453, 35, 51, 41, 4, -50 },
  { 3677, 30, 51, 41, 7, -50 },
  { 3869, 9, 34, 41, 18, -34 },
  { 3908, 14, 43, 41, 14, -34 },
  { 3984, 31, 28, 41, 6, -37 },
  { 4093, 32, 16, 41, 5, -31 },
  { 4157, 31, 28, 41, 4, -37 },
  { 4266, 26, 50, 41, 11, -50 },
  { 4429, 40, 51, 41, 1, -50 },
  { 4684, 34, 50, 41, 0, -50 },
  { 4897, 34, 50, 41, 4, -50 },
  { 5110, 34, 51, 41, 4, -50 },
  { 5327, 35, 50, 41, 3, -50 },
  { 5546, 36, 50, 41, 4, -50 },
  { 5771, 36, 50, 41, 4, -50 },
  { 5996, 35, 51, 41, 4, -50 },
  { 6220, 38, 50, 41, 2, -50 },
  { 6458, 36, 50, 41, 3, -50 },
  { 6683, 35, 51, 41, 3, -50 },
  { 6907, 39, 50, 41, 4, -50 },
  { 7151, 28, 50, 41, 4, -50 },
  { 7326, 38, 50, 41, 3, -50 },
  { 7564, 38, 50, 41, 2, -50 },
  { 7802, 34, 51, 41, 4, -50 },
  { 8019, 36, 50, 41, 4, -50 },
  { 8244, 35, 59, 41, 4, -50 },
  { 8503, 34, 50, 41, 4, -50 },
  { 8716, 35, 51, 41, 4, -50 },
  { 8940, 34, 50, 41, 8, -50 },
  { 9153, 35, 51, 41, 5, -50 },
  { 9377, 34, 50, 41, 8, -50 },
  { 9590, 36, 50, 41, 8, -50 },
  { 9815, 41, 50, 41, 1, -50 },
  { 10072, 34, 50, 41, 8, -50 },
  { 10285, 36, 50, 41, 2, -50 },
  { 10510, 20, 68, 41, 11, -57 },
  { 10680, 13, 54, 41, 14, -50 },
  { 10768, 21, 68, 41, 10, -57 },
  { 10947, 24, 28, 41, 9, -50 },
  { 11031, 29, 2, 41, 2, 0 },
  { 11039, 7, 9, 41, 21, -52 },
  { 11047, 31, 39, 41, 4, -38 },
  { 11199, 31, 54, 41, 4, -53 },
  { 11409, 30, 39, 41, 5, -38 },
  { 11556, 34, 54, 41, 5, -53 },
  { 11786, 32, 39, 41, 4, -38 },
  { 11942, 33, 53, 41, 9, -53 },
  { 12161, 33, 53, 41, 3, -38 },
  { 12380, 31, 53, 41, 4, -53 },
  { 12586, 28, 50, 41, 4, -50 },
  { 12761, 32, 65, 41, 0, -50 },
  { 13021, 33, 53, 41, 5, -53 },
  { 13240, 28, 53, 41, 4, -53 },
  { 13426, 40, 38, 41, -1, -38 },
  { 13616, 32, 38, 41, 3, -38 },
  { 13768, 32, 39, 41, 4, -38 },
  { 13924, 34, 52, 41, 1, -38 },
  { 14145, 31, 52, 41, 5, -38 },
  { 14347, 30, 38, 41, 9, -38 },
  { 14490, 31, 39, 41, 5, -38 },
  { 14642, 26, 48, 41, 9, -47 },
  { 14798, 31, 38, 41, 6, -37 },
  { 14946, 33, 37, 41, 6, -37 },
  { 15099, 37, 37, 41, 5, -37 },
  { 15271, 37, 37, 41, 2, -37 },
  { 15443, 42, 52, 41, -1, -37 },
  { 15716, 36, 37, 41, 1, -37 },
  { 15883, 27, 70, 41, 11, -55 },
  { 16120, 11, 59, 41, 15, -50 },
  { 16202, 27, 70, 41, 6, -55 },
  { 16439, 37, 11, 41, 2, -26 },
};

const GFXfont RobotoMono_ThinItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic70pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_THINITALIC70PT7B_H_
