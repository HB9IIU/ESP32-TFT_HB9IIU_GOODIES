#ifndef _ROBOTOMONO_THINITALIC41PT7B_H_
#define _ROBOTOMONO_THINITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x21,
  0x23, 0x62, 0x42, 0x42, 0x42, 0x42, 0x44, 0x84, 0x00, 0x08, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x03, 0x01, 0x00, 0x04,
  0x04, 0x00, 0x08, 0x08, 0x00, 0x30, 0x10, 0x1F, 0xFF, 0xFE, 0x00, 0x80,
  0x80, 0x03, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x20, 0x30,
  0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x02, 0x03, 0x00, 0x04, 0x04, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x30, 0x0F, 0xFF, 0xFF, 0x00, 0x80, 0x80, 0x02,
  0x02, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08, 0x00, 0x20, 0x20, 0x00, 0x40,
  0x40, 0x01, 0x80, 0x80, 0x02, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x06, 0x01, 0x01, 0x80,
  0x10, 0x60, 0x02, 0x08, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x06, 0x18, 0x01, 0x81, 0x80, 0xE0,
  0x0F, 0xF0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xF8, 0x00, 0x10, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x40,
  0x64, 0x04, 0x04, 0x40, 0x40, 0x84, 0x04, 0x18, 0x40, 0x41, 0x0C, 0x08,
  0x20, 0x40, 0x84, 0x04, 0x10, 0xC0, 0x63, 0x08, 0x03, 0xC1, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x3C, 0x00, 0x86, 0x20,
  0x10, 0x81, 0x02, 0x08, 0x10, 0x61, 0x01, 0x04, 0x10, 0x10, 0x81, 0x01,
  0x18, 0x10, 0x11, 0x02, 0x03, 0x20, 0x30, 0x20, 0x01, 0x06, 0x00, 0x10,
  0xC0, 0x00, 0xF8, 0x00, 0x10, 0x00, 0x07, 0xE0, 0x01, 0x83, 0x00, 0x10,
  0x10, 0x02, 0x01, 0x00, 0x20, 0x10, 0x02, 0x01, 0x00, 0x60, 0x10, 0x06,
  0x02, 0x00, 0x20, 0x40, 0x02, 0x08, 0x00, 0x23, 0x00, 0x01, 0x60, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x6C, 0x00, 0x0C, 0x40, 0x01, 0x82, 0x01,
  0x30, 0x30, 0x12, 0x01, 0x02, 0x40, 0x08, 0x24, 0x00, 0x86, 0xC0, 0x04,
  0x48, 0x00, 0x2C, 0x80, 0x02, 0x8C, 0x00, 0x10, 0x40, 0x03, 0x86, 0x00,
  0x48, 0x30, 0x18, 0x40, 0xFE, 0x06, 0x69, 0x24, 0xB4, 0x80, 0x00, 0x10,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x04, 0x04, 0x0D, 0xC2, 0x38, 0x1D, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0x90, 0x01, 0x8C, 0x01, 0x82, 0x01, 0x80, 0x81, 0x80, 0x60, 0x80, 0x10,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x11, 0x11, 0x22, 0x48, 0xFF, 0xFC, 0x7C,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x0C, 0x06, 0x03, 0x00, 0x40,
  0x40, 0x04, 0x10, 0x00, 0x84, 0x00, 0x18, 0x80, 0x01, 0x30, 0x00, 0x64,
  0x00, 0x14, 0x80, 0x0C, 0xB0, 0x03, 0x14, 0x00, 0xC2, 0x80, 0x30, 0x90,
  0x08, 0x12, 0x02, 0x02, 0x40, 0x80, 0x58, 0x60, 0x0A, 0x18, 0x03, 0x46,
  0x00, 0x49, 0x80, 0x09, 0x40, 0x01, 0x30, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x03, 0x08, 0x00, 0x41, 0x00, 0x10, 0x30, 0x04, 0x03, 0x03, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xC0, 0xE1, 0xC9, 0x82, 0x80, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x0C, 0x06, 0x03, 0x00,
  0x20, 0x40, 0x04, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0xC0, 0x20,
  0x06, 0x04, 0x00, 0x20, 0xC0, 0x03, 0x08, 0x00, 0x11, 0x80, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x48, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x18, 0x40, 0x01, 0x02, 0x00,
  0x60, 0x18, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x40, 0x00, 0x34, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x01, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x18,
  0x01, 0x01, 0x00, 0x20, 0x10, 0x06, 0x01, 0x00, 0xC0, 0x10, 0x18, 0x01,
  0x01, 0x00, 0x30, 0x20, 0x02, 0x04, 0x00, 0x20, 0xFF, 0xFF, 0xF0, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x7F,
  0x80, 0x3C, 0x04, 0x03, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x08,
  0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x0C, 0x00, 0x40,
  0x40, 0x08, 0x03, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x03,
  0xF0, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x43, 0xF0, 0x23,
  0x03, 0x0B, 0x00, 0x43, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0x50, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09,
  0x00, 0x02, 0x40, 0x01, 0x90, 0x00, 0x42, 0x00, 0x20, 0xC0, 0x18, 0x18,
  0x08, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x03, 0xFC, 0x00, 0x60, 0x18, 0x06, 0x00, 0x40, 0x60, 0x01, 0x02,
  0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00,
  0x82, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x40, 0x04, 0x01, 0x00, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x06, 0x01, 0x00, 0xC0, 0x04, 0x0C, 0x00, 0x10,
  0x40, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00,
  0x08, 0x40, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x60, 0x40, 0x06, 0x01,
  0x80, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x00, 0x60, 0x20,
  0x20, 0x04, 0x10, 0x01, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x09, 0x00, 0x06, 0x40, 0x02, 0x98, 0x01, 0x43, 0x01, 0x90,
  0x7F, 0x84, 0x03, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x80, 0x1F, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x40, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x08, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xC1, 0x81, 0x88, 0x03,
  0x40, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x30, 0x18, 0x00, 0x20, 0x60, 0x00,
  0x40, 0x80, 0x00, 0xC2, 0x07, 0xC0, 0x8C, 0x10, 0x41, 0x10, 0x40, 0x82,
  0x61, 0x01, 0x04, 0x82, 0x04, 0x0B, 0x08, 0x08, 0x14, 0x10, 0x10, 0x68,
  0x40, 0x20, 0x90, 0x80, 0x81, 0x41, 0x01, 0x02, 0x82, 0x02, 0x05, 0x0C,
  0x0C, 0x12, 0x10, 0x10, 0x24, 0x20, 0x60, 0xC8, 0x41, 0x41, 0x10, 0x46,
  0xC4, 0x20, 0xF8, 0xF0, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x05, 0x00, 0x00, 0x50, 0x00, 0x09, 0x00, 0x00,
  0x88, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00,
  0x40, 0x80, 0x04, 0x08, 0x00, 0xC0, 0x40, 0x08, 0x04, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00, 0x60, 0x7F, 0xFE,
  0x0C, 0x00, 0x20, 0x80, 0x02, 0x18, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00,
  0x22, 0x00, 0x03, 0x60, 0x00, 0x14, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x07,
  0xFF, 0x00, 0x40, 0x18, 0x04, 0x00, 0x60, 0x40, 0x02, 0x08, 0x00, 0x30,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x10, 0x00, 0x41, 0x00, 0x0C, 0x10, 0x03, 0x01, 0x03, 0xE0, 0x1F, 0xFE,
  0x03, 0x00, 0x18, 0x20, 0x00, 0xC2, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00,
  0x02, 0x20, 0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x84, 0x00, 0x10, 0x40, 0x02, 0x08, 0x01, 0xC0, 0xFF, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xF0, 0x03, 0x01, 0x80, 0x60, 0x04, 0x0C, 0x00,
  0x40, 0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18,
  0x80, 0x01, 0x0C, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x18,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x20, 0x0C, 0x02, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0x80, 0x02, 0x04, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x02,
  0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00,
  0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00,
  0x21, 0x00, 0x02, 0x08, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x30, 0x20,
  0x03, 0x01, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xFC, 0x00, 0x60, 0x30, 0x06, 0x00, 0x40, 0x60, 0x03, 0x06, 0x00,
  0x08, 0x20, 0x00, 0x43, 0x00, 0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x01, 0xFF, 0x10, 0x00, 0x09, 0x80,
  0x00, 0x4C, 0x00, 0x06, 0x60, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x43, 0x00, 0x02, 0x08, 0x00, 0x30, 0x60, 0x03, 0x01, 0x80,
  0x60, 0x03, 0xFC, 0x00, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00,
  0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82,
  0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x10, 0x00, 0x10, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x04, 0x00, 0x04,
  0x10, 0x00, 0x10, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x06, 0x10, 0x00, 0x10, 0x40, 0x00,
  0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0xC0, 0x00, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x88, 0x00, 0x18,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x02, 0x0C, 0x00, 0x40, 0x40, 0x0C,
  0x02, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x06, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x40, 0x20, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x30, 0x02,
  0x00, 0xC0, 0x04, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x20,
  0xC0, 0x00, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x30, 0x00, 0x04, 0x90,
  0x00, 0x0A, 0x30, 0x00, 0x18, 0x20, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40,
  0x01, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x18, 0x00, 0x80,
  0x20, 0x01, 0x00, 0x40, 0x01, 0x00, 0x80, 0x03, 0x01, 0x00, 0x02, 0x02,
  0x00, 0x02, 0x0C, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xFF, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xA0, 0x01,
  0x82, 0x80, 0x0A, 0x0A, 0x00, 0x68, 0x28, 0x01, 0x21, 0xA0, 0x0C, 0x84,
  0x40, 0x24, 0x11, 0x01, 0x10, 0x44, 0x04, 0x41, 0x10, 0x21, 0x04, 0x41,
  0x84, 0x20, 0x84, 0x30, 0x82, 0x30, 0x82, 0x08, 0x82, 0x08, 0x24, 0x08,
  0x20, 0x90, 0x20, 0x81, 0x80, 0x84, 0x06, 0x04, 0x10, 0x10, 0x10, 0x40,
  0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x80,
  0x06, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0x41, 0x40, 0x01, 0x05,
  0x00, 0x04, 0x22, 0x00, 0x20, 0x88, 0x00, 0x82, 0x20, 0x02, 0x08, 0x40,
  0x08, 0x21, 0x00, 0x20, 0x84, 0x00, 0x84, 0x08, 0x04, 0x10, 0x20, 0x10,
  0x40, 0x40, 0x41, 0x01, 0x01, 0x04, 0x04, 0x04, 0x10, 0x08, 0x30, 0x80,
  0x20, 0x82, 0x00, 0x82, 0x08, 0x01, 0x08, 0x20, 0x04, 0x20, 0x80, 0x08,
  0x82, 0x00, 0x26, 0x10, 0x00, 0x90, 0x40, 0x01, 0x41, 0x00, 0x05, 0x04,
  0x00, 0x14, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x80, 0x00, 0x18, 0x00, 0x1F,
  0xE0, 0x0C, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0x84, 0x00,
  0x09, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x14, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x41, 0x00, 0x10,
  0x30, 0x04, 0x03, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x40,
  0x06, 0x02, 0x00, 0x18, 0x10, 0x00, 0x60, 0x80, 0x01, 0x04, 0x00, 0x08,
  0x20, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x20, 0x00, 0x43, 0x00, 0x06, 0x10, 0x00, 0x60, 0x80, 0x06, 0x04,
  0x03, 0xC0, 0x3F, 0xF0, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x30, 0x06, 0x00, 0x40,
  0x40, 0x02, 0x06, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x03, 0x10, 0x00,
  0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x00, 0xA0,
  0x00, 0x0D, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x00,
  0xA0, 0x00, 0x05, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00,
  0x01, 0x18, 0x00, 0x08, 0x40, 0x00, 0x82, 0x00, 0x0C, 0x08, 0x00, 0xC0,
  0x60, 0x0C, 0x01, 0x80, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x00,
  0x40, 0x0C, 0x04, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x10, 0x80, 0x01,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x41, 0x00, 0x08, 0x10, 0x03, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x40, 0x20,
  0x06, 0x02, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x30, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x00, 0x84, 0x00, 0x08, 0x80, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x07, 0xFC, 0x00, 0x60, 0x10, 0x04, 0x00, 0x40, 0x40, 0x01, 0x04,
  0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x03, 0x10, 0x00, 0x18, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00,
  0x08, 0xC0, 0x00, 0x42, 0x00, 0x02, 0x18, 0x00, 0x20, 0x40, 0x02, 0x01,
  0x80, 0x60, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00,
  0x48, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00,
  0x18, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02, 0x04, 0x00, 0x40, 0x60,
  0x0C, 0x03, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x40, 0x00, 0x6C, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x02, 0x08, 0x00, 0x41, 0x80, 0x10, 0x10, 0x02, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x30, 0x02,
  0x04, 0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x12, 0x04,
  0x83, 0x20, 0x48, 0x22, 0x08, 0x82, 0x20, 0x88, 0x62, 0x08, 0x84, 0x20,
  0x88, 0x42, 0x10, 0x8C, 0x21, 0x08, 0x82, 0x10, 0x88, 0x22, 0x09, 0x82,
  0x20, 0x90, 0x22, 0x09, 0x02, 0x40, 0xA0, 0x24, 0x0A, 0x02, 0x40, 0xA0,
  0x28, 0x0C, 0x02, 0x80, 0xC0, 0x28, 0x0C, 0x03, 0x00, 0x80, 0x30, 0x08,
  0x03, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x08, 0x08,
  0x00, 0x20, 0x10, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x20,
  0x10, 0x00, 0x40, 0x60, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x88,
  0x00, 0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x68, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x10, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x10, 0x00, 0x80, 0x60, 0x01, 0x80, 0x80, 0x01, 0x02, 0x00,
  0x03, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x38, 0x00, 0x09, 0x00, 0x03,
  0x20, 0x00, 0x46, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x80, 0x20,
  0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x40, 0x04, 0x10, 0x00, 0x82, 0x00,
  0x10, 0x80, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x8F, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xFC, 0x00, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20,
  0x20, 0x20, 0x20, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08,
  0x08, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03,
  0x01, 0x01, 0x03, 0xF0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFC,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x08, 0x40,
  0x21, 0x01, 0x04, 0x0C, 0x10, 0x20, 0x61, 0x00, 0x84, 0x02, 0x20, 0x08,
  0x80, 0x34, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0x80, 0xC6, 0x23, 0x10, 0x00,
  0xFE, 0x00, 0x70, 0x70, 0x18, 0x02, 0x06, 0x00, 0x21, 0x80, 0x04, 0x20,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x07,
  0xFF, 0x07, 0x00, 0x21, 0x80, 0x08, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0xC0, 0x01, 0x90, 0x00, 0x33, 0x00, 0x0C, 0x20, 0x06, 0x82, 0x03,
  0x90, 0x3F, 0xC2, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x0F, 0xC0, 0x26, 0x0C, 0x05, 0x00, 0x41, 0x40, 0x0C, 0x30,
  0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x0C, 0xC0,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x04, 0x30, 0x01, 0x07, 0x00,
  0x40, 0xB0, 0x30, 0x21, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0x40,
  0x10, 0x20, 0x02, 0x10, 0x00, 0x88, 0x00, 0x32, 0x00, 0x05, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x84, 0x00,
  0x60, 0x80, 0x30, 0x30, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x1F, 0x84, 0x07, 0x06, 0x40,
  0xC0, 0x34, 0x18, 0x01, 0x41, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08,
  0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00, 0x10, 0x80, 0x01,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00,
  0x20, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x60, 0x0A, 0x03, 0x03, 0x20, 0x1F,
  0xE6, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0x40, 0x10, 0x20, 0x02, 0x10,
  0x00, 0x88, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x30, 0x80, 0x18, 0x10,
  0x0C, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x1F, 0xFF, 0xC0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFC, 0x20, 0x30, 0x64, 0x18,
  0x06, 0x86, 0x00, 0x50, 0x80, 0x06, 0x20, 0x00, 0x84, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x09, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x0C, 0x00,
  0x20, 0x80, 0x0C, 0x18, 0x02, 0x81, 0x81, 0x90, 0x1F, 0xE6, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x82, 0x00, 0x30, 0x40, 0x0C,
  0x06, 0x03, 0x00, 0x71, 0xC0, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x07, 0xC0, 0x23, 0x06, 0x09, 0x80,
  0x61, 0x60, 0x04, 0x28, 0x00, 0x86, 0x00, 0x18, 0x80, 0x03, 0x10, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00,
  0x88, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0x4C, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x40, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x01, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x08, 0x30, 0x00,
  0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x0C, 0x60, 0x03, 0x08, 0x00, 0x81, 0x00, 0x60, 0x20, 0x18,
  0x04, 0x06, 0x00, 0x81, 0x00, 0x30, 0xC0, 0x04, 0x30, 0x00, 0x88, 0x00,
  0x16, 0x80, 0x03, 0x98, 0x00, 0x41, 0x00, 0x10, 0x10, 0x02, 0x03, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x60, 0x20, 0x06, 0x08, 0x00, 0x41,
  0x00, 0x04, 0x20, 0x00, 0xC0, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x11, 0xF0, 0xF8, 0x2C, 0x33,
  0x08, 0x70, 0x28, 0x08, 0xC0, 0x60, 0x11, 0x00, 0xC0, 0x26, 0x01, 0x00,
  0x48, 0x02, 0x00, 0x90, 0x04, 0x01, 0x20, 0x08, 0x06, 0x40, 0x30, 0x08,
  0x80, 0x40, 0x12, 0x00, 0x80, 0x24, 0x01, 0x00, 0x48, 0x02, 0x00, 0x90,
  0x04, 0x02, 0x20, 0x10, 0x04, 0x40, 0x20, 0x09, 0x00, 0x40, 0x12, 0x00,
  0x80, 0x24, 0x01, 0x00, 0x48, 0x02, 0x01, 0x10, 0x08, 0x02, 0x00, 0x08,
  0x3E, 0x01, 0x18, 0x30, 0x4C, 0x03, 0x0B, 0x00, 0x21, 0x40, 0x04, 0x30,
  0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x06, 0x60, 0x00, 0x88, 0x00,
  0x11, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x60, 0x18, 0x02, 0x06,
  0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x40,
  0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xA0, 0x00, 0x16, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x21, 0x80,
  0x0C, 0x10, 0x03, 0x01, 0x81, 0xC0, 0x1F, 0xE0, 0x00, 0x04, 0x3F, 0x00,
  0x98, 0x30, 0x14, 0x01, 0x05, 0x00, 0x20, 0xC0, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88,
  0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x11, 0x00, 0x02, 0x20,
  0x00, 0x84, 0x00, 0x10, 0xC0, 0x04, 0x1C, 0x01, 0x06, 0xC0, 0xC0, 0x87,
  0xF0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x40,
  0xC1, 0x90, 0xC0, 0x34, 0x60, 0x05, 0x10, 0x00, 0xC8, 0x00, 0x22, 0x00,
  0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x02, 0x30,
  0x00, 0x84, 0x00, 0x61, 0x80, 0x28, 0x30, 0x32, 0x07, 0xF8, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x08, 0x1F, 0xC2, 0x18, 0x00, 0x98, 0x00,
  0x28, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xC0, 0xC0,
  0x80, 0x08, 0x40, 0x03, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x48,
  0x00, 0x11, 0x00, 0x08, 0x30, 0x0C, 0x07, 0xFC, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x3F, 0xFF, 0x81, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x1F, 0xC0, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x60, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x06, 0x40, 0x01, 0x10, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x03, 0x30, 0x00, 0xC4, 0x00, 0x61, 0x00, 0x28, 0x20,
  0x32, 0x07, 0xF0, 0x80, 0x80, 0x00, 0x30, 0x00, 0x0B, 0x00, 0x01, 0x20,
  0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x18, 0x00, 0xC1, 0x00, 0x10, 0x20,
  0x04, 0x04, 0x00, 0x80, 0xC0, 0x20, 0x08, 0x0C, 0x01, 0x01, 0x00, 0x20,
  0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x16,
  0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x28, 0x0F, 0x01, 0x60, 0x58,
  0x13, 0x02, 0x40, 0x88, 0x22, 0x0C, 0x41, 0x10, 0x42, 0x18, 0x82, 0x10,
  0x84, 0x20, 0x84, 0x21, 0x04, 0x41, 0x18, 0x22, 0x08, 0x81, 0x20, 0x44,
  0x09, 0x02, 0x40, 0x58, 0x12, 0x02, 0x80, 0xB0, 0x14, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x80, 0x20, 0x04, 0x00, 0x08, 0x00, 0x0C, 0x10, 0x00,
  0x60, 0x60, 0x03, 0x00, 0x80, 0x18, 0x03, 0x00, 0xC0, 0x04, 0x06, 0x00,
  0x08, 0x30, 0x00, 0x31, 0x80, 0x00, 0x4C, 0x00, 0x00, 0xA0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x58, 0x00, 0x02, 0x20, 0x00, 0x10, 0x40,
  0x00, 0xC1, 0x80, 0x06, 0x02, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x10, 0x0C,
  0x00, 0x20, 0x60, 0x00, 0xC3, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x81, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x60, 0x00, 0x40,
  0x10, 0x00, 0x60, 0x08, 0x00, 0x20, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x10, 0x00, 0x40, 0x18, 0x00, 0x30, 0x08, 0x00, 0x08, 0x08,
  0x00, 0x04, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x04, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x21, 0x84, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0xF0, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x7E, 0x00, 0x12, 0x04,
  0x00, 0xD0, 0x08, 0x02, 0x40, 0x10, 0x1A, 0x00, 0x30, 0xC8, 0x00, 0x7C,
  0x00,
};

const GFXglyph RobotoMono_ThinItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 29, 24, 9, -29 },
  { 23, 8, 9, 24, 10, -31 },
  { 32, 23, 29, 24, 1, -29 },
  { 116, 19, 37, 24, 3, -33 },
  { 204, 20, 30, 24, 2, -30 },
  { 279, 20, 30, 24, 2, -30 },
  { 354, 3, 9, 24, 12, -31 },
  { 358, 12, 41, 24, 7, -32 },
  { 420, 12, 41, 24, 4, -32 },
  { 482, 17, 16, 24, 6, -29 },
  { 516, 20, 21, 24, 2, -24 },
  { 569, 4, 8, 24, 5, -3 },
  { 573, 14, 1, 24, 5, -14 },
  { 575, 3, 2, 24, 9, -2 },
  { 576, 19, 31, 24, 3, -29 },
  { 650, 19, 30, 24, 3, -30 },
  { 722, 10, 29, 24, 7, -29 },
  { 759, 19, 30, 24, 1, -30 },
  { 831, 20, 30, 24, 1, -30 },
  { 906, 20, 29, 24, 1, -29 },
  { 979, 20, 29, 24, 4, -29 },
  { 1052, 18, 30, 24, 2, -30 },
  { 1120, 18, 29, 24, 5, -29 },
  { 1186, 21, 30, 24, 2, -30 },
  { 1265, 18, 30, 24, 4, -30 },
  { 1333, 5, 20, 24, 11, -20 },
  { 1346, 8, 25, 24, 8, -20 },
  { 1371, 19, 16, 24, 3, -21 },
  { 1409, 19, 9, 24, 3, -18 },
  { 1431, 19, 16, 24, 2, -21 },
  { 1469, 14, 30, 24, 7, -30 },
  { 1522, 23, 29, 24, 1, -29 },
  { 1606, 20, 29, 24, 0, -29 },
  { 1679, 20, 29, 24, 2, -29 },
  { 1752, 20, 30, 24, 3, -30 },
  { 1827, 21, 29, 24, 2, -29 },
  { 1904, 21, 29, 24, 2, -29 },
  { 1981, 22, 29, 24, 2, -29 },
  { 2061, 21, 30, 24, 2, -30 },
  { 2140, 22, 29, 24, 1, -29 },
  { 2220, 21, 29, 24, 2, -29 },
  { 2297, 20, 29, 24, 2, -29 },
  { 2370, 23, 29, 24, 2, -29 },
  { 2454, 16, 29, 24, 3, -29 },
  { 2512, 22, 29, 24, 2, -29 },
  { 2592, 22, 29, 24, 1, -29 },
  { 2672, 19, 30, 24, 3, -30 },
  { 2744, 21, 29, 24, 3, -29 },
  { 2821, 21, 35, 24, 2, -30 },
  { 2913, 20, 29, 24, 2, -29 },
  { 2986, 21, 30, 24, 2, -30 },
  { 3065, 20, 29, 24, 5, -29 },
  { 3138, 20, 29, 24, 3, -29 },
  { 3211, 19, 29, 24, 5, -29 },
  { 3280, 20, 29, 24, 5, -29 },
  { 3353, 23, 29, 24, 1, -29 },
  { 3437, 19, 29, 24, 5, -29 },
  { 3506, 21, 29, 24, 1, -29 },
  { 3583, 12, 39, 24, 6, -33 },
  { 3642, 8, 32, 24, 8, -29 },
  { 3674, 12, 39, 24, 6, -33 },
  { 3733, 14, 16, 24, 5, -29 },
  { 3761, 17, 1, 24, 1, 0 },
  { 3764, 4, 5, 24, 12, -30 },
  { 3767, 19, 22, 24, 2, -22 },
  { 3820, 19, 31, 24, 2, -31 },
  { 3894, 18, 22, 24, 3, -22 },
  { 3944, 20, 31, 24, 3, -31 },
  { 4022, 18, 22, 24, 3, -22 },
  { 4072, 19, 31, 24, 6, -31 },
  { 4146, 19, 31, 24, 2, -22 },
  { 4220, 19, 31, 24, 2, -31 },
  { 4294, 16, 29, 24, 3, -29 },
  { 4352, 19, 38, 24, 0, -29 },
  { 4443, 19, 31, 24, 3, -31 },
  { 4517, 16, 31, 24, 3, -31 },
  { 4579, 23, 22, 24, 0, -22 },
  { 4643, 19, 22, 24, 2, -22 },
  { 4696, 19, 22, 24, 2, -22 },
  { 4749, 19, 30, 24, 1, -22 },
  { 4821, 18, 30, 24, 3, -22 },
  { 4889, 18, 22, 24, 5, -22 },
  { 4939, 18, 22, 24, 3, -22 },
  { 4989, 15, 28, 24, 5, -28 },
  { 5042, 18, 22, 24, 3, -22 },
  { 5092, 19, 22, 24, 4, -22 },
  { 5145, 21, 22, 24, 3, -22 },
  { 5203, 22, 22, 24, 1, -22 },
  { 5264, 25, 31, 24, -1, -22 },
  { 5361, 21, 22, 24, 1, -22 },
  { 5419, 16, 41, 24, 6, -32 },
  { 5501, 6, 34, 24, 9, -29 },
  { 5527, 16, 41, 24, 3, -32 },
  { 5609, 22, 7, 24, 1, -16 },
};

const GFXfont RobotoMono_ThinItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic41pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_THINITALIC41PT7B_H_
