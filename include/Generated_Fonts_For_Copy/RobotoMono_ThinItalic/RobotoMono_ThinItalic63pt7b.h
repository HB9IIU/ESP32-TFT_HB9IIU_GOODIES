#ifndef _ROBOTOMONO_THINITALIC63PT7B_H_
#define _ROBOTOMONO_THINITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0xC0, 0xE0, 0x00, 0x30, 0x66,
  0x0C, 0x81, 0x90, 0x36, 0x06, 0xC0, 0x98, 0x33, 0x06, 0x40, 0xD8, 0x1B,
  0x02, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E,
  0x01, 0x00, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x86, 0x00,
  0x60, 0x07, 0x10, 0x01, 0x80, 0x18, 0xC0, 0x06, 0x00, 0xC3, 0x00, 0x18,
  0x06, 0x0C, 0x00, 0x40, 0x10, 0x30, 0x01, 0x00, 0xC0, 0x80, 0x0C, 0x06,
  0x03, 0x00, 0x30, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0x30, 0x30, 0x01, 0x81, 0x80, 0xC0, 0x03, 0x1C, 0x06, 0x00, 0x07,
  0xE0, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x1F, 0x80, 0x01, 0x80, 0xFF, 0x00, 0x04, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x08, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x30, 0x03,
  0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x02, 0x00, 0x30, 0x30, 0x08, 0x00, 0xC1,
  0x80, 0x60, 0x03, 0x0C, 0x01, 0x80, 0x0C, 0x60, 0x06, 0x00, 0x21, 0x80,
  0x18, 0x01, 0x8C, 0x00, 0x60, 0x06, 0x20, 0x01, 0x80, 0x30, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x40, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x04, 0x38, 0x06,
  0x00, 0x10, 0x60, 0x06, 0x00, 0x61, 0x80, 0x06, 0x00, 0xC6, 0x00, 0x0C,
  0x01, 0x8C, 0x00, 0x0C, 0x06, 0x30, 0x00, 0x08, 0x0C, 0x60, 0x00, 0x18,
  0x18, 0x80, 0x00, 0x18, 0x61, 0x00, 0x00, 0x10, 0xC2, 0x00, 0x00, 0x33,
  0x04, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x00, 0x78, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x0E, 0xC0, 0x70, 0x00, 0x38, 0xC0,
  0x70, 0x01, 0xC0, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0x3F, 0xF8, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x25, 0xB6, 0xD2, 0xDB, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0xFC, 0x03, 0x01, 0xF3, 0xE0, 0xC3,
  0xE0, 0x1E, 0x33, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x30, 0xC6, 0x30,
  0x40, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x07, 0x88, 0x00, 0x00, 0x6C, 0xC0, 0x00, 0x0E, 0x66, 0x00,
  0x00, 0xE2, 0x30, 0x00, 0x0C, 0x11, 0x00, 0x00, 0xC0, 0x98, 0x00, 0x0C,
  0x0C, 0xC0, 0x00, 0xC0, 0x66, 0x00, 0x0C, 0x03, 0x30, 0x00, 0xC0, 0x19,
  0x00, 0x1C, 0x00, 0x88, 0x01, 0x80, 0x04, 0xC0, 0x18, 0x00, 0x66, 0x01,
  0x80, 0x03, 0x30, 0x18, 0x00, 0x19, 0x81, 0x80, 0x00, 0xC8, 0x18, 0x00,
  0x04, 0x43, 0x80, 0x00, 0x62, 0x38, 0x00, 0x03, 0x13, 0x00, 0x00, 0x18,
  0xB0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x80, 0x20, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xE2, 0x07,
  0x86, 0x1E, 0x06, 0x70, 0x06, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x10,
  0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x20, 0x07, 0x00, 0x00, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0xFF, 0x80, 0x00, 0xDF, 0xFF, 0x80, 0x02, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x1F,
  0xF8, 0x03, 0x0F, 0x07, 0x80, 0x47, 0x00, 0x18, 0x19, 0x80, 0x01, 0x82,
  0x60, 0x00, 0x18, 0x50, 0x00, 0x01, 0x1C, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x02, 0x60, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x1E, 0x30, 0x00, 0x06, 0xC6, 0x00, 0x01, 0x90, 0x60, 0x00, 0x66,
  0x06, 0x00, 0x38, 0xC0, 0x70, 0x3C, 0x18, 0x07, 0xFF, 0x06, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x0F, 0x03, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x08,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC1, 0xC0, 0x1C, 0x00, 0xC0,
  0x70, 0x00, 0xC1, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x30,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0xF0, 0x02, 0x03, 0x80,
  0x7F, 0xC0, 0x30, 0x30, 0x0E, 0x0E, 0x03, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x60, 0x30, 0x06, 0x03, 0x0C, 0x06, 0x00, 0x40, 0x30, 0xC0, 0x60, 0x04,
  0x03, 0x18, 0x0C, 0x00, 0xC0, 0x31, 0x80, 0xC0, 0x0C, 0x03, 0x10, 0x18,
  0x00, 0x80, 0x23, 0x01, 0x80, 0x18, 0x02, 0x30, 0x10, 0x01, 0x80, 0x62,
  0x03, 0x00, 0x18, 0x06, 0x60, 0x30, 0x01, 0x00, 0x66, 0x02, 0x00, 0x30,
  0x04, 0x60, 0x60, 0x03, 0x00, 0x44, 0x06, 0x00, 0x20, 0x0C, 0x40, 0x60,
  0x06, 0x00, 0xC4, 0x06, 0x00, 0x60, 0x08, 0xC0, 0x40, 0x0E, 0x01, 0x8C,
  0x04, 0x00, 0xE0, 0x18, 0xC0, 0x40, 0x1C, 0x03, 0x0C, 0x04, 0x03, 0x40,
  0x30, 0xC0, 0x60, 0x66, 0x06, 0x04, 0x06, 0x0E, 0x60, 0xC0, 0x40, 0x31,
  0xC3, 0x38, 0x06, 0x01, 0xF0, 0x3F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x02, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x03, 0x80, 0x20, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x06, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x80, 0x80, 0x00,
  0x1C, 0x01, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x70, 0x01, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x40, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x09, 0x80, 0x03, 0xFF, 0xE3,
  0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x04, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x06,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x08,
  0x38, 0x00, 0x00, 0x02, 0x1F, 0x00, 0x00, 0x00, 0x8E, 0xC0, 0x00, 0x00,
  0x66, 0x18, 0x00, 0x00, 0x1B, 0x02, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0F,
  0x01, 0xA0, 0x00, 0x06, 0xC0, 0x6C, 0x00, 0x01, 0xB0, 0x1B, 0x00, 0x00,
  0xC8, 0x06, 0xC0, 0x00, 0x32, 0x01, 0x30, 0x00, 0x19, 0x80, 0xC4, 0x00,
  0x06, 0x60, 0x31, 0x00, 0x03, 0x18, 0x0C, 0x60, 0x01, 0x86, 0x03, 0x18,
  0x00, 0x61, 0x00, 0x86, 0x00, 0x30, 0x40, 0x20, 0x80, 0x0C, 0x30, 0x18,
  0x20, 0x06, 0x0C, 0x06, 0x0C, 0x01, 0x83, 0x01, 0x83, 0x00, 0xC0, 0x80,
  0x60, 0xC0, 0x60, 0x20, 0x10, 0x10, 0x18, 0x18, 0x04, 0x04, 0x0C, 0x06,
  0x03, 0x01, 0x83, 0x01, 0x80, 0xC0, 0x61, 0x80, 0x60, 0x30, 0x18, 0x60,
  0x10, 0x0C, 0x02, 0x30, 0x04, 0x02, 0x00, 0x88, 0x03, 0x00, 0x80, 0x36,
  0x00, 0xC0, 0x60, 0x0F, 0x00, 0x30, 0x18, 0x03, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x02, 0x01, 0x80, 0x10, 0x00, 0x80, 0x40, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x02,
  0x01, 0xA0, 0x00, 0x00, 0x80, 0x68, 0x00, 0x00, 0x60, 0x13, 0x00, 0x00,
  0x18, 0x04, 0x40, 0x00, 0x06, 0x03, 0x18, 0x00, 0x01, 0x80, 0xC6, 0x00,
  0x00, 0x40, 0x30, 0x80, 0x00, 0x10, 0x08, 0x30, 0x00, 0x0C, 0x02, 0x04,
  0x00, 0x03, 0x00, 0x81, 0x00, 0x00, 0xC0, 0x60, 0x60, 0x00, 0x20, 0x18,
  0x08, 0x00, 0x08, 0x06, 0x03, 0x00, 0x02, 0x01, 0x00, 0xC0, 0x01, 0x80,
  0x40, 0x10, 0x00, 0x60, 0x10, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x04,
  0x03, 0x00, 0x20, 0x01, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x20, 0x01, 0x00,
  0x30, 0x08, 0x00, 0x60, 0x0C, 0x02, 0x00, 0x18, 0x03, 0x01, 0x80, 0x02,
  0x00, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x18, 0x00, 0x10, 0x18, 0x04, 0x00,
  0x04, 0x06, 0x01, 0x00, 0x01, 0x81, 0x80, 0x40, 0x00, 0x20, 0x60, 0x30,
  0x00, 0x0C, 0x10, 0x0C, 0x00, 0x03, 0x04, 0x03, 0x00, 0x00, 0x43, 0x00,
  0x80, 0x00, 0x18, 0xC0, 0x20, 0x00, 0x02, 0x30, 0x18, 0x00, 0x00, 0x8C,
  0x06, 0x00, 0x00, 0x32, 0x01, 0x80, 0x00, 0x04, 0x80, 0x60, 0x00, 0x01,
  0xE0, 0x10, 0x00, 0x00, 0x78, 0x04, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xF0,
  0x01, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x07, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x40, 0x00, 0x38, 0x01,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x08,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x40,
  0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x02, 0xC0,
  0x03, 0x80, 0x06, 0xC0, 0x07, 0x80, 0x06, 0xC0, 0x07, 0x80, 0x04, 0xC0,
  0x04, 0x80, 0x0C, 0xC0, 0x0C, 0x80, 0x0C, 0xC0, 0x0C, 0x80, 0x08, 0xC0,
  0x08, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x10, 0xC0,
  0x10, 0x80, 0x10, 0xC0, 0x30, 0x80, 0x30, 0xC0, 0x30, 0x80, 0x20, 0xC0,
  0x20, 0x80, 0x20, 0xC0, 0x60, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x40, 0xC0,
  0x40, 0xC0, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0xC0, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC3,
  0x00, 0xC1, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0xC6,
  0x00, 0xC2, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xCC,
  0x00, 0xC4, 0x00, 0xCC, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0xCC, 0x00, 0xD8,
  0x00, 0xCC, 0x00, 0xD8, 0x00, 0xC8, 0x00, 0xD0, 0x00, 0xD8, 0x00, 0xF0,
  0x00, 0xD8, 0x00, 0xB0, 0x00, 0x50, 0x00, 0xA0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x08, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1A, 0x00, 0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x10, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x30, 0x01, 0x00, 0x80,
  0x18, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x20, 0x60, 0x01, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x01, 0x18,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x0C,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x01,
  0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0x01, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x70, 0x80, 0x00, 0x07, 0x04, 0x00, 0x00, 0x68, 0x30, 0x00, 0x06,
  0x40, 0xC0, 0x00, 0xE6, 0x07, 0x00, 0x0E, 0x30, 0x1E, 0x03, 0xC1, 0x80,
  0x3F, 0xF8, 0x0C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0xFC, 0x00, 0x0C, 0x1F,
  0xF8, 0x00, 0x43, 0x80, 0x70, 0x02, 0x30, 0x01, 0xC0, 0x17, 0x00, 0x06,
  0x01, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x40, 0x70, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x18, 0x1E, 0x00, 0x01, 0x80, 0xD8, 0x00, 0x18, 0x06, 0x60,
  0x03, 0x80, 0x21, 0xE0, 0x78, 0x01, 0x03, 0xFF, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x03, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x3F, 0x00, 0xC0, 0x03, 0xFF, 0x82, 0x00, 0x3C, 0x07, 0x08,
  0x01, 0xC0, 0x06, 0x60, 0x0C, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x16, 0x03,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x01, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x38, 0x06, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x1D, 0x00, 0x18, 0x00, 0xE4,
  0x00, 0x38, 0x1E, 0x30, 0x00, 0x7F, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x37, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x04, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x30, 0x03, 0xC0, 0x70, 0x80, 0x1C, 0x00, 0x66,
  0x00, 0xC0, 0x00, 0xD8, 0x06, 0x00, 0x01, 0x60, 0x30, 0x00, 0x07, 0x80,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x1E, 0x00, 0xC0, 0x01, 0xD8, 0x01, 0x80, 0x0E, 0x40, 0x03, 0x81, 0xE3,
  0x00, 0x07, 0xFE, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x7F, 0x00, 0x08, 0x0F, 0xFE,
  0x00, 0x41, 0xE0, 0x38, 0x06, 0x18, 0x00, 0x60, 0x33, 0x80, 0x01, 0x01,
  0x90, 0x00, 0x0C, 0x09, 0x00, 0x00, 0x60, 0x50, 0x00, 0x01, 0x03, 0x80,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x20, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x80, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x1C, 0x02, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x06, 0x00, 0x60, 0x00, 0x70,
  0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x40, 0x0E, 0x00, 0x01, 0x00, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0xF0,
  0x00, 0x00, 0x67, 0x60, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x07, 0x83, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x19, 0xFF, 0x83, 0xFE, 0x00, 0x9C,
  0x0C, 0x38, 0x18, 0x05, 0x80, 0x33, 0x00, 0x60, 0x78, 0x01, 0xB0, 0x01,
  0x03, 0x80, 0x07, 0x00, 0x08, 0x1C, 0x00, 0x30, 0x00, 0x40, 0xC0, 0x01,
  0x80, 0x02, 0x06, 0x00, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x00, 0x83,
  0x00, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x80,
  0x03, 0x04, 0x00, 0x08, 0x00, 0x18, 0x20, 0x00, 0x40, 0x00, 0x81, 0x00,
  0x02, 0x00, 0x04, 0x18, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x40, 0x00, 0x81, 0x00, 0x02,
  0x00, 0x04, 0x08, 0x00, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x00, 0xC1, 0x00, 0x02, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x01, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x00, 0xC1, 0x00, 0x02, 0x00, 0x06,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x40, 0x00, 0x80, 0x01, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x10, 0x1F, 0xFC, 0x00, 0x83,
  0x80, 0x70, 0x0C, 0x30, 0x00, 0xC0, 0x67, 0x00, 0x06, 0x03, 0x60, 0x00,
  0x18, 0x12, 0x00, 0x00, 0xC0, 0xA0, 0x00, 0x02, 0x07, 0x00, 0x00, 0x10,
  0x70, 0x00, 0x00, 0x83, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x60, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0x0F, 0xFE, 0x00, 0x08, 0x70, 0x0E, 0x00, 0x27, 0x00, 0x1C, 0x01, 0xB8,
  0x00, 0x30, 0x07, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x80, 0x70, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x06, 0x01,
  0xB0, 0x00, 0x70, 0x04, 0x60, 0x03, 0x80, 0x10, 0xE0, 0x78, 0x00, 0xC1,
  0xFF, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x83, 0x00,
  0xF0, 0x1C, 0x20, 0x1C, 0x00, 0x66, 0x03, 0x00, 0x03, 0x60, 0x60, 0x00,
  0x1E, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x01,
  0xE0, 0x30, 0x00, 0x74, 0x01, 0x80, 0x0E, 0x40, 0x0E, 0x07, 0x84, 0x00,
  0x7F, 0xE0, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x60, 0x3F, 0xFC, 0x0C, 0x1E, 0x00, 0x01,
  0x0E, 0x00, 0x00, 0x23, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x04, 0x00, 0x00, 0xA0, 0x60, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x60, 0x30, 0x01, 0xE6, 0x01, 0xC0, 0x78, 0x60, 0x0F,
  0xFE, 0x04, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x80, 0x06, 0xC0, 0x06,
  0x80, 0x06, 0xC0, 0x06, 0x80, 0x0C, 0xC0, 0x04, 0x80, 0x0C, 0xC0, 0x0C,
  0x80, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x20, 0x40, 0x20,
  0xC0, 0x60, 0x40, 0x60, 0xC0, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0xC0,
  0xC0, 0xC0, 0x40, 0xC0, 0x40, 0x80, 0x40, 0x80, 0x41, 0x80, 0x61, 0x80,
  0x41, 0x80, 0x61, 0x00, 0x43, 0x00, 0x63, 0x00, 0x43, 0x00, 0x63, 0x00,
  0x62, 0x00, 0x66, 0x00, 0x66, 0x00, 0x66, 0x00, 0x66, 0x00, 0x64, 0x00,
  0x64, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x68, 0x00, 0x6C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x30, 0xE0, 0x70, 0x00, 0x0C,
  0x60, 0x0E, 0x00, 0x03, 0x38, 0x01, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0x00,
  0x66, 0x00, 0x07, 0x00, 0x31, 0x80, 0x00, 0xE0, 0x18, 0x40, 0x00, 0x0E,
  0x1C, 0x30, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph RobotoMono_ThinItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 10, 45, 37, 13, -45 },
  { 58, 11, 12, 37, 16, -47 },
  { 75, 36, 45, 37, 1, -45 },
  { 278, 30, 57, 37, 4, -51 },
  { 492, 30, 46, 37, 4, -45 },
  { 665, 31, 46, 37, 3, -45 },
  { 844, 3, 12, 37, 19, -47 },
  { 849, 19, 64, 37, 11, -50 },
  { 1001, 19, 64, 37, 6, -50 },
  { 1153, 26, 25, 37, 9, -45 },
  { 1235, 30, 33, 37, 4, -37 },
  { 1359, 6, 13, 37, 8, -5 },
  { 1369, 22, 1, 37, 7, -21 },
  { 1372, 3, 3, 37, 15, -3 },
  { 1374, 29, 49, 37, 5, -45 },
  { 1552, 29, 46, 37, 5, -45 },
  { 1719, 16, 45, 37, 10, -45 },
  { 1809, 29, 45, 37, 2, -45 },
  { 1973, 30, 46, 37, 2, -45 },
  { 2146, 30, 45, 37, 2, -45 },
  { 2315, 30, 46, 37, 6, -45 },
  { 2488, 27, 46, 37, 4, -45 },
  { 2644, 28, 45, 37, 8, -45 },
  { 2802, 31, 46, 37, 4, -45 },
  { 2981, 27, 46, 37, 6, -45 },
  { 3137, 9, 30, 37, 16, -30 },
  { 3171, 12, 38, 37, 13, -30 },
  { 3228, 28, 25, 37, 5, -33 },
  { 3316, 29, 15, 37, 4, -28 },
  { 3371, 28, 25, 37, 4, -33 },
  { 3459, 23, 45, 37, 10, -45 },
  { 3589, 36, 45, 37, 1, -45 },
  { 3792, 31, 45, 37, 0, -45 },
  { 3967, 31, 45, 37, 3, -45 },
  { 4142, 31, 46, 37, 4, -45 },
  { 4321, 32, 45, 37, 3, -45 },
  { 4501, 33, 45, 37, 3, -45 },
  { 4687, 32, 45, 37, 4, -45 },
  { 4867, 31, 46, 37, 4, -45 },
  { 5046, 34, 45, 37, 2, -45 },
  { 5238, 32, 45, 37, 3, -45 },
  { 5418, 32, 46, 37, 2, -45 },
  { 5602, 34, 45, 37, 4, -45 },
  { 5794, 25, 45, 37, 4, -45 },
  { 5935, 34, 45, 37, 2, -45 },
  { 6127, 34, 45, 37, 2, -45 },
  { 6319, 30, 46, 37, 4, -45 },
  { 6492, 32, 45, 37, 4, -45 },
  { 6672, 32, 53, 37, 3, -45 },
  { 6884, 30, 45, 37, 4, -45 },
  { 7053, 32, 46, 37, 3, -45 },
  { 7237, 30, 45, 37, 8, -45 },
  { 7406, 32, 46, 37, 4, -45 },
  { 7590, 30, 45, 37, 7, -45 },
  { 7759, 32, 45, 37, 7, -45 },
  { 7939, 37, 45, 37, 1, -45 },
  { 8148, 31, 45, 37, 7, -45 },
  { 8323, 33, 45, 37, 1, -45 },
  { 8509, 18, 61, 37, 10, -51 },
  { 8647, 11, 49, 37, 13, -45 },
  { 8715, 19, 61, 37, 9, -51 },
  { 8860, 21, 25, 37, 8, -45 },
  { 8926, 26, 2, 37, 2, 0 },
  { 8933, 6, 9, 37, 19, -47 },
  { 8940, 29, 35, 37, 3, -34 },
  { 9067, 29, 48, 37, 3, -47 },
  { 9241, 27, 35, 37, 5, -34 },
  { 9360, 30, 48, 37, 5, -47 },
  { 9540, 28, 35, 37, 4, -34 },
  { 9663, 29, 48, 37, 9, -48 },
  { 9837, 30, 47, 37, 3, -34 },
  { 10014, 29, 47, 37, 3, -47 },
  { 10185, 25, 45, 37, 4, -45 },
  { 10326, 29, 58, 37, 0, -45 },
  { 10537, 30, 47, 37, 4, -47 },
  { 10714, 25, 47, 37, 4, -47 },
  { 10861, 37, 34, 37, -1, -34 },
  { 11019, 29, 34, 37, 3, -34 },
  { 11143, 30, 35, 37, 3, -34 },
  { 11275, 30, 47, 37, 1, -34 },
  { 11452, 28, 47, 37, 5, -34 },
  { 11617, 27, 34, 37, 8, -34 },
  { 11732, 29, 35, 37, 4, -34 },
  { 11859, 23, 43, 37, 8, -42 },
  { 11983, 28, 34, 37, 5, -33 },
  { 12102, 29, 33, 37, 6, -33 },
  { 12222, 32, 33, 37, 5, -33 },
  { 12354, 33, 33, 37, 2, -33 },
  { 12491, 38, 46, 37, -1, -33 },
  { 12710, 32, 33, 37, 1, -33 },
  { 12842, 24, 63, 37, 10, -49 },
  { 13031, 10, 53, 37, 13, -45 },
  { 13098, 25, 63, 37, 5, -49 },
  { 13295, 34, 10, 37, 1, -24 },
};

const GFXfont RobotoMono_ThinItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic63pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_THINITALIC63PT7B_H_
