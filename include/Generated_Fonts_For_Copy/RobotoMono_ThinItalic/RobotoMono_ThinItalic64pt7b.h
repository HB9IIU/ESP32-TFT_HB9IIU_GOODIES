#ifndef _ROBOTOMONO_THINITALIC64PT7B_H_
#define _ROBOTOMONO_THINITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x18, 0x00, 0x30,
  0x33, 0x03, 0x30, 0x23, 0x06, 0x20, 0x62, 0x06, 0x60, 0x66, 0x04, 0x60,
  0x46, 0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0x80, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x30, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x04, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x04,
  0x18, 0x01, 0x80, 0x0C, 0x30, 0x03, 0x00, 0x30, 0x40, 0x06, 0x00, 0x61,
  0x80, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x0C,
  0x00, 0x40, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x60,
  0x0C, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x60, 0x01, 0x81,
  0x80, 0xC0, 0x01, 0xFE, 0x03, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x1F, 0xC0, 0x00, 0xC0,
  0x71, 0xC0, 0x01, 0x81, 0x80, 0xC0, 0x06, 0x06, 0x01, 0x80, 0x18, 0x18,
  0x01, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x40, 0x06, 0x03, 0x01, 0x80,
  0x0C, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x06, 0x00, 0x20, 0x60, 0x08, 0x00,
  0x41, 0x80, 0x30, 0x01, 0x83, 0x00, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0x06,
  0x30, 0x00, 0x80, 0x18, 0x20, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x80, 0x03, 0x00, 0x01, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x30, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x70, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x60, 0x06, 0x00, 0x30, 0xC0, 0x04, 0x00, 0x63, 0x00, 0x0C, 0x00,
  0x8C, 0x00, 0x0C, 0x03, 0x18, 0x00, 0x18, 0x06, 0x60, 0x00, 0x18, 0x18,
  0xC0, 0x00, 0x18, 0x31, 0x80, 0x00, 0x30, 0xE2, 0x00, 0x00, 0x31, 0x84,
  0x00, 0x00, 0x36, 0x08, 0x00, 0x00, 0x6C, 0x10, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x0C, 0xC0, 0xE0,
  0x00, 0x70, 0x80, 0xE0, 0x03, 0xC1, 0x80, 0xF0, 0x1E, 0x01, 0x80, 0x7F,
  0xF0, 0x03, 0x80, 0x1D, 0x00, 0x00, 0x00, 0x33, 0x22, 0x66, 0x66, 0x44,
  0xCC, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x78, 0x01, 0x00,
  0x7F, 0xC0, 0xC0, 0xF8, 0x7C, 0x31, 0xF0, 0x03, 0xEF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00, 0xC0,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x82,
  0x0C, 0x10, 0x61, 0x87, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x4E, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x34, 0x40, 0x00, 0x07, 0x66, 0x00, 0x00, 0x73, 0x30, 0x00,
  0x07, 0x19, 0x80, 0x00, 0x60, 0xC8, 0x00, 0x06, 0x06, 0x40, 0x00, 0x60,
  0x36, 0x00, 0x06, 0x01, 0x30, 0x00, 0x60, 0x09, 0x80, 0x0E, 0x00, 0xCC,
  0x00, 0xE0, 0x06, 0x40, 0x0C, 0x00, 0x36, 0x00, 0xC0, 0x01, 0xB0, 0x0C,
  0x00, 0x09, 0x80, 0xC0, 0x00, 0x4C, 0x0C, 0x00, 0x06, 0x61, 0xC0, 0x00,
  0x32, 0x1C, 0x00, 0x01, 0x91, 0x80, 0x00, 0x08, 0x98, 0x00, 0x00, 0xC5,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7B, 0x03,
  0xC2, 0x0F, 0x02, 0x3C, 0x06, 0xE0, 0x06, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0xC8, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x30, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x0E, 0x00, 0x00, 0x31, 0xFF,
  0xC0, 0x00, 0x6F, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xE0, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x07, 0xF0,
  0x03, 0x07, 0xFF, 0x80, 0x63, 0xC0, 0x38, 0x18, 0xC0, 0x01, 0x83, 0x70,
  0x00, 0x18, 0x58, 0x00, 0x01, 0x8A, 0x00, 0x00, 0x33, 0x80, 0x00, 0x02,
  0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x08, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x03, 0x80,
  0x01, 0x80, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1E, 0x20, 0x00, 0x03, 0x43,
  0x00, 0x00, 0x6C, 0x18, 0x00, 0x0C, 0xC1, 0x80, 0x01, 0x8C, 0x0E, 0x00,
  0x70, 0x80, 0x7C, 0x7C, 0x18, 0x01, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x01, 0xC1, 0xE0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x07, 0x03, 0x81, 0xC0, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0xC0, 0x00,
  0xC3, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x3F, 0xC0,
  0x30, 0x30, 0x07, 0x8E, 0x03, 0x03, 0x00, 0xC0, 0x70, 0x30, 0x60, 0x18,
  0x02, 0x01, 0x06, 0x03, 0x00, 0x60, 0x10, 0xC0, 0x60, 0x06, 0x01, 0x0C,
  0x06, 0x00, 0x40, 0x31, 0x80, 0xC0, 0x04, 0x03, 0x18, 0x0C, 0x00, 0xC0,
  0x33, 0x01, 0x80, 0x0C, 0x03, 0x30, 0x18, 0x00, 0x80, 0x33, 0x01, 0x00,
  0x18, 0x03, 0x20, 0x30, 0x01, 0x80, 0x26, 0x03, 0x00, 0x18, 0x06, 0x60,
  0x20, 0x01, 0x00, 0x66, 0x02, 0x00, 0x30, 0x06, 0x40, 0x60, 0x03, 0x00,
  0x44, 0x06, 0x00, 0x20, 0x0C, 0xC0, 0x60, 0x06, 0x00, 0xCC, 0x06, 0x00,
  0x60, 0x08, 0xC0, 0x40, 0x0E, 0x01, 0x8C, 0x04, 0x01, 0xE0, 0x18, 0xC0,
  0x60, 0x36, 0x03, 0x0C, 0x06, 0x02, 0x60, 0x60, 0x40, 0x20, 0xE2, 0x0E,
  0x06, 0x03, 0xBC, 0x3B, 0xC0, 0x60, 0x1F, 0x01, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x00,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x40, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x08, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x40, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x0F,
  0x80, 0x04, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00, 0x40, 0x00, 0x38, 0x00, 0x80,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x01, 0xC0, 0x40, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1C, 0x02,
  0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0x80, 0x07, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x70, 0x01,
  0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x40, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x78, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xF3, 0x00, 0x07, 0xFF, 0xE6,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x06, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x10, 0x00,
  0x00, 0xE0, 0x02, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x70, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x02, 0x1F, 0x00, 0x00, 0x00, 0x46, 0x30, 0x00,
  0x00, 0x19, 0x86, 0x00, 0x00, 0x03, 0x60, 0x60, 0x00, 0x00, 0x78, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x20,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x50, 0x00, 0x00, 0xF0, 0x0A, 0x00, 0x00, 0x34,
  0x03, 0x60, 0x00, 0x06, 0x80, 0x6C, 0x00, 0x01, 0xB0, 0x0D, 0x80, 0x00,
  0x66, 0x01, 0x90, 0x00, 0x0C, 0xC0, 0x22, 0x00, 0x03, 0x10, 0x04, 0x60,
  0x00, 0x62, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x31, 0x80, 0x03, 0x18, 0x06,
  0x10, 0x00, 0xC3, 0x00, 0xC2, 0x00, 0x30, 0x60, 0x10, 0x60, 0x06, 0x08,
  0x06, 0x0C, 0x01, 0x81, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18, 0x10, 0x0C,
  0x0C, 0x03, 0x02, 0x01, 0x81, 0x80, 0x40, 0x60, 0x60, 0x30, 0x08, 0x0C,
  0x18, 0x04, 0x03, 0x01, 0x83, 0x00, 0x80, 0x60, 0x10, 0xC0, 0x30, 0x0C,
  0x02, 0x18, 0x06, 0x01, 0x80, 0x66, 0x00, 0xC0, 0x20, 0x0C, 0xC0, 0x18,
  0x04, 0x01, 0xB0, 0x02, 0x01, 0x80, 0x14, 0x00, 0xC0, 0x30, 0x03, 0x80,
  0x18, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x70, 0x00, 0x00, 0x60, 0x1A, 0x00, 0x00, 0x0C, 0x03, 0x40,
  0x00, 0x01, 0x80, 0x6C, 0x00, 0x00, 0x20, 0x08, 0x80, 0x00, 0x04, 0x01,
  0x18, 0x00, 0x01, 0x80, 0x63, 0x00, 0x00, 0x30, 0x0C, 0x20, 0x00, 0x06,
  0x01, 0x86, 0x00, 0x00, 0xC0, 0x30, 0x40, 0x00, 0x10, 0x04, 0x08, 0x00,
  0x02, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x30, 0x10, 0x00, 0x18, 0x06, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x04, 0x00, 0x08, 0x02,
  0x00, 0xC0, 0x01, 0x00, 0x40, 0x08, 0x00, 0x60, 0x18, 0x01, 0x00, 0x0C,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x60, 0x02, 0x00, 0x30, 0x08, 0x00, 0x60,
  0x04, 0x01, 0x00, 0x0C, 0x00, 0x80, 0x20, 0x00, 0x80, 0x30, 0x0C, 0x00,
  0x18, 0x06, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x04,
  0x00, 0x06, 0x02, 0x00, 0x80, 0x00, 0x40, 0x40, 0x10, 0x00, 0x0C, 0x18,
  0x06, 0x00, 0x01, 0x83, 0x00, 0xC0, 0x00, 0x10, 0x60, 0x18, 0x00, 0x03,
  0x08, 0x02, 0x00, 0x00, 0x21, 0x00, 0x40, 0x00, 0x04, 0x20, 0x08, 0x00,
  0x00, 0xCC, 0x03, 0x00, 0x00, 0x09, 0x80, 0x60, 0x00, 0x01, 0xB0, 0x0C,
  0x00, 0x00, 0x34, 0x01, 0x00, 0x00, 0x02, 0x80, 0x20, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x20, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x10, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x04,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x18, 0x00, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x08, 0x18,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x10,
  0x18, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40,
  0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x02, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xB0, 0x00, 0x60,
  0x00, 0x58, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x38, 0x00, 0x36, 0x00, 0x1C,
  0x00, 0x13, 0x00, 0x0A, 0x00, 0x19, 0x80, 0x0D, 0x00, 0x0C, 0xC0, 0x06,
  0xC0, 0x04, 0x60, 0x02, 0x60, 0x06, 0x30, 0x03, 0x30, 0x03, 0x18, 0x01,
  0x98, 0x01, 0x0C, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0xC3, 0x00,
  0x63, 0x00, 0x41, 0x80, 0x61, 0x80, 0x20, 0xC0, 0x30, 0xC0, 0x30, 0x60,
  0x18, 0x60, 0x18, 0x30, 0x18, 0x30, 0x08, 0x18, 0x0C, 0x18, 0x0C, 0x0C,
  0x04, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x01,
  0x81, 0x01, 0x81, 0x80, 0xC1, 0x80, 0xC0, 0x80, 0x60, 0xC0, 0x60, 0xC0,
  0x30, 0x40, 0x30, 0x60, 0x18, 0x60, 0x08, 0x20, 0x0C, 0x30, 0x04, 0x10,
  0x06, 0x10, 0x02, 0x18, 0x03, 0x18, 0x01, 0x08, 0x01, 0x8C, 0x00, 0x84,
  0x00, 0xCC, 0x00, 0x46, 0x00, 0x66, 0x00, 0x23, 0x00, 0x33, 0x00, 0x11,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x03,
  0x40, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xF0, 0x00,
  0x50, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x04, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80,
  0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x04, 0x00, 0x30, 0x18, 0x00, 0x80, 0x60, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0xC0, 0x03, 0x02, 0x00, 0x04, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x03, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0x80, 0x01, 0x81, 0xE0, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x70, 0x80,
  0x00, 0x07, 0x86, 0x00, 0x00, 0x7C, 0x30, 0x00, 0x07, 0x60, 0xC0, 0x00,
  0x63, 0x07, 0x00, 0x0E, 0x18, 0x1E, 0x03, 0xC0, 0xC0, 0x3F, 0xF8, 0x06,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x07, 0xFC, 0x00, 0x61, 0xE0, 0xF0,
  0x06, 0x70, 0x03, 0x80, 0x4E, 0x00, 0x1C, 0x05, 0x80, 0x00, 0xC0, 0xF0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x06, 0x0F, 0x00,
  0x00, 0xC0, 0xD8, 0x00, 0x18, 0x0C, 0xE0, 0x07, 0x00, 0xC7, 0x81, 0xE0,
  0x08, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0x83, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x03, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0x3E, 0x1E, 0x18, 0x00, 0xE0, 0x0E,
  0x30, 0x07, 0x00, 0x06, 0x60, 0x1C, 0x00, 0x06, 0x80, 0x30, 0x00, 0x0F,
  0x00, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x03,
  0x60, 0x03, 0x00, 0x1C, 0xC0, 0x03, 0x81, 0xE1, 0x80, 0x03, 0xFF, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x1E, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x03,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0x7C, 0x3C, 0x30,
  0x03, 0x80, 0x38, 0xC0, 0x38, 0x00, 0x33, 0x00, 0xC0, 0x00, 0x68, 0x06,
  0x00, 0x01, 0xE0, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0xD8,
  0x01, 0x80, 0x0E, 0x60, 0x03, 0x81, 0xF1, 0x80, 0x07, 0xFF, 0x04, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x40,
  0xF8, 0x78, 0x02, 0x1E, 0x00, 0xE0, 0x31, 0xC0, 0x01, 0x81, 0x98, 0x00,
  0x0C, 0x0D, 0x80, 0x00, 0x30, 0x78, 0x00, 0x01, 0x82, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x02, 0x00, 0x70, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x47, 0xC0, 0x00, 0x01, 0x3B,
  0x00, 0x00, 0x0D, 0x86, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x20, 0x03, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x60, 0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x1F, 0xE0, 0x1F, 0xC0, 0x11,
  0xE3, 0x83, 0xC3, 0x80, 0x98, 0x06, 0x30, 0x0C, 0x05, 0x80, 0x13, 0x00,
  0x30, 0x78, 0x00, 0xF0, 0x01, 0x83, 0x80, 0x07, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x20, 0x00, 0x40, 0x00, 0xC3, 0x00, 0x02, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x00, 0x20, 0xC0, 0x01, 0x80, 0x01, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x20,
  0x00, 0x60, 0x00, 0xC1, 0x00, 0x02, 0x00, 0x06, 0x18, 0x00, 0x10, 0x00,
  0x30, 0xC0, 0x01, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x20, 0x00,
  0x60, 0x00, 0xC1, 0x00, 0x03, 0x00, 0x06, 0x08, 0x00, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60,
  0x00, 0x41, 0x00, 0x03, 0x00, 0x06, 0x08, 0x00, 0x10, 0x00, 0x30, 0xC0,
  0x00, 0x80, 0x01, 0x86, 0x00, 0x04, 0x00, 0x08, 0x30, 0x00, 0x60, 0x00,
  0x41, 0x00, 0x03, 0x00, 0x02, 0x08, 0x00, 0x18, 0x00, 0x30, 0x40, 0x00,
  0x80, 0x01, 0x86, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xFF, 0x00,
  0x10, 0x3E, 0x1E, 0x00, 0x87, 0x80, 0x38, 0x0C, 0x70, 0x00, 0xE0, 0x66,
  0x00, 0x03, 0x03, 0x60, 0x00, 0x08, 0x1E, 0x00, 0x00, 0x60, 0xA0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0xFF, 0x80, 0x01, 0x87, 0x83, 0xC0, 0x02, 0x38, 0x01, 0xC0,
  0x04, 0xE0, 0x01, 0x80, 0x0B, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x10, 0x30, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x30, 0x06, 0xC0, 0x00, 0xC0,
  0x0C, 0xC0, 0x07, 0x00, 0x10, 0xF0, 0x3C, 0x00, 0x20, 0x7F, 0xE0, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x30, 0x07, 0xC3, 0xC3, 0x00, 0xE0,
  0x0E, 0x30, 0x38, 0x00, 0x33, 0x03, 0x00, 0x01, 0xA0, 0x60, 0x00, 0x1E,
  0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xE0,
  0x30, 0x00, 0x36, 0x01, 0x80, 0x0E, 0x60, 0x0E, 0x07, 0x86, 0x00, 0x7F,
  0xF0, 0x40, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0xFF, 0xC1, 0x81, 0xF8, 0x10, 0x61, 0xE0, 0x00, 0x18, 0xE0,
  0x00, 0x04, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x38,
  0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x0F,
  0x80, 0x78, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x0D, 0x80, 0xC0,
  0x01, 0xC8, 0x07, 0x00, 0x1C, 0xC0, 0x1E, 0x07, 0x86, 0x00, 0x3F, 0xF0,
  0x30, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x60,
  0x00, 0xD8, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x26, 0x00, 0x36,
  0x00, 0x33, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x09, 0x80, 0x18, 0xC0, 0x0C,
  0xC0, 0x0C, 0x60, 0x06, 0x60, 0x04, 0x30, 0x06, 0x30, 0x06, 0x18, 0x03,
  0x18, 0x03, 0x04, 0x01, 0x0C, 0x03, 0x02, 0x01, 0x86, 0x01, 0x81, 0x00,
  0x81, 0x00, 0x80, 0x80, 0xC0, 0x80, 0xC0, 0x40, 0x60, 0x40, 0x60, 0x30,
  0x60, 0x20, 0x60, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x10, 0x0C, 0x10, 0x06,
  0x18, 0x06, 0x18, 0x03, 0x08, 0x03, 0x0C, 0x01, 0x8C, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x62, 0x00, 0x33, 0x00, 0x33, 0x00,
  0x19, 0x00, 0x09, 0x80, 0x0D, 0x80, 0x04, 0x80, 0x06, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x01, 0x60, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x40, 0xFF, 0xC0, 0x00,
  0x0C, 0x38, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0xC0, 0x00, 0x63, 0x00, 0x0C,
  0x00, 0x08, 0x60, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x0C, 0x00, 0xC3, 0x00,
  0x00, 0xE0, 0x30, 0x40, 0x00, 0x0F, 0xFC, 0x18, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoMono_ThinItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 10, 46, 38, 13, -46 },
  { 59, 12, 13, 38, 16, -48 },
  { 79, 37, 45, 38, 1, -45 },
  { 288, 31, 59, 38, 4, -52 },
  { 517, 31, 47, 38, 4, -46 },
  { 700, 31, 47, 38, 3, -46 },
  { 883, 4, 13, 38, 19, -48 },
  { 890, 19, 66, 38, 11, -51 },
  { 1047, 19, 66, 38, 6, -51 },
  { 1204, 26, 25, 38, 9, -46 },
  { 1286, 30, 33, 38, 4, -38 },
  { 1410, 7, 13, 38, 8, -5 },
  { 1422, 23, 2, 38, 7, -22 },
  { 1428, 4, 4, 38, 15, -4 },
  { 1430, 29, 49, 38, 5, -45 },
  { 1608, 29, 47, 38, 5, -46 },
  { 1779, 16, 46, 38, 10, -46 },
  { 1871, 29, 46, 38, 2, -46 },
  { 2038, 31, 47, 38, 2, -46 },
  { 2221, 31, 46, 38, 2, -46 },
  { 2400, 31, 47, 38, 6, -46 },
  { 2583, 27, 47, 38, 4, -46 },
  { 2742, 29, 46, 38, 8, -46 },
  { 2909, 31, 47, 38, 4, -46 },
  { 3092, 28, 47, 38, 6, -46 },
  { 3257, 9, 31, 38, 16, -31 },
  { 3292, 12, 39, 38, 13, -31 },
  { 3351, 29, 25, 38, 5, -33 },
  { 3442, 30, 14, 38, 4, -28 },
  { 3495, 28, 26, 38, 4, -34 },
  { 3586, 23, 46, 38, 10, -46 },
  { 3719, 36, 46, 38, 1, -46 },
  { 3926, 31, 46, 38, 0, -46 },
  { 4105, 31, 46, 38, 3, -46 },
  { 4284, 31, 47, 38, 4, -46 },
  { 4467, 32, 46, 38, 3, -46 },
  { 4651, 33, 46, 38, 3, -46 },
  { 4841, 33, 46, 38, 4, -46 },
  { 5031, 31, 47, 38, 4, -46 },
  { 5214, 35, 46, 38, 2, -46 },
  { 5416, 33, 46, 38, 3, -46 },
  { 5606, 33, 47, 38, 2, -46 },
  { 5800, 35, 46, 38, 4, -46 },
  { 6002, 25, 46, 38, 4, -46 },
  { 6146, 35, 46, 38, 2, -46 },
  { 6348, 35, 46, 38, 2, -46 },
  { 6550, 31, 47, 38, 4, -46 },
  { 6733, 33, 46, 38, 4, -46 },
  { 6923, 33, 54, 38, 3, -46 },
  { 7146, 31, 46, 38, 4, -46 },
  { 7325, 32, 47, 38, 3, -46 },
  { 7513, 31, 46, 38, 8, -46 },
  { 7692, 33, 47, 38, 4, -46 },
  { 7886, 31, 46, 38, 7, -46 },
  { 8065, 33, 46, 38, 7, -46 },
  { 8255, 37, 46, 38, 1, -46 },
  { 8468, 31, 46, 38, 7, -46 },
  { 8647, 34, 46, 38, 1, -46 },
  { 8843, 19, 62, 38, 10, -52 },
  { 8991, 12, 50, 38, 13, -46 },
  { 9066, 19, 62, 38, 9, -52 },
  { 9214, 22, 25, 38, 8, -46 },
  { 9283, 26, 2, 38, 2, 0 },
  { 9290, 7, 8, 38, 19, -47 },
  { 9297, 29, 35, 38, 3, -34 },
  { 9424, 28, 49, 38, 4, -48 },
  { 9596, 27, 35, 38, 5, -34 },
  { 9715, 31, 49, 38, 5, -48 },
  { 9905, 29, 35, 38, 4, -34 },
  { 10032, 30, 49, 38, 9, -49 },
  { 10216, 30, 48, 38, 3, -34 },
  { 10396, 29, 48, 38, 3, -48 },
  { 10570, 26, 46, 38, 4, -46 },
  { 10720, 29, 60, 38, 0, -46 },
  { 10938, 30, 48, 38, 5, -48 },
  { 11118, 26, 48, 38, 4, -48 },
  { 11274, 37, 34, 38, -1, -34 },
  { 11432, 29, 34, 38, 3, -34 },
  { 11556, 30, 35, 38, 3, -34 },
  { 11688, 31, 47, 38, 1, -34 },
  { 11871, 28, 47, 38, 5, -34 },
  { 12036, 26, 34, 38, 9, -34 },
  { 12147, 29, 35, 38, 4, -34 },
  { 12274, 24, 44, 38, 8, -43 },
  { 12406, 29, 35, 38, 5, -34 },
  { 12533, 30, 34, 38, 6, -34 },
  { 12661, 33, 34, 38, 5, -34 },
  { 12802, 33, 34, 38, 2, -34 },
  { 12943, 38, 48, 38, -1, -34 },
  { 13171, 33, 34, 38, 1, -34 },
  { 13312, 25, 64, 38, 10, -50 },
  { 13512, 10, 54, 38, 14, -46 },
  { 13580, 25, 64, 38, 5, -50 },
  { 13780, 35, 10, 38, 1, -24 },
};

const GFXfont RobotoMono_ThinItalic64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic64pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_THINITALIC64PT7B_H_
