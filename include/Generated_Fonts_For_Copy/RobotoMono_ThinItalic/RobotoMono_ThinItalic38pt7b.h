#ifndef _ROBOTOMONO_THINITALIC38PT7B_H_
#define _ROBOTOMONO_THINITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x08, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x46, 0x89,
  0x16, 0x28, 0x50, 0xA2, 0x44, 0x00, 0x08, 0x08, 0x00, 0x10, 0x20, 0x00,
  0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08,
  0x18, 0x00, 0x30, 0x20, 0x0F, 0xFF, 0xFE, 0x00, 0x81, 0x00, 0x03, 0x02,
  0x00, 0x04, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40,
  0x00, 0x81, 0x00, 0x02, 0x02, 0x00, 0x04, 0x04, 0x01, 0xFF, 0xFF, 0x84,
  0x20, 0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x00, 0x02, 0x02, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x01, 0xFE, 0x00, 0xC0,
  0xC0, 0x40, 0x10, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x32, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x23,
  0x00, 0x18, 0x40, 0x0C, 0x08, 0x06, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x1F, 0x00, 0x06, 0x10, 0x00, 0x82,
  0x00, 0x20, 0x40, 0x44, 0x08, 0x10, 0x81, 0x06, 0x20, 0x20, 0x84, 0x04,
  0x20, 0x81, 0x0C, 0x08, 0x21, 0x01, 0x08, 0x40, 0x1E, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x3C, 0x01, 0x08, 0x40, 0x42,
  0x08, 0x18, 0x80, 0x82, 0x10, 0x10, 0x82, 0x04, 0x20, 0x40, 0x8C, 0x08,
  0x13, 0x01, 0x02, 0x20, 0x20, 0x80, 0x04, 0x30, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x41, 0x00, 0x20, 0x20, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x10, 0x30, 0x04, 0x18, 0x01, 0x08, 0x00, 0x24, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x20, 0x00, 0x88, 0x00, 0x41, 0x01, 0x20,
  0x20, 0x50, 0x08, 0x14, 0x01, 0x0A, 0x00, 0x62, 0x80, 0x09, 0xA0, 0x01,
  0x48, 0x00, 0x63, 0x00, 0x18, 0x40, 0x09, 0x08, 0x0C, 0x41, 0xFC, 0x08,
  0x29, 0x24, 0xA4, 0x00, 0x20, 0x08, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x20, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0xE0, 0x87, 0x38, 0x9C, 0x07, 0xE0, 0x01, 0x80, 0x02, 0x80, 0x04,
  0x40, 0x08, 0x20, 0x10, 0x30, 0x20, 0x10, 0x60, 0x18, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF0, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x12, 0x22, 0x24, 0xC8, 0xFF, 0xFC, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0x01, 0x01, 0x00, 0x41, 0x00, 0x31, 0x00, 0x08,
  0x80, 0x04, 0x80, 0x02, 0x40, 0x03, 0x20, 0x02, 0xA0, 0x02, 0x50, 0x06,
  0x28, 0x06, 0x14, 0x04, 0x0E, 0x04, 0x06, 0x04, 0x05, 0x04, 0x02, 0x84,
  0x01, 0x4C, 0x00, 0xAC, 0x00, 0xDC, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22,
  0x00, 0x10, 0x80, 0x10, 0x40, 0x10, 0x10, 0x10, 0x07, 0xF0, 0x00, 0x00,
  0xC0, 0xE1, 0xC9, 0x82, 0x80, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x01, 0xFE, 0x00,
  0xC0, 0xC0, 0x40, 0x18, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00,
  0x08, 0x80, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0xC0, 0x60, 0x60, 0x08, 0x30, 0x01, 0x08, 0x00, 0x44, 0x00, 0x11,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x31, 0x00, 0x08, 0x60, 0x04, 0x0C, 0x06, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x12, 0x00, 0x09, 0x00, 0x06,
  0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x20,
  0x0C, 0x08, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x20, 0x40, 0x10, 0x30,
  0x04, 0x18, 0x01, 0x04, 0x00, 0x43, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x03, 0xFF, 0xE0, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x4F, 0xC0, 0x0E, 0x06, 0x01, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x88,
  0x00, 0x20, 0x80, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0x20, 0x08, 0x06,
  0x06, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x78, 0x09, 0xC3, 0x05, 0x80, 0x45, 0x00, 0x33, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x12, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x20, 0x0C, 0x08, 0x08,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x30, 0x30, 0x08, 0x01, 0x02, 0x00, 0x20, 0x80,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x41, 0x00,
  0x18, 0x20, 0x02, 0x02, 0x01, 0x80, 0x39, 0xC0, 0x07, 0xF0, 0x03, 0x01,
  0x80, 0x80, 0x08, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x48, 0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x42, 0x00, 0x18, 0x60, 0x06,
  0x06, 0x01, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x0C, 0x0C, 0x18, 0x06,
  0x30, 0x02, 0x20, 0x03, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x40, 0x06,
  0x40, 0x1A, 0x20, 0x32, 0x1F, 0xC4, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x7C, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x60,
  0x42, 0x00, 0x98, 0x02, 0x40, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0x03, 0x00, 0x60, 0x0C, 0x04, 0x00, 0x20, 0x40, 0x00, 0x84, 0x06,
  0x04, 0x60, 0xD8, 0x22, 0x08, 0x21, 0x20, 0x81, 0x09, 0x08, 0x10, 0x50,
  0x40, 0x82, 0x84, 0x04, 0x14, 0x20, 0x40, 0xC1, 0x02, 0x0A, 0x10, 0x10,
  0x50, 0x80, 0x82, 0x84, 0x08, 0x14, 0x20, 0x41, 0x21, 0x06, 0x09, 0x08,
  0x50, 0x88, 0x64, 0x4C, 0x41, 0xC3, 0x81, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x60, 0x03, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x02, 0x04, 0x00, 0x40,
  0x80, 0x10, 0x10, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x04, 0x00,
  0x80, 0x80, 0x10, 0x3F, 0xFE, 0x04, 0x00, 0x41, 0x80, 0x04, 0x20, 0x00,
  0x88, 0x00, 0x11, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01,
  0x80, 0x07, 0xFC, 0x02, 0x00, 0xC0, 0x80, 0x08, 0x20, 0x01, 0x08, 0x00,
  0x42, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x21,
  0x00, 0x10, 0x40, 0x08, 0x20, 0x3C, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x80,
  0x04, 0x20, 0x00, 0x88, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x64, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x20, 0x06, 0x0F,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x30, 0x08, 0x02, 0x02, 0x00, 0x20,
  0x80, 0x04, 0x30, 0x00, 0x44, 0x00, 0x09, 0x80, 0x01, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x82, 0x00, 0x30, 0x20,
  0x0C, 0x02, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x01, 0x00, 0xC0,
  0x20, 0x04, 0x04, 0x00, 0x40, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10,
  0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x48,
  0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x06, 0x20,
  0x01, 0x84, 0x00, 0x60, 0x80, 0x18, 0x10, 0x0C, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xF0, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x40,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x30, 0x18, 0x03, 0x02,
  0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x44, 0x00, 0x09, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x03, 0xFE, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x4C, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0x43, 0x00,
  0x08, 0x20, 0x03, 0x02, 0x01, 0x80, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x08,
  0x20, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x08, 0x20, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04,
  0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x0F, 0xFF, 0xE0, 0x80, 0x01,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x10,
  0x40, 0x01, 0x02, 0x00, 0x08, 0x20, 0x00, 0x40, 0x0F, 0xFF, 0xE0, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x04, 0x00,
  0x40, 0x20, 0x0C, 0x03, 0x01, 0x80, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x18,
  0x20, 0x01, 0x82, 0x00, 0x10, 0x10, 0x01, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x00, 0x20, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x04,
  0x30, 0x00, 0x23, 0x00, 0x01, 0x30, 0x00, 0x13, 0x40, 0x00, 0xB3, 0x00,
  0x06, 0x08, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x02, 0x01, 0x00, 0x18, 0x08, 0x00, 0x40,
  0x40, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x20, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0xFF, 0xF8, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0A, 0x14, 0x00, 0xE0, 0xA0, 0x05,
  0x04, 0x80, 0x48, 0x24, 0x02, 0x41, 0x20, 0x22, 0x09, 0x01, 0x10, 0x88,
  0x11, 0x04, 0x21, 0x88, 0x21, 0x08, 0x41, 0x08, 0x82, 0x08, 0x44, 0x10,
  0x42, 0x41, 0x04, 0x0A, 0x08, 0x20, 0x60, 0x41, 0x03, 0x02, 0x08, 0x00,
  0x10, 0x40, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08,
  0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x30, 0x00, 0x40, 0x04, 0x00,
  0x08, 0x20, 0x00, 0x82, 0x80, 0x04, 0x14, 0x00, 0x20, 0x90, 0x01, 0x04,
  0x80, 0x08, 0x24, 0x00, 0x41, 0x10, 0x04, 0x10, 0x80, 0x20, 0x84, 0x01,
  0x04, 0x10, 0x08, 0x20, 0x80, 0x41, 0x02, 0x02, 0x08, 0x10, 0x20, 0x80,
  0x81, 0x04, 0x02, 0x08, 0x20, 0x10, 0x41, 0x00, 0x82, 0x08, 0x02, 0x20,
  0x40, 0x11, 0x04, 0x00, 0x48, 0x20, 0x02, 0x41, 0x00, 0x12, 0x08, 0x00,
  0x50, 0x40, 0x03, 0x02, 0x00, 0x08, 0x20, 0x00, 0x40, 0x00, 0xFE, 0x00,
  0x20, 0x20, 0x08, 0x02, 0x02, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x84,
  0x00, 0x11, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x05, 0x80, 0x01, 0x20,
  0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x80,
  0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x84, 0x00, 0x10, 0x80,
  0x06, 0x10, 0x00, 0x82, 0x00, 0x20, 0x20, 0x08, 0x02, 0x02, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x40, 0x18, 0x04, 0x00, 0x40, 0xC0, 0x02,
  0x08, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x31, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x04, 0x10, 0x00, 0x81, 0x00,
  0x30, 0x10, 0x1E, 0x03, 0xFE, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x60, 0x30, 0x18, 0x02, 0x06, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00,
  0x44, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x02, 0x10, 0x00, 0x82, 0x00, 0x30, 0x20, 0x0C, 0x02, 0x03, 0x00,
  0x3F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x07, 0xFC, 0x00, 0x80, 0x60, 0x20, 0x02, 0x04, 0x00, 0x20,
  0x80, 0x04, 0x10, 0x00, 0xC2, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x10, 0x40, 0x0C, 0x0F,
  0xFE, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x20,
  0x04, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x82, 0x00, 0x10, 0x40,
  0x02, 0x10, 0x00, 0x22, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x60, 0x30,
  0x10, 0x03, 0x04, 0x00, 0x20, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x30,
  0x00, 0x42, 0x00, 0x08, 0x60, 0x02, 0x06, 0x01, 0x80, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x42,
  0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x08,
  0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00,
  0x84, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00,
  0x40, 0x20, 0x0C, 0x01, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x68,
  0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0xC1, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x20, 0x04, 0x04, 0x00, 0x81, 0x00, 0x10,
  0x20, 0x02, 0x08, 0x00, 0x41, 0x00, 0x0C, 0x40, 0x00, 0x88, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x40, 0x18, 0x04, 0x02, 0x80, 0x40, 0x28, 0x0A, 0x02,
  0x80, 0xA0, 0x48, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20,
  0x88, 0x22, 0x08, 0x82, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x20, 0x88, 0x22, 0x08, 0x82, 0x20, 0x88, 0x22, 0x09, 0x02, 0x40, 0x90,
  0x24, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x00, 0x08, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x40, 0x01, 0x00, 0x80, 0x08, 0x02, 0x00, 0x40,
  0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0x20, 0x40, 0x00, 0x82, 0x00, 0x01,
  0x10, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x05, 0x00, 0x00, 0x34, 0x00, 0x00, 0x88, 0x00, 0x04, 0x20, 0x00,
  0x20, 0x40, 0x01, 0x81, 0x00, 0x04, 0x02, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x10, 0x08, 0x00, 0x40, 0x60, 0x00, 0x81, 0x00, 0x02, 0x08, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x00, 0x02, 0x10, 0x00, 0x82, 0x00,
  0x30, 0x40, 0x04, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x01, 0x02,
  0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x44, 0x00, 0x09, 0x00, 0x01, 0x20,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x0F, 0x80, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x07, 0xE0, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x0F, 0x80, 0x00, 0x80,
  0x0E, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02, 0x10, 0x10, 0x81, 0x04, 0x18,
  0x20, 0x81, 0x08, 0x04, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x20, 0xFF,
  0xFF, 0xC4, 0x23, 0x10, 0x01, 0xFE, 0x03, 0x01, 0x82, 0x00, 0x42, 0x00,
  0x11, 0x00, 0x09, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x01,
  0xFF, 0x87, 0x00, 0x46, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x06, 0x20, 0x05, 0x18, 0x0C, 0x87, 0xF8, 0x40, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0xFE, 0x04, 0x80, 0x82, 0x80,
  0x21, 0x80, 0x10, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90,
  0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x18, 0x02, 0x12, 0x02, 0x08, 0xFE,
  0x00, 0x03, 0xF8, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x01, 0x20, 0x01, 0x60,
  0x01, 0x40, 0x01, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x02, 0x80, 0x04, 0x40, 0x0C, 0x40,
  0x18, 0x20, 0x30, 0x1F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0xFE, 0x20, 0xC0, 0xD0, 0x60, 0x1C, 0x30, 0x03, 0x08, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x04, 0x20, 0x03, 0x04, 0x01, 0x40, 0x81, 0xA0, 0x1F, 0xC8, 0x00, 0x01,
  0xFC, 0x00, 0x80, 0xC0, 0xC0, 0x10, 0x20, 0x02, 0x10, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x09, 0x00, 0x02, 0x7F, 0xFF, 0x90, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x01, 0x81, 0x80, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0x80, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xFC, 0x41, 0x81, 0xA0, 0xC0, 0x38, 0x60, 0x06, 0x10,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x21,
  0x00, 0x08, 0x40, 0x06, 0x08, 0x02, 0x81, 0x03, 0x40, 0x3F, 0x90, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x80, 0x10, 0x30, 0x08,
  0x06, 0x0C, 0x00, 0x7E, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x7F, 0x04, 0xC0, 0x42, 0x80, 0x31, 0x80, 0x08, 0x80, 0x04, 0xC0,
  0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x64, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x3F, 0x80, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x44, 0x00, 0x61, 0x00, 0x30, 0x40, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x02,
  0x04, 0x00, 0x86, 0x00, 0x23, 0x00, 0x09, 0x80, 0x02, 0xA0, 0x01, 0xC4,
  0x00, 0x61, 0x80, 0x10, 0x20, 0x04, 0x04, 0x01, 0x00, 0x80, 0xC0, 0x20,
  0x20, 0x04, 0x08, 0x00, 0x82, 0x00, 0x30, 0x80, 0x06, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x17, 0xE3, 0xF0, 0xE0,
  0xB0, 0x46, 0x07, 0x02, 0x60, 0x30, 0x12, 0x01, 0x00, 0x90, 0x08, 0x04,
  0x80, 0x40, 0x24, 0x02, 0x01, 0x20, 0x10, 0x0A, 0x01, 0x00, 0x50, 0x08,
  0x04, 0x80, 0x40, 0x24, 0x02, 0x01, 0x20, 0x10, 0x09, 0x00, 0x80, 0x50,
  0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x01, 0x20, 0x10, 0x09, 0x00, 0x80,
  0x40, 0x10, 0xFE, 0x09, 0x80, 0x85, 0x00, 0x43, 0x00, 0x11, 0x00, 0x09,
  0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0xC0,
  0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x40, 0x01, 0xFC, 0x01, 0x80,
  0x80, 0x80, 0x10, 0x40, 0x02, 0x30, 0x00, 0x88, 0x00, 0x24, 0x00, 0x05,
  0x00, 0x01, 0x40, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x00, 0xA0, 0x00, 0x48, 0x00, 0x11, 0x00, 0x08, 0x40, 0x06, 0x08, 0x03,
  0x03, 0x01, 0x80, 0x3F, 0x80, 0x0C, 0xFE, 0x02, 0x40, 0x40, 0xE0, 0x08,
  0x30, 0x02, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x14, 0x01, 0x04, 0x80, 0x81,
  0x1F, 0xC0, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x86, 0x06,
  0x86, 0x01, 0xC6, 0x00, 0x62, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80,
  0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x20, 0x0A, 0x08, 0x1A,
  0x03, 0xF9, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x18, 0x7F, 0x11, 0x80,
  0x12, 0x00, 0x14, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x07, 0xFC, 0x06, 0x01, 0x04, 0x00, 0x44, 0x00, 0x22, 0x00, 0x09, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x09, 0x00, 0x04, 0x80, 0x06,
  0x60, 0x02, 0x18, 0x06, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x1F, 0x80, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44,
  0x00, 0x22, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x0C, 0x20, 0x0A, 0x18, 0x19, 0x07, 0xF1, 0x80,
  0xC0, 0x00, 0x50, 0x00, 0x24, 0x00, 0x09, 0x80, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x82, 0x00, 0x60, 0xC0, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x20, 0x40, 0x08, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x01, 0x40, 0x00, 0x70, 0x00, 0x08, 0x00, 0x80, 0x40, 0x38,
  0x04, 0x02, 0x80, 0xC0, 0x28, 0x0C, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08,
  0x81, 0x20, 0x88, 0x22, 0x08, 0x82, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22,
  0x0C, 0x82, 0x20, 0x48, 0x22, 0x04, 0x82, 0x40, 0x50, 0x24, 0x05, 0x02,
  0x80, 0x60, 0x28, 0x06, 0x02, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x18,
  0x00, 0x30, 0xC0, 0x04, 0x04, 0x00, 0xC0, 0x20, 0x18, 0x03, 0x03, 0x00,
  0x10, 0x60, 0x00, 0x8C, 0x00, 0x09, 0x80, 0x00, 0x50, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x09, 0x00, 0x01, 0x18, 0x00, 0x20, 0x80, 0x04, 0x0C,
  0x00, 0xC0, 0x40, 0x18, 0x02, 0x03, 0x00, 0x30, 0x60, 0x01, 0x0C, 0x00,
  0x08, 0x08, 0x00, 0x02, 0x18, 0x00, 0x08, 0x10, 0x00, 0x30, 0x20, 0x00,
  0x40, 0x40, 0x01, 0x00, 0x40, 0x06, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x03, 0x00, 0x40, 0x02, 0x01, 0x00, 0x04, 0x06, 0x00, 0x08, 0x08, 0x00,
  0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x21, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x48, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x01, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x04, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x02, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x00,
  0x12, 0x0C, 0x01, 0x40, 0x60, 0x2C, 0x03, 0x02, 0x80, 0x18, 0xC0, 0x00,
  0x70,
};

const GFXglyph RobotoMono_ThinItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 7, 8, 22, 10, -29 },
  { 29, 23, 27, 22, 0, -27 },
  { 107, 18, 35, 22, 3, -31 },
  { 186, 19, 27, 22, 2, -27 },
  { 251, 18, 27, 22, 2, -27 },
  { 312, 3, 8, 22, 11, -29 },
  { 315, 11, 39, 22, 7, -30 },
  { 369, 11, 39, 22, 4, -30 },
  { 423, 16, 15, 22, 5, -27 },
  { 453, 18, 19, 22, 2, -22 },
  { 496, 4, 8, 22, 5, -3 },
  { 500, 14, 1, 22, 4, -13 },
  { 502, 2, 2, 22, 9, -2 },
  { 503, 17, 29, 22, 3, -27 },
  { 565, 17, 27, 22, 3, -27 },
  { 623, 10, 27, 22, 6, -27 },
  { 657, 18, 27, 22, 1, -27 },
  { 718, 18, 27, 22, 1, -27 },
  { 779, 18, 27, 22, 1, -27 },
  { 840, 19, 27, 22, 3, -27 },
  { 905, 17, 27, 22, 2, -27 },
  { 963, 17, 27, 22, 5, -27 },
  { 1021, 19, 27, 22, 2, -27 },
  { 1086, 16, 27, 22, 4, -27 },
  { 1140, 5, 18, 22, 10, -18 },
  { 1152, 7, 23, 22, 8, -18 },
  { 1173, 17, 15, 22, 3, -20 },
  { 1205, 17, 9, 22, 3, -17 },
  { 1225, 17, 15, 22, 2, -20 },
  { 1257, 14, 27, 22, 6, -27 },
  { 1305, 21, 27, 22, 1, -27 },
  { 1376, 19, 27, 22, 0, -27 },
  { 1441, 18, 27, 22, 2, -27 },
  { 1502, 19, 27, 22, 2, -27 },
  { 1567, 19, 27, 22, 2, -27 },
  { 1632, 20, 27, 22, 2, -27 },
  { 1700, 20, 27, 22, 2, -27 },
  { 1768, 19, 27, 22, 2, -27 },
  { 1833, 21, 27, 22, 1, -27 },
  { 1904, 19, 27, 22, 2, -27 },
  { 1969, 20, 27, 22, 1, -27 },
  { 2037, 21, 27, 22, 2, -27 },
  { 2108, 15, 27, 22, 2, -27 },
  { 2159, 21, 27, 22, 1, -27 },
  { 2230, 21, 27, 22, 1, -27 },
  { 2301, 19, 27, 22, 2, -27 },
  { 2366, 20, 27, 22, 2, -27 },
  { 2434, 19, 32, 22, 2, -27 },
  { 2510, 19, 27, 22, 2, -27 },
  { 2575, 19, 27, 22, 2, -27 },
  { 2640, 18, 27, 22, 5, -27 },
  { 2701, 20, 27, 22, 2, -27 },
  { 2769, 19, 27, 22, 4, -27 },
  { 2834, 20, 27, 22, 4, -27 },
  { 2902, 22, 27, 22, 1, -27 },
  { 2977, 19, 27, 22, 4, -27 },
  { 3042, 20, 27, 22, 1, -27 },
  { 3110, 11, 37, 22, 6, -31 },
  { 3161, 7, 29, 22, 8, -27 },
  { 3187, 11, 37, 22, 6, -31 },
  { 3238, 13, 15, 22, 5, -27 },
  { 3263, 16, 1, 22, 1, 0 },
  { 3265, 4, 5, 22, 11, -28 },
  { 3268, 17, 20, 22, 2, -20 },
  { 3311, 17, 29, 22, 2, -29 },
  { 3373, 16, 20, 22, 3, -20 },
  { 3413, 18, 29, 22, 3, -29 },
  { 3479, 18, 20, 22, 2, -20 },
  { 3524, 18, 29, 22, 5, -29 },
  { 3590, 18, 28, 22, 2, -20 },
  { 3653, 17, 29, 22, 2, -29 },
  { 3715, 16, 27, 22, 2, -27 },
  { 3769, 17, 35, 22, 0, -27 },
  { 3844, 18, 29, 22, 3, -29 },
  { 3910, 16, 29, 22, 2, -29 },
  { 3968, 21, 20, 22, 0, -20 },
  { 4021, 17, 20, 22, 2, -20 },
  { 4064, 18, 20, 22, 2, -20 },
  { 4109, 18, 28, 22, 1, -20 },
  { 4172, 17, 28, 22, 3, -20 },
  { 4232, 16, 20, 22, 5, -20 },
  { 4272, 17, 20, 22, 3, -20 },
  { 4315, 14, 26, 22, 5, -26 },
  { 4361, 17, 20, 22, 3, -20 },
  { 4404, 18, 20, 22, 3, -20 },
  { 4449, 20, 20, 22, 3, -20 },
  { 4499, 20, 20, 22, 1, -20 },
  { 4549, 23, 28, 22, -1, -20 },
  { 4630, 19, 20, 22, 1, -20 },
  { 4678, 15, 38, 22, 6, -30 },
  { 4750, 6, 32, 22, 8, -27 },
  { 4774, 15, 38, 22, 3, -30 },
  { 4846, 20, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_ThinItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic38pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_THINITALIC38PT7B_H_
