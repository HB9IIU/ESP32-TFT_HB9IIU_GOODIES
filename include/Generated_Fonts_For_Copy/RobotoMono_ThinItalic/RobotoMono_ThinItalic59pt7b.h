#ifndef _ROBOTOMONO_THINITALIC59PT7B_H_
#define _ROBOTOMONO_THINITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x30, 0x64, 0x08, 0x81, 0x30, 0x66,
  0x0C, 0xC1, 0x90, 0x22, 0x04, 0xC1, 0x98, 0x33, 0x06, 0x40, 0x80, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x20, 0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x08, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0xCC, 0x00, 0xC0, 0x18, 0xC0,
  0x0C, 0x03, 0x0C, 0x00, 0x80, 0x20, 0x80, 0x08, 0x06, 0x08, 0x00, 0x80,
  0xC0, 0x80, 0x18, 0x08, 0x08, 0x01, 0x81, 0x80, 0x80, 0x30, 0x30, 0x08,
  0x03, 0x06, 0x00, 0xC0, 0x60, 0x60, 0x06, 0x0C, 0x0C, 0x00, 0x3F, 0x81,
  0x80, 0x01, 0xF0, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0F, 0x80, 0x03,
  0x03, 0xFC, 0x00, 0x30, 0x70, 0x60, 0x06, 0x04, 0x02, 0x00, 0xC0, 0xC0,
  0x30, 0x08, 0x18, 0x03, 0x01, 0x81, 0x80, 0x30, 0x30, 0x10, 0x03, 0x06,
  0x03, 0x00, 0x30, 0x60, 0x30, 0x03, 0x0C, 0x03, 0x00, 0x31, 0x80, 0x20,
  0x02, 0x10, 0x02, 0x00, 0x63, 0x00, 0x20, 0x06, 0x60, 0x03, 0x00, 0x40,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x01, 0x00, 0x01, 0x00, 0x08, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0,
  0x02, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x01, 0x80, 0x01, 0x00, 0x18,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0B,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x74, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x08,
  0x60, 0x18, 0x00, 0x86, 0x00, 0x60, 0x04, 0x20, 0x03, 0x00, 0x63, 0x00,
  0x0C, 0x03, 0x30, 0x00, 0x20, 0x31, 0x80, 0x01, 0x81, 0x88, 0x00, 0x06,
  0x08, 0x40, 0x00, 0x10, 0xC6, 0x00, 0x00, 0xCC, 0x30, 0x00, 0x03, 0x61,
  0x80, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x07, 0x81, 0x80,
  0x00, 0x7C, 0x06, 0x00, 0x06, 0x30, 0x18, 0x00, 0xE0, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0xFF, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x33, 0x33, 0x22,
  0x66, 0x64, 0x4C, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xE0, 0x08, 0x07, 0xBE,
  0x04, 0x1F, 0x03, 0xE2, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x83, 0x00,
  0x01, 0x81, 0x80, 0x01, 0x80, 0x60, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0x40, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x10, 0x43, 0x0C,
  0x30, 0x86, 0x10, 0xC6, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x46, 0x00, 0x00, 0xC8, 0x80, 0x00, 0x31,
  0x30, 0x00, 0x18, 0x26, 0x00, 0x06, 0x04, 0xC0, 0x01, 0x81, 0x90, 0x00,
  0x60, 0x32, 0x00, 0x18, 0x06, 0xC0, 0x06, 0x00, 0x98, 0x01, 0x80, 0x13,
  0x00, 0xE0, 0x02, 0x60, 0x30, 0x00, 0xC8, 0x0C, 0x00, 0x19, 0x03, 0x00,
  0x03, 0x20, 0xC0, 0x00, 0x4C, 0x30, 0x00, 0x09, 0x8C, 0x00, 0x03, 0x37,
  0x00, 0x00, 0x67, 0x80, 0x00, 0x08, 0xE0, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x18, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x3C, 0x01, 0xD8, 0x0E, 0x30, 0xF0, 0x47, 0x80, 0x98, 0x03,
  0x40, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x07, 0x00,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x70,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x18, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x02, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x04, 0x00, 0x60, 0x00, 0x40, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x7F, 0xE0, 0x00, 0x6F, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x10, 0x7F, 0xE0, 0x18, 0xF0, 0x1C, 0x0C, 0xE0,
  0x03, 0x04, 0xC0, 0x00, 0xC6, 0x80, 0x00, 0x23, 0x80, 0x00, 0x19, 0xC0,
  0x00, 0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x81,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x70, 0x01, 0x80,
  0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x70, 0x01, 0x80, 0x70, 0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x16, 0x20, 0x00, 0x1A, 0x18, 0x00, 0x39,
  0x06, 0x00, 0x31, 0x81, 0xC0, 0xF0, 0xC0, 0x7F, 0xE0, 0x40, 0x02, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0,
  0x60, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x01, 0xE0, 0x70,
  0x1C, 0x00, 0xC1, 0x80, 0x02, 0x18, 0x00, 0x19, 0x80, 0x00, 0x4C, 0x00,
  0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x18, 0x01, 0x80,
  0xC0, 0x1F, 0xC0, 0x20, 0x60, 0x1C, 0x38, 0x08, 0x18, 0x0C, 0x02, 0x02,
  0x0C, 0x06, 0x00, 0x80, 0x83, 0x03, 0x00, 0x60, 0x21, 0x80, 0xC0, 0x10,
  0x08, 0x60, 0x60, 0x04, 0x02, 0x10, 0x18, 0x03, 0x00, 0x8C, 0x0C, 0x00,
  0xC0, 0x63, 0x03, 0x00, 0x20, 0x18, 0x80, 0x80, 0x08, 0x06, 0x60, 0x60,
  0x06, 0x01, 0x18, 0x18, 0x01, 0x00, 0x44, 0x04, 0x00, 0x40, 0x31, 0x01,
  0x00, 0x30, 0x0C, 0x40, 0xC0, 0x0C, 0x03, 0x30, 0x30, 0x02, 0x00, 0x8C,
  0x0C, 0x01, 0x80, 0x63, 0x03, 0x00, 0xE0, 0x10, 0xC0, 0xC0, 0x28, 0x0C,
  0x30, 0x30, 0x1E, 0x02, 0x0C, 0x0C, 0x0C, 0x81, 0x83, 0x01, 0x06, 0x20,
  0xC0, 0x40, 0x7F, 0x0F, 0xE0, 0x18, 0x0F, 0x01, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60,
  0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x40, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x40, 0x00, 0xE0, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x80, 0x10, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x0F,
  0x00, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x06,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x3F,
  0xFC, 0x80, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10,
  0x0F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x40, 0x07,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x08, 0x07, 0x00, 0x00, 0x04, 0x07, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0xC6,
  0xC0, 0x00, 0x00, 0x46, 0x20, 0x00, 0x00, 0x26, 0x18, 0x00, 0x00, 0x16,
  0x06, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x18, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x10, 0x00, 0x06, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0x40, 0x00, 0x0F, 0x01,
  0x60, 0x00, 0x1A, 0x01, 0x60, 0x00, 0x12, 0x03, 0x60, 0x00, 0x32, 0x03,
  0x20, 0x00, 0x66, 0x03, 0x20, 0x00, 0x66, 0x02, 0x30, 0x00, 0xC6, 0x02,
  0x30, 0x00, 0xC4, 0x06, 0x30, 0x01, 0x84, 0x06, 0x10, 0x01, 0x0C, 0x06,
  0x10, 0x03, 0x0C, 0x06, 0x18, 0x02, 0x0C, 0x04, 0x18, 0x06, 0x08, 0x04,
  0x18, 0x0C, 0x08, 0x0C, 0x08, 0x0C, 0x08, 0x0C, 0x08, 0x18, 0x18, 0x0C,
  0x0C, 0x10, 0x18, 0x08, 0x0C, 0x30, 0x18, 0x08, 0x0C, 0x20, 0x10, 0x08,
  0x04, 0x60, 0x10, 0x18, 0x04, 0xC0, 0x10, 0x18, 0x04, 0xC0, 0x30, 0x18,
  0x07, 0x80, 0x30, 0x10, 0x07, 0x00, 0x30, 0x10, 0x03, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x02, 0x01, 0x40, 0x00, 0x02, 0x03,
  0x40, 0x00, 0x06, 0x03, 0x60, 0x00, 0x06, 0x03, 0x20, 0x00, 0x06, 0x02,
  0x20, 0x00, 0x04, 0x02, 0x30, 0x00, 0x04, 0x02, 0x10, 0x00, 0x04, 0x06,
  0x18, 0x00, 0x0C, 0x06, 0x08, 0x00, 0x0C, 0x06, 0x08, 0x00, 0x0C, 0x04,
  0x0C, 0x00, 0x08, 0x04, 0x04, 0x00, 0x08, 0x04, 0x04, 0x00, 0x18, 0x0C,
  0x06, 0x00, 0x18, 0x0C, 0x02, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x10, 0x08,
  0x01, 0x00, 0x10, 0x08, 0x01, 0x00, 0x10, 0x08, 0x01, 0x80, 0x30, 0x18,
  0x00, 0x80, 0x30, 0x18, 0x00, 0x80, 0x30, 0x18, 0x00, 0xC0, 0x20, 0x10,
  0x00, 0x40, 0x20, 0x10, 0x00, 0x60, 0x20, 0x10, 0x00, 0x20, 0x60, 0x30,
  0x00, 0x20, 0x60, 0x30, 0x00, 0x30, 0x60, 0x20, 0x00, 0x10, 0x40, 0x20,
  0x00, 0x10, 0x40, 0x20, 0x00, 0x18, 0x40, 0x20, 0x00, 0x08, 0xC0, 0x60,
  0x00, 0x0C, 0xC0, 0x60, 0x00, 0x04, 0xC0, 0x40, 0x00, 0x04, 0x80, 0x40,
  0x00, 0x06, 0x80, 0x40, 0x00, 0x02, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x31, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x03,
  0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x10, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x80, 0x80, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x1C, 0x01, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x04,
  0x00, 0x07, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x60,
  0x01, 0x00, 0x01, 0x00, 0x08, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x1C, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x10, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x10, 0x01, 0x00, 0x03, 0x00, 0x10, 0x00, 0x20, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x80, 0x18, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x02, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x28, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x80, 0x0E,
  0x00, 0x12, 0x00, 0x3C, 0x00, 0x48, 0x00, 0xB0, 0x03, 0x20, 0x06, 0xC0,
  0x08, 0x80, 0x1B, 0x00, 0x22, 0x00, 0x4C, 0x01, 0x88, 0x03, 0x30, 0x04,
  0x20, 0x0C, 0xC0, 0x10, 0x80, 0x23, 0x00, 0xC2, 0x01, 0x8C, 0x03, 0x08,
  0x04, 0x30, 0x08, 0x20, 0x10, 0xC0, 0x60, 0x80, 0xC3, 0x01, 0x82, 0x02,
  0x0C, 0x04, 0x08, 0x18, 0x30, 0x10, 0x20, 0x60, 0xC0, 0xC0, 0x81, 0x01,
  0x02, 0x02, 0x0C, 0x04, 0x08, 0x08, 0x30, 0x10, 0x60, 0x20, 0x80, 0x41,
  0x00, 0x86, 0x01, 0x04, 0x02, 0x18, 0x04, 0x30, 0x08, 0x40, 0x10, 0x80,
  0x23, 0x00, 0x42, 0x00, 0x8C, 0x01, 0x18, 0x02, 0x20, 0x04, 0x60, 0x09,
  0x80, 0x11, 0x00, 0x26, 0x00, 0x6C, 0x00, 0x90, 0x01, 0xB0, 0x02, 0xC0,
  0x06, 0x80, 0x0B, 0x00, 0x1E, 0x00, 0x28, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0x40, 0x03, 0x80, 0x05, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x10, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0x80,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x0B, 0x00,
  0x03, 0x20, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC1, 0x00,
  0x30, 0x20, 0x04, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x01, 0x03,
  0x00, 0x20, 0x60, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x01, 0x10,
  0x00, 0x36, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0x06, 0x08, 0x30, 0x41, 0x83, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x08, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x03, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x80, 0xE0, 0x00, 0x10, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x0D, 0x06, 0x00, 0x07, 0x20, 0x60,
  0x01, 0xC4, 0x07, 0x01, 0xE0, 0x80, 0x7F, 0xF0, 0x10, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x3E, 0x00, 0x04, 0x1F, 0xF8,
  0x01, 0x8E, 0x03, 0x80, 0x33, 0x00, 0x18, 0x04, 0xC0, 0x01, 0x80, 0xA0,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04,
  0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x10,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0x58, 0x00, 0x38, 0x09, 0x80, 0x0E, 0x01, 0x1C,
  0x07, 0x00, 0x60, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x03, 0x80,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x02, 0x18,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x06, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x07, 0x00, 0x18, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x1F, 0xF8, 0x20,
  0x03, 0x80, 0x61, 0x00, 0x38, 0x01, 0x98, 0x03, 0x00, 0x06, 0xC0, 0x30,
  0x00, 0x1E, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x08, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x04, 0x00, 0x07, 0x80, 0x30, 0x00,
  0x6C, 0x00, 0xC0, 0x06, 0x60, 0x03, 0x81, 0xE2, 0x00, 0x0F, 0xFC, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x08, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x37, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0x83, 0x00, 0x78, 0x0C, 0x20, 0x0E, 0x00, 0x66, 0x01, 0x80, 0x03,
  0x60, 0x30, 0x00, 0x1E, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x04, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x0E, 0x01, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x36,
  0x00, 0xC0, 0x06, 0x60, 0x07, 0x03, 0xC4, 0x00, 0x3F, 0xF0, 0x40, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x20, 0x0C,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x0F, 0x80, 0x0C, 0x0F, 0xFC, 0x01, 0x87, 0x00, 0xC0,
  0x21, 0x80, 0x0C, 0x04, 0x60, 0x00, 0xC0, 0x90, 0x00, 0x18, 0x34, 0x00,
  0x01, 0x07, 0x00, 0x00, 0x20, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x03, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x06, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0x40, 0x01, 0xC0,
  0x04, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0x08, 0x07, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x08, 0x38, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x9B, 0x00, 0x00, 0x17,
  0x10, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x20, 0x01, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x8F, 0xF0, 0x3F, 0xC0, 0x6E,
  0x06, 0x38, 0x18, 0x1F, 0x00, 0xDC, 0x03, 0x07, 0x00, 0x3C, 0x00, 0xC1,
  0xC0, 0x07, 0x00, 0x10, 0x60, 0x01, 0x80, 0x04, 0x10, 0x00, 0x40, 0x01,
  0x0C, 0x00, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00,
  0x0C, 0x20, 0x00, 0x80, 0x03, 0x08, 0x00, 0x20, 0x00, 0x82, 0x00, 0x08,
  0x00, 0x21, 0x80, 0x06, 0x00, 0x08, 0x60, 0x01, 0x80, 0x06, 0x18, 0x00,
  0x60, 0x01, 0x84, 0x00, 0x10, 0x00, 0x61, 0x00, 0x04, 0x00, 0x10, 0x40,
  0x01, 0x00, 0x04, 0x30, 0x00, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0x00, 0xC2,
  0x00, 0x0C, 0x00, 0x30, 0x80, 0x02, 0x00, 0x08, 0x20, 0x00, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x00, 0x86, 0x00, 0x18, 0x00, 0x21, 0x80, 0x06, 0x00,
  0x18, 0x40, 0x01, 0x00, 0x06, 0x10, 0x00, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x00, 0x43, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0xFF,
  0xC0, 0x18, 0x70, 0x1C, 0x02, 0x18, 0x00, 0xC0, 0x4E, 0x00, 0x0C, 0x19,
  0x00, 0x01, 0x83, 0x40, 0x00, 0x10, 0x70, 0x00, 0x02, 0x0E, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x08, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x86, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x02, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x18, 0x3F, 0xF0, 0x01, 0x8E, 0x03,
  0x80, 0x1B, 0x80, 0x0C, 0x01, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x20, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x60, 0x16, 0x00, 0x0E, 0x01, 0x30, 0x01, 0xC0, 0x31,
  0xC0, 0x70, 0x03, 0x07, 0xFC, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x20, 0x07, 0xFE, 0x08, 0x03, 0xC0, 0x61, 0x00, 0xE0,
  0x06, 0x60, 0x30, 0x00, 0x6C, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x10, 0x00, 0x1E, 0x03, 0x00,
  0x07, 0xC0, 0x30, 0x01, 0x98, 0x03, 0x81, 0xE2, 0x00, 0x3F, 0xF0, 0x40,
  0x00, 0x60, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7E, 0x83, 0x01, 0xFF, 0x81,
  0x83, 0xC0, 0x00, 0x87, 0x00, 0x00, 0x46, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x08, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x70, 0x07, 0x80, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01,
  0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00,
  0x0F, 0x0C, 0x00, 0x06, 0x81, 0x80, 0x03, 0x20, 0x30, 0x03, 0x98, 0x0E,
  0x03, 0xC6, 0x00, 0xFF, 0xC1, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x80, 0x08, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x70, 0x01, 0xA0, 0x01, 0xC0,
  0x06, 0x80, 0x0F, 0x00, 0x12, 0x00, 0x2C, 0x00, 0xC8, 0x01, 0xB0, 0x02,
  0x30, 0x06, 0xC0, 0x18, 0xC0, 0x31, 0x00, 0x63, 0x00, 0xC4, 0x01, 0x0C,
  0x02, 0x10, 0x0C, 0x30, 0x18, 0x40, 0x20, 0xC0, 0x41, 0x01, 0x83, 0x03,
  0x04, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0xC1, 0x81,
  0x83, 0x03, 0x04, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x10, 0x80, 0x61,
  0x00, 0x46, 0x01, 0x8C, 0x01, 0x18, 0x02, 0x30, 0x04, 0x40, 0x09, 0x80,
  0x13, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x60, 0x02, 0xC0, 0x05,
  0x00, 0x0B, 0x00, 0x14, 0x00, 0x28, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x0E,
  0x1C, 0x00, 0x03, 0x18, 0x06, 0x00, 0x02, 0x30, 0x03, 0x00, 0x06, 0x30,
  0x01, 0x80, 0x06, 0x60, 0x00, 0xC0, 0x0C, 0x60, 0x00, 0x70, 0x18, 0x40,
  0x00, 0x3C, 0x70, 0xC0, 0x00, 0x0F, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 10, 42, 35, 12, -42 },
  { 54, 11, 12, 35, 15, -44 },
  { 71, 34, 42, 35, 1, -42 },
  { 250, 28, 54, 35, 4, -48 },
  { 439, 28, 44, 35, 4, -43 },
  { 593, 29, 44, 35, 3, -43 },
  { 753, 4, 12, 35, 17, -44 },
  { 759, 18, 61, 35, 10, -47 },
  { 897, 17, 61, 35, 6, -47 },
  { 1027, 25, 23, 35, 8, -42 },
  { 1099, 28, 31, 35, 4, -35 },
  { 1208, 6, 12, 35, 7, -5 },
  { 1217, 20, 2, 35, 7, -20 },
  { 1222, 3, 3, 35, 14, -3 },
  { 1224, 26, 46, 35, 5, -42 },
  { 1374, 27, 44, 35, 4, -43 },
  { 1523, 15, 42, 35, 9, -42 },
  { 1602, 28, 43, 35, 1, -43 },
  { 1753, 28, 44, 35, 2, -43 },
  { 1907, 28, 42, 35, 2, -42 },
  { 2054, 29, 43, 35, 5, -42 },
  { 2210, 25, 44, 35, 4, -43 },
  { 2348, 27, 42, 35, 7, -42 },
  { 2490, 30, 44, 35, 3, -43 },
  { 2655, 25, 44, 35, 6, -43 },
  { 2793, 8, 28, 35, 15, -28 },
  { 2821, 11, 35, 35, 12, -28 },
  { 2870, 26, 23, 35, 5, -31 },
  { 2945, 27, 13, 35, 4, -26 },
  { 2989, 26, 23, 35, 4, -31 },
  { 3064, 21, 43, 35, 10, -43 },
  { 3177, 34, 42, 35, 1, -42 },
  { 3356, 29, 42, 35, 0, -42 },
  { 3509, 29, 42, 35, 3, -42 },
  { 3662, 28, 44, 35, 4, -43 },
  { 3816, 29, 42, 35, 3, -42 },
  { 3969, 30, 42, 35, 3, -42 },
  { 4127, 31, 42, 35, 3, -42 },
  { 4290, 28, 44, 35, 4, -43 },
  { 4444, 32, 42, 35, 2, -42 },
  { 4612, 30, 42, 35, 3, -42 },
  { 4770, 30, 43, 35, 2, -42 },
  { 4932, 33, 42, 35, 3, -42 },
  { 5106, 23, 42, 35, 4, -42 },
  { 5227, 32, 42, 35, 2, -42 },
  { 5395, 32, 42, 35, 2, -42 },
  { 5563, 28, 44, 35, 4, -43 },
  { 5717, 30, 42, 35, 4, -42 },
  { 5875, 30, 51, 35, 3, -43 },
  { 6067, 29, 42, 35, 3, -42 },
  { 6220, 30, 44, 35, 3, -43 },
  { 6385, 29, 42, 35, 7, -42 },
  { 6538, 30, 43, 35, 4, -42 },
  { 6700, 28, 42, 35, 7, -42 },
  { 6847, 30, 42, 35, 7, -42 },
  { 7005, 34, 42, 35, 1, -42 },
  { 7184, 28, 42, 35, 7, -42 },
  { 7331, 31, 42, 35, 1, -42 },
  { 7494, 17, 57, 35, 9, -48 },
  { 7616, 11, 46, 35, 12, -42 },
  { 7680, 17, 57, 35, 9, -48 },
  { 7802, 19, 23, 35, 8, -42 },
  { 7857, 24, 2, 35, 2, 0 },
  { 7863, 6, 8, 35, 18, -44 },
  { 7869, 27, 33, 35, 3, -32 },
  { 7981, 27, 45, 35, 3, -44 },
  { 8133, 26, 33, 35, 4, -32 },
  { 8241, 29, 45, 35, 4, -44 },
  { 8405, 26, 33, 35, 4, -32 },
  { 8513, 28, 45, 35, 8, -45 },
  { 8671, 28, 45, 35, 3, -32 },
  { 8829, 27, 44, 35, 3, -44 },
  { 8978, 23, 42, 35, 4, -42 },
  { 9099, 27, 55, 35, 0, -42 },
  { 9285, 28, 44, 35, 4, -44 },
  { 9439, 23, 44, 35, 4, -44 },
  { 9566, 34, 32, 35, -1, -32 },
  { 9702, 27, 32, 35, 3, -32 },
  { 9810, 28, 33, 35, 3, -32 },
  { 9926, 28, 44, 35, 1, -32 },
  { 10080, 27, 44, 35, 4, -32 },
  { 10229, 25, 32, 35, 8, -32 },
  { 10329, 27, 33, 35, 4, -32 },
  { 10441, 21, 41, 35, 8, -40 },
  { 10549, 26, 32, 35, 5, -31 },
  { 10653, 28, 31, 35, 5, -31 },
  { 10762, 30, 31, 35, 5, -31 },
  { 10879, 31, 31, 35, 1, -31 },
  { 11000, 35, 44, 35, -1, -31 },
  { 11193, 30, 31, 35, 1, -31 },
  { 11310, 23, 59, 35, 9, -46 },
  { 11480, 9, 50, 35, 13, -42 },
  { 11537, 23, 59, 35, 5, -46 },
  { 11707, 32, 9, 35, 1, -22 },
};

const GFXfont RobotoMono_ThinItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic59pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_THINITALIC59PT7B_H_
