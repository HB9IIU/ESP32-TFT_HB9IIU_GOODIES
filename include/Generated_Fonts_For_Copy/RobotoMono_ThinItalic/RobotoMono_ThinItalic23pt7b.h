#ifndef _ROBOTOMONO_THINITALIC23PT7B_H_
#define _ROBOTOMONO_THINITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x49, 0x20, 0x04, 0x99, 0x9A, 0x01, 0x18, 0x08,
  0x40, 0x21, 0x00, 0x88, 0x3F, 0xFC, 0x10, 0x80, 0x44, 0x02, 0x10, 0x08,
  0x40, 0x22, 0x01, 0x08, 0x3F, 0xFC, 0x11, 0x00, 0x84, 0x02, 0x10, 0x08,
  0x80, 0x02, 0x00, 0x40, 0x1C, 0x0C, 0x42, 0x04, 0x40, 0x90, 0x0A, 0x00,
  0x20, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x01, 0x20, 0x24, 0x04, 0x80,
  0x90, 0x21, 0xD8, 0x04, 0x01, 0x00, 0x18, 0x04, 0x81, 0x10, 0xC2, 0x28,
  0x49, 0x09, 0x22, 0x43, 0x90, 0x02, 0x00, 0x88, 0x26, 0x84, 0x91, 0x22,
  0x44, 0x50, 0x8A, 0x11, 0x01, 0xC0, 0x03, 0x01, 0x90, 0x22, 0x08, 0x41,
  0x08, 0x22, 0x04, 0x80, 0x60, 0x18, 0x04, 0x81, 0x08, 0xA1, 0x18, 0x13,
  0x01, 0xA0, 0x22, 0x0A, 0x3E, 0x20, 0xF0, 0x02, 0x08, 0x20, 0x82, 0x04,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x04, 0x08, 0x08, 0x00, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04, 0x30,
  0x00, 0x04, 0x01, 0x08, 0x45, 0xEE, 0x0C, 0x05, 0x02, 0x21, 0x08, 0x41,
  0x00, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x3F, 0xF8, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x56, 0x80, 0xFF, 0xC0, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x07, 0x06, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x38, 0x16, 0x09, 0x84, 0x62, 0x19, 0x07, 0x82, 0x80,
  0xA0, 0x28, 0x12, 0x08, 0x7C, 0x00, 0x1B, 0x62, 0x10, 0x84, 0x42, 0x10,
  0x84, 0x22, 0x10, 0x84, 0x07, 0x06, 0x22, 0x05, 0x01, 0x40, 0x40, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0xFF, 0x80, 0x07, 0x03, 0x18, 0x81, 0x10, 0x14, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x0F, 0x00, 0x20, 0x02, 0x00, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x08,
  0x7E, 0x00, 0x00, 0x40, 0x18, 0x05, 0x01, 0x40, 0x48, 0x11, 0x04, 0x20,
  0x84, 0x20, 0x88, 0x22, 0x04, 0x7F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x1F, 0xE2, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x1F, 0xC2, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x48, 0x09, 0x01, 0x10, 0x41, 0xF0, 0x00, 0xC0,
  0xC0, 0xC0, 0x40, 0x10, 0x08, 0x04, 0xF1, 0x42, 0x60, 0x50, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x14, 0x09, 0x04, 0x3E, 0x00, 0xFF, 0xC0, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x03, 0x80, 0xC4, 0x10, 0x21, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x21, 0x04, 0x0F, 0x81, 0x08, 0x60, 0x44, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x06, 0x06, 0x62, 0x05, 0x01, 0x40,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x34, 0x38, 0xF2, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x78, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x44, 0x88, 0x00, 0xC0, 0xC0, 0xC1, 0xC0, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x00,
  0x1C, 0x62, 0x81, 0x81, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x38, 0x82, 0x02, 0x20, 0x11,
  0x3C, 0x92, 0x25, 0x11, 0x29, 0x09, 0x48, 0x8A, 0x44, 0x64, 0x23, 0x23,
  0x29, 0x19, 0x27, 0x31, 0x00, 0x04, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x30,
  0x06, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08, 0x7F,
  0x90, 0x12, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x1F, 0xC4, 0x04, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x48, 0x31, 0xF8, 0x40, 0xC8, 0x09, 0x00, 0xA0, 0x14,
  0x05, 0x00, 0xA0, 0x27, 0xF8, 0x03, 0x80, 0xC4, 0x10, 0x22, 0x01, 0x20,
  0x14, 0x01, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x28, 0x04, 0x40, 0x84, 0x18, 0x3E, 0x00, 0x3F, 0xC2, 0x02, 0x20, 0x22,
  0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x04, 0x80, 0x48, 0x08, 0x81, 0x0F, 0xE0, 0x1F, 0xF1, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xF1, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x03, 0x80, 0xC4, 0x10, 0x22,
  0x01, 0x20, 0x14, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x3C, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x40, 0x44, 0x0C, 0x3F, 0x00, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x24, 0x02, 0x40, 0x27, 0xFE, 0x40, 0x24, 0x02,
  0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x1F, 0xF0, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x0F, 0xF8, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x07, 0xE0, 0x10, 0x18, 0x81,
  0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0x90, 0x05, 0x00, 0x54, 0x03,
  0x10, 0x10, 0x80, 0x82, 0x04, 0x08, 0x20, 0x42, 0x01, 0x10, 0x0C, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0xFF, 0x10, 0x13, 0x03, 0x30, 0x32,
  0x85, 0x28, 0x94, 0x8A, 0x49, 0x24, 0x92, 0x46, 0x24, 0x42, 0x44, 0x28,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x20, 0x13, 0x01, 0x30, 0x12,
  0x81, 0x28, 0x24, 0x42, 0x44, 0x24, 0x42, 0x42, 0x24, 0x22, 0x42, 0x48,
  0x14, 0x81, 0x48, 0x0C, 0x80, 0xC8, 0x08, 0x03, 0x81, 0x88, 0x40, 0x90,
  0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x05, 0x00, 0x90, 0x22, 0x08, 0x3E, 0x00, 0x1F, 0xE1, 0x01, 0x10, 0x12,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x04, 0x3F, 0x84, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x03, 0x80, 0xC4, 0x10, 0x22,
  0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x40, 0x44, 0x08, 0x3F, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x1F, 0xC1, 0x02, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22,
  0x0C, 0x3F, 0x04, 0x10, 0x41, 0x04, 0x08, 0x40, 0x84, 0x08, 0x80, 0x48,
  0x04, 0x03, 0x80, 0xC4, 0x10, 0x22, 0x01, 0x20, 0x12, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x28, 0x02, 0x80, 0x44,
  0x08, 0x3F, 0x00, 0xFF, 0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x80, 0x48, 0x04, 0x80, 0x44, 0x08, 0x41, 0x03,
  0xE0, 0x80, 0x70, 0x0A, 0x02, 0x40, 0x48, 0x09, 0x02, 0x10, 0x42, 0x10,
  0x42, 0x08, 0x81, 0x10, 0x24, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x84,
  0x30, 0x86, 0x30, 0xC6, 0x29, 0x45, 0x28, 0xA5, 0x25, 0x24, 0xA4, 0x94,
  0xA3, 0x14, 0x62, 0x88, 0x51, 0x04, 0x20, 0x84, 0x10, 0x10, 0x0C, 0x20,
  0x40, 0x81, 0x01, 0x08, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0x40, 0x03,
  0x00, 0x12, 0x00, 0x88, 0x02, 0x20, 0x10, 0x40, 0x81, 0x04, 0x02, 0x30,
  0x08, 0x80, 0x70, 0x0A, 0x02, 0x20, 0x84, 0x10, 0x84, 0x09, 0x01, 0x40,
  0x28, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F,
  0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xF8, 0x1C,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x0E, 0x00, 0x88, 0x88, 0x44, 0x44, 0x42, 0x22, 0x22,
  0x11, 0x10, 0x0E, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x3C, 0x00, 0x04,
  0x0C, 0x14, 0x12, 0x22, 0x22, 0x42, 0x81, 0x81, 0xFF, 0x80, 0x94, 0x1F,
  0x84, 0x08, 0x80, 0x80, 0x10, 0x04, 0x1F, 0x8C, 0x12, 0x02, 0x80, 0x50,
  0x12, 0x06, 0x3F, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x20, 0x5B,
  0x0C, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x80, 0x90,
  0x22, 0x08, 0xBE, 0x00, 0x1F, 0x08, 0x24, 0x06, 0x01, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0xA0, 0x48, 0x11, 0xF8, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x44, 0x36, 0x88, 0x32, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x20, 0x44, 0x18, 0x7D, 0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0,
  0x14, 0x02, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x08, 0x01, 0x02, 0x1F, 0x80,
  0x07, 0xE1, 0x00, 0x20, 0x08, 0x01, 0x01, 0xFF, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x00,
  0x0F, 0xA2, 0x0C, 0x80, 0xA0, 0x24, 0x04, 0x80, 0x90, 0x14, 0x02, 0x40,
  0x48, 0x11, 0x06, 0x1F, 0x40, 0x08, 0x02, 0x20, 0x46, 0x10, 0x3C, 0x00,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x30, 0x59, 0x8C, 0x11, 0x01, 0x40,
  0x28, 0x05, 0x01, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x43, 0xFF, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x30, 0xF0, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x14, 0x19, 0x08, 0x44, 0x16, 0x07,
  0x01, 0x20, 0x84, 0x21, 0x08, 0x22, 0x04, 0x81, 0x80, 0x1F, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC0, 0x3E, 0xF9, 0x08, 0x50, 0x42,
  0x84, 0x14, 0x20, 0xA1, 0x06, 0x08, 0x50, 0x42, 0x82, 0x14, 0x20, 0xA1,
  0x05, 0x08, 0x20, 0x2F, 0xC6, 0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x40, 0x0F, 0x86, 0x08, 0x80,
  0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x48, 0x11, 0x06, 0x1F,
  0x00, 0x17, 0xC3, 0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x24, 0x09, 0x82, 0x2F, 0x84, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x00, 0x1F, 0x48, 0x34, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80,
  0xA0, 0x48, 0x31, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x2F,
  0xCC, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x3F, 0x90, 0x14, 0x05, 0x00, 0x60, 0x07, 0x00, 0x30, 0x02,
  0x00, 0xA0, 0x28, 0x11, 0xF8, 0x08, 0x08, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x1E, 0x40, 0x50, 0x14, 0x06,
  0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x31, 0xF4, 0x80,
  0x30, 0x09, 0x01, 0x20, 0x44, 0x10, 0x82, 0x08, 0x81, 0x10, 0x24, 0x04,
  0x80, 0x60, 0x08, 0x00, 0x84, 0x18, 0x42, 0x8C, 0x28, 0xC4, 0x92, 0x49,
  0x24, 0xA2, 0x8A, 0x28, 0xA3, 0x0C, 0x30, 0xC2, 0x08, 0x20, 0x20, 0x31,
  0x04, 0x10, 0x80, 0x90, 0x0A, 0x00, 0x40, 0x06, 0x00, 0xA0, 0x11, 0x02,
  0x08, 0x40, 0x88, 0x04, 0x20, 0x09, 0x00, 0x88, 0x04, 0x20, 0x41, 0x02,
  0x08, 0x20, 0x22, 0x01, 0x10, 0x09, 0x00, 0x48, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0F, 0xFE, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x60, 0x80, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x44, 0x88, 0x88, 0x80, 0x18,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x80,
  0x30, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x03,
  0x00, 0x30, 0x0C, 0xC1, 0x82, 0x28, 0x1C,
};

const GFXglyph RobotoMono_ThinItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 16, 14, 5, -16 },
  { 7, 4, 4, 14, 6, -17 },
  { 9, 14, 16, 14, 0, -16 },
  { 37, 11, 21, 14, 2, -19 },
  { 66, 11, 17, 14, 1, -17 },
  { 90, 11, 17, 14, 1, -17 },
  { 114, 1, 4, 14, 7, -17 },
  { 115, 7, 23, 14, 4, -18 },
  { 136, 7, 23, 14, 2, -18 },
  { 157, 10, 9, 14, 3, -16 },
  { 169, 11, 12, 14, 1, -14 },
  { 186, 2, 5, 14, 3, -2 },
  { 188, 8, 1, 14, 3, -8 },
  { 189, 2, 1, 14, 5, -1 },
  { 190, 10, 17, 14, 2, -16 },
  { 212, 10, 17, 14, 2, -17 },
  { 234, 5, 16, 14, 4, -16 },
  { 244, 10, 17, 14, 1, -17 },
  { 266, 11, 17, 14, 1, -17 },
  { 290, 11, 16, 14, 1, -16 },
  { 312, 11, 16, 14, 2, -16 },
  { 334, 10, 17, 14, 1, -17 },
  { 356, 10, 16, 14, 3, -16 },
  { 376, 12, 17, 14, 1, -17 },
  { 402, 10, 17, 14, 2, -17 },
  { 424, 3, 11, 14, 6, -11 },
  { 429, 4, 14, 14, 5, -11 },
  { 436, 10, 9, 14, 2, -12 },
  { 448, 10, 5, 14, 2, -10 },
  { 455, 11, 9, 14, 1, -12 },
  { 468, 8, 17, 14, 4, -17 },
  { 485, 13, 17, 14, 0, -17 },
  { 513, 11, 16, 14, 0, -16 },
  { 535, 11, 16, 14, 1, -16 },
  { 557, 12, 17, 14, 1, -17 },
  { 583, 12, 16, 14, 1, -16 },
  { 607, 12, 16, 14, 1, -16 },
  { 631, 12, 16, 14, 1, -16 },
  { 655, 12, 17, 14, 1, -17 },
  { 681, 12, 16, 14, 1, -16 },
  { 705, 12, 16, 14, 1, -16 },
  { 729, 12, 16, 14, 1, -16 },
  { 753, 13, 16, 14, 1, -16 },
  { 779, 10, 16, 14, 1, -16 },
  { 799, 12, 16, 14, 1, -16 },
  { 823, 12, 16, 14, 1, -16 },
  { 847, 11, 17, 14, 1, -17 },
  { 871, 12, 16, 14, 1, -16 },
  { 895, 12, 20, 14, 1, -17 },
  { 925, 12, 16, 14, 1, -16 },
  { 949, 12, 17, 14, 1, -17 },
  { 975, 11, 16, 14, 3, -16 },
  { 997, 12, 16, 14, 1, -16 },
  { 1021, 11, 16, 14, 3, -16 },
  { 1043, 11, 16, 14, 3, -16 },
  { 1065, 14, 16, 14, 0, -16 },
  { 1093, 11, 16, 14, 3, -16 },
  { 1115, 12, 16, 14, 1, -16 },
  { 1139, 6, 23, 14, 4, -19 },
  { 1157, 4, 17, 14, 5, -16 },
  { 1166, 7, 23, 14, 3, -19 },
  { 1187, 8, 9, 14, 3, -16 },
  { 1196, 9, 1, 14, 1, 0 },
  { 1198, 2, 3, 14, 7, -17 },
  { 1199, 11, 12, 14, 1, -12 },
  { 1216, 11, 17, 14, 1, -17 },
  { 1240, 10, 12, 14, 2, -12 },
  { 1255, 11, 17, 14, 2, -17 },
  { 1279, 11, 12, 14, 1, -12 },
  { 1296, 11, 17, 14, 3, -17 },
  { 1320, 11, 17, 14, 1, -12 },
  { 1344, 11, 17, 14, 1, -17 },
  { 1368, 10, 16, 14, 1, -16 },
  { 1388, 10, 21, 14, 0, -16 },
  { 1415, 10, 17, 14, 2, -17 },
  { 1437, 10, 17, 14, 1, -17 },
  { 1459, 13, 12, 14, 0, -12 },
  { 1479, 11, 12, 14, 1, -12 },
  { 1496, 11, 12, 14, 1, -12 },
  { 1513, 11, 17, 14, 0, -12 },
  { 1537, 10, 17, 14, 2, -12 },
  { 1559, 10, 12, 14, 3, -12 },
  { 1574, 10, 12, 14, 2, -12 },
  { 1589, 8, 15, 14, 3, -15 },
  { 1604, 10, 12, 14, 2, -12 },
  { 1619, 11, 12, 14, 2, -12 },
  { 1636, 12, 12, 14, 2, -12 },
  { 1654, 12, 12, 14, 1, -12 },
  { 1672, 13, 17, 14, 0, -12 },
  { 1700, 12, 12, 14, 0, -12 },
  { 1718, 8, 23, 14, 4, -18 },
  { 1741, 4, 19, 14, 5, -16 },
  { 1751, 9, 23, 14, 2, -18 },
  { 1777, 12, 4, 14, 1, -9 },
};

const GFXfont RobotoMono_ThinItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic23pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_THINITALIC23PT7B_H_
