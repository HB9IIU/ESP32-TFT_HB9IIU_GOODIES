#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoMono_ThinItalic6pt7b, 6, "RobotoMono_ThinItalic6pt7b" },
  { &RobotoMono_ThinItalic7pt7b, 7, "RobotoMono_ThinItalic7pt7b" },
  { &RobotoMono_ThinItalic8pt7b, 8, "RobotoMono_ThinItalic8pt7b" },
  { &RobotoMono_ThinItalic9pt7b, 9, "RobotoMono_ThinItalic9pt7b" },
  { &RobotoMono_ThinItalic10pt7b, 10, "RobotoMono_ThinItalic10pt7b" },
  { &RobotoMono_ThinItalic11pt7b, 11, "RobotoMono_ThinItalic11pt7b" },
  { &RobotoMono_ThinItalic12pt7b, 12, "RobotoMono_ThinItalic12pt7b" },
  { &RobotoMono_ThinItalic13pt7b, 13, "RobotoMono_ThinItalic13pt7b" },
  { &RobotoMono_ThinItalic14pt7b, 14, "RobotoMono_ThinItalic14pt7b" },
  { &RobotoMono_ThinItalic15pt7b, 15, "RobotoMono_ThinItalic15pt7b" },
  { &RobotoMono_ThinItalic16pt7b, 16, "RobotoMono_ThinItalic16pt7b" },
  { &RobotoMono_ThinItalic17pt7b, 17, "RobotoMono_ThinItalic17pt7b" },
  { &RobotoMono_ThinItalic18pt7b, 18, "RobotoMono_ThinItalic18pt7b" },
  { &RobotoMono_ThinItalic19pt7b, 19, "RobotoMono_ThinItalic19pt7b" },
  { &RobotoMono_ThinItalic20pt7b, 20, "RobotoMono_ThinItalic20pt7b" },
  { &RobotoMono_ThinItalic21pt7b, 21, "RobotoMono_ThinItalic21pt7b" },
  { &RobotoMono_ThinItalic22pt7b, 22, "RobotoMono_ThinItalic22pt7b" },
  { &RobotoMono_ThinItalic23pt7b, 23, "RobotoMono_ThinItalic23pt7b" },
  { &RobotoMono_ThinItalic24pt7b, 24, "RobotoMono_ThinItalic24pt7b" },
  { &RobotoMono_ThinItalic25pt7b, 25, "RobotoMono_ThinItalic25pt7b" },
  { &RobotoMono_ThinItalic26pt7b, 26, "RobotoMono_ThinItalic26pt7b" },
  { &RobotoMono_ThinItalic27pt7b, 27, "RobotoMono_ThinItalic27pt7b" },
  { &RobotoMono_ThinItalic28pt7b, 28, "RobotoMono_ThinItalic28pt7b" },
  { &RobotoMono_ThinItalic29pt7b, 29, "RobotoMono_ThinItalic29pt7b" },
  { &RobotoMono_ThinItalic30pt7b, 30, "RobotoMono_ThinItalic30pt7b" },
  { &RobotoMono_ThinItalic31pt7b, 31, "RobotoMono_ThinItalic31pt7b" },
  { &RobotoMono_ThinItalic32pt7b, 32, "RobotoMono_ThinItalic32pt7b" },
  { &RobotoMono_ThinItalic33pt7b, 33, "RobotoMono_ThinItalic33pt7b" },
  { &RobotoMono_ThinItalic34pt7b, 34, "RobotoMono_ThinItalic34pt7b" },
  { &RobotoMono_ThinItalic35pt7b, 35, "RobotoMono_ThinItalic35pt7b" },
  { &RobotoMono_ThinItalic36pt7b, 36, "RobotoMono_ThinItalic36pt7b" },
  { &RobotoMono_ThinItalic37pt7b, 37, "RobotoMono_ThinItalic37pt7b" },
  { &RobotoMono_ThinItalic38pt7b, 38, "RobotoMono_ThinItalic38pt7b" },
  { &RobotoMono_ThinItalic39pt7b, 39, "RobotoMono_ThinItalic39pt7b" },
  { &RobotoMono_ThinItalic40pt7b, 40, "RobotoMono_ThinItalic40pt7b" },
  { &RobotoMono_ThinItalic41pt7b, 41, "RobotoMono_ThinItalic41pt7b" },
  { &RobotoMono_ThinItalic42pt7b, 42, "RobotoMono_ThinItalic42pt7b" },
  { &RobotoMono_ThinItalic43pt7b, 43, "RobotoMono_ThinItalic43pt7b" },
  { &RobotoMono_ThinItalic44pt7b, 44, "RobotoMono_ThinItalic44pt7b" },
  { &RobotoMono_ThinItalic45pt7b, 45, "RobotoMono_ThinItalic45pt7b" },
  { &RobotoMono_ThinItalic46pt7b, 46, "RobotoMono_ThinItalic46pt7b" },
  { &RobotoMono_ThinItalic47pt7b, 47, "RobotoMono_ThinItalic47pt7b" },
  { &RobotoMono_ThinItalic48pt7b, 48, "RobotoMono_ThinItalic48pt7b" },
  { &RobotoMono_ThinItalic49pt7b, 49, "RobotoMono_ThinItalic49pt7b" },
  { &RobotoMono_ThinItalic50pt7b, 50, "RobotoMono_ThinItalic50pt7b" },
  { &RobotoMono_ThinItalic51pt7b, 51, "RobotoMono_ThinItalic51pt7b" },
  { &RobotoMono_ThinItalic52pt7b, 52, "RobotoMono_ThinItalic52pt7b" },
  { &RobotoMono_ThinItalic53pt7b, 53, "RobotoMono_ThinItalic53pt7b" },
  { &RobotoMono_ThinItalic54pt7b, 54, "RobotoMono_ThinItalic54pt7b" },
  { &RobotoMono_ThinItalic55pt7b, 55, "RobotoMono_ThinItalic55pt7b" },
  { &RobotoMono_ThinItalic56pt7b, 56, "RobotoMono_ThinItalic56pt7b" },
  { &RobotoMono_ThinItalic57pt7b, 57, "RobotoMono_ThinItalic57pt7b" },
  { &RobotoMono_ThinItalic58pt7b, 58, "RobotoMono_ThinItalic58pt7b" },
  { &RobotoMono_ThinItalic59pt7b, 59, "RobotoMono_ThinItalic59pt7b" },
  { &RobotoMono_ThinItalic60pt7b, 60, "RobotoMono_ThinItalic60pt7b" },
  { &RobotoMono_ThinItalic61pt7b, 61, "RobotoMono_ThinItalic61pt7b" },
  { &RobotoMono_ThinItalic62pt7b, 62, "RobotoMono_ThinItalic62pt7b" },
  { &RobotoMono_ThinItalic63pt7b, 63, "RobotoMono_ThinItalic63pt7b" },
  { &RobotoMono_ThinItalic64pt7b, 64, "RobotoMono_ThinItalic64pt7b" },
  { &RobotoMono_ThinItalic65pt7b, 65, "RobotoMono_ThinItalic65pt7b" },
  { &RobotoMono_ThinItalic66pt7b, 66, "RobotoMono_ThinItalic66pt7b" },
  { &RobotoMono_ThinItalic67pt7b, 67, "RobotoMono_ThinItalic67pt7b" },
  { &RobotoMono_ThinItalic68pt7b, 68, "RobotoMono_ThinItalic68pt7b" },
  { &RobotoMono_ThinItalic69pt7b, 69, "RobotoMono_ThinItalic69pt7b" },
  { &RobotoMono_ThinItalic70pt7b, 70, "RobotoMono_ThinItalic70pt7b" },
  { &RobotoMono_ThinItalic71pt7b, 71, "RobotoMono_ThinItalic71pt7b" },
  { &RobotoMono_ThinItalic72pt7b, 72, "RobotoMono_ThinItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
