#ifndef _ROBOTOMONO_THINITALIC49PT7B_H_
#define _ROBOTOMONO_THINITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xE0,
  0x20, 0x90, 0x48, 0x24, 0x36, 0x1B, 0x09, 0x04, 0x82, 0x43, 0x61, 0x80,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0x60, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x04, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0x40,
  0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x18, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x04, 0x03, 0x00, 0x06, 0x06, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0x03, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x20, 0x00, 0x20, 0x20, 0x00, 0x60, 0x30, 0x0C, 0x40, 0x30, 0x18,
  0xC0, 0x30, 0x10, 0xC0, 0x20, 0x30, 0x80, 0x20, 0x60, 0x80, 0x20, 0x40,
  0x80, 0x60, 0x80, 0x80, 0x41, 0x80, 0xC0, 0xC1, 0x00, 0x41, 0x82, 0x00,
  0x77, 0x06, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x70, 0x00, 0x40, 0xFC, 0x00, 0xC1, 0x06,
  0x00, 0x82, 0x02, 0x01, 0x06, 0x02, 0x03, 0x04, 0x02, 0x06, 0x0C, 0x03,
  0x04, 0x0C, 0x02, 0x0C, 0x08, 0x02, 0x18, 0x08, 0x02, 0x10, 0x08, 0x06,
  0x20, 0x08, 0x04, 0x60, 0x08, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x04, 0x18,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x10, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x01, 0x00, 0x20, 0x01, 0x00, 0x60, 0x01, 0x00, 0x40,
  0x01, 0x00, 0x80, 0x01, 0x81, 0x00, 0x00, 0x86, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x10, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x0C, 0x01, 0x18, 0x04, 0x03,
  0x30, 0x02, 0x03, 0x20, 0x03, 0x02, 0x60, 0x01, 0x06, 0x40, 0x01, 0x84,
  0x40, 0x00, 0xCC, 0x40, 0x00, 0x48, 0x40, 0x00, 0x78, 0x40, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x20, 0x00, 0xD8, 0x30, 0x01, 0x88, 0x1C, 0x06, 0x04,
  0x07, 0xFC, 0x06, 0x24, 0x92, 0xD2, 0x58, 0x00, 0x04, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x80, 0x20, 0x1E, 0x06, 0x0F, 0x3C,
  0x67, 0x80, 0x7D, 0xC0, 0x00, 0xE0, 0x00, 0x0A, 0x00, 0x01, 0xB0, 0x00,
  0x31, 0x00, 0x06, 0x08, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x20,
  0x60, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x08, 0x46, 0x31, 0x08, 0xC4, 0x46,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x5D, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x81, 0x80, 0x18,
  0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x20, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x72, 0x00, 0x03, 0x48,
  0x00, 0x19, 0x60, 0x00, 0xC5, 0x80, 0x06, 0x14, 0x00, 0x20, 0xD0, 0x01,
  0x03, 0x40, 0x18, 0x09, 0x00, 0xC0, 0x2C, 0x06, 0x00, 0xA0, 0x30, 0x02,
  0x81, 0x80, 0x1A, 0x0C, 0x00, 0x68, 0x40, 0x01, 0x26, 0x00, 0x04, 0xB0,
  0x00, 0x33, 0x80, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00,
  0x43, 0x00, 0x03, 0x04, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x20, 0x06, 0x00,
  0x60, 0x70, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xB0, 0xE2,
  0x38, 0x2C, 0x02, 0x80, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x60, 0x18, 0x00, 0x60, 0x20,
  0x00, 0x40, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x38, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04, 0x00,
  0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x08, 0x00, 0x03, 0x08, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x10, 0x00, 0x10, 0x10, 0x00, 0x20, 0x10, 0x00, 0x60, 0x10, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x20, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00,
  0x40, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x7E, 0x00, 0x0B, 0xE7, 0x80, 0x0E, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x03, 0xE0, 0x18, 0xF3, 0xC0, 0x9C, 0x03, 0x05, 0x80,
  0x04, 0x78, 0x00, 0x33, 0x80, 0x00, 0x98, 0x00, 0x06, 0x80, 0x00, 0x34,
  0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x80, 0x00, 0x64, 0x00, 0x02, 0x20,
  0x00, 0x31, 0x80, 0x03, 0x04, 0x00, 0x30, 0x10, 0x03, 0x00, 0x60, 0x30,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00,
  0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00,
  0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x04, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x03, 0x00, 0x60, 0x00, 0xF7, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x04, 0xC0, 0x00,
  0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0xC0, 0x00,
  0x10, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x1C, 0x07,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1C, 0x0C, 0x01, 0x80, 0x10,
  0x18, 0x00, 0x41, 0x80, 0x03, 0x08, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00,
  0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00,
  0x36, 0x00, 0x01, 0x90, 0x00, 0x1C, 0xC0, 0x01, 0x62, 0x00, 0x32, 0x0C,
  0x03, 0x10, 0x3F, 0xE1, 0x80, 0x78, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x00,
  0x08, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x0E, 0x30, 0x01, 0x01, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08,
  0x0C, 0x0C, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0x81, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20,
  0x00, 0x90, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x60, 0x1E,
  0x02, 0x04, 0x07, 0x70, 0x20, 0xC0, 0xC1, 0x83, 0x18, 0x10, 0x18, 0x31,
  0x03, 0x01, 0x03, 0x30, 0x20, 0x10, 0x23, 0x04, 0x01, 0x02, 0x20, 0x40,
  0x20, 0x26, 0x08, 0x02, 0x02, 0x40, 0x80, 0x20, 0x24, 0x18, 0x06, 0x06,
  0x41, 0x80, 0x40, 0x4C, 0x10, 0x04, 0x04, 0xC1, 0x00, 0xC0, 0x48, 0x10,
  0x0C, 0x0C, 0x81, 0x01, 0x80, 0x88, 0x10, 0x18, 0x18, 0x81, 0x02, 0x81,
  0x08, 0x10, 0x68, 0x30, 0xC1, 0x8C, 0xC6, 0x0C, 0x0F, 0x87, 0xC0, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x40, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xA0,
  0x00, 0x01, 0xB0, 0x00, 0x01, 0x30, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x08, 0x00, 0x30, 0x08, 0x00, 0x20, 0x08,
  0x00, 0x60, 0x08, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C,
  0x01, 0x80, 0x04, 0x01, 0x00, 0x04, 0x03, 0x00, 0x04, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x02,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00, 0x02,
  0x20, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x07, 0xFF, 0x80,
  0x0C, 0x07, 0xC0, 0x10, 0x00, 0xE0, 0x20, 0x00, 0x60, 0x40, 0x00, 0x40,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x70, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x82, 0x00, 0x01, 0x84, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x19,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30,
  0x00, 0x08, 0x40, 0x00, 0x60, 0x80, 0x01, 0x81, 0x00, 0x1E, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x0C, 0x02, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x60, 0x60, 0x00, 0x40, 0x20,
  0x00, 0xC0, 0x10, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x00, 0xF0, 0x00, 0x80, 0x06, 0x00,
  0x40, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x10, 0x10, 0x00, 0x0C,
  0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00,
  0x02, 0x10, 0x00, 0x03, 0x18, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08,
  0x00, 0x02, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x02, 0x00, 0x01, 0x01,
  0x00, 0x01, 0x00, 0x80, 0x03, 0x00, 0x40, 0x03, 0x00, 0x60, 0x0F, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x70, 0x30, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x04, 0x02, 0x00, 0x06, 0x04,
  0x00, 0x02, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18, 0x00, 0x01, 0x10,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0F, 0xFC, 0x80, 0x0F, 0xFC, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40,
  0x00, 0x18, 0x60, 0x00, 0x10, 0x30, 0x00, 0x30, 0x18, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x10, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30, 0x00, 0x06, 0x08, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08,
  0x00, 0x01, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x18, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x10, 0x60, 0x00, 0x04, 0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00,
  0x01, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x06, 0x08, 0x00, 0x02, 0x06, 0x00,
  0x03, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x07, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x40,
  0x00, 0xC0, 0x08, 0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x02, 0x64, 0x00, 0x00, 0x58, 0xC0,
  0x00, 0x0E, 0x08, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x18, 0x00, 0x08,
  0x01, 0x00, 0x01, 0x00, 0x30, 0x00, 0x20, 0x02, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0x40, 0x04, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x80, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0D, 0x05, 0x80, 0x02,
  0xC1, 0x60, 0x01, 0xA0, 0x48, 0x00, 0x48, 0x12, 0x00, 0x32, 0x0C, 0x80,
  0x08, 0x83, 0x30, 0x06, 0x60, 0x8C, 0x03, 0x18, 0x21, 0x00, 0x84, 0x08,
  0x40, 0x61, 0x02, 0x10, 0x10, 0x41, 0x86, 0x0C, 0x10, 0x61, 0x82, 0x0C,
  0x10, 0x21, 0x83, 0x04, 0x08, 0xC0, 0x81, 0x02, 0x20, 0x20, 0x40, 0x98,
  0x08, 0x30, 0x34, 0x02, 0x08, 0x07, 0x01, 0x82, 0x01, 0x80, 0x40, 0x80,
  0x60, 0x10, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06, 0x08, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x50, 0x00, 0x0C,
  0x14, 0x00, 0x02, 0x05, 0x80, 0x00, 0x81, 0x20, 0x00, 0x20, 0x48, 0x00,
  0x08, 0x33, 0x00, 0x06, 0x08, 0x40, 0x01, 0x82, 0x10, 0x00, 0x40, 0x82,
  0x00, 0x10, 0x20, 0x80, 0x04, 0x08, 0x30, 0x01, 0x06, 0x04, 0x00, 0xC1,
  0x01, 0x00, 0x20, 0x40, 0x60, 0x08, 0x10, 0x08, 0x02, 0x04, 0x02, 0x00,
  0x81, 0x00, 0x40, 0x20, 0xC0, 0x10, 0x18, 0x20, 0x06, 0x04, 0x08, 0x00,
  0x81, 0x02, 0x00, 0x20, 0x40, 0x80, 0x0C, 0x10, 0x20, 0x01, 0x04, 0x18,
  0x00, 0x43, 0x04, 0x00, 0x08, 0x81, 0x00, 0x02, 0x20, 0x40, 0x00, 0xC8,
  0x10, 0x00, 0x12, 0x0C, 0x00, 0x05, 0x83, 0x00, 0x01, 0xE0, 0x80, 0x00,
  0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x10, 0x03, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0x00, 0x3C, 0x00,
  0x80, 0x03, 0x00, 0x40, 0x00, 0x40, 0x60, 0x00, 0x30, 0x30, 0x00, 0x08,
  0x10, 0x00, 0x06, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x40, 0x00,
  0x18, 0x20, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x08, 0x00,
  0x1C, 0x04, 0x00, 0x38, 0x03, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x70,
  0x30, 0x01, 0xC0, 0x08, 0x03, 0x00, 0x04, 0x06, 0x00, 0x06, 0x04, 0x00,
  0x02, 0x0C, 0x00, 0x02, 0x18, 0x00, 0x03, 0x10, 0x00, 0x01, 0x30, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x1C, 0x06,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0xFF,
  0x80, 0x02, 0x01, 0xF0, 0x06, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x04, 0x00,
  0x06, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x06, 0x08, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x10, 0x00,
  0x30, 0x10, 0x00, 0x60, 0x10, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x20, 0x01, 0x00, 0x20, 0x01,
  0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x40, 0x00,
  0x40, 0x40, 0x00, 0x60, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x00, 0xF0,
  0x38, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x00,
  0x03, 0x08, 0x00, 0x03, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0xC0, 0x00,
  0x18, 0x40, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x30,
  0x00, 0x06, 0x10, 0x00, 0x03, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18,
  0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x18, 0x00, 0x01,
  0x0C, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x04, 0x18, 0x00, 0x06, 0x04, 0x00, 0x02, 0x02, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x00, 0x40, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x98, 0x00, 0x03, 0x10, 0x00, 0x04, 0x20,
  0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x80, 0x01, 0x03, 0x00,
  0x06, 0x02, 0x00, 0x08, 0x04, 0x00, 0x30, 0x08, 0x00, 0x40, 0x10, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x10, 0x00, 0x80, 0x20,
  0x01, 0x00, 0xC0, 0x02, 0x01, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x08, 0x00,
  0x08, 0x30, 0x00, 0x10, 0x40, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00, 0x00,
  0x8C, 0x00, 0x01, 0x90, 0x00, 0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x05,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x2C, 0x01, 0xC0, 0x16,
  0x01, 0xE0, 0x0B, 0x00, 0x90, 0x09, 0x80, 0x48, 0x04, 0xC0, 0x64, 0x02,
  0x60, 0x22, 0x03, 0x30, 0x11, 0x01, 0x18, 0x18, 0x80, 0x8C, 0x08, 0x40,
  0xC6, 0x04, 0x20, 0x43, 0x06, 0x10, 0x21, 0x82, 0x08, 0x30, 0xC1, 0x04,
  0x10, 0x61, 0x82, 0x08, 0x30, 0x81, 0x04, 0x18, 0x40, 0x84, 0x0C, 0x60,
  0x42, 0x06, 0x20, 0x21, 0x03, 0x10, 0x11, 0x81, 0x98, 0x08, 0x80, 0xC8,
  0x04, 0x40, 0x6C, 0x02, 0x60, 0x36, 0x01, 0xA0, 0x1A, 0x00, 0xD0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x18, 0x00, 0x0C,
  0x00, 0x80, 0x01, 0x80, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x10,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x08, 0x03, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x32, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x18, 0x18, 0x00, 0x20,
  0x30, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x60, 0x04, 0x00, 0x40, 0x10, 0x00,
  0x80, 0x60, 0x01, 0x80, 0x80, 0x01, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x06,
  0x10, 0x00, 0x04, 0x40, 0x00, 0x09, 0x80, 0x00, 0x12, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xE0, 0x00, 0x80,
  0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60,
  0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x0A, 0x00,
  0x0D, 0x00, 0x04, 0x80, 0x06, 0x60, 0x02, 0x10, 0x02, 0x08, 0x03, 0x04,
  0x01, 0x03, 0x01, 0x81, 0x80, 0x80, 0x40, 0xC0, 0x20, 0x40, 0x10, 0x40,
  0x0C, 0x60, 0x02, 0x20, 0x01, 0x30, 0x00, 0xB0, 0x00, 0x60, 0xFF, 0xFF,
  0xF0, 0xC2, 0x18, 0x43, 0x0C, 0x00, 0x7F, 0xC0, 0x07, 0x01, 0x80, 0x30,
  0x03, 0x01, 0x00, 0x06, 0x08, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x01, 0xFF, 0xF8, 0x3C, 0x00, 0x41, 0x80, 0x01, 0x0C, 0x00,
  0x04, 0x60, 0x00, 0x13, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x62, 0x00, 0x03, 0x8C, 0x00, 0x1A, 0x10, 0x01, 0xC8, 0x30,
  0x1C, 0x60, 0x7F, 0xC1, 0x80, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x0F, 0xE0, 0x08, 0xE0, 0xE0, 0x2C, 0x00, 0xC0, 0xE0,
  0x01, 0x07, 0x00, 0x06, 0x18, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x02, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x88,
  0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x98, 0x00,
  0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x10, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x80, 0x06, 0x09, 0x00, 0x30, 0x23, 0x03, 0x80, 0x87,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00,
  0x61, 0x80, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x64, 0x00, 0x03, 0x60,
  0x00, 0x1A, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x09, 0x00, 0x00, 0xCC, 0x00, 0x04, 0x20, 0x00, 0x41,
  0x80, 0x06, 0x04, 0x00, 0x60, 0x18, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x07, 0xF8, 0x40, 0x38, 0x18,
  0x80, 0xC0, 0x19, 0x03, 0x00, 0x1E, 0x0C, 0x00, 0x1C, 0x10, 0x00, 0x30,
  0x40, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x42, 0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00,
  0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x60, 0xC0, 0x01, 0xC0, 0x80, 0x07,
  0x01, 0x80, 0x1A, 0x01, 0x80, 0xE4, 0x00, 0xFF, 0x08, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0x81, 0x80, 0x38, 0x03, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x08,
  0x20, 0x00, 0x31, 0x80, 0x00, 0x4C, 0x00, 0x01, 0x20, 0x00, 0x05, 0x80,
  0x00, 0x14, 0x00, 0x00, 0x5F, 0xFF, 0xFF, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC2,
  0x01, 0xC0, 0xC4, 0x06, 0x00, 0xC8, 0x18, 0x00, 0xF0, 0x60, 0x00, 0xE0,
  0x80, 0x01, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x40, 0x00,
  0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06, 0x00, 0x0E,
  0x04, 0x00, 0x3C, 0x0C, 0x00, 0xD0, 0x0E, 0x07, 0x20, 0x07, 0xF8, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x70, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0xFF, 0x00, 0x43, 0x03, 0x80, 0x98, 0x01, 0x03, 0x60, 0x03,
  0x05, 0x80, 0x02, 0x0A, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x18,
  0xC0, 0x00, 0x21, 0x80, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06, 0x30, 0x00,
  0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x07,
  0x04, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x08, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x08, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x13, 0x40, 0x00,
  0x1C, 0x60, 0x00, 0x38, 0x30, 0x00, 0x30, 0x10, 0x00, 0x20, 0x18, 0x00,
  0x20, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0,
  0x04, 0x7E, 0x0F, 0xE0, 0x2C, 0x18, 0xC1, 0x81, 0xC0, 0x68, 0x04, 0x1C,
  0x01, 0x80, 0x20, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0x40, 0x0C, 0x20, 0x06,
  0x00, 0x41, 0x00, 0x30, 0x02, 0x08, 0x01, 0x00, 0x10, 0xC0, 0x08, 0x00,
  0x84, 0x00, 0x40, 0x04, 0x20, 0x02, 0x00, 0x61, 0x00, 0x30, 0x02, 0x08,
  0x01, 0x80, 0x10, 0xC0, 0x08, 0x00, 0x86, 0x00, 0x40, 0x04, 0x20, 0x02,
  0x00, 0x21, 0x00, 0x10, 0x03, 0x08, 0x01, 0x80, 0x10, 0x40, 0x08, 0x00,
  0x86, 0x00, 0x40, 0x04, 0x20, 0x02, 0x00, 0x21, 0x00, 0x10, 0x03, 0x08,
  0x00, 0x80, 0x18, 0x40, 0x0C, 0x00, 0x86, 0x00, 0x40, 0x04, 0x00, 0x04,
  0x1F, 0xE0, 0x08, 0x60, 0x70, 0x33, 0x00, 0x20, 0x6C, 0x00, 0x60, 0xB0,
  0x00, 0x41, 0x40, 0x00, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00,
  0xC2, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C,
  0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x31, 0x80,
  0x00, 0x60, 0x00, 0x7F, 0x80, 0x07, 0x03, 0x80, 0x30, 0x03, 0x01, 0x80,
  0x04, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x23, 0x00, 0x00, 0xC8, 0x00, 0x01,
  0x60, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x21,
  0x00, 0x01, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x1F,
  0xE0, 0x00, 0x02, 0x1F, 0xE0, 0x04, 0x60, 0x70, 0x0B, 0x00, 0x20, 0x3C,
  0x00, 0x20, 0x70, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00,
  0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00,
  0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00, 0x41,
  0x00, 0x01, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x18, 0x16, 0x00, 0x60, 0x27,
  0x03, 0x80, 0x43, 0xFC, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x08, 0x1C, 0x0C, 0x41, 0x80, 0x32, 0x18, 0x00, 0xF1, 0x80, 0x03, 0x88,
  0x00, 0x18, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00,
  0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00, 0x11,
  0x00, 0x00, 0x88, 0x00, 0x0C, 0x60, 0x00, 0xE1, 0x00, 0x0F, 0x0C, 0x00,
  0xD0, 0x30, 0x1C, 0x80, 0x7F, 0x84, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x08, 0x0F, 0xF0,
  0x87, 0x80, 0x08, 0xC0, 0x01, 0x90, 0x00, 0x1A, 0x00, 0x01, 0x40, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x01, 0xC0, 0x60, 0x01, 0x83, 0x00,
  0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0x46, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x30, 0x00, 0x04, 0x40, 0x00, 0x11,
  0x00, 0x00, 0xC6, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x18, 0x03, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x0C, 0x40, 0x00,
  0x21, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x08, 0x80, 0x00, 0x62,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00,
  0x01, 0x10, 0x00, 0x0C, 0x40, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x02,
  0x30, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x06, 0x20,
  0x00, 0x10, 0x80, 0x00, 0xC3, 0x00, 0x07, 0x04, 0x00, 0x34, 0x18, 0x01,
  0xB0, 0x30, 0x1C, 0x80, 0x7F, 0xC2, 0x00, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x10, 0x00, 0x60, 0x10, 0x00,
  0x40, 0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x08, 0x01, 0x00, 0x08, 0x03,
  0x00, 0x0C, 0x02, 0x00, 0x04, 0x06, 0x00, 0x04, 0x04, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x03, 0x20,
  0x00, 0x03, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x50, 0x07,
  0x00, 0x68, 0x02, 0x80, 0x24, 0x01, 0x40, 0x12, 0x01, 0xA0, 0x19, 0x00,
  0x98, 0x08, 0xC0, 0xCC, 0x0C, 0x60, 0x46, 0x04, 0x30, 0x23, 0x02, 0x18,
  0x20, 0x83, 0x0C, 0x10, 0x41, 0x06, 0x18, 0x21, 0x83, 0x08, 0x10, 0x80,
  0x8C, 0x08, 0x40, 0x44, 0x04, 0x60, 0x22, 0x02, 0x20, 0x12, 0x01, 0x30,
  0x09, 0x00, 0x90, 0x05, 0x80, 0x48, 0x02, 0x80, 0x3C, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x20, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x04, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x20, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x01, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0x00, 0x40, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x20, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x20, 0x00, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x11, 0x83, 0x00, 0x04, 0xC0, 0x60, 0x03, 0x60, 0x0C, 0x00, 0x90, 0x01,
  0x80, 0x6C, 0x00, 0x38, 0x33, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_ThinItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 35, 29, 10, -35 },
  { 36, 9, 10, 29, 12, -37 },
  { 48, 28, 35, 29, 1, -35 },
  { 171, 24, 45, 29, 3, -40 },
  { 306, 24, 36, 29, 3, -35 },
  { 414, 24, 35, 29, 2, -35 },
  { 519, 3, 10, 29, 14, -37 },
  { 523, 14, 50, 29, 9, -39 },
  { 611, 14, 50, 29, 5, -39 },
  { 699, 20, 19, 29, 7, -35 },
  { 747, 23, 26, 29, 3, -29 },
  { 822, 5, 10, 29, 6, -4 },
  { 829, 17, 2, 29, 6, -17 },
  { 834, 3, 3, 29, 11, -3 },
  { 836, 22, 38, 29, 4, -35 },
  { 941, 22, 35, 29, 4, -35 },
  { 1038, 12, 35, 29, 8, -35 },
  { 1091, 23, 35, 29, 1, -35 },
  { 1192, 24, 35, 29, 1, -35 },
  { 1297, 24, 35, 29, 1, -35 },
  { 1402, 24, 35, 29, 4, -35 },
  { 1507, 21, 36, 29, 3, -35 },
  { 1602, 22, 35, 29, 6, -35 },
  { 1699, 24, 35, 29, 3, -35 },
  { 1804, 21, 35, 29, 5, -35 },
  { 1896, 6, 24, 29, 13, -24 },
  { 1914, 9, 30, 29, 10, -24 },
  { 1948, 22, 20, 29, 4, -26 },
  { 2003, 23, 11, 29, 3, -21 },
  { 2035, 22, 20, 29, 3, -26 },
  { 2090, 18, 35, 29, 8, -35 },
  { 2169, 28, 35, 29, 1, -35 },
  { 2292, 24, 35, 29, 0, -35 },
  { 2397, 23, 35, 29, 3, -35 },
  { 2498, 24, 36, 29, 3, -35 },
  { 2606, 25, 35, 29, 2, -35 },
  { 2716, 25, 35, 29, 3, -35 },
  { 2826, 25, 35, 29, 3, -35 },
  { 2936, 24, 36, 29, 3, -35 },
  { 3044, 26, 35, 29, 2, -35 },
  { 3158, 25, 35, 29, 2, -35 },
  { 3268, 25, 36, 29, 2, -35 },
  { 3381, 27, 35, 29, 3, -35 },
  { 3500, 19, 35, 29, 3, -35 },
  { 3584, 26, 35, 29, 2, -35 },
  { 3698, 26, 35, 29, 2, -35 },
  { 3812, 24, 35, 29, 3, -35 },
  { 3917, 25, 35, 29, 3, -35 },
  { 4027, 24, 41, 29, 3, -35 },
  { 4150, 24, 35, 29, 3, -35 },
  { 4255, 24, 35, 29, 3, -35 },
  { 4360, 24, 35, 29, 6, -35 },
  { 4465, 25, 35, 29, 3, -35 },
  { 4575, 23, 35, 29, 6, -35 },
  { 4676, 25, 35, 29, 5, -35 },
  { 4786, 28, 35, 29, 1, -35 },
  { 4909, 23, 35, 29, 6, -35 },
  { 5010, 26, 35, 29, 1, -35 },
  { 5124, 14, 47, 29, 8, -40 },
  { 5207, 9, 38, 29, 10, -35 },
  { 5250, 14, 47, 29, 7, -40 },
  { 5333, 17, 19, 29, 6, -35 },
  { 5374, 20, 1, 29, 2, 0 },
  { 5377, 5, 6, 29, 15, -36 },
  { 5381, 22, 27, 29, 3, -26 },
  { 5456, 22, 37, 29, 3, -37 },
  { 5558, 21, 26, 29, 4, -26 },
  { 5627, 23, 37, 29, 4, -37 },
  { 5734, 22, 26, 29, 3, -26 },
  { 5806, 23, 37, 29, 7, -37 },
  { 5913, 23, 36, 29, 2, -26 },
  { 6017, 23, 37, 29, 2, -37 },
  { 6124, 20, 35, 29, 3, -35 },
  { 6212, 22, 45, 29, 0, -35 },
  { 6336, 24, 37, 29, 3, -37 },
  { 6447, 20, 37, 29, 3, -37 },
  { 6540, 29, 26, 29, -1, -26 },
  { 6635, 23, 26, 29, 2, -26 },
  { 6710, 22, 26, 29, 3, -26 },
  { 6782, 23, 36, 29, 1, -26 },
  { 6886, 21, 36, 29, 4, -26 },
  { 6981, 20, 26, 29, 7, -26 },
  { 7046, 22, 26, 29, 3, -26 },
  { 7118, 18, 34, 29, 6, -33 },
  { 7195, 22, 26, 29, 4, -26 },
  { 7267, 24, 26, 29, 4, -26 },
  { 7345, 25, 26, 29, 4, -26 },
  { 7427, 26, 26, 29, 1, -26 },
  { 7512, 30, 36, 29, -1, -26 },
  { 7647, 25, 26, 29, 1, -26 },
  { 7729, 18, 49, 29, 8, -38 },
  { 7840, 8, 41, 29, 10, -35 },
  { 7881, 19, 49, 29, 4, -38 },
  { 7998, 26, 8, 29, 1, -19 },
};

const GFXfont RobotoMono_ThinItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic49pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_THINITALIC49PT7B_H_
