#ifndef _ROBOTOMONO_THINITALIC54PT7B_H_
#define _ROBOTOMONO_THINITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x03, 0x00, 0x60, 0xB0, 0x58, 0x2C,
  0x34, 0x1A, 0x0D, 0x05, 0x82, 0xC1, 0x41, 0xA0, 0xC0, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x01, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x40, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x03, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFD, 0xE0, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x40,
  0xC0, 0x00, 0x30, 0x40, 0x00, 0x18, 0x20, 0x00, 0x04, 0x30, 0x00, 0x02,
  0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x60, 0x00, 0x02, 0x20,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x70,
  0x03, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x08, 0x00, 0x18, 0x02, 0x00, 0xC6, 0x00, 0x80, 0x21, 0x00, 0x20,
  0x18, 0x40, 0x08, 0x0C, 0x30, 0x06, 0x02, 0x0C, 0x01, 0x81, 0x83, 0x00,
  0x40, 0xC0, 0xC0, 0x30, 0x20, 0x30, 0x08, 0x18, 0x04, 0x06, 0x0C, 0x01,
  0x83, 0x06, 0x00, 0x3F, 0x81, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x03, 0xF0, 0x00, 0x81, 0x86, 0x00, 0x60, 0xC0, 0xC0, 0x30, 0x60, 0x30,
  0x08, 0x10, 0x04, 0x06, 0x0C, 0x01, 0x03, 0x03, 0x00, 0x40, 0x80, 0x80,
  0x10, 0x60, 0x20, 0x04, 0x30, 0x08, 0x03, 0x18, 0x06, 0x00, 0xC4, 0x01,
  0x80, 0x23, 0x00, 0x60, 0x18, 0x40, 0x08, 0x04, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x20, 0x02, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x60, 0x01,
  0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x10, 0x03, 0x00, 0x04, 0x01, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x08, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0xC0, 0x0C,
  0x60, 0x18, 0x03, 0x30, 0x02, 0x00, 0x88, 0x00, 0xC0, 0x26, 0x00, 0x18,
  0x19, 0x00, 0x02, 0x04, 0xC0, 0x00, 0xC3, 0x30, 0x00, 0x10, 0x88, 0x00,
  0x06, 0x62, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x04,
  0x00, 0x03, 0xC1, 0x80, 0x01, 0x90, 0x30, 0x01, 0x86, 0x07, 0x01, 0xC0,
  0xC0, 0x7F, 0xC0, 0x18, 0x01, 0x00, 0x00, 0x24, 0xB6, 0xD2, 0xDA, 0x00,
  0x00, 0x01, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x78, 0x0C, 0x0F, 0x7C, 0x21, 0xF0,
  0x3C, 0xBE, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0x60, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x10, 0x18, 0x00, 0x60, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x46, 0x31, 0x08, 0xC4, 0x66, 0x20, 0xFF,
  0xFF, 0xE0, 0x67, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x18, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x04,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xE2, 0x00, 0x00, 0xF3, 0x00, 0x00, 0xD9,
  0x80, 0x00, 0xCC, 0x80, 0x00, 0xC6, 0x40, 0x00, 0x83, 0x20, 0x01, 0x81,
  0x30, 0x01, 0x80, 0x98, 0x01, 0x80, 0x48, 0x01, 0x80, 0x64, 0x01, 0x80,
  0x32, 0x01, 0x80, 0x1B, 0x01, 0x80, 0x09, 0x83, 0x00, 0x04, 0xC3, 0x00,
  0x02, 0x63, 0x00, 0x03, 0x23, 0x00, 0x01, 0x13, 0x00, 0x00, 0x8B, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x43, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x40,
  0x00, 0x30, 0x20, 0x00, 0x10, 0x18, 0x00, 0x18, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x38, 0x07, 0xC0, 0xE6, 0x1C, 0x27, 0x81, 0x60, 0x0A, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x03, 0x80,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x10, 0x18, 0x00, 0x0C, 0x08, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0x80, 0x70, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x06, 0x18, 0x00, 0x03, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10,
  0x08, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x10, 0x04, 0x00, 0x02, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x87, 0xF0, 0x00,
  0x2F, 0x07, 0x00, 0x1E, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x18, 0x00,
  0x18, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x3F, 0xC0, 0x10, 0xF0, 0xF0, 0x13, 0x80, 0x38, 0x36, 0x00, 0x0C,
  0x2C, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x02,
  0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x20, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x18, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10,
  0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x10, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x60, 0x10, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x38, 0x03,
  0x80, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x00, 0x86, 0x00, 0x01, 0x88,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x40, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x76, 0x00, 0x01, 0xC4, 0x00, 0x06, 0x8C, 0x00, 0x1B, 0x0C, 0x00, 0x66,
  0x0C, 0x07, 0x08, 0x0F, 0xFC, 0x30, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x06, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xE1, 0xC0, 0x00, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x18, 0x06, 0x03,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x08,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x38, 0x06, 0x0C, 0x00, 0x63,
  0x00, 0x04, 0xC0, 0x00, 0xD0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x70, 0x04, 0x0C, 0x03,
  0xF8, 0x08, 0x18, 0x1C, 0x18, 0x10, 0x60, 0x60, 0x10, 0x20, 0x80, 0x80,
  0x60, 0x43, 0x03, 0x00, 0x80, 0x84, 0x0C, 0x01, 0x01, 0x18, 0x10, 0x06,
  0x02, 0x30, 0x60, 0x0C, 0x04, 0x40, 0xC0, 0x10, 0x09, 0x81, 0x00, 0x20,
  0x33, 0x06, 0x00, 0xC0, 0x64, 0x0C, 0x01, 0x00, 0x88, 0x10, 0x02, 0x01,
  0x30, 0x20, 0x0C, 0x06, 0x60, 0x40, 0x18, 0x0C, 0xC1, 0x80, 0x60, 0x11,
  0x83, 0x00, 0xC0, 0x63, 0x06, 0x03, 0x80, 0x86, 0x0C, 0x0D, 0x03, 0x0C,
  0x08, 0x12, 0x04, 0x18, 0x18, 0xC6, 0x38, 0x10, 0x1F, 0x07, 0xC0, 0x20,
  0x18, 0x02, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x01, 0x04,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x18, 0x00, 0x04,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00, 0x60, 0x08, 0x00,
  0x10, 0x02, 0x00, 0x0C, 0x00, 0x80, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x03, 0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x10, 0x06, 0x00,
  0x04, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x08,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x08,
  0x20, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x03,
  0xFF, 0xF0, 0x00, 0xC0, 0x07, 0x00, 0x20, 0x00, 0x70, 0x08, 0x00, 0x04,
  0x02, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x10, 0x00,
  0x03, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60,
  0x20, 0x00, 0x30, 0x08, 0x00, 0x38, 0x06, 0x00, 0x78, 0x01, 0xFF, 0xFE,
  0x00, 0x40, 0x00, 0xE0, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x10, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x03, 0x80, 0x80, 0x0F, 0x80, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x18, 0x02, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x08, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x10, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x08, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x10, 0x01,
  0xC0, 0x01, 0x00, 0x07, 0x00, 0x30, 0x00, 0x10, 0x03, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x10, 0x20, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0xE0, 0x04, 0x00, 0x1C, 0x00,
  0x40, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x01, 0xFF, 0xE6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x60, 0x00, 0x02,
  0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x80, 0x0C, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x06, 0x07, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x81, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x06, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x02,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0x10, 0x01, 0x80, 0x00, 0x40, 0x0C,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x21, 0xC0, 0x00, 0x01, 0x8D, 0x00, 0x00, 0x06, 0x66, 0x00, 0x00, 0x16,
  0x0C, 0x00, 0x00, 0x70, 0x10, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x00, 0x80,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x04, 0x00, 0x40, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x40, 0x10, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1E, 0x05, 0x00, 0x00, 0xF0, 0x2C, 0x00, 0x0D, 0x01, 0x60,
  0x00, 0x48, 0x19, 0x00, 0x06, 0x40, 0xC8, 0x00, 0x26, 0x06, 0x40, 0x03,
  0x30, 0x23, 0x00, 0x31, 0x81, 0x18, 0x01, 0x88, 0x08, 0x40, 0x18, 0x40,
  0xC2, 0x00, 0x82, 0x06, 0x10, 0x0C, 0x30, 0x30, 0xC0, 0x41, 0x81, 0x06,
  0x06, 0x0C, 0x08, 0x10, 0x60, 0x40, 0x40, 0x82, 0x02, 0x06, 0x04, 0x30,
  0x10, 0x30, 0x31, 0x01, 0x81, 0x01, 0x98, 0x0C, 0x08, 0x04, 0x80, 0x40,
  0x40, 0x2C, 0x02, 0x02, 0x01, 0xC0, 0x10, 0x30, 0x0C, 0x00, 0x81, 0x80,
  0x60, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x80, 0xA0, 0x00, 0x04, 0x05, 0x00, 0x00,
  0x20, 0x2C, 0x00, 0x01, 0x03, 0x20, 0x00, 0x18, 0x19, 0x00, 0x00, 0xC0,
  0x8C, 0x00, 0x04, 0x04, 0x20, 0x00, 0x20, 0x21, 0x00, 0x01, 0x01, 0x04,
  0x00, 0x08, 0x18, 0x20, 0x00, 0xC0, 0xC1, 0x80, 0x06, 0x04, 0x04, 0x00,
  0x20, 0x20, 0x20, 0x01, 0x01, 0x01, 0x80, 0x08, 0x08, 0x04, 0x00, 0x40,
  0xC0, 0x20, 0x06, 0x06, 0x00, 0x80, 0x30, 0x20, 0x04, 0x01, 0x01, 0x00,
  0x30, 0x08, 0x08, 0x00, 0x80, 0x40, 0x40, 0x04, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x30, 0x00, 0x81, 0x81, 0x00, 0x06, 0x08, 0x08, 0x00, 0x10, 0x40,
  0x40, 0x00, 0x82, 0x02, 0x00, 0x06, 0x30, 0x30, 0x00, 0x11, 0x81, 0x00,
  0x00, 0x88, 0x08, 0x00, 0x06, 0x40, 0x40, 0x00, 0x12, 0x02, 0x00, 0x00,
  0xD0, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x08, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x60,
  0x30, 0x00, 0x08, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x08, 0x08, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0x40, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x70, 0x01, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x30, 0x08, 0x00, 0x06, 0x00, 0x80, 0x01, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xC0,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x30, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x13, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00,
  0x1C, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x08, 0x04, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x08, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x08, 0x08, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80, 0x10, 0x00,
  0x30, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x04, 0x03,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x00, 0x80, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x19, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x20, 0x00, 0x0C,
  0x08, 0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x40, 0x01, 0x80, 0x10,
  0x00, 0x40, 0x04, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x60, 0x06, 0x00,
  0x08, 0x01, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x20, 0x18,
  0x00, 0x0C, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10,
  0x60, 0x00, 0x04, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x90, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x38, 0x00, 0xC0, 0x02, 0x80, 0x0E, 0x00, 0x68, 0x00, 0xE0,
  0x04, 0x80, 0x1E, 0x00, 0x48, 0x01, 0xE0, 0x0C, 0x80, 0x16, 0x00, 0x88,
  0x03, 0x60, 0x08, 0x80, 0x26, 0x00, 0x88, 0x02, 0x60, 0x18, 0x80, 0x66,
  0x01, 0x08, 0x04, 0x60, 0x10, 0x80, 0x46, 0x03, 0x08, 0x0C, 0x20, 0x20,
  0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x60, 0x81, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x0C, 0x08, 0x30, 0x20, 0x80, 0x82, 0x02, 0x08,
  0x08, 0x60, 0x21, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x8C,
  0x02, 0x30, 0x08, 0xC0, 0x23, 0x00, 0x88, 0x02, 0x20, 0x09, 0x80, 0x22,
  0x00, 0x98, 0x03, 0x60, 0x09, 0x00, 0x34, 0x00, 0xB0, 0x03, 0x40, 0x0B,
  0x00, 0x3C, 0x00, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0x40, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x60, 0x18, 0x00, 0x30, 0x02, 0x00, 0x08,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x80, 0x01, 0x00,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x08, 0x08, 0x00, 0x02, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xFF, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18,
  0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80,
  0x60, 0x18, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06,
  0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40,
  0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x03, 0x40,
  0x00, 0x90, 0x00, 0x64, 0x00, 0x11, 0x80, 0x0C, 0x60, 0x06, 0x08, 0x01,
  0x02, 0x00, 0xC0, 0xC0, 0x20, 0x30, 0x18, 0x04, 0x04, 0x01, 0x03, 0x00,
  0x41, 0x80, 0x18, 0x40, 0x06, 0x30, 0x00, 0x88, 0x00, 0x26, 0x00, 0x0D,
  0x00, 0x03, 0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xFC, 0xC1, 0x82, 0x0C, 0x10,
  0x60, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x78, 0x01, 0xC0, 0x0C, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x07,
  0x00, 0x06, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x04, 0x60, 0x00, 0x04, 0x40,
  0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x68, 0x40, 0x00, 0xC8, 0x60, 0x03, 0x88, 0x38,
  0x0F, 0x08, 0x0F, 0xF8, 0x08, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x0F, 0xC0, 0x04,
  0x3C, 0x70, 0x04, 0xE0, 0x18, 0x0D, 0x80, 0x0C, 0x0F, 0x00, 0x06, 0x0E,
  0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30, 0x50,
  0x00, 0x60, 0xD8, 0x00, 0xC0, 0xCE, 0x03, 0x80, 0xC3, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xF1, 0xE0, 0x07, 0x00, 0xE0, 0x18,
  0x00, 0x60, 0x60, 0x00, 0x41, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00,
  0x01, 0x30, 0x00, 0x02, 0x40, 0x00, 0x05, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x98, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x18, 0x60,
  0x00, 0x20, 0x40, 0x00, 0xC0, 0x60, 0x07, 0x00, 0x60, 0x38, 0x00, 0x7F,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x3F, 0x83, 0x00,
  0x3C, 0x78, 0xC0, 0x38, 0x03, 0x30, 0x1C, 0x00, 0x68, 0x04, 0x00, 0x0A,
  0x03, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x01, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x70, 0x08, 0x00, 0x3C, 0x03, 0x00, 0x3A, 0x00,
  0x70, 0x38, 0x80, 0x0F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0x20, 0x30, 0x00, 0x18, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x18,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x37,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x00, 0xE0,
  0x38, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xF8, 0x20, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x40, 0x0F, 0x1E, 0x30, 0x06, 0x00, 0xCC, 0x07, 0x00, 0x1A, 0x01,
  0x00, 0x02, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x10, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x60, 0x00,
  0x04, 0x10, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x18, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x02, 0x00, 0x0F, 0x00, 0xC0,
  0x0E, 0x80, 0x1C, 0x0E, 0x20, 0x03, 0xFF, 0x08, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x07, 0xF0, 0x0C, 0x1E, 0x38, 0x0C, 0x70, 0x0C, 0x08, 0xC0, 0x06,
  0x09, 0x80, 0x02, 0x0B, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x1C, 0x00, 0x01,
  0x18, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10, 0x00, 0x03,
  0x10, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02,
  0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x04,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C,
  0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x20, 0x00, 0x18, 0x30, 0x00, 0x38, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x04, 0x00, 0x70, 0x02, 0x00, 0x70, 0x01, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0xE0, 0x00, 0x40, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x11, 0xC0,
  0x00, 0x09, 0xE0, 0x00, 0x0D, 0x98, 0x00, 0x07, 0x86, 0x00, 0x03, 0x03,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x10, 0x00, 0x40, 0x08, 0x00, 0x30, 0x04,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x06, 0x3F, 0x01,
  0xF8, 0x09, 0xE3, 0x0F, 0x38, 0x16, 0x03, 0x30, 0x18, 0x38, 0x02, 0xC0,
  0x10, 0x60, 0x07, 0x00, 0x20, 0xC0, 0x0C, 0x00, 0x43, 0x00, 0x18, 0x00,
  0x86, 0x00, 0x20, 0x01, 0x08, 0x00, 0x40, 0x02, 0x10, 0x00, 0x80, 0x04,
  0x20, 0x03, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x42,
  0x00, 0x10, 0x00, 0x84, 0x00, 0x20, 0x01, 0x08, 0x00, 0x40, 0x02, 0x10,
  0x01, 0x80, 0x0C, 0x60, 0x03, 0x00, 0x18, 0xC0, 0x04, 0x00, 0x21, 0x00,
  0x08, 0x00, 0x42, 0x00, 0x10, 0x00, 0x84, 0x00, 0x20, 0x01, 0x08, 0x00,
  0xC0, 0x06, 0x30, 0x01, 0x80, 0x08, 0x60, 0x02, 0x00, 0x10, 0x80, 0x04,
  0x00, 0x21, 0x00, 0x08, 0x00, 0x42, 0x00, 0x10, 0x01, 0x8C, 0x00, 0x60,
  0x03, 0x00, 0x04, 0x07, 0xF0, 0x0C, 0x1E, 0x38, 0x0C, 0x70, 0x0C, 0x08,
  0xC0, 0x06, 0x09, 0x80, 0x02, 0x0A, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x1C,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10,
  0x00, 0x03, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40,
  0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x78, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x20, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x00, 0x7F, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x03, 0xF0, 0x00, 0x43, 0xC7, 0x00, 0x33, 0x80,
  0x60, 0x0D, 0x80, 0x0C, 0x02, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x30,
  0x00, 0x08, 0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x10, 0x18, 0x00, 0x0C,
  0x07, 0x00, 0x06, 0x03, 0x60, 0x07, 0x00, 0xCE, 0x03, 0x80, 0x20, 0xFF,
  0x80, 0x08, 0x06, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x81, 0x00, 0xF1, 0xE3, 0x01, 0x80, 0x33, 0x07, 0x00,
  0x1A, 0x06, 0x00, 0x0A, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x10, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x60, 0x00, 0x70, 0x20, 0x00, 0xF0, 0x30, 0x03, 0xA0, 0x1C, 0x0E,
  0x20, 0x0F, 0xF8, 0x20, 0x00, 0x80, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x06, 0x01, 0xFE, 0x08, 0x1F, 0x08, 0x10, 0xE0, 0x00, 0x23, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xF9, 0xF0, 0x03, 0x80, 0x1C, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x30, 0x30, 0x00, 0x60, 0x1C, 0x03,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x10, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x20, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0x40, 0x00, 0x30, 0x40, 0x00, 0x50, 0x60, 0x00, 0xD0, 0x30, 0x03,
  0xB0, 0x18, 0x0E, 0x30, 0x0F, 0xF8, 0x20, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x01,
  0x80, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x2C, 0x00, 0xE0, 0x06, 0xC0, 0x0A, 0x00, 0x6C, 0x01,
  0xA0, 0x04, 0xC0, 0x12, 0x00, 0xCC, 0x03, 0x20, 0x08, 0x40, 0x32, 0x01,
  0x84, 0x02, 0x20, 0x18, 0x40, 0x62, 0x01, 0x04, 0x04, 0x30, 0x30, 0x40,
  0xC3, 0x02, 0x04, 0x08, 0x30, 0x60, 0x40, 0x83, 0x06, 0x04, 0x18, 0x30,
  0x40, 0x41, 0x01, 0x0C, 0x04, 0x30, 0x10, 0x80, 0x62, 0x01, 0x18, 0x06,
  0x20, 0x11, 0x80, 0x66, 0x01, 0x10, 0x06, 0x40, 0x13, 0x00, 0x6C, 0x01,
  0x20, 0x06, 0x80, 0x12, 0x00, 0x78, 0x01, 0x60, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x28, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x03, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x30, 0x00, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x60, 0x01, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x08, 0xE0, 0xC0, 0x00, 0xC4, 0x03,
  0x00, 0x06, 0x60, 0x0C, 0x00, 0x66, 0x00, 0x30, 0x03, 0x20, 0x00, 0xC0,
  0x31, 0x00, 0x03, 0x87, 0x18, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoMono_ThinItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 9, 38, 32, 11, -38 },
  { 44, 9, 11, 32, 14, -41 },
  { 57, 31, 38, 32, 1, -38 },
  { 205, 25, 49, 32, 4, -44 },
  { 359, 26, 40, 32, 3, -39 },
  { 489, 26, 40, 32, 3, -39 },
  { 619, 3, 11, 32, 16, -41 },
  { 624, 17, 55, 32, 9, -43 },
  { 741, 16, 55, 32, 5, -43 },
  { 851, 22, 21, 32, 8, -38 },
  { 909, 26, 28, 32, 3, -32 },
  { 1000, 5, 11, 32, 7, -4 },
  { 1007, 19, 1, 32, 6, -18 },
  { 1010, 4, 3, 32, 12, -3 },
  { 1012, 24, 41, 32, 5, -38 },
  { 1135, 25, 40, 32, 4, -39 },
  { 1260, 13, 38, 32, 9, -38 },
  { 1322, 25, 39, 32, 1, -39 },
  { 1444, 26, 40, 32, 1, -39 },
  { 1574, 27, 38, 32, 1, -38 },
  { 1703, 26, 39, 32, 5, -38 },
  { 1830, 24, 40, 32, 3, -39 },
  { 1950, 24, 38, 32, 7, -38 },
  { 2064, 27, 40, 32, 3, -39 },
  { 2199, 23, 40, 32, 5, -39 },
  { 2314, 7, 26, 32, 14, -26 },
  { 2337, 10, 33, 32, 11, -26 },
  { 2379, 24, 21, 32, 4, -28 },
  { 2442, 25, 13, 32, 4, -24 },
  { 2483, 24, 21, 32, 3, -28 },
  { 2546, 19, 39, 32, 9, -39 },
  { 2639, 31, 39, 32, 1, -39 },
  { 2791, 26, 38, 32, 0, -38 },
  { 2915, 26, 38, 32, 3, -38 },
  { 3039, 27, 40, 32, 3, -39 },
  { 3174, 28, 38, 32, 2, -38 },
  { 3307, 28, 38, 32, 3, -38 },
  { 3440, 28, 38, 32, 3, -38 },
  { 3573, 27, 40, 32, 3, -39 },
  { 3708, 29, 38, 32, 2, -38 },
  { 3846, 27, 38, 32, 3, -38 },
  { 3975, 28, 39, 32, 2, -38 },
  { 4112, 30, 38, 32, 3, -38 },
  { 4255, 22, 38, 32, 3, -38 },
  { 4360, 29, 38, 32, 2, -38 },
  { 4498, 29, 38, 32, 2, -38 },
  { 4636, 26, 40, 32, 3, -39 },
  { 4766, 28, 38, 32, 3, -38 },
  { 4899, 27, 46, 32, 3, -39 },
  { 5055, 27, 38, 32, 3, -38 },
  { 5184, 27, 40, 32, 3, -39 },
  { 5319, 26, 38, 32, 7, -38 },
  { 5443, 27, 39, 32, 4, -38 },
  { 5575, 26, 38, 32, 6, -38 },
  { 5699, 28, 38, 32, 6, -38 },
  { 5832, 31, 38, 32, 1, -38 },
  { 5980, 26, 38, 32, 6, -38 },
  { 6104, 28, 38, 32, 1, -38 },
  { 6237, 16, 52, 32, 8, -44 },
  { 6341, 10, 41, 32, 11, -38 },
  { 6393, 16, 52, 32, 8, -44 },
  { 6497, 18, 21, 32, 7, -38 },
  { 6545, 22, 1, 32, 2, 0 },
  { 6548, 6, 7, 32, 16, -40 },
  { 6554, 24, 30, 32, 3, -29 },
  { 6644, 24, 42, 32, 3, -41 },
  { 6770, 23, 30, 32, 4, -29 },
  { 6857, 26, 42, 32, 4, -41 },
  { 6994, 25, 30, 32, 3, -29 },
  { 7088, 26, 41, 32, 7, -41 },
  { 7222, 26, 41, 32, 2, -29 },
  { 7356, 24, 41, 32, 3, -41 },
  { 7479, 22, 39, 32, 3, -39 },
  { 7587, 25, 51, 32, 0, -39 },
  { 7747, 25, 41, 32, 4, -41 },
  { 7876, 22, 41, 32, 3, -41 },
  { 7989, 31, 29, 32, -1, -29 },
  { 8102, 24, 29, 32, 3, -29 },
  { 8189, 25, 30, 32, 3, -29 },
  { 8283, 26, 40, 32, 1, -29 },
  { 8413, 24, 40, 32, 4, -29 },
  { 8533, 23, 29, 32, 7, -29 },
  { 8617, 24, 30, 32, 4, -29 },
  { 8707, 20, 37, 32, 7, -36 },
  { 8800, 24, 30, 32, 4, -29 },
  { 8890, 25, 29, 32, 5, -29 },
  { 8981, 28, 29, 32, 4, -29 },
  { 9083, 29, 29, 32, 1, -29 },
  { 9189, 32, 41, 32, -1, -29 },
  { 9353, 28, 29, 32, 1, -29 },
  { 9455, 21, 54, 32, 8, -42 },
  { 9597, 9, 45, 32, 11, -38 },
  { 9648, 20, 54, 32, 5, -42 },
  { 9783, 29, 8, 32, 1, -20 },
};

const GFXfont RobotoMono_ThinItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic54pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_THINITALIC54PT7B_H_
