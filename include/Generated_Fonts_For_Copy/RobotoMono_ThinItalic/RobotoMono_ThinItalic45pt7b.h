#ifndef _ROBOTOMONO_THINITALIC45PT7B_H_
#define _ROBOTOMONO_THINITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x40,
  0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x70, 0x21, 0x90, 0x88, 0x4C, 0x24, 0x12, 0x19,
  0x08, 0x84, 0xC2, 0x00, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x20, 0x10, 0x00, 0x08, 0x04, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x40, 0x20, 0x00, 0x30, 0x18, 0x07, 0xFF, 0xFF,
  0xF0, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x10,
  0x08, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x60, 0x20, 0x00, 0x10, 0x08, 0x00, 0x04, 0x06, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x80, 0x40, 0x0F, 0xFF, 0xFF, 0xC0, 0x10, 0x08, 0x00, 0x04, 0x02,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x18,
  0x0C, 0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x3F, 0xE0, 0x03, 0x01, 0x80, 0x60, 0x06, 0x02, 0x00, 0x10,
  0x20, 0x00, 0xC3, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x4C, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x01, 0x88, 0x00, 0x08,
  0x40, 0x00, 0xC3, 0x00, 0x04, 0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x86, 0x00, 0x08, 0x10, 0x00, 0x80,
  0x80, 0x44, 0x04, 0x03, 0x60, 0x20, 0x32, 0x01, 0x01, 0x10, 0x08, 0x10,
  0x80, 0x41, 0x84, 0x06, 0x18, 0x20, 0x20, 0x81, 0x03, 0x08, 0x04, 0x30,
  0xC0, 0x3F, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0xFC, 0x03, 0x0C, 0x30, 0x10, 0xC0, 0x81, 0x04,
  0x04, 0x18, 0x60, 0x20, 0x82, 0x01, 0x08, 0x10, 0x08, 0xC0, 0x80, 0x4C,
  0x04, 0x02, 0x40, 0x20, 0x34, 0x01, 0x01, 0x00, 0x08, 0x18, 0x00, 0x61,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0x82, 0x00, 0x08, 0x0C, 0x00,
  0x60, 0x10, 0x01, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x80,
  0x20, 0x02, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x43, 0x00,
  0x01, 0x90, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x02,
  0x20, 0x00, 0x30, 0xC0, 0x00, 0x81, 0x00, 0x44, 0x02, 0x03, 0x20, 0x0C,
  0x0C, 0x80, 0x10, 0x24, 0x00, 0x21, 0x90, 0x00, 0x84, 0x40, 0x01, 0x31,
  0x00, 0x06, 0x84, 0x00, 0x0E, 0x10, 0x00, 0x30, 0x60, 0x01, 0xE0, 0x80,
  0x0C, 0x81, 0x80, 0xC1, 0x03, 0xFC, 0x06, 0x24, 0xB4, 0x92, 0xC0, 0x00,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x38, 0x10, 0x39, 0xE2, 0x3C, 0x07, 0x7C, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0x90, 0x00, 0x21, 0x00, 0x08, 0x30, 0x02, 0x02, 0x00, 0x80,
  0x20, 0x20, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x0F,
  0xFF, 0xFF, 0x80, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x11, 0x11, 0x22, 0x64, 0x88,
  0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x06,
  0x00, 0xC0, 0x08, 0x04, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00, 0x08, 0x20,
  0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x03, 0x48, 0x00, 0x32,
  0x40, 0x03, 0x12, 0x00, 0x30, 0x90, 0x03, 0x0D, 0x80, 0x20, 0x48, 0x02,
  0x02, 0x40, 0x60, 0x12, 0x06, 0x00, 0x90, 0x60, 0x04, 0x86, 0x00, 0x6C,
  0x60, 0x02, 0x44, 0x00, 0x12, 0x40, 0x00, 0x9C, 0x00, 0x08, 0xC0, 0x00,
  0x42, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80, 0x02, 0x02, 0x00, 0x30, 0x18,
  0x03, 0x00, 0x60, 0x70, 0x01, 0xFE, 0x00, 0x00, 0x20, 0x3C, 0x1C, 0x8E,
  0x16, 0x07, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x0E, 0x07, 0x00, 0xC0, 0x0C, 0x0C,
  0x00, 0x20, 0x40, 0x01, 0x86, 0x00, 0x04, 0x20, 0x00, 0x23, 0x00, 0x01,
  0x10, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0x81, 0x80, 0x18, 0x01, 0x00,
  0xC0, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x30, 0x80, 0x00, 0x42, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x23,
  0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x10, 0x60, 0x00, 0x80, 0xC0,
  0x04, 0x01, 0x80, 0x60, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x05, 0x00, 0x00, 0x34, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x80,
  0x00, 0x22, 0x00, 0x01, 0x08, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x03,
  0x06, 0x00, 0x08, 0x10, 0x00, 0x40, 0x40, 0x02, 0x01, 0x00, 0x18, 0x04,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x08, 0x04,
  0x00, 0x20, 0x30, 0x00, 0x81, 0x80, 0x02, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x01,
  0xFF, 0xFC, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x11, 0xFC, 0x00, 0x5C,
  0x1C, 0x01, 0x80, 0x18, 0x04, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x02, 0x0C, 0x00,
  0x08, 0x10, 0x00, 0x40, 0x40, 0x03, 0x00, 0x80, 0x18, 0x01, 0x81, 0xC0,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x7E, 0x02, 0x38, 0x70, 0x58, 0x03,
  0x16, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x68, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x1B, 0x00, 0x02, 0x20, 0x00, 0xC6, 0x00, 0x30,
  0x60, 0x0C, 0x06, 0x03, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0x01, 0x80, 0x30, 0x01, 0x00,
  0x80, 0x06, 0x04, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0xC2, 0x00,
  0x03, 0x18, 0x00, 0x08, 0x60, 0x00, 0x21, 0x80, 0x01, 0x82, 0x00, 0x04,
  0x0C, 0x00, 0x20, 0x18, 0x03, 0x00, 0x30, 0x38, 0x00, 0x3F, 0x80, 0x03,
  0x87, 0x00, 0x30, 0x03, 0x01, 0x00, 0x04, 0x08, 0x00, 0x08, 0x60, 0x00,
  0x21, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x32,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0x40, 0x00, 0x81, 0x80,
  0x0C, 0x03, 0x80, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x18,
  0x06, 0x00, 0xC0, 0xC0, 0x04, 0x18, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00,
  0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x06, 0x40,
  0x00, 0xA2, 0x00, 0x1E, 0x30, 0x03, 0x41, 0x80, 0xE4, 0x0F, 0xF8, 0xC0,
  0x3C, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x07, 0xF0, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x03, 0x81, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x60,
  0x20, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x0C,
  0x06, 0x18, 0x02, 0x30, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x00, 0x80, 0x38,
  0x00, 0x60, 0x30, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x18, 0x0C, 0x02, 0x18,
  0x1F, 0x81, 0x08, 0x10, 0x20, 0x8C, 0x10, 0x10, 0x44, 0x18, 0x18, 0x24,
  0x08, 0x08, 0x12, 0x08, 0x04, 0x0B, 0x04, 0x02, 0x05, 0x04, 0x02, 0x02,
  0x82, 0x01, 0x03, 0x41, 0x00, 0x81, 0x61, 0x80, 0xC0, 0xA0, 0x80, 0x40,
  0x50, 0x40, 0x20, 0x68, 0x20, 0x30, 0x24, 0x10, 0x38, 0x32, 0x08, 0x14,
  0x11, 0x04, 0x12, 0x18, 0x81, 0x31, 0xB8, 0x60, 0x70, 0x70, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x14, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x19, 0x00, 0x00, 0x44,
  0x00, 0x03, 0x10, 0x00, 0x08, 0x60, 0x00, 0x60, 0x80, 0x01, 0x02, 0x00,
  0x0C, 0x08, 0x00, 0x20, 0x20, 0x01, 0x80, 0x80, 0x04, 0x02, 0x00, 0x30,
  0x0C, 0x00, 0x80, 0x10, 0x06, 0x00, 0x40, 0x10, 0x01, 0x00, 0xC0, 0x04,
  0x02, 0x00, 0x10, 0x1F, 0xFF, 0xC0, 0x40, 0x01, 0x83, 0x00, 0x02, 0x08,
  0x00, 0x08, 0x60, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00,
  0x08, 0x80, 0x00, 0x34, 0x00, 0x00, 0x70, 0x00, 0x01, 0x03, 0xFF, 0x80,
  0x08, 0x07, 0x80, 0x60, 0x03, 0x01, 0x00, 0x02, 0x04, 0x00, 0x0C, 0x10,
  0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x00,
  0x30, 0x80, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x30, 0x20, 0x01, 0x81,
  0x80, 0x18, 0x07, 0xFF, 0xC0, 0x10, 0x01, 0xC0, 0x40, 0x01, 0x81, 0x00,
  0x03, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x62, 0x00, 0x01,
  0x88, 0x00, 0x06, 0x20, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x02, 0x10,
  0x00, 0x18, 0x40, 0x00, 0xC1, 0x00, 0x06, 0x04, 0x00, 0xE0, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x04,
  0x04, 0x00, 0x18, 0x20, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01,
  0x04, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x60, 0x03, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x08, 0x03, 0x80, 0x10,
  0x01, 0x80, 0x20, 0x00, 0x80, 0x40, 0x01, 0x80, 0x80, 0x01, 0x03, 0x00,
  0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x20, 0x00,
  0x18, 0x40, 0x00, 0x11, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x60, 0x00, 0x08, 0x80, 0x00, 0x31,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x04, 0x30,
  0x00, 0x08, 0x40, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x03, 0x02, 0x00,
  0x0C, 0x04, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x20, 0x0E, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x03, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x04, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x21, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x7F, 0xC8, 0x03,
  0xFF, 0x20, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10,
  0x00, 0x18, 0x60, 0x00, 0x40, 0xC0, 0x06, 0x01, 0x80, 0x70, 0x03, 0xFF,
  0x00, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x04, 0x18, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x3F, 0xFF,
  0xF8, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x20, 0x00,
  0x10, 0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0x80, 0x00,
  0x40, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x01, 0x82,
  0x00, 0x02, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0C,
  0x07, 0x00, 0x07, 0xF8, 0x00, 0x04, 0x00, 0x03, 0x04, 0x00, 0x06, 0x04,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x30, 0x08, 0x00, 0x60, 0x08,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x08, 0x02, 0x00, 0x18, 0x04, 0x00, 0x10,
  0x08, 0x00, 0x10, 0x30, 0x00, 0x10, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x11,
  0x80, 0x00, 0x33, 0xC0, 0x00, 0x26, 0x40, 0x00, 0x2C, 0x20, 0x00, 0x30,
  0x30, 0x00, 0x20, 0x10, 0x00, 0x20, 0x18, 0x00, 0x60, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40,
  0x01, 0x00, 0xC0, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x80,
  0x00, 0x60, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0xFF, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x07, 0x00, 0x0E, 0x0D, 0x00, 0x0A, 0x09, 0x00, 0x12, 0x09,
  0x00, 0x32, 0x09, 0x00, 0x22, 0x09, 0x80, 0x66, 0x08, 0x80, 0x44, 0x18,
  0x80, 0xC4, 0x10, 0x80, 0x84, 0x10, 0x81, 0x04, 0x10, 0xC1, 0x04, 0x10,
  0x42, 0x0C, 0x10, 0x46, 0x08, 0x30, 0x44, 0x08, 0x20, 0x4C, 0x08, 0x20,
  0x68, 0x08, 0x20, 0x30, 0x18, 0x20, 0x30, 0x10, 0x60, 0x20, 0x10, 0x60,
  0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40,
  0x00, 0x20, 0xC0, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80,
  0x00, 0x20, 0x80, 0x00, 0x60, 0x04, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06,
  0x00, 0x02, 0x0E, 0x00, 0x02, 0x09, 0x00, 0x02, 0x09, 0x00, 0x02, 0x08,
  0x80, 0x06, 0x08, 0x80, 0x04, 0x08, 0x80, 0x04, 0x18, 0x40, 0x04, 0x10,
  0x40, 0x04, 0x10, 0x40, 0x04, 0x10, 0x20, 0x0C, 0x10, 0x20, 0x08, 0x10,
  0x10, 0x08, 0x30, 0x10, 0x08, 0x20, 0x10, 0x08, 0x20, 0x08, 0x08, 0x20,
  0x08, 0x18, 0x20, 0x08, 0x10, 0x20, 0x04, 0x10, 0x40, 0x04, 0x10, 0x40,
  0x02, 0x10, 0x40, 0x02, 0x30, 0x40, 0x02, 0x20, 0x40, 0x01, 0x20, 0x40,
  0x01, 0x20, 0x80, 0x01, 0x20, 0x80, 0x00, 0xA0, 0x80, 0x00, 0xE0, 0x80,
  0x00, 0x40, 0x80, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x06, 0x06, 0x00, 0xC0,
  0x08, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x22,
  0x00, 0x01, 0x30, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00,
  0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00,
  0x06, 0x10, 0x00, 0x20, 0x80, 0x03, 0x06, 0x00, 0x30, 0x10, 0x03, 0x00,
  0x60, 0x70, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x08, 0x00, 0xE0, 0x10,
  0x00, 0x60, 0x20, 0x00, 0x60, 0x40, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00,
  0x01, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00,
  0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x30, 0x10, 0x01, 0xC0, 0x7F, 0xFE, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x18, 0x00,
  0x40, 0x60, 0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x08, 0x40, 0x00,
  0x10, 0x80, 0x00, 0x41, 0x00, 0x01, 0x81, 0x00, 0x02, 0x02, 0x00, 0x08,
  0x02, 0x00, 0x60, 0x03, 0x01, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x07, 0xFF, 0x00, 0x10, 0x07, 0x00, 0x40, 0x02, 0x03,
  0x00, 0x04, 0x08, 0x00, 0x18, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00,
  0x02, 0x08, 0x00, 0x08, 0x60, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06,
  0x10, 0x00, 0x10, 0x40, 0x00, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x20,
  0x03, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x18, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x01, 0x01,
  0x00, 0x04, 0x04, 0x00, 0x18, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00,
  0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x01, 0xC0,
  0x60, 0x06, 0x00, 0x60, 0x10, 0x00, 0x60, 0x40, 0x00, 0x40, 0x80, 0x00,
  0xC2, 0x00, 0x01, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x80, 0x00, 0x21, 0x00, 0x00,
  0x43, 0x00, 0x01, 0x02, 0x00, 0x06, 0x06, 0x00, 0x18, 0x03, 0x00, 0xC0,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x06, 0x10, 0x00,
  0x08, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01, 0x84, 0x00, 0x02, 0x18,
  0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00,
  0x00, 0xC2, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x08, 0x40, 0x00, 0x30, 0x80, 0x00, 0x41, 0x00, 0x01, 0x83, 0x00, 0x02,
  0x02, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x06, 0x07, 0x00,
  0x07, 0xF8, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x24, 0x00, 0x01, 0x90,
  0x00, 0x04, 0x40, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x06, 0x18, 0x00,
  0x10, 0x20, 0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00, 0x40,
  0x20, 0x01, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x04, 0x01, 0x00, 0x10,
  0x04, 0x00, 0x40, 0x30, 0x01, 0x00, 0x80, 0x04, 0x06, 0x00, 0x18, 0x10,
  0x00, 0x20, 0xC0, 0x00, 0x82, 0x00, 0x02, 0x18, 0x00, 0x08, 0x40, 0x00,
  0x23, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x20, 0x00, 0x05, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x14, 0x01, 0x80, 0x28, 0x07, 0x00, 0xD0, 0x0A, 0x01,
  0x20, 0x14, 0x02, 0x40, 0x68, 0x04, 0x80, 0x90, 0x11, 0x01, 0x20, 0x22,
  0x06, 0x40, 0x44, 0x08, 0x81, 0x08, 0x11, 0x02, 0x10, 0x43, 0x04, 0x20,
  0x86, 0x10, 0x41, 0x0C, 0x20, 0x84, 0x18, 0x41, 0x08, 0x31, 0x82, 0x30,
  0x22, 0x04, 0x40, 0x44, 0x08, 0x80, 0x98, 0x13, 0x01, 0x20, 0x24, 0x02,
  0x40, 0x48, 0x04, 0x80, 0xB0, 0x0A, 0x01, 0x40, 0x14, 0x02, 0x80, 0x28,
  0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x40, 0x04, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x04, 0x00, 0x08, 0x01, 0x00, 0x04, 0x00, 0x20, 0x03, 0x00, 0x08,
  0x01, 0x80, 0x03, 0x00, 0x40, 0x00, 0x40, 0x20, 0x00, 0x18, 0x18, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x11, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x00, 0xC0,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00,
  0x30, 0x08, 0x00, 0x04, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x0D, 0x00, 0x00, 0x64, 0x00, 0x01, 0x18, 0x00, 0x08, 0x20, 0x00,
  0x60, 0x80, 0x01, 0x03, 0x00, 0x08, 0x04, 0x00, 0x60, 0x10, 0x01, 0x00,
  0x60, 0x08, 0x00, 0x80, 0x60, 0x02, 0x01, 0x00, 0x0C, 0x08, 0x00, 0x10,
  0x60, 0x00, 0x41, 0x00, 0x00, 0x88, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x81, 0xF8, 0x00, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20,
  0x20, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x08, 0x0C,
  0x04, 0x04, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x03, 0xF8, 0x1F, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x01,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x04, 0x80, 0x19, 0x00,
  0x22, 0x00, 0x84, 0x03, 0x0C, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0xC0,
  0x61, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x02, 0xC0, 0x07, 0x00, 0x04,
  0xFF, 0xFF, 0xC0, 0x84, 0x42, 0x21, 0x00, 0x7F, 0x80, 0x0E, 0x06, 0x00,
  0xC0, 0x08, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x60, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x03,
  0xFF, 0xE0, 0x70, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x00, 0x8C, 0x00, 0x04,
  0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x01, 0x84, 0x00,
  0x14, 0x30, 0x03, 0x20, 0xC0, 0x71, 0x03, 0xFE, 0x08, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x0F, 0xC0, 0x11, 0x81, 0x80, 0x90, 0x06, 0x05, 0x00, 0x10, 0x30, 0x00,
  0x41, 0x00, 0x02, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00, 0x04, 0x20,
  0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x02,
  0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0xC6, 0x00,
  0x04, 0x30, 0x00, 0x41, 0xC0, 0x06, 0x0A, 0x00, 0x60, 0x4C, 0x0E, 0x06,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x18, 0x06, 0x00, 0x40, 0xC0,
  0x06, 0x08, 0x00, 0x21, 0x00, 0x02, 0x30, 0x00, 0x32, 0x00, 0x03, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x04,
  0x40, 0x00, 0x84, 0x00, 0x08, 0x20, 0x01, 0x03, 0x00, 0x20, 0x18, 0x0C,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x0F, 0xE1, 0x00, 0xE0, 0xC4,
  0x06, 0x00, 0x90, 0x30, 0x01, 0xC1, 0x80, 0x07, 0x04, 0x00, 0x08, 0x30,
  0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00,
  0x41, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0x42,
  0x00, 0x03, 0x08, 0x00, 0x08, 0x30, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00,
  0x06, 0x06, 0x00, 0x38, 0x08, 0x01, 0xE0, 0x18, 0x19, 0x00, 0x3F, 0xC4,
  0x00, 0x00, 0x7F, 0x00, 0x18, 0x18, 0x06, 0x00, 0xC0, 0xC0, 0x06, 0x08,
  0x00, 0x21, 0x00, 0x03, 0x30, 0x00, 0x12, 0x00, 0x01, 0x60, 0x00, 0x14,
  0x00, 0x01, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x83, 0x00, 0x10, 0x18, 0x06, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x08, 0x0E, 0x0C,
  0x40, 0xC0, 0x12, 0x0C, 0x00, 0x50, 0xC0, 0x03, 0x84, 0x00, 0x08, 0x60,
  0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x0C,
  0x40, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x01, 0x83,
  0x00, 0x1C, 0x08, 0x01, 0xE0, 0x30, 0x3A, 0x00, 0xFF, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x40,
  0x03, 0x01, 0x00, 0x30, 0x06, 0x03, 0x00, 0x1F, 0xE0, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x07, 0xE0, 0x10, 0xC0, 0xC0, 0x98, 0x03, 0x05,
  0x80, 0x08, 0x38, 0x00, 0x43, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC4, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80,
  0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08,
  0xC0, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00,
  0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x06, 0x10, 0x00, 0x60,
  0x80, 0x04, 0x04, 0x00, 0xC0, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x18,
  0x00, 0x81, 0x80, 0x04, 0x18, 0x00, 0x21, 0x00, 0x01, 0x30, 0x00, 0x1B,
  0x40, 0x00, 0xA3, 0x00, 0x06, 0x08, 0x00, 0x20, 0x20, 0x01, 0x01, 0x80,
  0x18, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x40, 0x20, 0x03, 0x01, 0x00,
  0x08, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x84, 0x00, 0x06, 0x00, 0x03, 0xFE,
  0x01, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x3F, 0xFF, 0xF0, 0x09, 0xF8, 0x3F, 0x09, 0x86, 0x60, 0xC5, 0x01, 0x60,
  0x23, 0x00, 0xE0, 0x11, 0x80, 0x60, 0x08, 0x80, 0x30, 0x04, 0x40, 0x10,
  0x02, 0x60, 0x08, 0x01, 0x20, 0x04, 0x00, 0x90, 0x02, 0x00, 0x48, 0x01,
  0x00, 0x44, 0x01, 0x80, 0x22, 0x00, 0x80, 0x12, 0x00, 0x40, 0x09, 0x00,
  0x20, 0x04, 0x80, 0x10, 0x06, 0x40, 0x08, 0x02, 0x20, 0x08, 0x01, 0x30,
  0x04, 0x00, 0x90, 0x02, 0x00, 0x48, 0x01, 0x00, 0x24, 0x00, 0x80, 0x32,
  0x00, 0x40, 0x11, 0x00, 0x40, 0x08, 0x0C, 0x1F, 0x80, 0x43, 0x03, 0x02,
  0x60, 0x08, 0x16, 0x00, 0x20, 0xE0, 0x01, 0x0E, 0x00, 0x08, 0x60, 0x00,
  0x43, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x60,
  0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04,
  0x20, 0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x18, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x20, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x18, 0x00, 0x7F, 0x00,
  0x0E, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x0C, 0x00,
  0x0C, 0x40, 0x00, 0x26, 0x00, 0x01, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00,
  0x48, 0x00, 0x02, 0x40, 0x00, 0x32, 0x00, 0x01, 0x10, 0x00, 0x18, 0xC0,
  0x01, 0x82, 0x00, 0x18, 0x08, 0x01, 0x80, 0x30, 0x38, 0x00, 0xFF, 0x00,
  0x06, 0x1F, 0x80, 0x23, 0x03, 0x01, 0x60, 0x0C, 0x0E, 0x00, 0x20, 0x60,
  0x01, 0x82, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x11, 0x80, 0x00, 0x88, 0x00,
  0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x10, 0x80, 0x01, 0x0C,
  0x00, 0x08, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x14, 0x00, 0xC0, 0x98, 0x1C,
  0x0C, 0x7F, 0x80, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x10, 0x38, 0x31, 0x06, 0x00, 0x90, 0xC0,
  0x05, 0x18, 0x00, 0x71, 0x00, 0x02, 0x30, 0x00, 0x22, 0x00, 0x02, 0x60,
  0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x64, 0x00, 0x04, 0xC0, 0x00, 0x4C,
  0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x08,
  0x40, 0x00, 0x84, 0x00, 0x18, 0x60, 0x03, 0x82, 0x00, 0x78, 0x18, 0x19,
  0x00, 0xFF, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x08, 0x1F, 0xE1, 0x0E, 0x00, 0x26, 0x00, 0x05, 0x80, 0x01,
  0xE0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x38, 0x1C, 0x04, 0x00, 0x60, 0x80, 0x03, 0x18, 0x00, 0x11,
  0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x80, 0x00, 0x4C, 0x00,
  0x04, 0x40, 0x00, 0xC6, 0x00, 0x18, 0x30, 0x07, 0x00, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x30,
  0x00, 0x32, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22,
  0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0x4C, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00,
  0x30, 0x80, 0x07, 0x04, 0x00, 0xD0, 0x60, 0x31, 0x03, 0xFE, 0x30, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x04, 0x80, 0x00, 0x46, 0x00, 0x06,
  0x10, 0x00, 0x20, 0x80, 0x03, 0x04, 0x00, 0x10, 0x30, 0x01, 0x80, 0x80,
  0x08, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x40, 0x04, 0x06, 0x00,
  0x20, 0x20, 0x01, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x21, 0x00, 0x01, 0x18,
  0x00, 0x0C, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x03, 0x40, 0x18, 0x02, 0x40, 0x18, 0x02, 0x40,
  0x28, 0x04, 0x40, 0x28, 0x04, 0x40, 0x68, 0x0C, 0x40, 0x48, 0x08, 0x40,
  0xC8, 0x08, 0x40, 0x88, 0x18, 0x40, 0x88, 0x10, 0x41, 0x08, 0x30, 0x41,
  0x08, 0x20, 0x43, 0x0C, 0x20, 0x42, 0x0C, 0x60, 0x42, 0x0C, 0x40, 0x44,
  0x04, 0xC0, 0x44, 0x04, 0x80, 0x6C, 0x04, 0x80, 0x68, 0x05, 0x80, 0x78,
  0x05, 0x00, 0x70, 0x05, 0x00, 0x30, 0x06, 0x00, 0x20, 0x06, 0x00, 0x20,
  0x06, 0x00, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x03,
  0x00, 0x18, 0x01, 0x00, 0x30, 0x00, 0x80, 0x60, 0x00, 0xC0, 0xC0, 0x00,
  0x41, 0x80, 0x00, 0x63, 0x00, 0x00, 0x36, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x34, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xC2, 0x00, 0x01, 0x83, 0x00, 0x03, 0x01, 0x00, 0x06, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x18, 0x00, 0x40, 0x30, 0x00, 0x60, 0x20, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x18, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x40, 0x20, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x80, 0x08, 0x00, 0x30, 0x01, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x02, 0x00, 0x60, 0x00, 0x40, 0x08, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x10, 0x18, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82,
  0x04, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02,
  0x04, 0x08, 0x10, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x18, 0xE0, 0x01, 0x20, 0x30,
  0x03, 0x60, 0x18, 0x02, 0x40, 0x0C, 0x06, 0xC0, 0x06, 0x0C, 0x80, 0x01,
  0xF0,
};

const GFXglyph RobotoMono_ThinItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 32, 26, 9, -32 },
  { 29, 9, 9, 26, 11, -34 },
  { 40, 26, 32, 26, 1, -32 },
  { 144, 21, 42, 26, 3, -37 },
  { 255, 21, 32, 26, 3, -32 },
  { 339, 22, 32, 26, 2, -32 },
  { 427, 3, 9, 26, 13, -34 },
  { 431, 13, 46, 26, 8, -36 },
  { 506, 14, 46, 26, 4, -36 },
  { 587, 19, 17, 26, 6, -32 },
  { 628, 21, 24, 26, 3, -27 },
  { 691, 4, 10, 26, 6, -4 },
  { 696, 16, 1, 26, 5, -15 },
  { 698, 3, 2, 26, 10, -2 },
  { 699, 20, 35, 26, 4, -32 },
  { 787, 21, 32, 26, 3, -32 },
  { 871, 11, 32, 26, 7, -32 },
  { 915, 21, 32, 26, 1, -32 },
  { 999, 22, 32, 26, 1, -32 },
  { 1087, 22, 32, 26, 1, -32 },
  { 1175, 22, 32, 26, 4, -32 },
  { 1263, 19, 32, 26, 3, -32 },
  { 1339, 20, 32, 26, 6, -32 },
  { 1419, 22, 32, 26, 3, -32 },
  { 1507, 20, 32, 26, 4, -32 },
  { 1587, 6, 21, 26, 12, -21 },
  { 1603, 9, 27, 26, 9, -21 },
  { 1634, 20, 17, 26, 4, -23 },
  { 1677, 21, 10, 26, 3, -20 },
  { 1704, 20, 18, 26, 3, -24 },
  { 1749, 16, 32, 26, 7, -32 },
  { 1813, 25, 32, 26, 1, -32 },
  { 1913, 22, 32, 26, 0, -32 },
  { 2001, 22, 32, 26, 2, -32 },
  { 2089, 22, 32, 26, 3, -32 },
  { 2177, 23, 32, 26, 2, -32 },
  { 2269, 24, 32, 26, 2, -32 },
  { 2365, 23, 32, 26, 3, -32 },
  { 2457, 22, 32, 26, 3, -32 },
  { 2545, 24, 32, 26, 2, -32 },
  { 2641, 23, 32, 26, 2, -32 },
  { 2733, 23, 32, 26, 2, -32 },
  { 2825, 24, 32, 26, 3, -32 },
  { 2921, 18, 32, 26, 3, -32 },
  { 2993, 24, 32, 26, 2, -32 },
  { 3089, 24, 32, 26, 2, -32 },
  { 3185, 21, 32, 26, 3, -32 },
  { 3269, 23, 32, 26, 3, -32 },
  { 3361, 23, 38, 26, 2, -32 },
  { 3471, 22, 32, 26, 3, -32 },
  { 3559, 23, 32, 26, 2, -32 },
  { 3651, 22, 32, 26, 5, -32 },
  { 3739, 23, 32, 26, 3, -32 },
  { 3831, 22, 32, 26, 5, -32 },
  { 3919, 23, 32, 26, 5, -32 },
  { 4011, 26, 32, 26, 1, -32 },
  { 4115, 22, 32, 26, 5, -32 },
  { 4203, 24, 32, 26, 1, -32 },
  { 4299, 13, 44, 26, 7, -37 },
  { 4371, 8, 35, 26, 9, -32 },
  { 4406, 13, 44, 26, 7, -37 },
  { 4478, 15, 18, 26, 6, -32 },
  { 4512, 18, 1, 26, 2, 0 },
  { 4515, 4, 6, 26, 14, -33 },
  { 4518, 21, 24, 26, 2, -24 },
  { 4581, 21, 34, 26, 2, -34 },
  { 4671, 20, 24, 26, 3, -24 },
  { 4731, 22, 34, 26, 3, -34 },
  { 4825, 20, 24, 26, 3, -24 },
  { 4885, 21, 34, 26, 6, -34 },
  { 4975, 21, 34, 26, 2, -24 },
  { 5065, 21, 34, 26, 2, -34 },
  { 5155, 18, 32, 26, 3, -32 },
  { 5227, 20, 42, 26, 0, -32 },
  { 5332, 21, 34, 26, 3, -34 },
  { 5422, 18, 34, 26, 3, -34 },
  { 5499, 25, 24, 26, 0, -24 },
  { 5574, 21, 24, 26, 2, -24 },
  { 5637, 21, 24, 26, 2, -24 },
  { 5700, 21, 33, 26, 1, -24 },
  { 5787, 20, 33, 26, 3, -24 },
  { 5870, 19, 24, 26, 6, -24 },
  { 5927, 20, 24, 26, 3, -24 },
  { 5987, 16, 30, 26, 6, -30 },
  { 6047, 20, 24, 26, 4, -24 },
  { 6107, 21, 24, 26, 4, -24 },
  { 6170, 24, 24, 26, 3, -24 },
  { 6242, 24, 24, 26, 1, -24 },
  { 6314, 27, 34, 26, -1, -24 },
  { 6429, 23, 24, 26, 1, -24 },
  { 6498, 17, 45, 26, 7, -35 },
  { 6594, 7, 38, 26, 10, -32 },
  { 6628, 17, 45, 26, 4, -35 },
  { 6724, 24, 7, 26, 1, -17 },
};

const GFXfont RobotoMono_ThinItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic45pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_THINITALIC45PT7B_H_
