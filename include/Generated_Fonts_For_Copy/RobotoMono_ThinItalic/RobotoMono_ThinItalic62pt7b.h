#ifndef _ROBOTOMONO_THINITALIC62PT7B_H_
#define _ROBOTOMONO_THINITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x03, 0x80, 0x30, 0x64, 0x0D, 0x81,
  0xB0, 0x26, 0x04, 0xC1, 0x98, 0x32, 0x06, 0xC0, 0x98, 0x13, 0x06, 0x60,
  0xC8, 0x18, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0x80, 0x08, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x06, 0x00, 0x40, 0x06, 0x18, 0x01, 0x80, 0x10, 0xC0, 0x04, 0x00, 0xC3,
  0x00, 0x10, 0x06, 0x0C, 0x00, 0x40, 0x30, 0x30, 0x03, 0x00, 0xC0, 0x80,
  0x0C, 0x06, 0x02, 0x00, 0x30, 0x30, 0x08, 0x01, 0x80, 0xC0, 0x30, 0x06,
  0x06, 0x00, 0xC0, 0x30, 0x30, 0x01, 0x01, 0xC0, 0x80, 0x06, 0x0E, 0x06,
  0x00, 0x0F, 0xF0, 0x30, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x0F, 0x00, 0x01, 0x80, 0xFE, 0x00, 0x0C, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x18, 0x01, 0x81, 0x80, 0x20, 0x0C, 0x04, 0x00, 0x80, 0x30,
  0x30, 0x03, 0x01, 0x80, 0x80, 0x0C, 0x0C, 0x06, 0x00, 0x30, 0x20, 0x18,
  0x00, 0x81, 0x80, 0x60, 0x02, 0x0C, 0x01, 0x80, 0x18, 0x60, 0x04, 0x00,
  0x61, 0x80, 0x10, 0x01, 0x8C, 0x00, 0x40, 0x0C, 0x20, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38,
  0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x87, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0xC3, 0x00, 0x20, 0x03, 0x18, 0x00, 0xC0, 0x0C, 0xC0, 0x01, 0x80, 0x63,
  0x00, 0x06, 0x01, 0x98, 0x00, 0x0C, 0x06, 0x60, 0x00, 0x18, 0x31, 0x00,
  0x00, 0x60, 0xC4, 0x00, 0x00, 0xC6, 0x10, 0x00, 0x01, 0x18, 0xC0, 0x00,
  0x06, 0xC1, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x0E, 0xC0, 0xC0, 0x00, 0x61, 0x01, 0xC0, 0x07, 0x06,
  0x03, 0xC0, 0xF0, 0x0C, 0x03, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00,
  0x33, 0x33, 0x32, 0x26, 0x66, 0x44, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x03, 0xFC, 0x04, 0x0F, 0x87, 0xC2,
  0x1F, 0x00, 0x7B, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x01,
  0xC0, 0x01, 0xC0, 0x40, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x84,
  0x30, 0x86, 0x30, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x0D, 0x30, 0x00, 0x01, 0xB3, 0x00, 0x00, 0x73, 0x30, 0x00, 0x0E, 0x32,
  0x00, 0x01, 0x83, 0x60, 0x00, 0x30, 0x36, 0x00, 0x06, 0x03, 0x60, 0x00,
  0xC0, 0x26, 0x00, 0x18, 0x02, 0x40, 0x07, 0x00, 0x64, 0x00, 0xE0, 0x06,
  0xC0, 0x18, 0x00, 0x6C, 0x03, 0x00, 0x04, 0xC0, 0x60, 0x00, 0x4C, 0x0C,
  0x00, 0x0C, 0x81, 0x80, 0x00, 0xC8, 0x30, 0x00, 0x0C, 0x8E, 0x00, 0x00,
  0x89, 0x80, 0x00, 0x18, 0xB0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x03,
  0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x1E,
  0x30, 0xF0, 0x67, 0x80, 0xB8, 0x01, 0x40, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x70, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x40, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x02, 0x00, 0x38, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0x80, 0x00,
  0x23, 0xFF, 0xC0, 0x00, 0xBC, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x00, 0xE0, 0x3C,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x0F, 0xE0, 0x06, 0x1F, 0xFE, 0x01, 0x1E, 0x00, 0xE0, 0xCE,
  0x00, 0x1C, 0x36, 0x00, 0x03, 0x0B, 0x00, 0x00, 0x67, 0x80, 0x00, 0x19,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x06, 0x00,
  0x0E, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0xE0, 0x03, 0x00, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x06, 0x86, 0x00, 0x01, 0xB0, 0x60, 0x00, 0x66, 0x0E, 0x00, 0x38, 0x80,
  0xE0, 0x1C, 0x30, 0x07, 0xFF, 0x06, 0x00, 0x3F, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xF9, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x0E,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x23, 0x00, 0x00, 0xD8,
  0x00, 0x03, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x0C, 0x06, 0x00, 0xFE, 0x01, 0x81, 0x80, 0x78, 0xE0,
  0x30, 0x70, 0x1C, 0x0E, 0x06, 0x0C, 0x06, 0x00, 0x80, 0xC3, 0x00, 0xC0,
  0x10, 0x18, 0x60, 0x30, 0x06, 0x03, 0x18, 0x0C, 0x00, 0xC0, 0x63, 0x01,
  0x80, 0x10, 0x0C, 0x40, 0x60, 0x02, 0x01, 0x98, 0x0C, 0x00, 0xC0, 0x33,
  0x01, 0x00, 0x10, 0x06, 0x40, 0x60, 0x02, 0x00, 0x98, 0x0C, 0x00, 0xC0,
  0x13, 0x01, 0x00, 0x18, 0x06, 0x60, 0x60, 0x02, 0x00, 0xC8, 0x0C, 0x00,
  0xC0, 0x11, 0x01, 0x80, 0x18, 0x06, 0x20, 0x20, 0x03, 0x00, 0xCC, 0x04,
  0x00, 0xC0, 0x19, 0x80, 0x80, 0x18, 0x06, 0x30, 0x10, 0x07, 0x00, 0xC6,
  0x02, 0x01, 0xA0, 0x30, 0xC0, 0x40, 0x64, 0x06, 0x18, 0x0C, 0x18, 0x81,
  0x81, 0x01, 0x86, 0x18, 0xE0, 0x30, 0x1F, 0x81, 0xF8, 0x06, 0x00, 0x40,
  0x08, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x03, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x20, 0x01,
  0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x40, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x60, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x70, 0x10, 0x00, 0x03, 0x80, 0x40, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0xF0,
  0x02, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0E, 0x01, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x08, 0x00, 0x07, 0x00, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38, 0x08,
  0x00, 0x00, 0xE0, 0x10, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x70, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xCC, 0x00, 0x1F, 0xFF,
  0x30, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x40, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x08,
  0x00, 0x07, 0x00, 0x02, 0x00, 0x03, 0x80, 0x00, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x08, 0x78, 0x00, 0x00, 0x06, 0x3B,
  0x00, 0x00, 0x01, 0x9C, 0xC0, 0x00, 0x00, 0x6C, 0x18, 0x00, 0x00, 0x1E,
  0x03, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x1A, 0x01, 0xA0, 0x00, 0x06, 0x80, 0x68, 0x00,
  0x03, 0x60, 0x13, 0x00, 0x00, 0xD8, 0x04, 0xC0, 0x00, 0x66, 0x03, 0x30,
  0x00, 0x31, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x31, 0x00, 0x06, 0x30, 0x0C,
  0x60, 0x01, 0x8C, 0x02, 0x18, 0x00, 0xC3, 0x00, 0x86, 0x00, 0x30, 0xC0,
  0x60, 0x80, 0x18, 0x20, 0x18, 0x20, 0x0C, 0x08, 0x06, 0x0C, 0x03, 0x06,
  0x01, 0x83, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x60, 0x60, 0x10, 0x10, 0x30,
  0x10, 0x0C, 0x04, 0x0C, 0x04, 0x03, 0x01, 0x86, 0x03, 0x00, 0xC0, 0x61,
  0x00, 0xC0, 0x20, 0x18, 0xC0, 0x30, 0x08, 0x02, 0x60, 0x0C, 0x02, 0x00,
  0x98, 0x02, 0x01, 0x80, 0x3C, 0x00, 0x80, 0x60, 0x0E, 0x00, 0x60, 0x18,
  0x03, 0x80, 0x18, 0x04, 0x00, 0x40, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0xE0, 0x00, 0x00, 0x40, 0x70, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x00, 0x30,
  0x16, 0x00, 0x00, 0x18, 0x09, 0x00, 0x00, 0x08, 0x04, 0xC0, 0x00, 0x04,
  0x06, 0x20, 0x00, 0x06, 0x03, 0x10, 0x00, 0x03, 0x01, 0x8C, 0x00, 0x01,
  0x80, 0x82, 0x00, 0x00, 0xC0, 0x41, 0x80, 0x00, 0x40, 0x20, 0xC0, 0x00,
  0x20, 0x30, 0x20, 0x00, 0x30, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x04, 0x00,
  0x0C, 0x04, 0x02, 0x00, 0x06, 0x02, 0x01, 0x80, 0x02, 0x01, 0x00, 0x40,
  0x01, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x04,
  0x00, 0x60, 0x20, 0x03, 0x00, 0x20, 0x10, 0x00, 0x80, 0x10, 0x08, 0x00,
  0x40, 0x08, 0x0C, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x08, 0x06, 0x03, 0x00,
  0x06, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x80, 0x00, 0x80, 0x80, 0xC0,
  0x00, 0x60, 0x40, 0x60, 0x00, 0x10, 0x60, 0x30, 0x00, 0x08, 0x30, 0x10,
  0x00, 0x06, 0x18, 0x08, 0x00, 0x01, 0x08, 0x04, 0x00, 0x00, 0xC4, 0x06,
  0x00, 0x00, 0x62, 0x03, 0x00, 0x00, 0x13, 0x01, 0x80, 0x00, 0x0D, 0x80,
  0x80, 0x00, 0x02, 0xC0, 0x40, 0x00, 0x01, 0x40, 0x20, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x01, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x06, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x01, 0x00, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x70, 0x08, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x03, 0x80, 0x08, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x08, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x40, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x40, 0x02, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x06, 0x00, 0x20, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x04, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x00, 0x60, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x03, 0x80, 0x06, 0x80, 0x03,
  0x80, 0x04, 0x80, 0x07, 0x80, 0x04, 0x80, 0x07, 0x80, 0x0C, 0x80, 0x05,
  0x80, 0x0C, 0x80, 0x0D, 0x80, 0x08, 0x80, 0x0D, 0x80, 0x18, 0x80, 0x09,
  0x80, 0x18, 0x80, 0x19, 0x80, 0x10, 0x80, 0x19, 0x80, 0x30, 0x80, 0x11,
  0x80, 0x30, 0x80, 0x31, 0x80, 0x20, 0x80, 0x31, 0x80, 0x20, 0x80, 0x21,
  0x80, 0x60, 0x80, 0x61, 0x80, 0x40, 0x80, 0x61, 0x80, 0x40, 0x80, 0xC0,
  0x80, 0xC0, 0x80, 0xC0, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x00, 0x81, 0x00, 0x83, 0x00,
  0x83, 0x00, 0x83, 0x00, 0x83, 0x00, 0x82, 0x00, 0x82, 0x00, 0x86, 0x00,
  0x86, 0x00, 0x86, 0x00, 0xC6, 0x00, 0x84, 0x00, 0xC4, 0x00, 0x8C, 0x00,
  0xC4, 0x00, 0x8C, 0x00, 0xCC, 0x00, 0x88, 0x00, 0xC8, 0x00, 0x98, 0x00,
  0xC8, 0x00, 0x98, 0x00, 0xD8, 0x00, 0x90, 0x00, 0xD8, 0x00, 0xB0, 0x00,
  0xD0, 0x00, 0xB0, 0x00, 0xF0, 0x00, 0xA0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xF8, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x0F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x06, 0x04, 0x00, 0x20, 0x30,
  0x03, 0x01, 0x80, 0x10, 0x0C, 0x01, 0x80, 0x20, 0x18, 0x01, 0x80, 0xC0,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00, 0x0C, 0x20, 0x00, 0x63,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x58, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x06, 0x08, 0x30, 0x41, 0x83, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x60, 0x3C,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x84, 0x00, 0x00,
  0x78, 0x60, 0x00, 0x0D, 0x87, 0x00, 0x03, 0x98, 0x38, 0x00, 0xF1, 0x81,
  0xE0, 0x3C, 0x18, 0x07, 0xFF, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x07, 0xFC, 0x00, 0x21, 0xF0, 0xF0, 0x02, 0x38, 0x03, 0x80, 0x26, 0x00,
  0x0C, 0x06, 0xC0, 0x00, 0xC0, 0x78, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x60, 0x78, 0x00, 0x0E, 0x06, 0xC0, 0x01, 0xC0, 0x66, 0x00, 0x38, 0x04,
  0x38, 0x1E, 0x00, 0xC1, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x12, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x03, 0x00, 0x0F, 0x0F,
  0x0C, 0x00, 0xE0, 0x06, 0x30, 0x07, 0x00, 0x0C, 0xC0, 0x30, 0x00, 0x1A,
  0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x00, 0x80,
  0x00, 0x38, 0x03, 0x00, 0x01, 0xA0, 0x06, 0x00, 0x0D, 0x80, 0x1C, 0x00,
  0xE6, 0x00, 0x3C, 0x0F, 0x18, 0x00, 0x3F, 0xF0, 0x60, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x70, 0x03, 0x00,
  0x1C, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x18, 0x00, 0xF0, 0xF0, 0xC0, 0x1C, 0x00, 0xC6, 0x01, 0xC0, 0x03, 0x30,
  0x18, 0x00, 0x0D, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x20,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0xD0, 0x06, 0x00, 0x0C, 0x80, 0x38, 0x01,
  0xCC, 0x00, 0xF0, 0x3C, 0x60, 0x01, 0xFF, 0x83, 0x00, 0x01, 0xC0, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x01, 0xFE,
  0x00, 0x20, 0x78, 0x78, 0x06, 0x1C, 0x00, 0xC0, 0x63, 0x00, 0x06, 0x06,
  0x60, 0x00, 0x60, 0x4C, 0x00, 0x03, 0x05, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x21, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0C,
  0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x1C, 0x02, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x70, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x40, 0x0E, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x02, 0x0E, 0x00, 0x00, 0x08, 0x70, 0x00, 0x00, 0x67, 0xC0, 0x00, 0x01,
  0xB9, 0x80, 0x00, 0x07, 0x83, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x01, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x30, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x1F, 0xE0, 0x3F, 0x80,
  0x27, 0x87, 0x0F, 0x0C, 0x02, 0xE0, 0x31, 0x80, 0x60, 0x7C, 0x01, 0xB0,
  0x03, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x70, 0x00, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x80, 0x03, 0x04, 0x00, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x00,
  0x02, 0x08, 0x00, 0x10, 0x00, 0x60, 0x80, 0x03, 0x00, 0x06, 0x08, 0x00,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x41,
  0x80, 0x02, 0x00, 0x04, 0x10, 0x00, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x40, 0x00, 0x83, 0x00, 0x04, 0x00, 0x08, 0x20, 0x00, 0x40, 0x01, 0x82,
  0x00, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00,
  0x10, 0x60, 0x00, 0x80, 0x01, 0x04, 0x00, 0x08, 0x00, 0x10, 0x40, 0x00,
  0x80, 0x03, 0x04, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x01, 0xFE, 0x00, 0x20, 0x78, 0x78, 0x06, 0x1C, 0x00, 0xC0, 0x63,
  0x00, 0x06, 0x06, 0x60, 0x00, 0x60, 0x4C, 0x00, 0x02, 0x05, 0x80, 0x00,
  0x30, 0xF0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC1, 0xFF, 0x00, 0x02, 0x1F, 0x0F, 0x00, 0x08, 0xE0, 0x0E, 0x00,
  0x66, 0x00, 0x1C, 0x01, 0xB0, 0x00, 0x30, 0x07, 0x80, 0x00, 0x60, 0x1C,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x01, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x03,
  0x00, 0x6C, 0x00, 0x1C, 0x01, 0x38, 0x00, 0xC0, 0x04, 0x38, 0x1E, 0x00,
  0x30, 0x7F, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x60, 0x0F, 0x0F, 0x0C,
  0x07, 0x00, 0x31, 0x81, 0xC0, 0x03, 0x30, 0x60, 0x00, 0x34, 0x18, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38,
  0x20, 0x00, 0x0E, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0xC8, 0x0E, 0x00,
  0x73, 0x00, 0xF0, 0x3C, 0x60, 0x07, 0xFE, 0x0C, 0x00, 0x1C, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x80, 0xF8, 0x10,
  0x20, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x14, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE1, 0xF0,
  0x01, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x38, 0x20, 0x00, 0x0F, 0x06, 0x00, 0x03, 0x60, 0xC0, 0x00,
  0xC8, 0x0C, 0x00, 0x71, 0x00, 0xE0, 0x7C, 0x60, 0x0F, 0xFE, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x02, 0xC0,
  0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x07, 0x80, 0x0C, 0xC0,
  0x05, 0x80, 0x0C, 0xC0, 0x0D, 0x80, 0x08, 0xC0, 0x0D, 0x80, 0x18, 0xC0,
  0x09, 0x80, 0x18, 0xC0, 0x18, 0x80, 0x30, 0xC0, 0x10, 0x80, 0x30, 0xC0,
  0x30, 0x80, 0x20, 0xC0, 0x30, 0x80, 0x60, 0xC0, 0x60, 0x80, 0x60, 0xC0,
  0x60, 0xC0, 0xC0, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0xC0, 0xC0, 0x80, 0x40,
  0xC0, 0xC1, 0x80, 0x41, 0x80, 0xC1, 0x80, 0x41, 0x80, 0xC3, 0x00, 0x41,
  0x00, 0xC3, 0x00, 0x43, 0x00, 0x43, 0x00, 0x62, 0x00, 0x46, 0x00, 0x66,
  0x00, 0x46, 0x00, 0x66, 0x00, 0x44, 0x00, 0x64, 0x00, 0x4C, 0x00, 0x6C,
  0x00, 0x4C, 0x00, 0x68, 0x00, 0x58, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x08, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xC3, 0xC7, 0x80, 0x00,
  0x21, 0xC0, 0x30, 0x00, 0x18, 0x60, 0x06, 0x00, 0x06, 0x30, 0x00, 0xC0,
  0x03, 0x08, 0x00, 0x18, 0x00, 0xC6, 0x00, 0x03, 0x00, 0x61, 0x00, 0x00,
  0x70, 0x70, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00,
};

const GFXglyph RobotoMono_ThinItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 10, 44, 36, 13, -44 },
  { 56, 11, 13, 36, 16, -47 },
  { 74, 36, 44, 36, 1, -44 },
  { 272, 30, 56, 36, 4, -50 },
  { 482, 30, 46, 36, 4, -45 },
  { 655, 30, 46, 36, 3, -45 },
  { 828, 4, 13, 36, 18, -47 },
  { 835, 18, 63, 36, 11, -49 },
  { 977, 18, 63, 36, 6, -49 },
  { 1119, 25, 24, 36, 9, -44 },
  { 1194, 29, 33, 36, 4, -37 },
  { 1314, 6, 13, 36, 8, -5 },
  { 1324, 22, 2, 36, 7, -21 },
  { 1330, 4, 3, 36, 14, -3 },
  { 1332, 28, 48, 36, 5, -44 },
  { 1500, 28, 46, 36, 5, -45 },
  { 1661, 15, 44, 36, 10, -44 },
  { 1744, 28, 45, 36, 2, -45 },
  { 1902, 30, 46, 36, 2, -45 },
  { 2075, 30, 44, 36, 2, -44 },
  { 2240, 30, 45, 36, 6, -44 },
  { 2409, 26, 46, 36, 4, -45 },
  { 2559, 27, 44, 36, 8, -44 },
  { 2708, 30, 46, 36, 4, -45 },
  { 2881, 27, 46, 36, 6, -45 },
  { 3037, 8, 30, 36, 16, -30 },
  { 3067, 12, 38, 36, 12, -30 },
  { 3124, 28, 24, 36, 5, -32 },
  { 3208, 29, 14, 36, 4, -27 },
  { 3259, 27, 24, 36, 4, -32 },
  { 3340, 22, 45, 36, 10, -45 },
  { 3464, 35, 45, 36, 1, -45 },
  { 3661, 30, 44, 36, 0, -44 },
  { 3826, 30, 44, 36, 3, -44 },
  { 3991, 30, 46, 36, 4, -45 },
  { 4164, 31, 44, 36, 3, -44 },
  { 4335, 32, 44, 36, 3, -44 },
  { 4511, 32, 44, 36, 4, -44 },
  { 4687, 30, 46, 36, 4, -45 },
  { 4860, 33, 44, 36, 2, -44 },
  { 5042, 31, 44, 36, 3, -44 },
  { 5213, 32, 45, 36, 2, -44 },
  { 5393, 34, 44, 36, 4, -44 },
  { 5580, 24, 44, 36, 4, -44 },
  { 5712, 34, 44, 36, 2, -44 },
  { 5899, 33, 44, 36, 2, -44 },
  { 6081, 30, 46, 36, 4, -45 },
  { 6254, 32, 44, 36, 4, -44 },
  { 6430, 32, 53, 36, 3, -45 },
  { 6642, 30, 44, 36, 4, -44 },
  { 6807, 31, 46, 36, 3, -45 },
  { 6986, 29, 44, 36, 8, -44 },
  { 7146, 31, 45, 36, 4, -44 },
  { 7321, 30, 44, 36, 7, -44 },
  { 7486, 32, 44, 36, 7, -44 },
  { 7662, 36, 44, 36, 1, -44 },
  { 7860, 30, 44, 36, 7, -44 },
  { 8025, 33, 44, 36, 1, -44 },
  { 8207, 18, 59, 36, 10, -50 },
  { 8340, 11, 48, 36, 13, -44 },
  { 8406, 18, 59, 36, 9, -50 },
  { 8539, 21, 24, 36, 8, -44 },
  { 8602, 25, 2, 36, 2, 0 },
  { 8609, 6, 8, 36, 19, -46 },
  { 8615, 28, 34, 36, 3, -33 },
  { 8734, 28, 48, 36, 3, -47 },
  { 8902, 26, 34, 36, 5, -33 },
  { 9013, 30, 48, 36, 4, -47 },
  { 9193, 28, 34, 36, 4, -33 },
  { 9312, 30, 47, 36, 8, -47 },
  { 9489, 29, 46, 36, 3, -33 },
  { 9656, 28, 47, 36, 3, -47 },
  { 9821, 25, 44, 36, 4, -44 },
  { 9959, 28, 57, 36, 0, -44 },
  { 10159, 30, 47, 36, 4, -47 },
  { 10336, 25, 47, 36, 4, -47 },
  { 10483, 36, 33, 36, -1, -33 },
  { 10632, 28, 33, 36, 3, -33 },
  { 10748, 29, 34, 36, 3, -33 },
  { 10872, 30, 46, 36, 1, -33 },
  { 11045, 27, 46, 36, 5, -33 },
  { 11201, 26, 33, 36, 8, -33 },
  { 11309, 28, 34, 36, 4, -33 },
  { 11428, 23, 43, 36, 8, -42 },
  { 11552, 27, 34, 36, 5, -33 },
  { 11667, 29, 33, 36, 6, -33 },
  { 11787, 32, 33, 36, 5, -33 },
  { 11919, 32, 33, 36, 2, -33 },
  { 12051, 37, 46, 36, -1, -33 },
  { 12264, 32, 33, 36, 1, -33 },
  { 12396, 23, 61, 36, 10, -48 },
  { 12572, 10, 52, 36, 13, -44 },
  { 12637, 24, 61, 36, 5, -48 },
  { 12820, 34, 10, 36, 1, -23 },
};

const GFXfont RobotoMono_ThinItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic62pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOMONO_THINITALIC62PT7B_H_
