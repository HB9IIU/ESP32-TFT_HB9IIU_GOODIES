#ifndef _ROBOTOMONO_THINITALIC18PT7B_H_
#define _ROBOTOMONO_THINITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-ThinItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_ThinItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x92, 0x80, 0x08, 0xB6, 0xD0, 0x04, 0x40, 0x88, 0x12,
  0x04, 0x43, 0xFE, 0x12, 0x04, 0x40, 0x88, 0x12, 0x1D, 0xF0, 0x90, 0x12,
  0x04, 0x40, 0x04, 0x02, 0x07, 0xC4, 0x12, 0x0A, 0x04, 0x80, 0x40, 0x1C,
  0x01, 0x00, 0x50, 0x28, 0x14, 0x11, 0xB0, 0x20, 0x10, 0x00, 0x70, 0x44,
  0x22, 0x52, 0x49, 0x43, 0x20, 0x20, 0x26, 0x14, 0x94, 0x52, 0x31, 0x10,
  0x70, 0x0C, 0x09, 0x08, 0x84, 0x42, 0x40, 0xC0, 0xC0, 0x91, 0x84, 0xC2,
  0xA0, 0x90, 0x47, 0xD0, 0xF0, 0x0C, 0x42, 0x08, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x40, 0x80, 0x30, 0x82, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x84, 0x44, 0x00, 0x10, 0x22, 0x4A, 0xE3, 0x09,
  0x22, 0x00, 0x04, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x20, 0x10,
  0x08, 0x00, 0x58, 0xFC, 0x80, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x06, 0x00, 0x1E, 0x10, 0x88,
  0x28, 0x14, 0x3A, 0x26, 0x23, 0x22, 0xA1, 0x60, 0xA0, 0x88, 0x47, 0xC0,
  0x17, 0x91, 0x11, 0x12, 0x22, 0x22, 0x20, 0x0F, 0x18, 0x48, 0x28, 0x10,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0F, 0xF0, 0x0F, 0x08,
  0x48, 0x24, 0x10, 0x08, 0x08, 0x38, 0x02, 0x01, 0x40, 0x60, 0x48, 0x23,
  0xE0, 0x00, 0x80, 0x80, 0xC0, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x42, 0x7F,
  0xC0, 0x80, 0x40, 0x20, 0x3F, 0x20, 0x40, 0x40, 0x40, 0x7C, 0x02, 0x02,
  0x02, 0x02, 0x82, 0x84, 0x78, 0x07, 0x18, 0x20, 0x20, 0x4C, 0x72, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x1F, 0x10, 0x48, 0x28, 0x14,
  0x09, 0x08, 0x78, 0xC2, 0x81, 0x40, 0xA0, 0x50, 0x47, 0xC0, 0x3C, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC3, 0x7A, 0x08, 0x10, 0x4F, 0x00, 0x40, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x52, 0x00, 0x03, 0x1C, 0x20, 0xC0, 0x30, 0x0C,
  0x03, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x70, 0x0C, 0x02, 0x03, 0x0C, 0x70,
  0x80, 0x39, 0x18, 0x41, 0x04, 0x21, 0x08, 0x20, 0x00, 0x00, 0x40, 0x07,
  0x83, 0x08, 0x88, 0x92, 0x94, 0x92, 0xA2, 0x64, 0x94, 0x92, 0x92, 0x52,
  0xD2, 0x24, 0x20, 0x03, 0xE0, 0x02, 0x01, 0x01, 0x40, 0xA0, 0x90, 0x48,
  0x44, 0x22, 0x3F, 0x10, 0x50, 0x28, 0x18, 0x08, 0x3E, 0x10, 0x90, 0x28,
  0x14, 0x12, 0x09, 0xF8, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x4F, 0xC0, 0x1E,
  0x10, 0x88, 0x28, 0x14, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xA0, 0x50,
  0x47, 0xC0, 0x3E, 0x10, 0x90, 0x28, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x81,
  0x40, 0xA0, 0x90, 0xCF, 0x80, 0x3F, 0x90, 0x08, 0x08, 0x04, 0x02, 0x01,
  0xF8, 0x80, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xE0, 0x3F, 0x90, 0x08, 0x08,
  0x04, 0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x00, 0x1F,
  0x10, 0x50, 0x28, 0x14, 0x04, 0x02, 0x01, 0x1E, 0x81, 0x40, 0xA0, 0x50,
  0x27, 0xE0, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0xFD, 0x02, 0x81,
  0x40, 0xA0, 0x50, 0x28, 0x20, 0x3F, 0x82, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x0F, 0xE0, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x41, 0x20, 0x90, 0x87, 0x80, 0x20,
  0x48, 0x22, 0x11, 0x08, 0x44, 0x16, 0x07, 0x01, 0x20, 0x44, 0x21, 0x08,
  0x22, 0x08, 0x81, 0x00, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x0F, 0xE0, 0x20, 0x90, 0x58, 0x6C, 0x35, 0x2A, 0xA5, 0x53,
  0x32, 0x89, 0x40, 0xA0, 0x50, 0x28, 0x10, 0x20, 0x90, 0x58, 0x2A, 0x15,
  0x0A, 0x46, 0x25, 0x12, 0x85, 0x42, 0xA1, 0x50, 0x48, 0x20, 0x1E, 0x10,
  0x88, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x47,
  0xC0, 0x3F, 0x10, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x04, 0xFC, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x00, 0x1E, 0x10, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xA0, 0x50, 0x47, 0xC0, 0x20, 0x08, 0x3E, 0x10, 0x88,
  0x28, 0x14, 0x0A, 0x09, 0x08, 0xF8, 0x44, 0x41, 0x20, 0x90, 0x48, 0x10,
  0x1F, 0x10, 0x50, 0x28, 0x14, 0x01, 0x80, 0x30, 0x04, 0x01, 0x00, 0xA0,
  0x50, 0x27, 0xE0, 0xFF, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x00, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x0A,
  0x06, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x90, 0x47, 0xC0, 0x80, 0xC0, 0xA0,
  0x50, 0x48, 0x22, 0x21, 0x10, 0x90, 0x48, 0x24, 0x14, 0x04, 0x02, 0x00,
  0x88, 0xC4, 0x62, 0x33, 0x29, 0x95, 0x4A, 0xA5, 0x54, 0xCA, 0x65, 0x23,
  0x10, 0x88, 0x40, 0x20, 0x22, 0x08, 0x42, 0x04, 0x80, 0x90, 0x0C, 0x01,
  0x00, 0x50, 0x12, 0x02, 0x20, 0x84, 0x20, 0x88, 0x08, 0x80, 0xC0, 0x90,
  0x88, 0x44, 0x41, 0x40, 0xA0, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x1F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x02, 0x01, 0x00, 0xFF, 0x00, 0x19, 0x08, 0x42, 0x21, 0x08, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x86, 0x00, 0x92, 0x48, 0x92, 0x48, 0x92, 0x40, 0x38,
  0x42, 0x11, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x26, 0x00, 0x08,
  0x61, 0x49, 0x25, 0x18, 0x40, 0xFE, 0xD0, 0x1E, 0x21, 0x41, 0x01, 0x0F,
  0x71, 0x81, 0x82, 0x82, 0x7E, 0x20, 0x20, 0x20, 0x20, 0x5E, 0x61, 0x41,
  0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x1E, 0x21, 0x41, 0x41, 0x80,
  0x80, 0x80, 0x81, 0x42, 0x7C, 0x00, 0x80, 0x40, 0x20, 0x11, 0xC9, 0x19,
  0x04, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x48, 0x23, 0xF0, 0x1E, 0x21, 0x41,
  0x41, 0xFF, 0x80, 0x80, 0x80, 0x42, 0x3C, 0x07, 0x84, 0x04, 0x02, 0x0F,
  0xE0, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x1D,
  0x23, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7E, 0x02, 0x04, 0x84,
  0x78, 0x20, 0x20, 0x20, 0x40, 0x4E, 0x71, 0x41, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x04, 0x00, 0x01, 0xE0, 0x40, 0x82, 0x04, 0x08, 0x10,
  0x20, 0x8F, 0xE0, 0x01, 0x00, 0x00, 0x1E, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0xF0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x0A, 0x19, 0x10, 0x90, 0x50, 0x38, 0x12, 0x10, 0x88, 0x44, 0x10,
  0x3C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x9F,
  0xC0, 0x59, 0x99, 0x94, 0x45, 0x11, 0x84, 0x61, 0x18, 0x86, 0x21, 0x88,
  0xA2, 0x20, 0x4E, 0x71, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82,
  0x1E, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x2F, 0x18,
  0x48, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x3F, 0x10, 0x10, 0x08,
  0x04, 0x00, 0x1D, 0x23, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7E,
  0x02, 0x02, 0x02, 0x04, 0x2F, 0x30, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x1E, 0x21, 0x41, 0x40, 0x30, 0x0E, 0x01, 0x01, 0x82, 0x7C,
  0x10, 0x23, 0xF8, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xE0, 0x41,
  0x41, 0x41, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x7E, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x48, 0x48, 0x50, 0x30, 0x20, 0x84, 0x62, 0x18, 0x8A, 0x52,
  0x95, 0x29, 0x4A, 0x52, 0x98, 0x46, 0x11, 0x00, 0x20, 0x44, 0x21, 0x10,
  0x28, 0x0C, 0x01, 0x00, 0xA0, 0x48, 0x21, 0x30, 0x20, 0x40, 0x50, 0x12,
  0x08, 0x82, 0x21, 0x04, 0x41, 0x20, 0x50, 0x14, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x00, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x3F, 0xE0, 0x06, 0x10, 0x40, 0x81, 0x04, 0x08, 0x10, 0xC0,
  0x81, 0x01, 0x04, 0x08, 0x10, 0x20, 0x20, 0x20, 0x24, 0xA4, 0x92, 0x52,
  0x49, 0x20, 0x30, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x21, 0x04, 0x10,
  0x42, 0x08, 0x42, 0x00, 0x38, 0x51, 0x18, 0x38,
};

const GFXglyph RobotoMono_ThinItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 3, 4, 11, 5, -14 },
  { 8, 11, 13, 11, 0, -13 },
  { 26, 9, 17, 11, 1, -15 },
  { 46, 9, 13, 11, 1, -13 },
  { 61, 9, 13, 11, 1, -13 },
  { 76, 1, 4, 11, 5, -14 },
  { 77, 6, 18, 11, 3, -14 },
  { 91, 5, 18, 11, 2, -14 },
  { 103, 7, 7, 11, 3, -13 },
  { 110, 9, 10, 11, 1, -11 },
  { 122, 2, 3, 11, 2, -1 },
  { 123, 6, 1, 11, 2, -6 },
  { 124, 1, 1, 11, 4, -1 },
  { 125, 9, 14, 11, 1, -13 },
  { 141, 9, 13, 11, 1, -13 },
  { 156, 4, 13, 11, 3, -13 },
  { 163, 9, 13, 11, 0, -13 },
  { 178, 9, 13, 11, 0, -13 },
  { 193, 9, 13, 11, 0, -13 },
  { 208, 8, 13, 11, 2, -13 },
  { 221, 8, 13, 11, 1, -13 },
  { 234, 8, 13, 11, 2, -13 },
  { 247, 9, 13, 11, 1, -13 },
  { 262, 7, 13, 11, 2, -13 },
  { 274, 2, 9, 11, 5, -9 },
  { 277, 3, 11, 11, 4, -9 },
  { 282, 8, 7, 11, 1, -9 },
  { 289, 9, 4, 11, 1, -8 },
  { 294, 8, 7, 11, 1, -9 },
  { 301, 6, 13, 11, 3, -13 },
  { 311, 11, 13, 11, 0, -13 },
  { 329, 9, 13, 11, 0, -13 },
  { 344, 9, 13, 11, 1, -13 },
  { 359, 9, 13, 11, 1, -13 },
  { 374, 9, 13, 11, 1, -13 },
  { 389, 9, 13, 11, 1, -13 },
  { 404, 9, 13, 11, 1, -13 },
  { 419, 9, 13, 11, 1, -13 },
  { 434, 9, 13, 11, 1, -13 },
  { 449, 9, 13, 11, 1, -13 },
  { 464, 9, 13, 11, 1, -13 },
  { 479, 10, 13, 11, 1, -13 },
  { 496, 7, 13, 11, 1, -13 },
  { 508, 9, 13, 11, 1, -13 },
  { 523, 9, 13, 11, 1, -13 },
  { 538, 9, 13, 11, 1, -13 },
  { 553, 9, 13, 11, 1, -13 },
  { 568, 9, 15, 11, 1, -13 },
  { 585, 9, 13, 11, 1, -13 },
  { 600, 9, 13, 11, 1, -13 },
  { 615, 9, 13, 11, 2, -13 },
  { 630, 9, 13, 11, 1, -13 },
  { 645, 9, 13, 11, 2, -13 },
  { 660, 9, 13, 11, 2, -13 },
  { 675, 11, 13, 11, 0, -13 },
  { 693, 9, 13, 11, 2, -13 },
  { 708, 10, 13, 11, 0, -13 },
  { 725, 5, 18, 11, 3, -15 },
  { 737, 3, 14, 11, 4, -13 },
  { 743, 5, 18, 11, 3, -15 },
  { 755, 6, 7, 11, 2, -13 },
  { 761, 7, 1, 11, 1, 0 },
  { 762, 2, 2, 11, 5, -13 },
  { 763, 8, 10, 11, 1, -10 },
  { 773, 8, 14, 11, 1, -14 },
  { 787, 8, 10, 11, 1, -10 },
  { 797, 9, 14, 11, 1, -14 },
  { 813, 8, 10, 11, 1, -10 },
  { 823, 9, 14, 11, 2, -14 },
  { 839, 8, 14, 11, 1, -10 },
  { 853, 8, 14, 11, 1, -14 },
  { 867, 7, 13, 11, 1, -13 },
  { 879, 8, 17, 11, 0, -13 },
  { 896, 9, 14, 11, 1, -14 },
  { 912, 7, 14, 11, 1, -14 },
  { 925, 10, 10, 11, 0, -10 },
  { 938, 8, 10, 11, 1, -10 },
  { 948, 8, 10, 11, 1, -10 },
  { 958, 9, 14, 11, 0, -10 },
  { 974, 8, 14, 11, 1, -10 },
  { 988, 8, 10, 11, 2, -10 },
  { 998, 8, 10, 11, 1, -10 },
  { 1008, 7, 12, 11, 2, -12 },
  { 1019, 8, 10, 11, 1, -10 },
  { 1029, 8, 10, 11, 2, -10 },
  { 1039, 10, 10, 11, 1, -10 },
  { 1052, 10, 10, 11, 0, -10 },
  { 1065, 10, 14, 11, 0, -10 },
  { 1083, 10, 10, 11, 0, -10 },
  { 1096, 7, 18, 11, 3, -14 },
  { 1112, 3, 15, 11, 4, -13 },
  { 1118, 6, 18, 11, 2, -14 },
  { 1132, 10, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_ThinItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_ThinItalic18pt7bBitmaps,
  (GFXglyph *)RobotoMono_ThinItalic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_THINITALIC18PT7B_H_
