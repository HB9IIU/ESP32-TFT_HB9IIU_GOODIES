#ifndef _NOTOSANS_EXTRACONDENSED_BOLD23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEE, 0x66, 0x66, 0x60, 0x4F, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0x0C, 0xC1, 0xB8, 0x36, 0x0E, 0xC7, 0xFE, 0xFF, 0xC6,
  0x60, 0xCC, 0x1B, 0x9F, 0xFF, 0xFF, 0x9D, 0x83, 0x30, 0x66, 0x0C, 0xC1,
  0xB8, 0x08, 0x0F, 0x1F, 0xFF, 0xEE, 0x97, 0x43, 0xE0, 0xF0, 0x3E, 0x07,
  0x83, 0xC1, 0x78, 0xBF, 0x7B, 0xFC, 0xF8, 0x08, 0x04, 0x00, 0x30, 0x00,
  0x78, 0x30, 0xFC, 0x60, 0xCC, 0x60, 0xCC, 0xE0, 0xCC, 0xC0, 0xCC, 0xC0,
  0xCD, 0x9E, 0xFD, 0xBE, 0x7B, 0xB7, 0x33, 0x33, 0x03, 0x33, 0x07, 0x33,
  0x06, 0x33, 0x0E, 0x37, 0x0C, 0x3E, 0x0C, 0x1E, 0x1C, 0x03, 0xE0, 0x7F,
  0x07, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x03, 0xE0, 0x7C, 0xEF, 0xCE, 0xEE,
  0xEE, 0x7E, 0xE7, 0xCE, 0x3C, 0xF7, 0xCF, 0xFE, 0x7E, 0xF0, 0xFF, 0xFF,
  0xC0, 0x1C, 0xE3, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x87,
  0x1C, 0x30, 0xE1, 0x87, 0xF1, 0xC3, 0x8E, 0x18, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xC7, 0x38, 0x0E, 0x03, 0x00, 0xC1, 0xB6,
  0x7F, 0xEF, 0xC1, 0xE0, 0xFC, 0x73, 0x84, 0x80, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC7, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x77, 0xEE, 0xEC,
  0xFF, 0xFE, 0x4F, 0xFE, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x00,
  0x18, 0x1F, 0x1F, 0xDE, 0xEE, 0x77, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x39, 0xFC, 0xFC, 0x3E, 0x00, 0x0E, 0x3C, 0xFB, 0xFE,
  0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x18, 0x3F,
  0x3F, 0xD8, 0xE4, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07,
  0x83, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x7F, 0x3F, 0xC8, 0xE0, 0x70,
  0x38, 0x1C, 0x7C, 0x3C, 0x1F, 0x81, 0xC0, 0xF0, 0x38, 0x3F, 0x3D, 0xFE,
  0xFE, 0x00, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x1B, 0x86, 0xE3, 0x38, 0xCE,
  0x73, 0x98, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0x0E, 0x7F, 0x3F,
  0x98, 0x1C, 0x0E, 0x07, 0x03, 0xF9, 0xFE, 0x47, 0x03, 0xC0, 0xE0, 0x70,
  0x77, 0x7B, 0xFD, 0xF8, 0x07, 0x1F, 0x9F, 0xCE, 0x0E, 0x07, 0x03, 0xB9,
  0xFE, 0xFF, 0x73, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xDC, 0xFE, 0x3E, 0x00,
  0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x18, 0x3F, 0x3F, 0xDC,
  0xEE, 0x3F, 0x19, 0xDC, 0xFC, 0x3C, 0x3F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F,
  0x9F, 0xFE, 0x7E, 0x00, 0x18, 0x3F, 0x3F, 0xDC, 0xEE, 0x7F, 0x1F, 0x8F,
  0xC7, 0xE7, 0xFF, 0xDE, 0xE0, 0x70, 0x70, 0x3A, 0x79, 0xFC, 0xFC, 0x00,
  0x6F, 0xF6, 0x00, 0x00, 0x02, 0xFF, 0xE0, 0x6F, 0xF6, 0x00, 0x00, 0x00,
  0x77, 0xEE, 0xEC, 0x00, 0x80, 0xC1, 0xE3, 0xEF, 0xC7, 0x83, 0xE0, 0xFC,
  0x0F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x80, 0x60, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x3E, 0x7C, 0xF8, 0x70, 0x20,
  0x00, 0x18, 0xFE, 0xFF, 0x47, 0x07, 0x07, 0x0F, 0x0E, 0x1C, 0x18, 0x38,
  0x38, 0x00, 0x10, 0x38, 0x38, 0x38, 0x03, 0x80, 0x1F, 0xC0, 0x71, 0xE1,
  0x80, 0xC7, 0x00, 0xCC, 0xFD, 0xB9, 0xFB, 0xE6, 0x77, 0xCC, 0xE7, 0x99,
  0xCF, 0x33, 0x3E, 0x66, 0x6C, 0xFF, 0xDC, 0xE7, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x30, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0x9C, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0xFC, 0x7F, 0xE7, 0xFE,
  0x70, 0xE7, 0x0E, 0xF0, 0xFE, 0x07, 0xFF, 0xBF, 0xEF, 0x3F, 0xC7, 0xF1,
  0xFC, 0xFF, 0xFB, 0xFC, 0xFF, 0xBC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xFF,
  0xFB, 0xFC, 0x06, 0x07, 0xF3, 0xF9, 0xE2, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0xF8, 0xFE, 0x1F, 0x80,
  0xFF, 0x1F, 0xF3, 0xCF, 0x78, 0xEF, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF8, 0xEF, 0x3D, 0xFF, 0x3F, 0xE7, 0xF0, 0xFF, 0xFF,
  0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xFF, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0x07, 0x03, 0xFC, 0xFF, 0x3C, 0x27, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE7, 0xFC, 0xFF, 0x9F, 0xF0, 0xFF, 0x1E, 0xE3, 0xDF, 0xF9, 0xFF,
  0x1F, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xE7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFF, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xEF,
  0xBE, 0xE0, 0xE3, 0xF9, 0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x8F, 0xC3, 0xF0,
  0xFE, 0x3B, 0x8E, 0xF3, 0x9C, 0xE7, 0x38, 0xEE, 0x3B, 0x8F, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x1F, 0xD8, 0x7F, 0x63,
  0xFD, 0xCD, 0xFF, 0x37, 0xED, 0xDF, 0xB7, 0x7E, 0xF9, 0xFB, 0xE7, 0xE7,
  0x9F, 0x9E, 0x7E, 0x71, 0xF9, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F,
  0x8F, 0xB9, 0xF7, 0x3E, 0x77, 0xEE, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F,
  0xC7, 0xF8, 0x7F, 0x0F, 0x0E, 0x03, 0xF8, 0x7F, 0xC7, 0x9E, 0x70, 0xEF,
  0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xF0, 0xE7,
  0x1E, 0x7F, 0xC3, 0xFC, 0x1F, 0x80, 0xFF, 0x3F, 0xEF, 0x3B, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3B, 0xFE, 0xFF, 0x3F, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x0E, 0x03, 0xF8, 0x7F, 0xC7, 0x9E, 0x70, 0xEF, 0x0E, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xF0, 0xE7, 0x1E, 0x7F,
  0xE3, 0xFC, 0x1F, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0xFF, 0x1F,
  0xF3, 0xCE, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3,
  0xDC, 0x7B, 0xCF, 0x39, 0xE7, 0xBC, 0x77, 0x8F, 0x1C, 0x7F, 0xFF, 0xF2,
  0xE0, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x07, 0x87, 0xFF, 0xFE,
  0xFC, 0xFF, 0xFF, 0xF1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F,
  0xE3, 0xFF, 0xEF, 0xF8, 0xFC, 0xE0, 0x7E, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xC7, 0x1C, 0x39, 0xC3, 0x9C, 0x39, 0x83, 0xB8, 0x1B, 0x81, 0xF8, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC,
  0x7C, 0x77, 0x3E, 0x73, 0x9B, 0x39, 0xCD, 0x9C, 0xE6, 0xCE, 0x77, 0x77,
  0x1F, 0xBB, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x78,
  0xF8, 0x3C, 0x38, 0xF1, 0xCE, 0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0x3E, 0x07,
  0xC0, 0x70, 0x1F, 0x03, 0xE0, 0xFC, 0x1D, 0xC3, 0xB8, 0xE3, 0x9C, 0x77,
  0x8F, 0xF1, 0xEE, 0x39, 0xC7, 0x3D, 0xC3, 0xB8, 0x77, 0x07, 0xC0, 0xF8,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF,
  0xFF, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF, 0xE0, 0x30, 0x1C, 0x0E,
  0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x3F, 0xFF, 0xF0, 0x0C, 0x03, 0xC0, 0x78, 0x1F, 0x83, 0xB0,
  0xE7, 0x1C, 0xE3, 0x0E, 0xE1, 0xD8, 0x1C, 0xFF, 0xFF, 0xC0, 0xE3, 0x8C,
  0x30, 0x3C, 0x7F, 0x7F, 0x07, 0x07, 0x3F, 0x7F, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0x7B, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE6, 0x3B, 0xCF, 0xFB, 0xCE,
  0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xEF, 0x3B, 0xFE, 0xEF, 0x00,
  0x1E, 0x7F, 0x7E, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF2, 0x7E,
  0x3E, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0xBB, 0xFD, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xDE, 0xFF, 0x3D, 0x80, 0x1C, 0x3F, 0x1F,
  0xDC, 0x6E, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x3C, 0x4F, 0xE3, 0xF0,
  0x0C, 0x3F, 0x3E, 0x38, 0x38, 0x7E, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0xBF, 0xDF, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFD, 0xEF, 0xF3, 0xB8, 0x1C, 0x0F, 0x0F,
  0xFF, 0x7F, 0x04, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x67, 0xFF, 0xFF,
  0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80,
  0x5F, 0xB1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x11, 0xCE, 0x30, 0x1C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xC8, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE1, 0xF8, 0xEE, 0x3B, 0x9C, 0xEE, 0x3B, 0x8F, 0xE3,
  0xF8, 0xF7, 0x39, 0xCE, 0x3B, 0x8E, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE7, 0x39, 0xFE, 0xFB, 0xFF, 0xFF, 0x9E, 0x7E, 0x38,
  0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F,
  0x1C, 0x7E, 0x38, 0xE0, 0xE6, 0x7F, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0x1C, 0x3F, 0x9F, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xDD, 0xEF, 0xE3, 0xE0, 0xE6, 0x3B,
  0xCF, 0xFB, 0xCE, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xEF, 0x3B,
  0xFE, 0xEF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x39, 0xBF,
  0xDF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFD, 0xEF, 0xF3,
  0xB8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE7, 0xDF, 0xFF, 0xDF,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x39, 0xFF, 0xF7, 0x0E,
  0x1E, 0x1F, 0x1F, 0x0E, 0x1F, 0x7F, 0xEF, 0xC0, 0x30, 0x60, 0xFF, 0xFF,
  0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xA7, 0xCF, 0x80, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xFD, 0xEF, 0xB3,
  0xD8, 0xE1, 0xF8, 0x77, 0x1D, 0xCE, 0x73, 0x9C, 0xE3, 0x30, 0xFC, 0x3F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x00, 0xE3, 0xC7, 0xE3, 0xCE, 0x73, 0xCE,
  0x73, 0xCE, 0x76, 0xCE, 0x76, 0xCC, 0x76, 0x7C, 0x36, 0x7C, 0x3E, 0x7C,
  0x3E, 0x78, 0x3E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0xE3, 0xDC, 0xE7, 0x38,
  0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0x0F, 0xC7, 0x79, 0xCE, 0xE3,
  0xC0, 0xE1, 0xF8, 0x77, 0x1D, 0xCE, 0x73, 0x8C, 0xE3, 0xB0, 0xFC, 0x3F,
  0x07, 0xC1, 0xE0, 0x78, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x7C, 0x1E, 0x02,
  0x00, 0x7F, 0x7F, 0x7F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x7F,
  0xFF, 0xFF, 0x1E, 0x3C, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0xF9, 0xE3, 0xE1,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x3C, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x3E, 0x3C, 0xF9,
  0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0xC6, 0x00, 0xF0, 0xFF, 0xEF, 0xF0,
  0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 11, 16, 12, 0, -16 },
  { 37, 9, 18, 11, 1, -17 },
  { 58, 16, 17, 18, 1, -17 },
  { 92, 12, 17, 13, 1, -17 },
  { 118, 3, 6, 5, 1, -16 },
  { 121, 6, 20, 7, 1, -16 },
  { 136, 6, 20, 7, 0, -16 },
  { 151, 10, 10, 10, 0, -18 },
  { 164, 9, 11, 11, 1, -14 },
  { 177, 4, 6, 6, 1, -3 },
  { 180, 5, 3, 7, 1, -8 },
  { 182, 4, 4, 6, 1, -4 },
  { 184, 9, 17, 9, 0, -17 },
  { 204, 9, 17, 11, 1, -17 },
  { 224, 7, 16, 11, 1, -16 },
  { 238, 9, 17, 11, 1, -17 },
  { 258, 9, 17, 11, 1, -17 },
  { 278, 10, 16, 11, 0, -16 },
  { 298, 9, 16, 11, 1, -16 },
  { 316, 9, 17, 11, 1, -17 },
  { 336, 10, 16, 11, 0, -16 },
  { 356, 9, 17, 11, 1, -17 },
  { 376, 9, 17, 11, 1, -17 },
  { 396, 4, 13, 6, 1, -13 },
  { 403, 4, 16, 6, 1, -13 },
  { 411, 9, 11, 11, 1, -14 },
  { 424, 9, 7, 11, 1, -12 },
  { 432, 9, 11, 11, 1, -14 },
  { 445, 8, 17, 8, 0, -17 },
  { 462, 15, 19, 17, 1, -17 },
  { 498, 12, 16, 12, 0, -16 },
  { 522, 10, 16, 12, 1, -16 },
  { 542, 10, 17, 11, 1, -17 },
  { 564, 11, 16, 13, 1, -16 },
  { 586, 7, 16, 10, 2, -16 },
  { 600, 7, 16, 10, 2, -16 },
  { 614, 11, 17, 13, 1, -17 },
  { 638, 10, 16, 14, 2, -16 },
  { 658, 6, 16, 7, 1, -16 },
  { 670, 6, 21, 6, -1, -16 },
  { 686, 10, 16, 12, 2, -16 },
  { 706, 8, 16, 9, 1, -16 },
  { 722, 14, 16, 18, 2, -16 },
  { 750, 11, 16, 14, 2, -16 },
  { 772, 12, 17, 14, 1, -17 },
  { 798, 10, 16, 11, 1, -16 },
  { 818, 12, 21, 14, 1, -17 },
  { 850, 11, 16, 12, 1, -16 },
  { 872, 8, 17, 10, 1, -17 },
  { 889, 10, 16, 10, 0, -16 },
  { 909, 10, 16, 13, 2, -16 },
  { 929, 12, 16, 12, 0, -16 },
  { 953, 17, 16, 17, 0, -16 },
  { 987, 11, 16, 11, 0, -16 },
  { 1009, 11, 16, 11, 0, -16 },
  { 1031, 9, 16, 9, 0, -16 },
  { 1049, 6, 20, 7, 1, -16 },
  { 1064, 9, 17, 9, 0, -17 },
  { 1084, 5, 20, 7, 1, -16 },
  { 1097, 11, 10, 12, 1, -16 },
  { 1111, 9, 2, 9, 0, 2 },
  { 1114, 5, 4, 7, 1, -18 },
  { 1117, 8, 13, 11, 1, -13 },
  { 1130, 10, 17, 12, 1, -17 },
  { 1152, 8, 13, 9, 1, -13 },
  { 1165, 9, 17, 12, 1, -17 },
  { 1185, 9, 13, 11, 1, -13 },
  { 1200, 8, 18, 7, 0, -18 },
  { 1218, 9, 19, 12, 1, -13 },
  { 1240, 9, 17, 12, 1, -17 },
  { 1260, 3, 18, 6, 1, -18 },
  { 1267, 5, 24, 6, -1, -18 },
  { 1282, 10, 17, 11, 1, -17 },
  { 1304, 3, 17, 6, 1, -17 },
  { 1311, 15, 13, 17, 1, -13 },
  { 1336, 9, 13, 12, 1, -13 },
  { 1351, 9, 13, 11, 1, -13 },
  { 1366, 10, 19, 12, 1, -13 },
  { 1390, 9, 19, 12, 1, -13 },
  { 1412, 7, 13, 8, 1, -13 },
  { 1424, 7, 13, 9, 1, -13 },
  { 1436, 7, 15, 8, 0, -15 },
  { 1450, 9, 13, 12, 1, -13 },
  { 1465, 10, 13, 10, 0, -13 },
  { 1482, 16, 13, 16, 0, -13 },
  { 1508, 10, 13, 10, 0, -13 },
  { 1525, 10, 19, 10, 0, -13 },
  { 1549, 8, 13, 8, 0, -13 },
  { 1562, 7, 20, 8, 0, -16 },
  { 1580, 2, 23, 10, 4, -18 },
  { 1586, 7, 20, 8, 1, -16 },
  { 1604, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Bold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD23PT7B_H_
