#ifndef _NOTOSANS_EXTRACONDENSED_BOLD7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xB4, 0x7D, 0xFA, 0x79, 0x3C, 0xD6, 0xBE, 0x75, 0x80, 0x6A,
  0x5A, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xFD, 0x00, 0x5D, 0x00, 0xC0,
  0xC0, 0x80, 0x29, 0x28, 0x76, 0xD6, 0x75, 0x40, 0xE4, 0xAE, 0xE5, 0x1E,
  0x2E, 0xF2, 0xF3, 0x9E, 0x73, 0xD6, 0xE5, 0x24, 0xF5, 0x5E, 0xF7, 0x9C,
  0x90, 0x98, 0x71, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xD4, 0x40, 0x75, 0xF7,
  0xF4, 0x18, 0x66, 0x6E, 0x90, 0xF7, 0xDE, 0x72, 0x46, 0xE9, 0x9A, 0xE0,
  0xF3, 0xCE, 0xF3, 0xC8, 0x78, 0xB9, 0x70, 0x99, 0xF9, 0x90, 0xD5, 0xC0,
  0xFC, 0xBA, 0xEA, 0xB0, 0x92, 0x4E, 0xDE, 0xEF, 0x5A, 0x80, 0xDD, 0xBB,
  0x90, 0x69, 0x99, 0x60, 0xF7, 0xC8, 0x69, 0x99, 0x63, 0xEA, 0xEA, 0xB0,
  0xF1, 0x1C, 0xE9, 0x24, 0x99, 0x99, 0x60, 0xBA, 0x66, 0x40, 0xAD, 0x6A,
  0xB5, 0x00, 0xAD, 0x3A, 0xAD, 0x24, 0xE9, 0x4E, 0xEA, 0xB0, 0x89, 0x22,
  0xD5, 0x70, 0x46, 0xB0, 0xE0, 0xC0, 0xEE, 0xF0, 0x9E, 0xDE, 0x72, 0x30,
  0x2E, 0xD6, 0x77, 0x30, 0x7A, 0x80, 0x76, 0xB3, 0x80, 0x9E, 0xDA, 0xF8,
  0xFE, 0x97, 0x7A, 0xF8, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0x76, 0xB0, 0xF6,
  0xF9, 0x00, 0x76, 0xB2, 0x40, 0xEA, 0xE7, 0x7A, 0x40, 0xB6, 0xB0, 0xB5,
  0x20, 0xAD, 0x94, 0xA0, 0xA9, 0x50, 0xB5, 0x25, 0x00, 0xD7, 0x57, 0x50,
  0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 3, 2, 3, 0, -5 },
  { 3, 3, 5, 4, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 5, 5, 0, -5 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 1, 2, 2, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 3, 3, 3, 0, -5 },
  { 21, 3, 3, 3, 0, -4 },
  { 23, 1, 2, 2, 0, -1 },
  { 24, 2, 1, 2, 0, -2 },
  { 25, 1, 1, 2, 0, -1 },
  { 26, 3, 5, 3, 0, -5 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 2, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 1, 4, 2, 0, -4 },
  { 49, 1, 5, 2, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 3, 3, 0, -4 },
  { 54, 3, 3, 3, 0, -4 },
  { 56, 2, 5, 3, 0, -5 },
  { 58, 5, 6, 5, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 3, 5, 4, 0, -5 },
  { 67, 3, 5, 3, 0, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 3, 5, 3, 0, -5 },
  { 74, 3, 5, 3, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 2, 5, 2, 0, -5 },
  { 84, 1, 6, 2, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 3, 5, 3, 0, -5 },
  { 90, 5, 5, 5, 0, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 4, 6, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 5, 5, 5, 0, -5 },
  { 122, 3, 5, 3, 0, -5 },
  { 124, 3, 5, 3, 0, -5 },
  { 126, 3, 5, 3, 0, -5 },
  { 128, 2, 6, 2, 0, -5 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 2, 6, 2, 0, -5 },
  { 134, 4, 3, 4, 0, -5 },
  { 136, 3, 1, 3, 0, 0 },
  { 137, 2, 1, 2, 0, -5 },
  { 138, 3, 4, 3, 0, -4 },
  { 140, 3, 5, 4, 0, -5 },
  { 142, 3, 4, 3, 0, -4 },
  { 144, 3, 5, 4, 0, -5 },
  { 146, 3, 4, 3, 0, -4 },
  { 148, 2, 5, 2, 0, -5 },
  { 150, 3, 6, 4, 0, -4 },
  { 153, 3, 5, 4, 0, -5 },
  { 155, 1, 5, 2, 0, -5 },
  { 156, 1, 7, 2, 0, -5 },
  { 157, 3, 5, 3, 0, -5 },
  { 159, 1, 5, 2, 0, -5 },
  { 160, 5, 4, 5, 0, -4 },
  { 163, 3, 4, 4, 0, -4 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 3, 6, 4, 0, -4 },
  { 170, 3, 6, 4, 0, -4 },
  { 173, 2, 4, 2, 0, -4 },
  { 174, 2, 4, 3, 0, -4 },
  { 175, 2, 5, 2, 0, -5 },
  { 177, 3, 4, 4, 0, -4 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 5, 4, 5, 0, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 3, 6, 3, 0, -4 },
  { 189, 2, 4, 3, 0, -4 },
  { 190, 2, 6, 2, 0, -5 },
  { 192, 1, 7, 3, 1, -5 },
  { 193, 2, 6, 2, 0, -5 },
  { 195, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Bold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD7PT7B_H_
