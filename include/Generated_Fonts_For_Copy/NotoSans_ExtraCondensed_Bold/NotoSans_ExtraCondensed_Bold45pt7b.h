#ifndef _NOTOSANS_EXTRACONDENSED_BOLD45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x00, 0x00, 0x79,
  0xFF, 0xFF, 0xFF, 0xDF, 0xBE, 0x10, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x83, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC1, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x7F,
  0x00, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0xCF, 0x7E,
  0x61, 0x3F, 0x30, 0x1F, 0x98, 0x0F, 0xCC, 0x07, 0xF6, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0x7E, 0x01, 0x9F, 0x80, 0xCF, 0xE0, 0x6F, 0xFC,
  0x37, 0xFF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x3F,
  0xF0, 0x1F, 0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x7C, 0xF0, 0x3E, 0x00, 0x78,
  0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x3C, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0xF8,
  0x78, 0x78, 0x00, 0xF8, 0x78, 0x78, 0x00, 0xF8, 0x78, 0xF8, 0x00, 0xF8,
  0xF8, 0xF0, 0x00, 0x78, 0xF9, 0xF0, 0xF0, 0x78, 0xF9, 0xE3, 0xF8, 0x7C,
  0xF1, 0xE7, 0xFC, 0x7F, 0xF3, 0xE7, 0xFE, 0x3F, 0xF3, 0xCF, 0xFE, 0x3F,
  0xE7, 0xCF, 0x9F, 0x1F, 0xC7, 0xCF, 0x1F, 0x02, 0x07, 0x8F, 0x0F, 0x00,
  0x0F, 0x8F, 0x0F, 0x00, 0x0F, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x0F, 0x00,
  0x1F, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x0F, 0x00, 0x3E, 0x0F, 0x1F, 0x00,
  0x3C, 0x0F, 0x1F, 0x00, 0x3C, 0x0F, 0x9F, 0x00, 0x7C, 0x07, 0xFE, 0x00,
  0x78, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x40, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x7E, 0x3F, 0xF8, 0x7E, 0x3F, 0xFC, 0x7E, 0x7F, 0xFC, 0xFE, 0x7E,
  0x7E, 0xFC, 0xFC, 0x7F, 0xFC, 0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xF8, 0xFC,
  0x1F, 0xF8, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFE, 0x0F,
  0xF8, 0x7F, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0,
  0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x61, 0xE1, 0x9E, 0x79, 0xE7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xCF,
  0x83, 0xF3, 0xF8, 0x78, 0x78, 0x0E, 0x1C, 0x01, 0x02, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x40, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x0F, 0x9F, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF,
  0x83, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFD, 0xF0, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F,
  0x7E, 0x0F, 0xDF, 0x83, 0xE3, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFD, 0xF3, 0xF3, 0x8F, 0xC4, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xC1, 0xF8, 0xC0, 0x7E, 0x10,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x07, 0xFF,
  0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3, 0x81, 0xF8,
  0x40, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1E,
  0xFC, 0x07, 0xDF, 0x80, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0x8F, 0xC1, 0xF1,
  0xF8, 0x3C, 0x3F, 0x0F, 0x87, 0xE1, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x98, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xB8, 0x1F,
  0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xF0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF1, 0xF0, 0x7C, 0xFE, 0x1F, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xF7, 0xC0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF3, 0xF1, 0xFC,
  0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x40, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xC7,
  0xE7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xF8,
  0xFC, 0x7E, 0x3F, 0xBF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0xFE, 0x7F, 0x1F, 0x9F, 0x83,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFD,
  0xF8, 0x3F, 0x7F, 0xBF, 0xDF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0x87, 0xE7, 0xE1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xFD,
  0xFC, 0xFF, 0x7F, 0xFF, 0xCF, 0xFD, 0xF3, 0xFF, 0x7C, 0x7F, 0xBF, 0x07,
  0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0x3C, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xFF, 0xFF, 0xBF, 0x7C,
  0x20, 0x3C, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBF, 0x7C, 0xFB,
  0xF7, 0xEF, 0x9F, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFF, 0x30, 0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3C, 0x3C, 0x0F, 0xE1, 0xF3, 0xE0, 0xFF, 0xCF, 0x9E, 0x0F, 0xFE,
  0x3C, 0xF0, 0xFD, 0xF1, 0xEF, 0x8F, 0x8F, 0x8F, 0xFC, 0x7C, 0x7C, 0x7F,
  0xC3, 0xC3, 0xE3, 0xFE, 0x3E, 0x1F, 0x1F, 0xF1, 0xF0, 0xF8, 0xFF, 0x8F,
  0x87, 0xC7, 0xFC, 0x7C, 0x3E, 0x3F, 0xE3, 0xE1, 0xE1, 0xEF, 0x1F, 0x0F,
  0x0F, 0x78, 0x78, 0xF8, 0x7B, 0xC3, 0xE7, 0xE7, 0xDF, 0x1F, 0xFF, 0xFC,
  0xF8, 0x7F, 0xBF, 0xC3, 0xC1, 0xF8, 0xFE, 0x1F, 0x07, 0x83, 0xC0, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x18, 0x01, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x07,
  0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x01, 0xFC, 0x3F,
  0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F,
  0xEF, 0xC3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFB, 0xF0, 0x7F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x8F, 0xF0, 0x61, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x01, 0x1F, 0xE0, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xC3, 0xFC, 0xFC, 0x1F,
  0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC1, 0xFC,
  0xFC, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0x81, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03,
  0xFB, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xFF, 0xFD, 0xFF, 0xBF, 0xE7,
  0xFC, 0xFE, 0x06, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7, 0xF0,
  0xFC, 0x7F, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x0F, 0xDF, 0xC0, 0xFD, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0x7F, 0xFB, 0xC0, 0xFB, 0xFF, 0xDF, 0x07, 0xDF, 0xFE,
  0xF8, 0x3C, 0xFF, 0xF7, 0xC3, 0xE7, 0xFF, 0x9E, 0x1F, 0x3F, 0xFC, 0xF8,
  0xF9, 0xFF, 0xE7, 0xCF, 0x8F, 0xFF, 0x3E, 0x7C, 0x7F, 0xF8, 0xF3, 0xE3,
  0xFF, 0xC7, 0xDE, 0x1F, 0xFE, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0x87, 0xFF,
  0x87, 0xFC, 0x3F, 0xFC, 0x3F, 0xC1, 0xFF, 0xE1, 0xFE, 0x0F, 0xFF, 0x0F,
  0xF0, 0x7F, 0xF8, 0x7F, 0x83, 0xFF, 0xC1, 0xF8, 0x1F, 0xFE, 0x0F, 0xC0,
  0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0x83, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFD, 0xF8, 0x7F, 0xF7, 0xE1, 0xFF, 0xCF,
  0xC7, 0xFF, 0x3F, 0x1F, 0xFC, 0x7C, 0x7F, 0xF1, 0xF9, 0xFF, 0xC7, 0xE7,
  0xFF, 0x0F, 0xDF, 0xFC, 0x3F, 0x7F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0x00, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFC, 0x7F,
  0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0,
  0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC,
  0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x1F,
  0xEF, 0xC1, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC3, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x01,
  0xFC, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F,
  0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0xFE,
  0x03, 0xF8, 0xFC, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC7, 0xF8,
  0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFE, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE,
  0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x00, 0x60, 0x03, 0xFE, 0x07, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x38, 0xFC, 0x04, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F,
  0xF8, 0x0F, 0xDF, 0x0F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC,
  0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x07,
  0xEF, 0xC0, 0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xE0, 0x3F, 0xBF, 0x00, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0x7C, 0x07, 0xF0, 0x1F, 0x8F, 0xC0,
  0xFF, 0x03, 0xF1, 0xF8, 0x1F, 0xE0, 0x7E, 0x3F, 0x07, 0xFC, 0x1F, 0x87,
  0xE0, 0xFF, 0x83, 0xF0, 0x7C, 0x1F, 0xF0, 0x7E, 0x0F, 0xC3, 0xDF, 0x0F,
  0xC1, 0xF8, 0x7B, 0xE1, 0xF8, 0x3F, 0x1F, 0x7C, 0x7E, 0x07, 0xE3, 0xE7,
  0x8F, 0xC0, 0x7C, 0x7C, 0xF1, 0xF8, 0x0F, 0x8F, 0x9F, 0x3F, 0x01, 0xF9,
  0xF3, 0xE7, 0xE0, 0x3F, 0x7C, 0x7C, 0xF8, 0x07, 0xEF, 0x8F, 0xBF, 0x00,
  0x7D, 0xF0, 0xF7, 0xE0, 0x0F, 0xBE, 0x1E, 0xFC, 0x01, 0xF7, 0xC3, 0xFF,
  0x80, 0x3E, 0xF0, 0x7F, 0xE0, 0x07, 0xDE, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x03, 0xF3, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x3F, 0x81, 0xF9, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFC,
  0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE1, 0xF0, 0x1F,
  0x87, 0xC0, 0x7C, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x7E, 0x01,
  0xF1, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x03,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xE0, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xFF, 0xE3, 0xFF,
  0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xF7, 0xE7, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0x7F, 0xCF, 0x1F, 0xC7, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x3E, 0x0F, 0x9F, 0xE3, 0xEF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF,
  0xEF, 0xE3, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFE, 0x1F, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xEF, 0xFC, 0xFB, 0xFE, 0x3C, 0x7F, 0x00, 0x03, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0xE1, 0xBF, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x27,
  0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC3, 0xE3, 0xF1, 0xFE, 0xFC, 0xFF, 0xBF,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xDF, 0xDF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xE7, 0xC3,
  0xF1, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xF3, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x27, 0xF9, 0xF3, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0x87, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xBF, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x90, 0x07, 0xE7, 0x87, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7C, 0x3E, 0x7F, 0x9F, 0x7F, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x7C, 0xFB,
  0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF8, 0x0F, 0x83, 0xE1, 0xFC, 0x7F, 0x1F, 0x83, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x1F, 0x87, 0xE1, 0xFA, 0xFE, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81,
  0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F,
  0x87, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x3F, 0x03, 0xEF, 0xC0, 0x7D, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x3F,
  0x3F, 0x07, 0xE7, 0xE0, 0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xFC, 0x1F, 0x8F,
  0x1F, 0xE3, 0xFC, 0xFB, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFE, 0x7F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x81,
  0xF8, 0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x1F, 0x83,
  0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x81, 0xF8, 0x3F, 0xF8,
  0x1F, 0x83, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x81, 0xF8,
  0x3F, 0xF8, 0x1F, 0x83, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x1F, 0x83, 0xF0,
  0xF0, 0xF8, 0x78, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF, 0xE1, 0xFB, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFD, 0xF8, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xF8, 0x00, 0xF0, 0xF8, 0x3E, 0x7F, 0x8F, 0xBF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0x8F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF8, 0x7E,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xBF, 0xF3, 0xE7, 0xF8, 0xF8, 0xFC, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x0F, 0x87, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xBF, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0x1F,
  0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0x83, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x07,
  0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC, 0x7F, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xFF, 0xCF, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xF8, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFF, 0x7C, 0xFF, 0x9F, 0x0F, 0xC7, 0xC0, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xF0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0x83, 0xF7, 0xC0, 0xFE, 0x0F, 0xDF, 0x87,
  0xF8, 0x3F, 0x7E, 0x1F, 0xE0, 0xF9, 0xF8, 0x7F, 0x83, 0xE3, 0xE1, 0xFF,
  0x1F, 0x8F, 0xC7, 0xBC, 0x7E, 0x3F, 0x1E, 0xF1, 0xF8, 0xFC, 0xF3, 0xC7,
  0xC3, 0xF3, 0xCF, 0x3F, 0x07, 0xCF, 0x1E, 0xFC, 0x1F, 0x3C, 0x7B, 0xF0,
  0x7E, 0xF1, 0xEF, 0x81, 0xFB, 0xC7, 0xBE, 0x03, 0xFE, 0x1E, 0xF8, 0x0F,
  0xF8, 0x7B, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xEF,
  0xC1, 0xF9, 0xF8, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x3F, 0x7E, 0x07,
  0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xF7, 0xC0, 0x7E, 0xFC, 0x0F, 0x9F, 0x83, 0xF1, 0xF8, 0x7E,
  0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xE0, 0x7C,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x9F,
  0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xDF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x2F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0x83,
  0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x7F, 0x87, 0xFC,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x27, 0xF0, 0x07, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xF4, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 33, 12, 2, -32 },
  { 30, 16, 11, 20, 2, -32 },
  { 52, 21, 32, 23, 1, -32 },
  { 136, 17, 37, 21, 2, -34 },
  { 215, 32, 33, 35, 1, -33 },
  { 347, 24, 33, 25, 1, -33 },
  { 446, 7, 11, 11, 2, -32 },
  { 456, 12, 39, 14, 2, -32 },
  { 515, 11, 39, 14, 1, -32 },
  { 569, 18, 18, 20, 1, -34 },
  { 610, 19, 22, 21, 1, -27 },
  { 663, 8, 11, 11, 1, -5 },
  { 674, 11, 6, 14, 1, -15 },
  { 683, 7, 8, 11, 2, -7 },
  { 690, 18, 32, 18, 0, -32 },
  { 762, 18, 33, 21, 1, -33 },
  { 837, 14, 32, 21, 2, -32 },
  { 893, 18, 33, 21, 1, -33 },
  { 968, 18, 33, 21, 1, -33 },
  { 1043, 19, 32, 21, 1, -32 },
  { 1119, 17, 32, 21, 2, -32 },
  { 1187, 18, 32, 21, 1, -32 },
  { 1259, 18, 32, 21, 1, -32 },
  { 1331, 18, 33, 21, 1, -33 },
  { 1406, 18, 32, 21, 1, -32 },
  { 1478, 7, 26, 12, 2, -25 },
  { 1501, 7, 31, 12, 2, -25 },
  { 1529, 19, 22, 21, 1, -27 },
  { 1582, 19, 14, 21, 1, -23 },
  { 1616, 19, 22, 21, 1, -27 },
  { 1669, 16, 34, 17, 0, -33 },
  { 1737, 29, 36, 32, 2, -32 },
  { 1868, 24, 32, 24, 0, -32 },
  { 1964, 19, 32, 24, 3, -32 },
  { 2040, 19, 33, 22, 2, -33 },
  { 2119, 20, 32, 25, 3, -32 },
  { 2199, 14, 32, 20, 3, -32 },
  { 2255, 14, 32, 19, 3, -32 },
  { 2311, 21, 33, 25, 2, -33 },
  { 2398, 20, 32, 26, 3, -32 },
  { 2478, 12, 32, 14, 1, -32 },
  { 2526, 11, 42, 12, -2, -32 },
  { 2584, 20, 32, 23, 3, -32 },
  { 2664, 15, 32, 18, 3, -32 },
  { 2724, 29, 32, 35, 3, -32 },
  { 2840, 22, 32, 28, 3, -32 },
  { 2928, 23, 33, 27, 2, -33 },
  { 3023, 18, 32, 22, 3, -32 },
  { 3095, 23, 41, 27, 2, -33 },
  { 3213, 20, 32, 23, 3, -32 },
  { 3293, 17, 33, 19, 1, -33 },
  { 3364, 18, 32, 19, 1, -32 },
  { 3436, 20, 32, 26, 3, -32 },
  { 3516, 23, 32, 23, 0, -32 },
  { 3608, 35, 32, 34, -1, -32 },
  { 3748, 21, 32, 21, 0, -32 },
  { 3832, 21, 32, 21, 0, -32 },
  { 3916, 17, 32, 19, 1, -32 },
  { 3984, 10, 39, 14, 3, -32 },
  { 4033, 18, 32, 18, 0, -32 },
  { 4105, 10, 39, 14, 1, -32 },
  { 4154, 22, 19, 24, 1, -32 },
  { 4207, 18, 3, 18, 0, 4 },
  { 4214, 10, 7, 14, 2, -34 },
  { 4223, 17, 25, 21, 1, -25 },
  { 4277, 18, 34, 23, 3, -34 },
  { 4354, 15, 25, 18, 2, -25 },
  { 4401, 18, 34, 23, 2, -34 },
  { 4478, 17, 25, 21, 2, -25 },
  { 4532, 15, 34, 13, 0, -34 },
  { 4596, 18, 36, 23, 2, -25 },
  { 4677, 17, 34, 23, 3, -34 },
  { 4750, 7, 34, 11, 2, -34 },
  { 4780, 10, 45, 11, -1, -34 },
  { 4837, 19, 34, 22, 3, -34 },
  { 4918, 5, 34, 11, 3, -34 },
  { 4940, 28, 25, 34, 3, -25 },
  { 5028, 17, 25, 23, 3, -25 },
  { 5082, 18, 25, 22, 2, -25 },
  { 5139, 18, 36, 23, 3, -25 },
  { 5220, 18, 36, 23, 2, -25 },
  { 5301, 12, 25, 16, 3, -25 },
  { 5339, 15, 25, 17, 1, -25 },
  { 5386, 13, 30, 15, 1, -30 },
  { 5435, 18, 25, 23, 2, -25 },
  { 5492, 20, 25, 20, 0, -25 },
  { 5555, 30, 25, 31, 0, -25 },
  { 5649, 19, 25, 19, 0, -25 },
  { 5709, 20, 36, 20, 0, -25 },
  { 5799, 14, 25, 16, 1, -25 },
  { 5843, 14, 39, 16, 0, -32 },
  { 5912, 5, 44, 20, 7, -34 },
  { 5940, 13, 39, 16, 2, -32 },
  { 6004, 19, 8, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Bold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD45PT7B_H_
