#ifndef _NOTOSANS_EXTRACONDENSED_BOLD13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA3, 0xC0, 0xBB, 0x90, 0x3C, 0xA7, 0xDF, 0x2B, 0xF7, 0x96,
  0x50, 0x27, 0xFA, 0xC7, 0x3B, 0xF2, 0x20, 0x72, 0x35, 0x8D, 0x43, 0x56,
  0x7F, 0x82, 0xB0, 0xAC, 0x4A, 0x11, 0x80, 0x78, 0xD1, 0xE3, 0x87, 0x7B,
  0xF3, 0x76, 0x7E, 0xE0, 0x7B, 0x49, 0x24, 0xC9, 0x80, 0xCC, 0x92, 0x49,
  0x6F, 0x00, 0x32, 0xEF, 0xCC, 0x58, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00,
  0x69, 0x60, 0xF0, 0xF0, 0x18, 0x84, 0x62, 0x31, 0x88, 0xC0, 0x79, 0x64,
  0xB3, 0xCF, 0x24, 0x9E, 0x78, 0x7F, 0xB3, 0x33, 0x33, 0x30, 0xFA, 0xC2,
  0x31, 0x99, 0x8F, 0xF8, 0xF9, 0x60, 0x9E, 0x78, 0x20, 0xE6, 0xF8, 0x18,
  0xE3, 0x9E, 0x5B, 0x6F, 0xC6, 0x18, 0xF8, 0x8F, 0xF1, 0x1B, 0xE0, 0x39,
  0x84, 0x3E, 0xFB, 0x3C, 0xDE, 0x78, 0xFC, 0x21, 0x86, 0x10, 0xC3, 0x08,
  0x60, 0x79, 0x24, 0x9E, 0x79, 0x6C, 0xF2, 0x78, 0x79, 0x6C, 0xB3, 0x7D,
  0xA0, 0x86, 0x70, 0xF0, 0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x04, 0x77, 0x38,
  0x38, 0x30, 0xFF, 0xF0, 0x3F, 0x83, 0x83, 0x87, 0x73, 0x00, 0xF4, 0xC6,
  0x62, 0x30, 0x0C, 0x60, 0x3E, 0x30, 0x93, 0xEA, 0xD5, 0x6E, 0xA5, 0x7C,
  0x94, 0x62, 0x0F, 0x00, 0x38, 0x70, 0xA3, 0x46, 0xCF, 0x9F, 0x62, 0xC6,
  0xFE, 0xF7, 0xFF, 0xEF, 0x7B, 0xF0, 0x7E, 0x71, 0x08, 0x43, 0x1D, 0x78,
  0xF3, 0x6C, 0xF3, 0xCF, 0x3C, 0xBE, 0xF0, 0xFC, 0xCF, 0xFC, 0xCF, 0xF0,
  0xFC, 0xCC, 0xFC, 0xCC, 0xC0, 0x7F, 0x2C, 0x20, 0x9E, 0x3C, 0xF3, 0x7C,
  0xCF, 0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xCC, 0xF6, 0x66, 0x66, 0x66, 0xF0,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xEC, 0xDF, 0x6F, 0x3C, 0xF3, 0xCD, 0xB6,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE3, 0xE7, 0xA5, 0xE7, 0xFF, 0xFF,
  0xDB, 0xDB, 0xDB, 0xC7, 0x9E, 0x6D, 0xF7, 0x5D, 0xF3, 0xCC, 0x7B, 0x3C,
  0xE3, 0x8E, 0x3C, 0xFF, 0x78, 0xF6, 0xF7, 0xBF, 0xF3, 0x18, 0xC0, 0x7B,
  0x3C, 0xE3, 0x8E, 0x3C, 0xFF, 0x78, 0x60, 0xC0, 0xF3, 0x6D, 0xB6, 0xF3,
  0xCD, 0x36, 0xDC, 0x7A, 0x70, 0xC3, 0x0C, 0x7F, 0xF0, 0xF9, 0x8C, 0x63,
  0x18, 0xC6, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF6, 0x78, 0xC7, 0x89,
  0x33, 0x66, 0x8D, 0x0E, 0x1C, 0x30, 0xCC, 0xF3, 0x3C, 0xC9, 0x76, 0x5F,
  0x9D, 0xE7, 0x39, 0xCC, 0x33, 0x00, 0xCD, 0xE7, 0x8C, 0x30, 0xE7, 0x92,
  0xCC, 0xCD, 0x27, 0x9E, 0x30, 0xC3, 0x0C, 0x30, 0xF8, 0xC4, 0x62, 0x31,
  0x1F, 0xF8, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x18, 0x42, 0x18, 0x43,
  0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0x70, 0xA3, 0x6C, 0x60, 0xF8,
  0xCC, 0x7A, 0xC2, 0xFC, 0xED, 0xA0, 0x84, 0x21, 0x6D, 0xCE, 0x73, 0xDD,
  0x80, 0x7B, 0x51, 0x84, 0x35, 0xE0, 0x0C, 0x30, 0xDF, 0x6D, 0x3C, 0xD3,
  0x6D, 0xF0, 0x79, 0x24, 0xFF, 0x41, 0xA7, 0x80, 0x77, 0x6F, 0x66, 0x66,
  0x66, 0x7D, 0xB4, 0xF3, 0x4D, 0xB7, 0xC3, 0x59, 0xE0, 0x84, 0x21, 0x6D,
  0xCE, 0x73, 0x9C, 0xC0, 0xB2, 0xAA, 0xA0, 0x4C, 0x24, 0x92, 0x49, 0x2C,
  0x84, 0x21, 0x3B, 0x53, 0xDE, 0x9C, 0xC0, 0xFF, 0xC0, 0xB7, 0xDB, 0x9B,
  0x9B, 0x9B, 0x9B, 0x9B, 0xB6, 0xE7, 0x39, 0xCE, 0x60, 0x79, 0xB4, 0xF3,
  0x4D, 0xB7, 0x80, 0xB6, 0xE7, 0x39, 0xEE, 0xD0, 0x84, 0x00, 0x7D, 0xB4,
  0xF3, 0x4D, 0xB7, 0xC3, 0x0C, 0x30, 0xBF, 0x49, 0x20, 0x76, 0xB8, 0xE1,
  0x4F, 0xC0, 0x66, 0xF6, 0x66, 0x67, 0x70, 0x9C, 0xE7, 0x39, 0xEF, 0xE0,
  0xCF, 0x25, 0x9E, 0x70, 0xC3, 0x00, 0xD9, 0xEE, 0x95, 0x4A, 0xE7, 0x73,
  0xB0, 0xD8, 0xDB, 0xDC, 0x67, 0x2F, 0x60, 0xCF, 0x25, 0x9E, 0x70, 0xC3,
  0x0C, 0x63, 0x80, 0xF3, 0x36, 0x6C, 0xF0, 0x36, 0x66, 0x6C, 0x66, 0x62,
  0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0xE6, 0x66, 0x23, 0x66, 0x66, 0xE0, 0x67,
  0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 6, 9, 7, 0, -9 },
  { 13, 4, 11, 6, 1, -10 },
  { 19, 10, 9, 10, 0, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 1, 3, 3, 1, -9 },
  { 40, 3, 11, 4, 1, -9 },
  { 45, 3, 11, 4, 0, -9 },
  { 50, 6, 5, 6, 0, -10 },
  { 54, 6, 7, 6, 0, -8 },
  { 60, 3, 4, 3, 0, -2 },
  { 62, 4, 1, 4, 0, -4 },
  { 63, 2, 2, 3, 1, -2 },
  { 64, 5, 9, 5, 0, -9 },
  { 70, 6, 9, 6, 0, -9 },
  { 77, 4, 9, 6, 1, -9 },
  { 82, 5, 9, 6, 0, -9 },
  { 88, 6, 9, 6, 0, -9 },
  { 95, 6, 9, 6, 0, -9 },
  { 102, 4, 9, 6, 1, -9 },
  { 107, 6, 9, 6, 0, -9 },
  { 114, 6, 9, 6, 0, -9 },
  { 121, 6, 9, 6, 0, -9 },
  { 128, 6, 9, 6, 0, -9 },
  { 135, 2, 7, 3, 1, -7 },
  { 137, 3, 9, 3, 0, -7 },
  { 141, 6, 6, 6, 0, -8 },
  { 146, 6, 4, 6, 0, -7 },
  { 149, 6, 6, 6, 0, -8 },
  { 154, 5, 9, 5, 0, -9 },
  { 160, 9, 10, 9, 0, -9 },
  { 172, 7, 9, 7, 0, -9 },
  { 180, 5, 9, 7, 1, -9 },
  { 186, 5, 9, 6, 1, -9 },
  { 192, 6, 9, 7, 1, -9 },
  { 199, 4, 9, 6, 1, -9 },
  { 204, 4, 9, 6, 1, -9 },
  { 209, 6, 9, 7, 1, -9 },
  { 216, 6, 9, 8, 1, -9 },
  { 223, 4, 9, 4, 0, -9 },
  { 228, 4, 12, 4, -1, -9 },
  { 234, 6, 9, 7, 1, -9 },
  { 241, 4, 9, 5, 1, -9 },
  { 246, 8, 9, 10, 1, -9 },
  { 255, 6, 9, 8, 1, -9 },
  { 262, 6, 9, 8, 1, -9 },
  { 269, 5, 9, 6, 1, -9 },
  { 275, 6, 11, 8, 1, -9 },
  { 284, 6, 9, 7, 1, -9 },
  { 291, 5, 9, 6, 0, -9 },
  { 297, 5, 9, 6, 0, -9 },
  { 303, 6, 9, 7, 1, -9 },
  { 310, 7, 9, 7, 0, -9 },
  { 318, 10, 9, 10, 0, -9 },
  { 330, 6, 9, 6, 0, -9 },
  { 337, 6, 9, 6, 0, -9 },
  { 344, 5, 9, 5, 0, -9 },
  { 350, 3, 11, 4, 1, -9 },
  { 355, 5, 9, 5, 0, -9 },
  { 361, 3, 11, 4, 0, -9 },
  { 366, 7, 5, 7, 0, -9 },
  { 371, 5, 1, 5, 0, 1 },
  { 372, 3, 2, 4, 1, -10 },
  { 373, 5, 7, 6, 0, -7 },
  { 378, 5, 10, 7, 1, -10 },
  { 385, 5, 7, 5, 0, -7 },
  { 390, 6, 10, 7, 0, -10 },
  { 398, 6, 7, 6, 0, -7 },
  { 404, 4, 10, 4, 0, -10 },
  { 409, 6, 10, 7, 0, -7 },
  { 417, 5, 10, 7, 1, -10 },
  { 424, 2, 10, 3, 1, -10 },
  { 427, 3, 13, 3, 0, -10 },
  { 432, 5, 10, 6, 1, -10 },
  { 439, 1, 10, 3, 1, -10 },
  { 441, 8, 7, 10, 1, -7 },
  { 448, 5, 7, 7, 1, -7 },
  { 453, 6, 7, 6, 0, -7 },
  { 459, 5, 10, 7, 1, -7 },
  { 466, 6, 10, 7, 0, -7 },
  { 474, 3, 7, 5, 1, -7 },
  { 477, 5, 7, 5, 0, -7 },
  { 482, 4, 9, 4, 0, -9 },
  { 487, 5, 7, 7, 1, -7 },
  { 492, 6, 7, 6, 0, -7 },
  { 498, 9, 7, 9, 0, -7 },
  { 506, 5, 7, 6, 0, -7 },
  { 511, 6, 10, 6, 0, -7 },
  { 519, 4, 7, 5, 0, -7 },
  { 523, 4, 11, 5, 0, -9 },
  { 529, 2, 13, 6, 2, -10 },
  { 533, 4, 11, 5, 0, -9 },
  { 539, 6, 3, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Bold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD13PT7B_H_
