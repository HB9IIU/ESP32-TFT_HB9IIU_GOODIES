#ifndef _NOTOSANS_EXTRACONDENSED_BOLD35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x70,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xF9, 0xFF, 0x9F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xF0, 0xE0, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x3C, 0x07, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1C,
  0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xF0, 0x3C, 0xE0, 0x3C,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xF8, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x9E, 0xC4, 0x7B,
  0x01, 0xEC, 0x07, 0xB0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x0D, 0xF0, 0x37, 0xC0, 0xCF, 0xC3, 0x7F, 0xCF, 0xEF,
  0xFF, 0xBF, 0xFC, 0x3F, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x3F, 0x01, 0xE0, 0x3F, 0x80, 0xE0, 0x1F, 0xE0, 0x70, 0x0E, 0x70, 0x78,
  0x0F, 0x3C, 0x38, 0x07, 0x9E, 0x3C, 0x03, 0xCF, 0x1E, 0x01, 0xE7, 0x8E,
  0x00, 0xF3, 0xCF, 0x00, 0x79, 0xE7, 0x00, 0x3C, 0xF7, 0x9F, 0x8E, 0x73,
  0xDF, 0xC7, 0xF9, 0xCF, 0xF1, 0xFD, 0xEF, 0x38, 0xFC, 0xE7, 0x9E, 0x00,
  0x73, 0xCF, 0x00, 0x79, 0xE7, 0x80, 0x38, 0xF3, 0xC0, 0x3C, 0x79, 0xE0,
  0x1E, 0x3C, 0xF0, 0x0E, 0x1E, 0x78, 0x0F, 0x07, 0x38, 0x07, 0x03, 0xFC,
  0x07, 0x80, 0xFC, 0x03, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE7, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x7C, 0xFF, 0x8F, 0x9F, 0xF9, 0xE7, 0xCF, 0xFC, 0xF9, 0xFF, 0x9F,
  0x1F, 0xE3, 0xE1, 0xFC, 0x7C, 0x3F, 0x0F, 0xC7, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE,
  0xF0, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE7, 0x3B, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC0, 0x7F, 0x03, 0xDE, 0x1F, 0x3C, 0x38, 0xF8, 0x61, 0x80,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0xBC,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF,
  0x1F, 0xFC, 0x7C, 0xF9, 0xE1, 0xE7, 0x87, 0xBE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xBF,
  0xCF, 0x63, 0xC8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1F,
  0xC1, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x70, 0xF8, 0x81, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFE, 0x20, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07,
  0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F,
  0xF8, 0x7F, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0x78, 0x0E, 0xF0, 0x39, 0xE0, 0x73, 0xC1,
  0xC7, 0x83, 0x8F, 0x0E, 0x1E, 0x1C, 0x3C, 0x78, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x7F, 0xE3, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x21,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE8, 0x1F,
  0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xE1, 0xFF,
  0x8F, 0xFE, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xEF,
  0x8F, 0x7F, 0x3D, 0xFE, 0xFF, 0xFB, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xDE, 0x1F, 0x7C, 0x7D, 0xFF, 0xE3, 0xFF, 0x87,
  0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0x3E, 0x78, 0x79, 0xE1, 0xF7, 0x87, 0x9E,
  0x1E, 0x7C, 0xF8, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xC7,
  0xDF, 0x9E, 0x3E, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F,
  0xF3, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0x87, 0xFF,
  0x1F, 0xFE, 0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x3F, 0x7F, 0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0xDF, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x3D, 0xF7, 0xDF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xC7, 0xF8, 0x3F, 0x80, 0xF8,
  0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xC0,
  0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0xFF, 0x83, 0xF8, 0x0F,
  0x80, 0x38, 0x00, 0x80, 0x00, 0x3F, 0xC7, 0xFE, 0xFF, 0xF7, 0xFF, 0x61,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07,
  0x0F, 0x07, 0x8F, 0x1C, 0x3F, 0xCE, 0x78, 0xFF, 0x9E, 0xE3, 0xCF, 0x3D,
  0xC7, 0x1E, 0x7B, 0x8E, 0x3C, 0x7F, 0x3C, 0x78, 0xFE, 0x78, 0xF1, 0xFC,
  0xF1, 0xE7, 0xF9, 0xE3, 0x8F, 0xF3, 0xC7, 0x1C, 0xE3, 0x9F, 0x39, 0xC7,
  0xFF, 0xF3, 0x87, 0xEF, 0xC7, 0x87, 0x8F, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x20, 0x1F, 0x81, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0xC1,
  0xE1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xC0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xDF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1E, 0xF8, 0x7D, 0xF0, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFF, 0x9F, 0xFF, 0xBE, 0x1F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xF0, 0x47, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x47, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E, 0xF8,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7E, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x06,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F, 0x3F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFC, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xFB, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFB, 0xFD, 0xF8, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9,
  0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0x7F, 0xEF, 0x1E, 0xFF, 0xDE,
  0x3D, 0xFF, 0xBC, 0x73, 0xFF, 0x79, 0xE7, 0xFE, 0x7B, 0xCF, 0xFC, 0xF7,
  0x9F, 0xF9, 0xEE, 0x3F, 0xF3, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1,
  0xFF, 0x8F, 0xC3, 0xFF, 0x1F, 0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3C, 0x1F,
  0xF8, 0x78, 0x3E, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFE,
  0xF1, 0xFF, 0xBC, 0x7F, 0xEF, 0x9F, 0xF9, 0xE7, 0xFE, 0x7D, 0xFF, 0x8F,
  0x7F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xC0,
  0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x1F, 0x9F,
  0x83, 0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFC, 0xF8, 0x3E, 0x3F, 0x1F, 0x8F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F,
  0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0x1F, 0x9F, 0x83, 0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFC,
  0xF8, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF8,
  0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xE0, 0xF9,
  0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0x1F, 0xE1, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7,
  0xC7, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xFE, 0x1F, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0xF8,
  0x07, 0xFE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F, 0x9F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x3E, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xDE, 0x00, 0x77, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xFF,
  0x03, 0xC0, 0xFB, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F, 0x83, 0xEF, 0x83, 0xF0,
  0x7C, 0xF0, 0x7E, 0x0F, 0x1E, 0x0F, 0xC1, 0xE3, 0xE1, 0xFC, 0x7C, 0x7C,
  0x7F, 0x8F, 0x8F, 0x8F, 0xF1, 0xF0, 0xF1, 0xFE, 0x3C, 0x1E, 0x39, 0xC7,
  0x83, 0xC7, 0x39, 0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xBC, 0xF7, 0xC0, 0xF7,
  0x9E, 0xF8, 0x1E, 0xF1, 0xDE, 0x03, 0xDC, 0x3B, 0xC0, 0x7B, 0x87, 0x78,
  0x0F, 0xF0, 0xEF, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x1F, 0x3E,
  0x1F, 0x0F, 0x0F, 0x87, 0xC7, 0xC3, 0xE7, 0xC0, 0xF3, 0xE0, 0x7D, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07,
  0xDF, 0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3E,
  0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0xBC, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC3,
  0xC3, 0xE1, 0xF1, 0xE0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1F, 0x78, 0x07, 0xBC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C, 0x0F, 0x1E,
  0x0F, 0x0F, 0x07, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3E, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x01, 0x00, 0xFF,
  0x1F, 0xFC, 0x7F, 0xF3, 0x8F, 0x90, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0xF9,
  0xFF, 0xDF, 0xFF, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xFD,
  0xFB, 0xFF, 0xDF, 0xCE, 0x7C, 0x70, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF3, 0xE3, 0xDF, 0xCF,
  0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0xFE,
  0xFF, 0xFB, 0xDF, 0xCF, 0x3E, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xFF,
  0x7F, 0xE7, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC1, 0x7F, 0xF3, 0xFF, 0x3F, 0xF0, 0xFE,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x82, 0x1F, 0x1F, 0xBE, 0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7,
  0xEF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xEF, 0x07, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFC, 0x7E, 0x78, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x79,
  0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x9F, 0xDE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0x23, 0xE0, 0x3E, 0x03,
  0xE0, 0x7F, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x04, 0x00, 0x3F, 0x3C, 0xFF, 0xF9,
  0xFF, 0xF7, 0xEF, 0xEF, 0x8F, 0xDE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xDE, 0x0F, 0xBE, 0x3F,
  0x7F, 0xFE, 0x7F, 0xFC, 0xFE, 0xF8, 0xF9, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x20, 0x3E, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x20, 0xF3, 0xF3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7B, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0x67,
  0xBF, 0xFF, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0C, 0x1E, 0x1F, 0x1F, 0x1E, 0x04, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0xFE,
  0xFE, 0xFC, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xF0, 0xFB, 0xE3, 0xE7,
  0xC7, 0x8F, 0x9F, 0x1F, 0x7C, 0x3E, 0xF0, 0x7F, 0xE0, 0xF7, 0xC1, 0xFF,
  0x83, 0xFF, 0x87, 0xEF, 0x0F, 0x9F, 0x1F, 0x1E, 0x3E, 0x3E, 0x7C, 0x3C,
  0xF8, 0x7D, 0xF0, 0xFB, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x80, 0x43, 0xCF, 0xCF, 0xCF, 0x7F, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF1, 0xFF, 0x87, 0xC7, 0xFE, 0x1F, 0x0F, 0xF8, 0x78, 0x3F,
  0xE1, 0xE0, 0xFF, 0x87, 0x83, 0xFE, 0x1E, 0x0F, 0xF8, 0x78, 0x3F, 0xE1,
  0xE0, 0xFF, 0x87, 0x83, 0xFE, 0x1E, 0x0F, 0xF8, 0x78, 0x3F, 0xE1, 0xE0,
  0xFF, 0x87, 0x83, 0xFE, 0x1E, 0x0F, 0x00, 0x83, 0xCF, 0xCF, 0x7F, 0x3F,
  0xFE, 0xFF, 0xFB, 0xE1, 0xEF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x01, 0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF,
  0xC7, 0xEF, 0xCF, 0x8F, 0x9E, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0x3E, 0x3E, 0x7F,
  0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x00, 0x83, 0xCF, 0x8F, 0x7F,
  0x3F, 0xFE, 0xFC, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFF,
  0xFB, 0xFF, 0xEF, 0x7F, 0x3C, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x04, 0x00, 0x3F, 0x3C,
  0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0x8F, 0xDE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xDE, 0x0F,
  0xBE, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0xFE, 0xF8, 0xF9, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0xBC, 0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0x9F, 0xC3, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0x04, 0x07, 0xF9, 0xFF, 0xFF, 0xEF, 0x9D, 0xE0, 0xBE, 0x07,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xF8, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFD, 0xFE, 0xF3, 0xF3, 0xC0,
  0xF8, 0x1E, 0xF0, 0x7D, 0xE0, 0xFB, 0xE1, 0xE7, 0xC3, 0xC7, 0x8F, 0x8F,
  0x1F, 0x1E, 0x3C, 0x3E, 0x78, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0x80, 0xEF,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0xF8, 0x7E, 0x1F, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x3E,
  0x7C, 0xFE, 0x3E, 0x7C, 0xFE, 0x3C, 0x3C, 0xEF, 0x3C, 0x3C, 0xE7, 0x3C,
  0x3C, 0xE7, 0x7C, 0x3E, 0xE7, 0x78, 0x1E, 0xE7, 0x78, 0x1F, 0xC7, 0x78,
  0x1F, 0xC3, 0x78, 0x1F, 0xC3, 0x78, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0xF8,
  0xF9, 0xF1, 0xE1, 0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFF, 0x03, 0xDE, 0x0F,
  0xBE, 0x1E, 0x7C, 0x7C, 0x7C, 0xF8, 0xFB, 0xE0, 0xF8, 0xF8, 0x1E, 0xF0,
  0x7D, 0xF0, 0xFB, 0xE1, 0xE7, 0xC3, 0xC7, 0x8F, 0x8F, 0x1F, 0x1F, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF1, 0xFE, 0x3F, 0x87,
  0xE0, 0xFE, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0x83, 0xF8, 0x7F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3F, 0xC3,
  0xF8, 0x1F, 0x0F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x20, 0x00, 0x7E,
  0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 12, 9, 16, 2, -25 },
  { 31, 16, 25, 18, 1, -25 },
  { 81, 14, 29, 16, 1, -27 },
  { 132, 25, 25, 27, 1, -25 },
  { 211, 19, 25, 19, 1, -25 },
  { 271, 5, 9, 8, 2, -25 },
  { 277, 9, 31, 11, 2, -25 },
  { 312, 9, 31, 11, 0, -25 },
  { 347, 14, 14, 16, 1, -27 },
  { 372, 14, 17, 16, 1, -21 },
  { 402, 6, 9, 9, 1, -4 },
  { 409, 9, 5, 11, 1, -12 },
  { 415, 5, 5, 9, 2, -5 },
  { 419, 14, 25, 14, 0, -25 },
  { 463, 14, 25, 16, 1, -25 },
  { 507, 10, 25, 16, 2, -25 },
  { 539, 14, 25, 16, 1, -25 },
  { 583, 14, 25, 16, 1, -25 },
  { 627, 15, 25, 16, 1, -25 },
  { 674, 13, 25, 16, 2, -25 },
  { 715, 14, 25, 16, 1, -25 },
  { 759, 14, 25, 16, 1, -25 },
  { 803, 14, 25, 16, 1, -25 },
  { 847, 14, 25, 16, 1, -25 },
  { 891, 5, 19, 9, 2, -19 },
  { 903, 6, 24, 9, 1, -19 },
  { 921, 14, 17, 16, 1, -21 },
  { 951, 14, 11, 16, 1, -18 },
  { 971, 14, 17, 16, 1, -21 },
  { 1001, 12, 25, 13, 0, -25 },
  { 1039, 23, 28, 25, 1, -25 },
  { 1120, 18, 25, 18, 0, -25 },
  { 1177, 15, 25, 18, 2, -25 },
  { 1224, 15, 25, 17, 1, -25 },
  { 1271, 16, 25, 20, 2, -25 },
  { 1321, 12, 25, 15, 2, -25 },
  { 1359, 11, 25, 15, 2, -25 },
  { 1394, 16, 25, 20, 2, -25 },
  { 1444, 16, 25, 21, 2, -25 },
  { 1494, 9, 25, 11, 1, -25 },
  { 1523, 9, 32, 10, -2, -25 },
  { 1559, 16, 25, 18, 2, -25 },
  { 1609, 12, 25, 14, 2, -25 },
  { 1647, 23, 25, 27, 2, -25 },
  { 1719, 18, 25, 22, 2, -25 },
  { 1776, 18, 25, 21, 1, -25 },
  { 1833, 14, 25, 17, 2, -25 },
  { 1877, 18, 31, 21, 1, -25 },
  { 1947, 16, 25, 18, 2, -25 },
  { 1997, 13, 25, 15, 1, -25 },
  { 2038, 15, 25, 15, 0, -25 },
  { 2085, 16, 25, 20, 2, -25 },
  { 2135, 18, 25, 18, 0, -25 },
  { 2192, 27, 25, 26, 0, -25 },
  { 2277, 17, 25, 17, 0, -25 },
  { 2331, 17, 25, 17, 0, -25 },
  { 2385, 14, 25, 14, 0, -25 },
  { 2429, 8, 31, 11, 2, -25 },
  { 2460, 14, 25, 14, 0, -25 },
  { 2504, 8, 31, 11, 1, -25 },
  { 2535, 17, 15, 19, 1, -25 },
  { 2567, 14, 2, 14, 0, 3 },
  { 2571, 8, 6, 11, 1, -27 },
  { 2577, 13, 20, 16, 1, -20 },
  { 2610, 14, 27, 18, 2, -27 },
  { 2658, 12, 20, 14, 1, -20 },
  { 2688, 15, 27, 18, 1, -27 },
  { 2739, 14, 19, 16, 1, -19 },
  { 2773, 12, 27, 10, 0, -27 },
  { 2814, 15, 28, 18, 1, -20 },
  { 2867, 14, 27, 18, 2, -27 },
  { 2915, 5, 27, 9, 2, -27 },
  { 2932, 8, 35, 9, -1, -27 },
  { 2967, 15, 27, 17, 2, -27 },
  { 3018, 5, 27, 8, 2, -27 },
  { 3035, 22, 20, 26, 2, -20 },
  { 3090, 14, 20, 18, 2, -20 },
  { 3125, 15, 20, 17, 1, -20 },
  { 3163, 14, 28, 18, 2, -20 },
  { 3212, 15, 28, 18, 1, -20 },
  { 3265, 10, 20, 12, 2, -20 },
  { 3290, 11, 20, 13, 1, -20 },
  { 3318, 11, 23, 12, 0, -23 },
  { 3350, 14, 19, 18, 2, -19 },
  { 3384, 15, 19, 16, 0, -19 },
  { 3420, 24, 19, 24, 0, -19 },
  { 3477, 15, 19, 15, 0, -19 },
  { 3513, 15, 27, 16, 0, -19 },
  { 3564, 11, 19, 13, 1, -19 },
  { 3591, 11, 31, 12, 0, -25 },
  { 3634, 4, 35, 15, 6, -27 },
  { 3652, 11, 31, 12, 1, -25 },
  { 3695, 14, 6, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Bold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD35PT7B_H_
