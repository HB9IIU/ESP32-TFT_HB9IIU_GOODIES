#ifndef _NOTOSANS_EXTRACONDENSED_BOLD16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3C, 0xDE, 0xF7, 0xB0, 0x16, 0x16, 0x34, 0x7F, 0x34,
  0x24, 0xFE, 0xFE, 0x2C, 0x6C, 0x68, 0x21, 0xFF, 0xB8, 0xE3, 0x83, 0x8F,
  0x2E, 0xFF, 0x88, 0x20, 0x20, 0x07, 0x98, 0x59, 0x0D, 0xB0, 0xDB, 0x05,
  0xAE, 0x7E, 0xB2, 0x5B, 0x05, 0xB0, 0xDB, 0x08, 0xB1, 0x8E, 0x18, 0x1E,
  0x1B, 0x0D, 0x86, 0xC1, 0xC1, 0xEE, 0xFE, 0xEF, 0x73, 0x1F, 0xCF, 0xF0,
  0xFF, 0x76, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x63, 0xE6, 0x33, 0x33, 0x33,
  0x33, 0x36, 0x6C, 0x19, 0x27, 0xF9, 0xC6, 0xCD, 0x80, 0x18, 0x33, 0xFF,
  0xF1, 0x83, 0x06, 0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x04, 0x30, 0xC6, 0x18,
  0x43, 0x0C, 0x61, 0x86, 0x30, 0x21, 0xED, 0xB3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x7F, 0x9C, 0x3B, 0xF7, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x11, 0xF9, 0x30,
  0x70, 0xC1, 0x87, 0x0C, 0x30, 0xC1, 0xFB, 0xF0, 0x31, 0xF9, 0x30, 0x70,
  0xC7, 0x8F, 0x07, 0x06, 0x1D, 0xF3, 0xC0, 0x0C, 0x38, 0x71, 0xE2, 0xCD,
  0x93, 0x7F, 0xFE, 0x18, 0x30, 0xFB, 0x0C, 0x30, 0xFB, 0xE1, 0xC3, 0x1F,
  0xEF, 0x00, 0x0C, 0x79, 0xC3, 0x06, 0x0B, 0xBB, 0xF3, 0x66, 0xCD, 0xF1,
  0xE0, 0xFE, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x61, 0xC0, 0x10,
  0xF9, 0xBB, 0x36, 0xC7, 0x8F, 0x37, 0xE7, 0xCD, 0xFB, 0xE0, 0x10, 0xF9,
  0xB7, 0x3E, 0x6C, 0xDF, 0xBB, 0x06, 0x19, 0xF3, 0xC0, 0xFC, 0x03, 0xC0,
  0xFC, 0x03, 0xF8, 0x02, 0x0C, 0x7B, 0x8E, 0x07, 0x03, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x81, 0xC1, 0xE0, 0xF0, 0xE7, 0xBC, 0x60, 0x33, 0xE5,
  0xC3, 0x18, 0xE3, 0x08, 0x00, 0x07, 0x1C, 0x0C, 0x0F, 0xC6, 0x1B, 0x32,
  0xDE, 0xE4, 0xBB, 0x6E, 0xDB, 0xB6, 0xE7, 0xEC, 0x01, 0x84, 0x3F, 0x00,
  0x1C, 0x3C, 0x3C, 0x36, 0x36, 0x66, 0x7E, 0x7F, 0x63, 0xE3, 0xC3, 0xFD,
  0x9B, 0x3E, 0x6F, 0xDF, 0xB3, 0xE3, 0xCF, 0xFB, 0xE0, 0x19, 0xF6, 0x70,
  0xC3, 0x0C, 0x30, 0xC3, 0x87, 0xCF, 0xFD, 0xBB, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xCF, 0xFB, 0xE0, 0xFE, 0x31, 0x8F, 0xFF, 0x18, 0xC7, 0xFE, 0xFE,
  0x31, 0x8C, 0x7F, 0x18, 0xC6, 0x30, 0x08, 0xFD, 0xCF, 0x0C, 0x18, 0x37,
  0xEF, 0xC7, 0xCD, 0xF9, 0xF0, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3,
  0xC7, 0x8F, 0x18, 0xFB, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xBE, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xFF, 0xCF, 0x9B, 0x76, 0xCF, 0x9F, 0x3E, 0x6E,
  0xCD, 0x9F, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFE, 0xE1, 0xFC,
  0x7F, 0x3F, 0xCF, 0xD3, 0xF6, 0xBD, 0xEF, 0x7B, 0xCE, 0xF3, 0x3C, 0xCC,
  0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xCF, 0xC7, 0xC7, 0x18,
  0x7C, 0xEE, 0xC6, 0xC7, 0xC3, 0xC3, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C, 0xFF,
  0x7C, 0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x0C, 0x00, 0x18, 0x7C, 0xEE, 0xC6,
  0xC7, 0xC3, 0xC3, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C, 0x0C, 0x0E, 0x07, 0xFD,
  0xBB, 0x36, 0x6C, 0xDF, 0x3E, 0x6E, 0xCD, 0x9B, 0x18, 0x11, 0xF6, 0xD8,
  0x61, 0xC3, 0x87, 0x0E, 0x3F, 0xDE, 0xFE, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xFD, 0xF0, 0xC3, 0xC3, 0x66, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x3C,
  0x18, 0xC6, 0x3C, 0x63, 0xCE, 0x76, 0xF6, 0x6F, 0x66, 0xF6, 0x69, 0x66,
  0x96, 0x39, 0xC3, 0x9C, 0x39, 0xC0, 0xE6, 0x6E, 0x7C, 0x3C, 0x38, 0x38,
  0x3C, 0x3C, 0x6C, 0x66, 0xE7, 0xE7, 0x66, 0x6C, 0x7C, 0x3C, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFC, 0x30, 0xC6, 0x18, 0xC3, 0x18, 0x63, 0xFF,
  0xC0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0x06, 0x18, 0x30,
  0xC3, 0x06, 0x18, 0x20, 0xC3, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF,
  0x18, 0x1C, 0x3C, 0x36, 0x66, 0x63, 0xC3, 0xFE, 0xCC, 0x38, 0xF8, 0x38,
  0x77, 0xED, 0xFB, 0xBF, 0x76, 0xC3, 0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFE, 0x7F, 0xF1, 0x8C, 0x63, 0x1F, 0x78, 0x0C, 0x30, 0xDB, 0xFF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xDF, 0x73, 0xEC, 0xF3, 0xFF, 0x0C, 0x3E, 0x78,
  0x3B, 0xD8, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xC0, 0x6F, 0xFC, 0xF3, 0xCF,
  0x3C, 0xFF, 0x7C, 0x38, 0xFE, 0x70, 0xC3, 0x0C, 0x36, 0xFF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xF3, 0xFF, 0xFF, 0x6C, 0x36, 0xDB, 0x6D, 0xB6, 0xFE,
  0xC1, 0x83, 0x06, 0x7C, 0xDB, 0x3C, 0x78, 0xF9, 0xBB, 0x36, 0x70, 0xFF,
  0xFF, 0xFF, 0xD9, 0xBF, 0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33,
  0xCC, 0xC0, 0xDB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0x73, 0xFC, 0xF3,
  0xCF, 0x3C, 0xFF, 0x78, 0xDB, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0xFB, 0x0C,
  0x30, 0xC0, 0x6F, 0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0x30, 0xC3, 0x0C,
  0xDF, 0xEC, 0xCC, 0xCC, 0xC0, 0x39, 0xEC, 0x18, 0x78, 0x61, 0xFE, 0xF8,
  0x23, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0xCE, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xFF, 0x7C, 0xC7, 0x8D, 0xB3, 0x66, 0xCD, 0x8A, 0x1C, 0x38, 0xCE, 0x79,
  0xCD, 0xAB, 0x35, 0x66, 0xAC, 0xF5, 0x9E, 0xE1, 0xDC, 0x33, 0x80, 0xCE,
  0xD9, 0xB1, 0xC3, 0x87, 0x1F, 0x36, 0xCE, 0xC7, 0xCD, 0xB3, 0x66, 0xC5,
  0x8E, 0x1C, 0x38, 0x70, 0xC3, 0x86, 0x00, 0xFF, 0xC6, 0x63, 0x39, 0x9F,
  0xF8, 0x39, 0x8C, 0x63, 0x3B, 0x0E, 0x31, 0x8C, 0x63, 0x84, 0xFF, 0xFF,
  0xC6, 0x66, 0x66, 0x36, 0x66, 0x66, 0xE8, 0x73, 0xFE, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_Bold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 8, 11, 8, 0, -11 },
  { 18, 6, 13, 7, 1, -12 },
  { 28, 12, 12, 12, 0, -12 },
  { 46, 9, 12, 9, 0, -12 },
  { 60, 2, 4, 4, 1, -11 },
  { 61, 4, 14, 5, 1, -11 },
  { 68, 4, 14, 5, 0, -11 },
  { 75, 7, 6, 7, 0, -12 },
  { 81, 7, 7, 7, 0, -9 },
  { 88, 3, 4, 4, 0, -2 },
  { 90, 4, 2, 5, 0, -5 },
  { 91, 2, 2, 4, 1, -2 },
  { 92, 6, 12, 6, 0, -12 },
  { 101, 6, 12, 7, 1, -12 },
  { 110, 5, 11, 7, 1, -11 },
  { 117, 7, 12, 7, 0, -12 },
  { 128, 7, 12, 7, 0, -12 },
  { 139, 7, 11, 7, 0, -11 },
  { 149, 6, 11, 7, 1, -11 },
  { 158, 7, 12, 7, 0, -12 },
  { 169, 7, 11, 7, 0, -11 },
  { 179, 7, 12, 7, 0, -12 },
  { 190, 7, 12, 7, 0, -12 },
  { 201, 2, 9, 4, 1, -9 },
  { 204, 2, 11, 4, 1, -9 },
  { 207, 7, 8, 7, 0, -10 },
  { 214, 7, 5, 7, 0, -8 },
  { 219, 7, 8, 7, 0, -10 },
  { 226, 6, 12, 6, 0, -12 },
  { 235, 10, 13, 12, 1, -12 },
  { 252, 8, 11, 8, 0, -11 },
  { 263, 7, 11, 8, 1, -11 },
  { 273, 6, 12, 8, 1, -12 },
  { 282, 7, 11, 9, 1, -11 },
  { 292, 5, 11, 7, 1, -11 },
  { 299, 5, 11, 7, 1, -11 },
  { 306, 7, 12, 9, 1, -12 },
  { 317, 7, 11, 9, 1, -11 },
  { 327, 5, 11, 5, 0, -11 },
  { 334, 4, 14, 4, -1, -11 },
  { 341, 7, 11, 8, 1, -11 },
  { 351, 5, 11, 7, 1, -11 },
  { 358, 10, 11, 12, 1, -11 },
  { 372, 8, 11, 10, 1, -11 },
  { 383, 8, 12, 9, 1, -12 },
  { 395, 6, 11, 8, 1, -11 },
  { 404, 8, 15, 9, 1, -12 },
  { 419, 7, 11, 8, 1, -11 },
  { 429, 6, 12, 7, 0, -12 },
  { 438, 7, 11, 7, 0, -11 },
  { 448, 7, 11, 9, 1, -11 },
  { 458, 8, 11, 8, 0, -11 },
  { 469, 12, 11, 12, 0, -11 },
  { 486, 8, 11, 8, 0, -11 },
  { 497, 8, 11, 8, 0, -11 },
  { 508, 6, 11, 7, 0, -11 },
  { 517, 4, 14, 5, 1, -11 },
  { 524, 6, 12, 6, 0, -12 },
  { 533, 4, 14, 5, 0, -11 },
  { 540, 8, 7, 9, 0, -11 },
  { 547, 7, 1, 7, 0, 1 },
  { 548, 3, 2, 5, 1, -12 },
  { 549, 7, 9, 7, 0, -9 },
  { 557, 6, 12, 8, 1, -12 },
  { 566, 5, 9, 6, 1, -9 },
  { 572, 6, 12, 8, 1, -12 },
  { 581, 6, 9, 7, 1, -9 },
  { 588, 5, 12, 5, 0, -12 },
  { 596, 6, 13, 8, 1, -9 },
  { 606, 6, 12, 8, 1, -12 },
  { 615, 2, 12, 4, 1, -12 },
  { 618, 3, 16, 4, 0, -12 },
  { 624, 7, 12, 8, 1, -12 },
  { 635, 2, 12, 4, 1, -12 },
  { 638, 10, 9, 12, 1, -9 },
  { 650, 6, 9, 8, 1, -9 },
  { 657, 6, 9, 8, 1, -9 },
  { 664, 6, 13, 8, 1, -9 },
  { 674, 6, 13, 8, 1, -9 },
  { 684, 4, 9, 6, 1, -9 },
  { 689, 6, 9, 6, 0, -9 },
  { 696, 5, 11, 5, 0, -11 },
  { 703, 6, 9, 8, 1, -9 },
  { 710, 7, 9, 7, 0, -9 },
  { 718, 11, 9, 11, 0, -9 },
  { 731, 7, 9, 7, 0, -9 },
  { 739, 7, 13, 7, 0, -9 },
  { 751, 5, 9, 6, 0, -9 },
  { 757, 5, 14, 6, 0, -11 },
  { 766, 1, 16, 7, 3, -12 },
  { 768, 4, 14, 6, 1, -11 },
  { 775, 7, 3, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Bold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD16PT7B_H_
