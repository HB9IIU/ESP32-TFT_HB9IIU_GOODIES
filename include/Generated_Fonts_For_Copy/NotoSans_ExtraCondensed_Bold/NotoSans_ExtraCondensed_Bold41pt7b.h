#ifndef _NOTOSANS_EXTRACONDENSED_BOLD41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xC0, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x7C, 0xFC,
  0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0x78, 0x7D, 0xE1, 0xF0, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x3C,
  0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x3C, 0x1F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x7F, 0x81, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0x7F, 0xDE, 0xF9, 0x85, 0xF3, 0x03, 0xE6, 0x07, 0xCC,
  0x0F, 0xD8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1B, 0xE0, 0x37, 0xE0, 0x6F, 0xE0, 0xDF, 0xF1,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0x81, 0xFC, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFF, 0xC0, 0xF0, 0x07, 0x9E, 0x07, 0x80, 0x3C, 0xF0,
  0x3C, 0x03, 0xE3, 0xC3, 0xC0, 0x1E, 0x1E, 0x1E, 0x00, 0xF0, 0xF1, 0xE0,
  0x07, 0x87, 0x8F, 0x00, 0x3C, 0x3C, 0x78, 0x01, 0xE3, 0xE7, 0x80, 0x0F,
  0x9F, 0x3C, 0x7C, 0x3C, 0xF3, 0xE7, 0xF1, 0xE7, 0x9E, 0x7F, 0xCF, 0xFC,
  0xF3, 0xFE, 0x3F, 0xCF, 0x3E, 0x78, 0xFC, 0x79, 0xE3, 0xC1, 0xC7, 0xCF,
  0x1E, 0x00, 0x3C, 0x78, 0xF0, 0x01, 0xE3, 0xC7, 0x80, 0x1E, 0x1E, 0x3C,
  0x00, 0xF0, 0xF1, 0xE0, 0x07, 0x87, 0x8F, 0x00, 0x78, 0x3C, 0x78, 0x03,
  0xC1, 0xE3, 0xC0, 0x3E, 0x07, 0xBE, 0x01, 0xE0, 0x3F, 0xE0, 0x0F, 0x00,
  0xFE, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF7, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x7E, 0x3F, 0xF1, 0xF9, 0xFF, 0xE7, 0xCF, 0xCF, 0x9F, 0x3F, 0x3F, 0xFC,
  0xFC, 0x7F, 0xF3, 0xF0, 0xFF, 0x8F, 0xC3, 0xFE, 0x3F, 0x07, 0xF0, 0xFC,
  0x1F, 0xC3, 0xFD, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFD,
  0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0x79, 0xE0,
  0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0xF8, 0x1E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x63, 0xC6, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x07, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0x7C, 0x7E, 0x7E, 0x1C, 0x3C, 0x0C, 0x30,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x7C, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E,
  0x79, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF,
  0xFF, 0xFD, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x3F, 0x7E, 0x3E, 0x3F, 0x7E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF,
  0x7F, 0xFF, 0xDF, 0xF9, 0xF7, 0x1F, 0x21, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x01,
  0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0x7C, 0x7E, 0x30,
  0x3F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x38, 0x7F, 0x20,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x01,
  0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80,
  0x3F, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xBF, 0x03, 0xDF, 0x83, 0xCF,
  0xC1, 0xE7, 0xE1, 0xE3, 0xF0, 0xF1, 0xF8, 0xF0, 0xFC, 0x78, 0x7E, 0x7C,
  0x3F, 0x3C, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xEF, 0x07, 0xFF, 0x8F,
  0xFF, 0x9F, 0xFF, 0xBF, 0xFF, 0x10, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0xF1, 0xFD,
  0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x9F, 0x0F, 0x9F, 0xC7,
  0xDF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFE, 0x3F, 0x7E, 0x0F, 0xBF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E,
  0x3F, 0x1F, 0xBF, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xE3, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x8F, 0x87, 0xEF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xBF, 0x1F, 0x8F, 0xCF, 0x87, 0xEF, 0xC1, 0xF7, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0x1F, 0x9F, 0xFF, 0xC7,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0x80, 0x07, 0xF8, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xF3, 0xF1, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC,
  0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFD,
  0xF0, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xF7, 0xC1, 0xF3,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x20,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x39, 0xFF,
  0xFF, 0xFD, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF7, 0xC0, 0x1C, 0x3E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E,
  0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0x7F, 0xFD, 0xE3, 0xF2, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0x83, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x7C, 0x1F, 0x87, 0x9E, 0x1F, 0xF9, 0xE7,
  0x8F, 0xFE, 0x3F, 0xC3, 0xE7, 0x8F, 0xF1, 0xF1, 0xE3, 0xFC, 0x78, 0x78,
  0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0x87, 0x8F, 0xF3, 0xE3, 0xE3, 0xFC, 0xF8,
  0xF8, 0xFF, 0x1E, 0x3C, 0x3F, 0xC7, 0x8F, 0x0F, 0xF1, 0xE3, 0xC7, 0xBC,
  0x79, 0xF9, 0xEF, 0x1F, 0xFF, 0xF3, 0xC3, 0xF9, 0xFC, 0x78, 0x7C, 0x7E,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x10, 0x07, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF1,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x87, 0xF7, 0xC1, 0xFB,
  0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE, 0x0F, 0xDF, 0x1F,
  0xCF, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0xF8, 0x7F, 0x7C,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF1,
  0xFC, 0x79, 0xFC, 0x04, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0xFF, 0x3E, 0x0F, 0xEF, 0x81, 0xFB, 0xE0, 0x7E, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0x83, 0xFB, 0xE1, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F,
  0x87, 0x8F, 0xE0, 0x23, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x07, 0xE7, 0xFB,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x3F, 0x0F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFC, 0xFE, 0x1C, 0x00, 0xF8, 0x0F, 0xFE,
  0x07, 0xEF, 0x81, 0xFB, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0x8F,
  0xE3, 0xE3, 0xF0, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xBF, 0x03, 0xEF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x83,
  0xE3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x3F,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xF7, 0xFF, 0xF0, 0x3D, 0xFF,
  0xBC, 0x1F, 0x7F, 0xEF, 0x07, 0x9F, 0xFB, 0xE1, 0xE7, 0xFE, 0xF8, 0xFB,
  0xFF, 0x9E, 0x3E, 0xFF, 0xE7, 0x8F, 0x3F, 0xF9, 0xF3, 0xCF, 0xFE, 0x7D,
  0xF3, 0xFF, 0x8F, 0x7C, 0xFF, 0xE3, 0xDE, 0x3F, 0xF8, 0xFF, 0x8F, 0xFE,
  0x3F, 0xE3, 0xFF, 0x87, 0xF0, 0xFF, 0xE1, 0xFC, 0x3F, 0xF8, 0x7F, 0x0F,
  0xFE, 0x1F, 0xC3, 0xFF, 0x83, 0xE0, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E,
  0x0F, 0xC0, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFB, 0xE1, 0xFF, 0xBE, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F,
  0x1F, 0xF9, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xFD, 0xFF, 0x87, 0xDF, 0xF8,
  0x7D, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC7, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFE,
  0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x7F, 0x07, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7E,
  0xF8, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC7, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x7F,
  0x07, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFB, 0xFE, 0x3E, 0x1F, 0xCF,
  0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0,
  0xFC, 0xF8, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0x9F, 0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F,
  0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0,
  0x7E, 0xF8, 0x0F, 0xC0, 0x01, 0xC0, 0x1F, 0xF0, 0x7F, 0xF9, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x9F, 0x83, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0xF8, 0x01, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x07,
  0xC0, 0x7F, 0xF0, 0x0F, 0x80, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x7E,
  0x03, 0xEF, 0xC0, 0xFE, 0x07, 0xCF, 0x81, 0xFC, 0x1F, 0x9F, 0x03, 0xF8,
  0x3F, 0x3E, 0x0F, 0xF0, 0x7E, 0x7E, 0x1F, 0xE0, 0xF8, 0xFC, 0x3F, 0xE1,
  0xF0, 0xF8, 0x7B, 0xC3, 0xE1, 0xF0, 0xF7, 0x8F, 0xC3, 0xE3, 0xEF, 0x1F,
  0x87, 0xC7, 0xDE, 0x3E, 0x0F, 0xCF, 0x3E, 0x7C, 0x0F, 0x9E, 0x7C, 0xF8,
  0x1F, 0x3C, 0x7B, 0xF0, 0x3E, 0xF8, 0xF7, 0xE0, 0x7D, 0xF1, 0xEF, 0x80,
  0xFB, 0xC3, 0xDF, 0x00, 0xF7, 0x87, 0xBE, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xEF, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F, 0x8F,
  0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFB, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x0F, 0x87, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x03, 0xFF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0x3F, 0x07, 0xE3, 0xE0, 0xFC,
  0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x9F, 0x01, 0xF7, 0xE0,
  0x3E, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFE, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x3F,
  0x8F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x70, 0x7E, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xBF, 0x8F, 0xDF, 0xFF,
  0xEF, 0xFF, 0xE7, 0xDF, 0xE3, 0xE7, 0xE0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF,
  0xCF, 0xFF, 0x3F, 0xF9, 0xFC, 0x27, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x17, 0xF1, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0x80,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0x8F, 0x87, 0xE7, 0xC7, 0xFB, 0xE7,
  0xFF, 0xF3, 0xFF, 0xFB, 0xF1, 0xFD, 0xF8, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBF, 0x0F, 0xDF, 0xCF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF8, 0xFF, 0x7C, 0x3F, 0x1E, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x3F, 0x7E, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0x3F, 0x06, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F,
  0x90, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x07, 0xF7, 0xC7, 0xFB, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xF1, 0xFD,
  0xF8, 0x7E, 0xF8, 0x3F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBF,
  0x0F, 0xDF, 0xCF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x7C, 0x3F, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xEE, 0x07, 0xE7, 0xFF,
  0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0xF0, 0xF9, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xF7, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x07, 0xEF, 0xC1, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xFD,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xEF, 0xC3, 0xF1, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x8F, 0xC3, 0xF3,
  0xF0, 0x7C, 0xFC, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x1E,
  0x3E, 0x7F, 0x1F, 0xCF, 0xBF, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xE3, 0xFF, 0xC3, 0xF8, 0x7F, 0xF0, 0x7C, 0x1F, 0xFC,
  0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xF0, 0x7C, 0x1F,
  0xFC, 0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xF0, 0x7C,
  0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xF0,
  0x7C, 0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF, 0xC1, 0xF0, 0x7C,
  0x00, 0xF0, 0xF9, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x01, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0x87, 0xE7,
  0xE1, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0xC0, 0xFB, 0xF0,
  0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x87, 0xE3, 0xF3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0xF0, 0x7C, 0xFE, 0x3E, 0xFF, 0x9F, 0x7F, 0xCF, 0xFF,
  0xF7, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xBF, 0xCF, 0xDF, 0xFF, 0xEF, 0xBF, 0xE7, 0xEF,
  0xF3, 0xF3, 0xE1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xF7, 0xC7, 0xFB, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB,
  0xF1, 0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0x7C, 0x0F, 0xBE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x1F, 0xBF, 0x0F, 0xDF, 0xCF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0x7C,
  0x3F, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0x9F, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0x81, 0xFF, 0x9F, 0xFE, 0xFF, 0xEF, 0xFF, 0x7C, 0x0B, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF,
  0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x23, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xCF, 0x1F, 0x8F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xF9,
  0xF8, 0x3E, 0x7E, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F,
  0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x3E, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x83, 0xF7, 0xC1,
  0xF8, 0x3E, 0x7C, 0x3F, 0x83, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x3F, 0xC7,
  0xE3, 0xE3, 0xFC, 0x7C, 0x3E, 0x3B, 0xC7, 0xC3, 0xE3, 0x9C, 0x7C, 0x3E,
  0x79, 0xE7, 0xC3, 0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xF7, 0x1E,
  0xF8, 0x1F, 0x70, 0xEF, 0x81, 0xF7, 0x0E, 0xF8, 0x0F, 0x70, 0xEF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0xBF, 0x0F, 0x8F, 0x8F, 0xC7, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E,
  0x1F, 0x9F, 0x0F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC1, 0xFF, 0xE0, 0xFC, 0xFC,
  0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87,
  0xC3, 0xE1, 0xF0, 0xFC, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x0F,
  0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xFF, 0x07, 0xF8, 0x0F,
  0xC1, 0xFE, 0x1F, 0xF0, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0x81, 0x80, 0x00, 0x1E, 0x00, 0xBF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFA, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 29, 11, 2, -29 },
  { 23, 14, 10, 18, 2, -29 },
  { 41, 19, 29, 21, 1, -29 },
  { 110, 15, 33, 19, 2, -31 },
  { 172, 29, 30, 32, 1, -30 },
  { 281, 22, 30, 23, 1, -30 },
  { 364, 6, 10, 10, 2, -29 },
  { 372, 10, 35, 13, 2, -29 },
  { 416, 10, 35, 13, 1, -29 },
  { 460, 16, 16, 18, 1, -31 },
  { 492, 17, 19, 19, 1, -24 },
  { 533, 7, 10, 10, 1, -5 },
  { 542, 10, 6, 13, 1, -14 },
  { 550, 6, 6, 10, 2, -6 },
  { 555, 16, 30, 17, 0, -30 },
  { 615, 16, 30, 19, 1, -30 },
  { 675, 12, 29, 19, 2, -29 },
  { 719, 16, 30, 19, 1, -30 },
  { 779, 16, 30, 19, 1, -30 },
  { 839, 17, 29, 19, 1, -29 },
  { 901, 15, 29, 19, 2, -29 },
  { 956, 17, 30, 19, 1, -30 },
  { 1020, 17, 29, 19, 1, -29 },
  { 1082, 17, 30, 19, 1, -30 },
  { 1146, 17, 30, 19, 1, -30 },
  { 1210, 6, 23, 11, 2, -23 },
  { 1228, 8, 28, 11, 1, -23 },
  { 1256, 17, 19, 19, 1, -24 },
  { 1297, 17, 13, 19, 1, -21 },
  { 1325, 17, 19, 19, 1, -24 },
  { 1366, 14, 30, 15, 0, -30 },
  { 1419, 26, 33, 30, 2, -30 },
  { 1527, 22, 29, 22, 0, -29 },
  { 1607, 17, 29, 22, 3, -29 },
  { 1669, 17, 30, 20, 2, -30 },
  { 1733, 18, 29, 23, 3, -29 },
  { 1799, 13, 29, 18, 3, -29 },
  { 1847, 13, 29, 18, 3, -29 },
  { 1895, 19, 30, 23, 2, -30 },
  { 1967, 18, 29, 24, 3, -29 },
  { 2033, 11, 29, 13, 1, -29 },
  { 2073, 10, 38, 11, -2, -29 },
  { 2121, 18, 29, 21, 3, -29 },
  { 2187, 13, 29, 17, 3, -29 },
  { 2235, 26, 29, 32, 3, -29 },
  { 2330, 20, 29, 26, 3, -29 },
  { 2403, 21, 30, 24, 2, -30 },
  { 2482, 16, 29, 20, 3, -29 },
  { 2540, 21, 37, 24, 2, -30 },
  { 2638, 18, 29, 21, 3, -29 },
  { 2704, 15, 30, 17, 1, -30 },
  { 2761, 16, 29, 18, 1, -29 },
  { 2819, 18, 29, 23, 3, -29 },
  { 2885, 21, 29, 21, 0, -29 },
  { 2962, 31, 29, 31, 0, -29 },
  { 3075, 19, 29, 19, 0, -29 },
  { 3144, 19, 29, 19, 0, -29 },
  { 3213, 15, 29, 17, 1, -29 },
  { 3268, 10, 36, 13, 2, -29 },
  { 3313, 16, 30, 17, 0, -30 },
  { 3373, 9, 36, 13, 1, -29 },
  { 3414, 20, 18, 22, 1, -29 },
  { 3459, 17, 2, 17, 0, 4 },
  { 3464, 9, 6, 13, 2, -31 },
  { 3471, 16, 23, 19, 1, -23 },
  { 3517, 17, 31, 21, 2, -31 },
  { 3583, 14, 23, 16, 1, -23 },
  { 3624, 17, 31, 21, 1, -31 },
  { 3690, 16, 23, 19, 1, -23 },
  { 3736, 14, 31, 12, 0, -31 },
  { 3791, 17, 33, 21, 1, -23 },
  { 3862, 16, 31, 21, 2, -31 },
  { 3924, 6, 31, 10, 2, -31 },
  { 3948, 9, 41, 10, -1, -31 },
  { 3995, 18, 31, 20, 2, -31 },
  { 4065, 6, 31, 10, 2, -31 },
  { 4089, 26, 23, 31, 2, -23 },
  { 4164, 16, 23, 21, 2, -23 },
  { 4210, 18, 23, 20, 1, -23 },
  { 4262, 17, 33, 21, 2, -23 },
  { 4333, 17, 33, 21, 1, -23 },
  { 4404, 12, 23, 14, 2, -23 },
  { 4439, 13, 23, 15, 1, -23 },
  { 4477, 13, 27, 14, 0, -27 },
  { 4521, 16, 22, 21, 2, -22 },
  { 4565, 18, 22, 18, 0, -22 },
  { 4615, 28, 22, 28, 0, -22 },
  { 4692, 17, 22, 17, 0, -22 },
  { 4739, 18, 32, 18, 0, -22 },
  { 4811, 13, 22, 15, 1, -22 },
  { 4847, 13, 36, 14, 0, -29 },
  { 4906, 4, 41, 18, 7, -31 },
  { 4927, 13, 36, 14, 1, -29 },
  { 4986, 17, 7, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Bold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD41PT7B_H_
