#ifndef _NOTOSANS_EXTRACONDENSED_BOLD51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFF, 0x1F,
  0xFF, 0xC7, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF, 0x87, 0xF7,
  0xE1, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3E, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xF0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE3,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xC3,
  0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F,
  0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xF9, 0x87, 0x7F, 0x30, 0x0F, 0xE6, 0x01, 0xFC,
  0xC0, 0x1F, 0x98, 0x03, 0xFB, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x6F, 0xE0, 0x0D, 0xFC, 0x01, 0x9F, 0x80, 0x33, 0xF8, 0x06,
  0x7F, 0x80, 0xCF, 0xFC, 0x1B, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0x00,
  0x7C, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x0F, 0xCF, 0x80, 0xF8, 0x00, 0xF8,
  0xF8, 0x0F, 0x80, 0x0F, 0x8F, 0xC1, 0xF8, 0x00, 0xF8, 0x7C, 0x1F, 0x00,
  0x0F, 0x87, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x7E, 0x00, 0x0F, 0x87, 0xC7, 0xC0, 0x00, 0xF8,
  0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xCF, 0x87, 0xF0, 0xF8, 0xF8, 0xF8, 0xFF,
  0x8F, 0xCF, 0x8F, 0x9F, 0xFC, 0x7F, 0xF9, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F,
  0x3F, 0x7E, 0x3F, 0xF3, 0xE3, 0xE3, 0xE1, 0xFE, 0x3E, 0x3E, 0x3E, 0x0F,
  0x83, 0xE7, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xE3,
  0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0x00, 0x0F, 0x87, 0xE1, 0xF0, 0x00, 0xF8,
  0x7E, 0x3F, 0x00, 0x1F, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0x3E, 0x3F, 0x00,
  0x1F, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x3E, 0x3E, 0x00, 0x3E, 0x03, 0xF7,
  0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x07, 0xC0,
  0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x3F, 0xF0, 0x7F, 0x0F,
  0xFF, 0x0F, 0xE3, 0xFF, 0xE1, 0xFC, 0xFF, 0xFE, 0x3F, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF9, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x9F, 0xC1, 0xFF, 0xE3, 0xF8,
  0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0x0F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xE1, 0xFE,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x30, 0x7C,
  0x11, 0xF3, 0xE7, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7C,
  0x03, 0xFB, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x7F, 0x03, 0xC1, 0xE0, 0x0E,
  0x0E, 0x00, 0x20, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x9F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0,
  0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE,
  0x7E, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C,
  0x7F, 0x18, 0x7F, 0x08, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x9F, 0x07, 0xF3, 0xC0, 0xFF, 0x30, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x78, 0x1F, 0xE3, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE8, 0x00, 0xFE, 0xC0, 0x1F, 0xEF, 0x8F,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB,
  0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0,
  0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x80, 0x0F, 0xEE, 0x01, 0xFE, 0xFE, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0x01, 0xF9, 0xFE, 0x0F, 0xDF, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0x0F, 0xEF, 0xF0, 0x7F, 0x7F,
  0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xF8, 0xFE,
  0x1F, 0xC7, 0xFB, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC,
  0x7E, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE7, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7E, 0x03,
  0xFB, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFD, 0xFC, 0x0F, 0xEF, 0xF0, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF0,
  0x3F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xF7,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xEF, 0xC0,
  0xFE, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x06, 0x1F, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0xFE, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x18, 0x3E, 0x3F, 0x9F, 0xCF,
  0xF7, 0xFB, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7E, 0x7F,
  0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE3, 0xC3, 0xFC, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0xFF, 0x87, 0xC7,
  0xC1, 0xFF, 0xE3, 0xE7, 0xC1, 0xFF, 0xF1, 0xF3, 0xE1, 0xFF, 0xF8, 0xF9,
  0xF0, 0xFC, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x0F,
  0xFC, 0x3E, 0x0F, 0x87, 0xFE, 0x1F, 0x07, 0xC3, 0xFF, 0x0F, 0x87, 0xE1,
  0xFF, 0x87, 0xC3, 0xF0, 0xFF, 0xC3, 0xE1, 0xF8, 0x7F, 0xE1, 0xF0, 0xFC,
  0x3F, 0xF0, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F,
  0x8F, 0xBE, 0x1F, 0x9F, 0xCF, 0x9F, 0x87, 0xFF, 0xFF, 0xC7, 0xC3, 0xFE,
  0x7F, 0xC3, 0xE0, 0xFF, 0x3F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xFC,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xF8, 0x7F, 0xEF, 0xE0,
  0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFE, 0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xC3, 0xC7, 0xFC, 0x06, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x04, 0xFF, 0x80, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x02,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x83, 0xFE, 0x7F, 0x01, 0xFE,
  0xFE, 0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x7F,
  0x9F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x3C, 0x1F, 0xE0, 0x04, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0x7F, 0x0F, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0xC0, 0x7F, 0x3F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x0C, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE,
  0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xC0,
  0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xE7, 0xE0,
  0x3F, 0x8F, 0xC0, 0xFF, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF8, 0x7E, 0x1F,
  0xE0, 0xFC, 0x3F, 0xC1, 0xF8, 0xFF, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF8,
  0x0F, 0xCF, 0xE0, 0x1F, 0xBF, 0xC0, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFF, 0x0F, 0xC0,
  0xFE, 0x1F, 0x81, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xFC, 0xFC, 0x03,
  0xF9, 0xF8, 0x07, 0xFB, 0xF0, 0x0F, 0xF7, 0xE0, 0x0F, 0xF0, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFD, 0xF0, 0x1F, 0x7F, 0xFD, 0xF8, 0x1F, 0x7F, 0xFD,
  0xF8, 0x3F, 0x7F, 0xFD, 0xF8, 0x3F, 0x7F, 0xFC, 0xF8, 0x3E, 0x7F, 0xFC,
  0xFC, 0x7E, 0x7F, 0xFC, 0xFC, 0x7E, 0x7F, 0xFC, 0xFC, 0x7C, 0x7F, 0xFC,
  0x7C, 0x7C, 0x7F, 0xFC, 0x7E, 0xFC, 0x7F, 0xFC, 0x7E, 0xFC, 0x7F, 0xFC,
  0x7E, 0xF8, 0x7F, 0xFC, 0x3E, 0xF8, 0x7F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xFC, 0x3F, 0xF0, 0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xFC, 0x1F, 0xE0, 0x7F, 0xFC, 0x1F, 0xE0, 0x7F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x7F, 0xFC,
  0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x83, 0xFF, 0xEF, 0xE1, 0xFF, 0xF7,
  0xF0, 0xFF, 0xF9, 0xF8, 0x7F, 0xFC, 0xFE, 0x3F, 0xFE, 0x3F, 0x1F, 0xFF,
  0x1F, 0xCF, 0xFF, 0x87, 0xE7, 0xFF, 0xC3, 0xFB, 0xFF, 0xE1, 0xFD, 0xFF,
  0xF0, 0x7E, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80,
  0x7F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x03,
  0xFB, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7,
  0xF0, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F,
  0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0x83,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0x07, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0x0C, 0xFE, 0x01, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x3F,
  0x00, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFF,
  0x81, 0xFC, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xFC,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0x83, 0xFF, 0x83, 0xF8, 0x1F, 0xC3,
  0xFF, 0xC3, 0xF8, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x0F, 0xC3, 0xE7, 0xC3,
  0xF8, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0x0F, 0xC7, 0xE7, 0xC7, 0xF0, 0x0F,
  0xE7, 0xE7, 0xE7, 0xF0, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x07, 0xE7, 0xC3,
  0xE7, 0xF0, 0x07, 0xE7, 0xC3, 0xE7, 0xE0, 0x07, 0xEF, 0xC3, 0xE7, 0xE0,
  0x07, 0xEF, 0xC3, 0xEF, 0xE0, 0x07, 0xEF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xEF, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xE7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F,
  0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xE0, 0xFE, 0x08, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFC, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0xFF, 0x7F,
  0x1F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x3F, 0xF1, 0xF1,
  0xFE, 0x1F, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0xFE,
  0x0F, 0xCF, 0xF8, 0x7E, 0xFF, 0xE3, 0xF7, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xDF, 0xE7, 0xF8, 0x7F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F,
  0x7F, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB,
  0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFF, 0x07, 0xF7, 0xFC, 0x7F, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xDF, 0xFC, 0x7E, 0x7F, 0xC3, 0xE1, 0xFC, 0x00,
  0x01, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF,
  0xF3, 0xFE, 0x79, 0xFC, 0x04, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x05, 0xFF, 0x1E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xC0, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC7, 0xF1,
  0xFF, 0x3F, 0x8F, 0xFD, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x9F,
  0xFB, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0x7F, 0x07, 0xFB, 0xFC, 0x7F, 0xDF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xDF, 0x8F, 0xFC, 0xFC, 0x3F, 0xC7, 0xE0, 0x10,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x02, 0x7F, 0x81, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x20, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x07, 0xE1, 0xF8, 0xFF, 0xCF, 0xC7, 0xFE, 0x7E, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xCF, 0xFD, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xBF, 0x83, 0xFD, 0xFE,
  0x7F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xDF, 0xC7, 0xFE, 0xFE,
  0x1F, 0xC7, 0xF0, 0x10, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x40, 0x07, 0xF3, 0x00, 0x7F, 0x9F, 0xDF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC7, 0xF0, 0xFC, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xF0,
  0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x81, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE1,
  0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x9F, 0xE3, 0xF8, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xFB, 0xF8, 0x1F,
  0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F,
  0xE3, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF0, 0x0F, 0xDF,
  0xC0, 0x3F, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7F, 0x03, 0xF8, 0xF8, 0xFF, 0x8F, 0xFC,
  0xFD, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F,
  0xFE, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x3F,
  0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x7F, 0x0F, 0x8F,
  0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x1F,
  0xCF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE7, 0xE0,
  0x7F, 0x3F, 0x83, 0xF9, 0xFE, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xF8,
  0x7F, 0x07, 0xE7, 0xFC, 0x3F, 0x7F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xC7, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0,
  0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x80,
  0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x83, 0xFB, 0xFE, 0x3F, 0x9F,
  0xFF, 0xFC, 0xFD, 0xFF, 0xE7, 0xEF, 0xFE, 0x3F, 0x3F, 0xE1, 0xF8, 0xFE,
  0x0F, 0xC0, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0xFF,
  0xCF, 0xC7, 0xFE, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xCF, 0xFD,
  0xFC, 0x1F, 0xEF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xBF, 0x83, 0xFD, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xDF, 0xC7, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0, 0x10, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xF8, 0x73, 0xF8, 0x09, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xE1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x3F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE3, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x63, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8,
  0x01, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFB, 0xF7, 0xFF, 0xBF, 0x3F, 0xF3, 0xF1, 0xFE, 0x3F,
  0x03, 0x00, 0x00, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xDF, 0x81, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x81, 0xFD, 0xF8, 0x1F, 0xF0,
  0x7F, 0x7F, 0x07, 0xFC, 0x1F, 0x9F, 0xC1, 0xFF, 0x07, 0xE3, 0xF0, 0xFF,
  0xC1, 0xF8, 0xFC, 0x3E, 0xF0, 0xFE, 0x3F, 0x8F, 0xBE, 0x3F, 0x8F, 0xE3,
  0xEF, 0x8F, 0xC1, 0xF8, 0xF3, 0xE3, 0xF0, 0x7E, 0x3C, 0xF9, 0xFC, 0x1F,
  0x9F, 0x1E, 0x7F, 0x07, 0xF7, 0xC7, 0x9F, 0x81, 0xFD, 0xF1, 0xF7, 0xE0,
  0x3F, 0x78, 0x7D, 0xF8, 0x0F, 0xDE, 0x1F, 0x7E, 0x03, 0xF7, 0x83, 0xDF,
  0x00, 0xFD, 0xE0, 0xFF, 0xC0, 0x1F, 0x78, 0x3F, 0xF0, 0x07, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFB, 0xF8, 0x1F,
  0xDF, 0xC1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x80,
  0xFD, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x87,
  0xF3, 0xF8, 0x3F, 0x9F, 0xC0, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFD,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xF8, 0xFC,
  0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFE, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0B, 0xFF,
  0x80, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x00, 0xFF, 0xD0, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Bold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 18, 13, 23, 2, -36 },
  { 64, 24, 36, 26, 1, -36 },
  { 172, 19, 42, 24, 2, -39 },
  { 272, 36, 37, 39, 2, -37 },
  { 439, 27, 38, 28, 1, -37 },
  { 568, 8, 13, 12, 2, -36 },
  { 581, 13, 45, 16, 2, -37 },
  { 655, 13, 45, 16, 1, -37 },
  { 729, 21, 21, 23, 1, -39 },
  { 785, 21, 24, 24, 1, -30 },
  { 848, 8, 13, 13, 2, -6 },
  { 861, 13, 7, 16, 1, -17 },
  { 873, 7, 9, 13, 3, -8 },
  { 881, 20, 37, 21, 0, -37 },
  { 974, 20, 38, 24, 2, -37 },
  { 1069, 16, 36, 24, 2, -36 },
  { 1141, 19, 37, 24, 2, -37 },
  { 1229, 20, 38, 24, 2, -37 },
  { 1324, 22, 36, 24, 1, -36 },
  { 1423, 20, 37, 24, 2, -36 },
  { 1516, 21, 38, 24, 1, -37 },
  { 1616, 21, 36, 24, 1, -36 },
  { 1711, 21, 38, 24, 1, -37 },
  { 1811, 21, 38, 24, 1, -37 },
  { 1911, 8, 29, 13, 3, -28 },
  { 1940, 9, 35, 13, 2, -28 },
  { 1980, 21, 24, 24, 1, -30 },
  { 2043, 21, 16, 24, 1, -26 },
  { 2085, 21, 24, 24, 1, -30 },
  { 2148, 18, 38, 19, 0, -37 },
  { 2234, 33, 41, 37, 2, -37 },
  { 2404, 27, 36, 27, 0, -36 },
  { 2526, 22, 36, 27, 3, -36 },
  { 2625, 21, 38, 25, 2, -37 },
  { 2725, 23, 36, 29, 3, -36 },
  { 2829, 16, 36, 22, 4, -36 },
  { 2901, 16, 36, 22, 4, -36 },
  { 2973, 24, 38, 29, 2, -37 },
  { 3087, 22, 36, 30, 4, -36 },
  { 3186, 14, 36, 16, 1, -36 },
  { 3249, 13, 47, 14, -3, -36 },
  { 3326, 23, 36, 26, 4, -36 },
  { 3430, 17, 36, 21, 3, -36 },
  { 3507, 32, 36, 39, 4, -36 },
  { 3651, 25, 36, 32, 4, -36 },
  { 3764, 26, 38, 30, 2, -37 },
  { 3888, 21, 36, 25, 3, -36 },
  { 3983, 26, 46, 30, 2, -37 },
  { 4133, 23, 36, 26, 3, -36 },
  { 4237, 18, 38, 22, 2, -37 },
  { 4323, 20, 36, 22, 1, -36 },
  { 4413, 23, 37, 29, 3, -36 },
  { 4520, 26, 36, 26, 0, -36 },
  { 4637, 40, 36, 38, -1, -36 },
  { 4817, 24, 36, 24, 0, -36 },
  { 4925, 24, 36, 24, 0, -36 },
  { 5033, 19, 36, 21, 1, -36 },
  { 5119, 12, 45, 16, 3, -37 },
  { 5187, 20, 37, 21, 0, -37 },
  { 5280, 12, 45, 16, 1, -37 },
  { 5348, 25, 22, 27, 1, -36 },
  { 5417, 21, 4, 21, 0, 4 },
  { 5428, 12, 8, 16, 2, -39 },
  { 5440, 20, 29, 24, 1, -28 },
  { 5513, 21, 40, 26, 3, -39 },
  { 5618, 17, 29, 20, 2, -28 },
  { 5680, 21, 40, 26, 2, -39 },
  { 5785, 20, 29, 23, 2, -28 },
  { 5858, 17, 39, 15, 0, -39 },
  { 5941, 21, 40, 26, 2, -28 },
  { 6046, 20, 39, 26, 3, -39 },
  { 6144, 7, 39, 12, 3, -39 },
  { 6179, 11, 51, 12, -1, -39 },
  { 6250, 22, 39, 25, 3, -39 },
  { 6358, 6, 39, 12, 3, -39 },
  { 6388, 32, 28, 38, 3, -28 },
  { 6500, 20, 28, 26, 3, -28 },
  { 6570, 21, 29, 25, 2, -28 },
  { 6647, 21, 40, 26, 3, -28 },
  { 6752, 21, 40, 26, 2, -28 },
  { 6857, 14, 28, 18, 3, -28 },
  { 6906, 17, 29, 19, 1, -28 },
  { 6968, 15, 35, 17, 1, -34 },
  { 7034, 20, 29, 26, 3, -28 },
  { 7107, 22, 28, 23, 0, -28 },
  { 7184, 34, 28, 35, 0, -28 },
  { 7303, 21, 28, 22, 0, -28 },
  { 7377, 22, 40, 23, 0, -28 },
  { 7487, 16, 28, 18, 1, -28 },
  { 7543, 15, 44, 18, 1, -36 },
  { 7626, 6, 51, 22, 8, -39 },
  { 7665, 15, 44, 18, 2, -36 },
  { 7748, 21, 8, 24, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Bold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD51PT7B_H_
