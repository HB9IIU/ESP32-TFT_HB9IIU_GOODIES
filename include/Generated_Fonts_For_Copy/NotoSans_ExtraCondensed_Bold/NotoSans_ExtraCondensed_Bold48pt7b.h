#ifndef _NOTOSANS_EXTRACONDENSED_BOLD48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x08,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF7, 0xE1, 0xFB, 0xF0,
  0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xC1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x87,
  0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xEF, 0xBF, 0xB8, 0x4F, 0xCE,
  0x03, 0xF3, 0x80, 0xFC, 0xE0, 0x3F, 0xB8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xBF, 0x00, 0xEF, 0xC0, 0x3B, 0xF8, 0x0E,
  0xFF, 0x83, 0xBF, 0xF8, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x1F, 0xF8, 0x03, 0xC0, 0x07, 0xFF, 0x80,
  0xF8, 0x00, 0xF9, 0xF0, 0x1F, 0x00, 0x1F, 0x1F, 0x07, 0xC0, 0x03, 0xE3,
  0xE0, 0xF8, 0x00, 0x78, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0xC7, 0xC0,
  0x00, 0xF0, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x3E, 0x1F, 0x03, 0xE3, 0xE7,
  0xC7, 0xF8, 0x7C, 0xF8, 0xF1, 0xFF, 0x87, 0xFF, 0x3E, 0x7F, 0xF0, 0xFF,
  0xE7, 0xCF, 0xBF, 0x0F, 0xF9, 0xF3, 0xE3, 0xE0, 0xFE, 0x3E, 0x7C, 0x7C,
  0x0F, 0x07, 0x8F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0xF0, 0x00, 0x3E, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x0F, 0x00, 0x0F, 0x83, 0xE3, 0xE0, 0x01, 0xF0, 0x7C, 0x7C, 0x00,
  0x3C, 0x0F, 0x8F, 0x80, 0x0F, 0x80, 0xF9, 0xF0, 0x01, 0xF0, 0x1F, 0xFC,
  0x00, 0x7C, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x3F, 0xE0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F,
  0xE1, 0xFF, 0xC3, 0xF8, 0xFF, 0xF8, 0xFC, 0x7F, 0xFE, 0x3F, 0x1F, 0x9F,
  0xDF, 0xCF, 0xE3, 0xFF, 0xF3, 0xF8, 0x7F, 0xF8, 0xFE, 0x1F, 0xFE, 0x3F,
  0x83, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xC3, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE0, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xC3, 0xE1, 0x9F, 0x7C, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xEF,
  0xC0, 0xFC, 0xFC, 0x3F, 0x1F, 0xC3, 0xE1, 0xE0, 0x18, 0x38, 0x01, 0x02,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3F,
  0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7E,
  0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF3, 0xF9, 0xF8, 0x7E,
  0xFE, 0x1F, 0xBF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0x9F,
  0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0x7F, 0xFC, 0xFD, 0xF1, 0xF9, 0xC3, 0xF1,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0x07, 0xF1, 0xC0, 0x7E,
  0x10, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0x07, 0xF0, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF4,
  0x00, 0xFE, 0xE0, 0x7F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xDF, 0x80, 0x7D, 0xF8, 0x07,
  0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0x1F, 0x81, 0xF1, 0xF8, 0x1E, 0x1F, 0x83,
  0xE1, 0xF8, 0x3C, 0x1F, 0x87, 0xC1, 0xF8, 0x78, 0x1F, 0x8F, 0x81, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x7C, 0xFF,
  0x87, 0xDF, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xF0,
  0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7E,
  0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3,
  0xF8, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF9, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x8F,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xBF, 0xC7, 0xF1, 0xFE, 0x7E,
  0x0F, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0x1F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF,
  0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x7E, 0x0F, 0xF7, 0xF9, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xBE, 0x3F, 0xFB,
  0xE1, 0xFF, 0x7E, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x11, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0,
  0x80, 0x08, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0xFE, 0x40, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x07, 0xC0,
  0xF0, 0xF8, 0x3F, 0xF1, 0xF3, 0xE0, 0xFF, 0xE3, 0xE7, 0xC3, 0xFF, 0xC3,
  0xCF, 0x0F, 0xC7, 0x87, 0xBE, 0x1F, 0x0F, 0x0F, 0xFC, 0x3E, 0x3E, 0x1F,
  0xF8, 0xF8, 0x7C, 0x3F, 0xF1, 0xF0, 0xF8, 0x7F, 0xE3, 0xE1, 0xF0, 0xFF,
  0xC7, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xC3, 0xFE, 0x1F, 0x0F, 0x87, 0xBE,
  0x3E, 0x1F, 0x0F, 0x7C, 0x7C, 0x3E, 0x1E, 0xF8, 0xF8, 0xFC, 0x7D, 0xF0,
  0xFF, 0xFD, 0xF3, 0xE1, 0xFF, 0xFF, 0xE3, 0xC1, 0xFE, 0x7F, 0x87, 0xC1,
  0xF8, 0x7E, 0x0F, 0x80, 0xC0, 0x20, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x00, 0x3F, 0xE0,
  0x7C, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE1, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE,
  0x0F, 0xEF, 0xE3, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xE0, 0xE3,
  0xFC, 0x04, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x23, 0xFF, 0x1E, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF9, 0xFF, 0x8F, 0xE0, 0xFF, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xE0,
  0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF,
  0x3F, 0x87, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE1, 0xFF, 0x03, 0x8F, 0xF0, 0x02, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xCF, 0xE0,
  0x3F, 0x3F, 0x80, 0xFC, 0xFF, 0x87, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF3, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x03, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF1, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F,
  0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF3, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3E, 0xFF,
  0xF7, 0xC0, 0x7D, 0xFF, 0xEF, 0x80, 0xFB, 0xFF, 0xDF, 0x03, 0xF7, 0xFF,
  0xBF, 0x07, 0xCF, 0xFF, 0x3E, 0x0F, 0x9F, 0xFE, 0x7C, 0x1F, 0x3F, 0xFC,
  0xF8, 0x7C, 0xFF, 0xF9, 0xF8, 0xF9, 0xFF, 0xF1, 0xF1, 0xF3, 0xFF, 0xE3,
  0xE7, 0xE7, 0xFF, 0xC7, 0xCF, 0x8F, 0xFF, 0x8F, 0xDF, 0x1F, 0xFF, 0x0F,
  0xBE, 0x3F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFC, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F,
  0xE1, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xC1, 0xFE,
  0x0F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0x03, 0xF8, 0x3F, 0xFE, 0x07, 0xE0,
  0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x3F, 0xFD, 0xF8, 0x3F,
  0xFC, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F,
  0xFC, 0x7F, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x1F, 0xBF,
  0xFC, 0x1F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE,
  0x7F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD,
  0xFC, 0xFF, 0xBF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x81, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE,
  0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x1F, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0x7F, 0x07,
  0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0,
  0x00, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xFD, 0xF9, 0xFC, 0x0C, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xF7, 0xF8, 0xFF, 0xBF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xF7,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0x00, 0xFE, 0xFC, 0x03, 0xF8, 0x07, 0xF7, 0xF0,
  0x1F, 0xE0, 0x3F, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0xC0, 0xFE, 0x3F, 0x03, 0xFE, 0x07, 0xF1, 0xFC, 0x1F,
  0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xC1, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3D, 0xF0, 0x7E, 0x0F, 0xC3, 0xEF, 0x87, 0xF0, 0x7E, 0x1F, 0x3E,
  0x3F, 0x01, 0xF8, 0xF9, 0xF1, 0xF8, 0x0F, 0xC7, 0xCF, 0x8F, 0xC0, 0x7E,
  0x3E, 0x7C, 0x7E, 0x03, 0xF3, 0xF3, 0xE7, 0xF0, 0x1F, 0x9F, 0x1F, 0xBF,
  0x80, 0x7C, 0xF8, 0x7D, 0xF8, 0x03, 0xF7, 0xC3, 0xEF, 0xC0, 0x1F, 0xBE,
  0x1F, 0x7E, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x07, 0xFF, 0x07, 0xDF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF0,
  0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x03,
  0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0,
  0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0xFC,
  0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xF0,
  0x7F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3E,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xFC, 0x3F, 0x00, 0xF8,
  0x7C, 0x01, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1E, 0x7F, 0x82, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x83, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0xFC, 0x3F, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xF7, 0xE7, 0xFC, 0x7C, 0x7F, 0x0F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x87, 0x03,
  0xF3, 0xF8, 0x7E, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xF8, 0xFE, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC7, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xE7, 0xFC, 0x7C,
  0x7F, 0x00, 0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7F, 0x06, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0x7F, 0x07, 0x7F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x70, 0xFC, 0x3F, 0x9F, 0x8F, 0xFB,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xDF, 0xC7, 0xFB, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F, 0xCF, 0x87, 0xF1, 0xF0, 0x00, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xCF, 0xE7,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x5F, 0xC0, 0x67,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x03, 0x80, 0x01, 0xFC, 0x7C, 0x7F, 0xCF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFE, 0xFE, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xF7,
  0xE3, 0xFE, 0xFC, 0x3F, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFA, 0x00, 0x7F, 0x70, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x20, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0E, 0x0F, 0xCF, 0xE3, 0xF7,
  0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x10, 0xFD, 0xFF, 0xFF, 0xEF,
  0xDF, 0x8C, 0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xE0, 0x02, 0x03, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0,
  0xFC, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF1, 0xFF, 0xFF, 0xFF,
  0xBF, 0xEF, 0xF3, 0xF8, 0x30, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFE,
  0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7E,
  0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xF7, 0xE0, 0xFE,
  0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0x83, 0xE3, 0xFC, 0x3F, 0xCF, 0x9F,
  0xF9, 0xFF, 0xBE, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0x87, 0xF8, 0x7F, 0xFC, 0x0F, 0xE0,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF,
  0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0,
  0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F,
  0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x38, 0x3E,
  0x3F, 0x8F, 0x9F, 0xF3, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0x7E,
  0x7E, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x1F, 0x1F, 0xC3, 0xE7,
  0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x87, 0xF7, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xBF, 0xE3, 0xF3, 0xF8, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x7C, 0x7F, 0xCF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFE, 0xFC, 0x3F, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0x3C, 0xFE, 0x04, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x4F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xDF, 0x3F, 0xE7, 0xC7, 0xF1, 0xF0, 0xFE, 0x01, 0xFB,
  0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0x83,
  0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x7E, 0x0F,
  0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x7F, 0x7E, 0x0F,
  0xF8, 0x7E, 0x7F, 0x0F, 0xF8, 0x7E, 0x3F, 0x0F, 0x78, 0x7E, 0x3F, 0x1F,
  0x78, 0x7E, 0x3F, 0x1F, 0x78, 0xFC, 0x3F, 0x1E, 0x7C, 0xFC, 0x1F, 0x9E,
  0x7C, 0xFC, 0x1F, 0x9E, 0x3C, 0xFC, 0x1F, 0x9E, 0x3C, 0xFC, 0x1F, 0xBE,
  0x3D, 0xF8, 0x1F, 0xBC, 0x3D, 0xF8, 0x0F, 0xBC, 0x3D, 0xF8, 0x0F, 0xBC,
  0x3D, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0xFE, 0x07, 0xF7, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC,
  0x1F, 0x9F, 0xC1, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xE7,
  0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F,
  0xDF, 0x80, 0xFC, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC,
  0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x7E, 0x00, 0xFB,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC3, 0xFF, 0x87,
  0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0xC1, 0xFF,
  0x01, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE,
  0x03, 0x00, 0x00, 0x1F, 0x00, 0x17, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Bold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 35, 12, 2, -34 },
  { 36, 17, 12, 21, 2, -34 },
  { 62, 22, 34, 24, 1, -34 },
  { 156, 18, 39, 22, 2, -36 },
  { 244, 35, 35, 37, 1, -35 },
  { 398, 26, 35, 27, 1, -35 },
  { 512, 7, 12, 11, 2, -34 },
  { 523, 12, 42, 15, 2, -34 },
  { 586, 12, 42, 15, 1, -34 },
  { 649, 19, 20, 21, 1, -37 },
  { 697, 20, 23, 22, 1, -28 },
  { 755, 9, 12, 12, 1, -6 },
  { 769, 12, 6, 15, 1, -16 },
  { 778, 8, 8, 12, 2, -7 },
  { 786, 19, 35, 19, 0, -35 },
  { 870, 18, 35, 22, 2, -35 },
  { 949, 15, 34, 22, 2, -34 },
  { 1013, 19, 35, 22, 1, -35 },
  { 1097, 19, 35, 22, 1, -35 },
  { 1181, 20, 34, 22, 1, -34 },
  { 1266, 18, 34, 22, 2, -34 },
  { 1343, 20, 35, 22, 1, -35 },
  { 1431, 20, 34, 22, 1, -34 },
  { 1516, 20, 35, 22, 1, -35 },
  { 1604, 20, 35, 22, 1, -35 },
  { 1692, 7, 28, 12, 3, -27 },
  { 1717, 8, 33, 12, 2, -27 },
  { 1750, 20, 23, 22, 1, -29 },
  { 1808, 20, 14, 22, 1, -24 },
  { 1843, 20, 23, 22, 1, -29 },
  { 1901, 17, 36, 18, 0, -35 },
  { 1978, 31, 39, 35, 2, -35 },
  { 2130, 25, 34, 25, 0, -34 },
  { 2237, 20, 34, 25, 3, -34 },
  { 2322, 20, 35, 23, 2, -35 },
  { 2410, 22, 34, 27, 3, -34 },
  { 2504, 16, 34, 21, 3, -34 },
  { 2572, 15, 34, 21, 3, -34 },
  { 2636, 22, 35, 27, 2, -35 },
  { 2733, 22, 34, 28, 3, -34 },
  { 2827, 13, 34, 15, 1, -34 },
  { 2883, 13, 44, 13, -3, -34 },
  { 2955, 22, 34, 25, 3, -34 },
  { 3049, 16, 34, 19, 3, -34 },
  { 3117, 31, 34, 37, 3, -34 },
  { 3249, 24, 34, 30, 3, -34 },
  { 3351, 24, 35, 28, 2, -35 },
  { 3456, 19, 34, 24, 3, -34 },
  { 3537, 24, 43, 28, 2, -35 },
  { 3666, 21, 34, 25, 3, -34 },
  { 3756, 18, 35, 20, 1, -35 },
  { 3835, 19, 34, 21, 1, -34 },
  { 3916, 21, 34, 27, 3, -34 },
  { 4006, 24, 34, 24, 0, -34 },
  { 4108, 37, 34, 36, -1, -34 },
  { 4266, 23, 34, 23, 0, -34 },
  { 4364, 23, 34, 23, 0, -34 },
  { 4462, 18, 34, 20, 1, -34 },
  { 4539, 11, 42, 15, 3, -34 },
  { 4597, 19, 35, 19, 0, -35 },
  { 4681, 11, 42, 15, 1, -34 },
  { 4739, 23, 21, 25, 1, -34 },
  { 4800, 20, 3, 20, 0, 4 },
  { 4808, 11, 8, 15, 2, -37 },
  { 4819, 19, 27, 22, 1, -27 },
  { 4884, 19, 36, 24, 3, -36 },
  { 4970, 16, 27, 19, 2, -27 },
  { 5024, 19, 36, 24, 2, -36 },
  { 5110, 18, 27, 22, 2, -27 },
  { 5171, 16, 37, 14, 0, -37 },
  { 5245, 19, 39, 24, 2, -27 },
  { 5338, 18, 36, 24, 3, -36 },
  { 5419, 7, 37, 12, 2, -37 },
  { 5452, 10, 49, 12, -1, -37 },
  { 5514, 20, 36, 23, 3, -36 },
  { 5604, 6, 36, 12, 3, -36 },
  { 5631, 30, 27, 36, 3, -27 },
  { 5733, 18, 27, 24, 3, -27 },
  { 5794, 20, 27, 23, 2, -27 },
  { 5862, 19, 39, 24, 3, -27 },
  { 5955, 19, 39, 24, 2, -27 },
  { 6048, 13, 27, 17, 3, -27 },
  { 6092, 16, 27, 18, 1, -27 },
  { 6146, 14, 32, 16, 1, -32 },
  { 6202, 18, 26, 24, 3, -26 },
  { 6261, 21, 26, 21, 0, -26 },
  { 6330, 32, 26, 33, 0, -26 },
  { 6434, 20, 26, 20, 0, -26 },
  { 6499, 21, 38, 21, 0, -26 },
  { 6599, 15, 26, 17, 1, -26 },
  { 6648, 15, 42, 17, 0, -34 },
  { 6727, 5, 48, 21, 8, -37 },
  { 6757, 14, 42, 17, 2, -34 },
  { 6831, 20, 8, 22, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Bold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD48PT7B_H_
