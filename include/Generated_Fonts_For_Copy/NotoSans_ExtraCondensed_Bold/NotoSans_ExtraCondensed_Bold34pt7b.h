#ifndef _NOTOSANS_EXTRACONDENSED_BOLD34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0x00,
  0x01, 0xEF, 0xFF, 0xFE, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38,
  0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x39, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F,
  0xE3, 0xFF, 0xBF, 0xFD, 0xFD, 0xCF, 0x62, 0x7B, 0x03, 0xD8, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1B, 0xC0,
  0xDF, 0x86, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xC7, 0xF8, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x01, 0xC0, 0x7F, 0x03,
  0xC0, 0x7F, 0x83, 0x80, 0xF3, 0x83, 0x80, 0xF3, 0x87, 0x80, 0xF3, 0xC7,
  0x00, 0xE3, 0xCF, 0x00, 0xE3, 0xCE, 0x00, 0xF3, 0xCE, 0x00, 0xF3, 0x9E,
  0x78, 0xF3, 0x9C, 0xFC, 0x7F, 0x9D, 0xFE, 0x7F, 0x3D, 0xEF, 0x3F, 0x39,
  0xCF, 0x0C, 0x79, 0xC7, 0x00, 0x71, 0xC7, 0x00, 0x71, 0xC7, 0x00, 0xF1,
  0xC7, 0x00, 0xE1, 0xC7, 0x01, 0xE1, 0xCF, 0x01, 0xC1, 0xCF, 0x01, 0xC1,
  0xFE, 0x03, 0xC0, 0xFE, 0x03, 0x80, 0x7C, 0x03, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x87,
  0x9F, 0xF3, 0xE7, 0xFC, 0xFB, 0xEF, 0xBE, 0xF9, 0xFF, 0x3C, 0x3F, 0xCF,
  0x0F, 0xE3, 0xE1, 0xF8, 0xF8, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF,
  0xFE, 0x1F, 0xCF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0xF8, 0x1C, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x80, 0x0F,
  0x80, 0x38, 0x01, 0xC1, 0x0E, 0x1F, 0x77, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC,
  0x1F, 0xC0, 0xFE, 0x0F, 0x78, 0xF1, 0xE3, 0x8E, 0x04, 0x20, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00,
  0x07, 0x00, 0xFE, 0x0F, 0xF8, 0x7F, 0xE7, 0xDF, 0x3C, 0x7D, 0xE3, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xDE, 0x1E, 0xF1, 0xF7, 0xCF, 0xBF, 0xF8,
  0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDE,
  0xFF, 0xBD, 0xCF, 0x27, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xE7, 0x9F, 0xB0, 0x7C, 0x83, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x01, 0xFF, 0x3F, 0xFC, 0xFF, 0xE7, 0x1F,
  0x90, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x81, 0xF8, 0x3F, 0x81,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x01,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x03, 0xFC, 0x1D,
  0xF0, 0x77, 0xC3, 0x9F, 0x0E, 0x7C, 0x71, 0xF1, 0xC7, 0xCF, 0x1F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF2, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0x77, 0xF0, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0xFF, 0xEF, 0xFE,
  0xFF, 0xCF, 0xF0, 0x00, 0x60, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0x89,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC7, 0x0F, 0x7F, 0x3D, 0xFC,
  0xFF, 0xFB, 0xF3, 0xEF, 0x87, 0xBE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xDE, 0x1E, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xFC, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFE,
  0x7C, 0xF9, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF9, 0xF7, 0xC3, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0x3E, 0xF8, 0x7B, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xF3, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xC0, 0x02, 0x00, 0x7F, 0x03, 0xFE, 0x1F, 0xFC, 0x7D, 0xF3, 0xE3, 0xEF,
  0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xFF, 0x87, 0xFE, 0x3F, 0xFC, 0xFD,
  0xFF, 0xE7, 0xFF, 0x8F, 0xDE, 0x0C, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0x00, 0x77, 0xFF, 0xFF,
  0xB8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDF, 0xFF, 0xFC, 0x39, 0xF7, 0xDF,
  0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7D, 0xF7, 0x9E,
  0x79, 0xCF, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x03,
  0xE0, 0x0E, 0x00, 0x20, 0x00, 0x06, 0x03, 0xFC, 0xFF, 0xE7, 0xFE, 0x7B,
  0xF4, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0xF0, 0x70, 0x01, 0xE3,
  0xC0, 0x03, 0x8E, 0x1F, 0xCE, 0x78, 0xFF, 0x3D, 0xC7, 0xFC, 0x77, 0x1C,
  0x71, 0xDC, 0xF1, 0xC7, 0xF3, 0xC7, 0x1F, 0xCE, 0x1C, 0x7F, 0x38, 0x71,
  0xFC, 0xE3, 0xC7, 0xF3, 0xCF, 0x1F, 0xCF, 0x3C, 0xE7, 0x1F, 0xFF, 0x9C,
  0x7E, 0xFC, 0x78, 0xF1, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x10, 0x1F, 0x83, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xF7, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3,
  0xE0, 0x78, 0xF8, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F,
  0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF3,
  0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x9F, 0x1F, 0xBE, 0x1F, 0x7C, 0x1E,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xC3, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F,
  0xFC, 0x7F, 0xE0, 0x00, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xE3, 0xFB,
  0xC7, 0xC0, 0x9F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x47, 0xFF, 0x87, 0xFF, 0x07, 0xFE,
  0x07, 0xF8, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7C,
  0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x40, 0x0F, 0xF8,
  0x7F, 0xF9, 0xFF, 0xF3, 0xF9, 0xCF, 0xC0, 0x9F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0xC3, 0xEF,
  0xFF, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE7, 0xFF, 0xFF, 0xFF, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC7, 0xFF, 0xEF, 0xF7, 0xF3, 0xF0, 0xF8, 0x3F, 0xF8,
  0x3E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xFB,
  0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFD, 0xE0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x70,
  0x3B, 0xFD, 0xE1, 0xEF, 0xFF, 0x87, 0xBF, 0xFE, 0x1E, 0xFF, 0xB8, 0x73,
  0xFE, 0xF3, 0xDF, 0xFB, 0xCF, 0x7F, 0xEF, 0x39, 0xFF, 0x9C, 0xE7, 0xFE,
  0x7F, 0x9F, 0xF9, 0xFE, 0x7F, 0xE7, 0xF1, 0xFF, 0x8F, 0xC7, 0xFE, 0x3F,
  0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E, 0x1F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xEF, 0x0F, 0xF7, 0x87, 0xFD, 0xE3, 0xFE, 0xF1, 0xFF,
  0x7C, 0xFF, 0x9E, 0x7F, 0xCF, 0xBF, 0xE3, 0xDF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xBF, 0x0F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x07, 0x9E,
  0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80,
  0x7D, 0xE0, 0x1F, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x3E, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xEF, 0x8F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xBF, 0x0F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x07, 0x9E, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x3E, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF,
  0x8F, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF1, 0xF3, 0xE7,
  0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3E, 0xF8, 0x7C, 0xF0, 0xF9, 0xF1,
  0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xCF, 0x87, 0xDF, 0x0F, 0xBE, 0x0F, 0xFC,
  0x1F, 0x07, 0x01, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0x82, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFB, 0xE1, 0xF7, 0xFF,
  0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0xF0, 0x07, 0xFC, 0x07, 0xDE, 0x03,
  0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C,
  0x1E, 0x1F, 0x0F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xFC, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0x7B, 0xE0, 0xF8, 0x3E, 0x78, 0x3F,
  0x0F, 0x9E, 0x0F, 0xC3, 0xE7, 0x87, 0xF0, 0xF1, 0xF1, 0xFC, 0x3C, 0x7C,
  0x77, 0x0F, 0x0F, 0x1D, 0xE7, 0xC3, 0xC7, 0x79, 0xF0, 0xF3, 0xDE, 0x78,
  0x3C, 0xF3, 0x9E, 0x0F, 0xBC, 0xE7, 0x81, 0xEE, 0x3D, 0xE0, 0x7B, 0x8F,
  0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x03, 0xE0, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C,
  0x3C, 0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F,
  0xE2, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x7F, 0x3F, 0xFB, 0xFF, 0xDF, 0xBF,
  0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0xE3, 0xFF, 0x3F, 0xFF, 0xFB, 0xFB, 0xCF,
  0x8E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x70, 0xF7, 0xF3, 0xDF, 0xCF, 0xFF, 0xBE, 0x3E, 0xF8, 0x7B,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0x7B, 0xE3, 0xEF, 0xFF, 0xBF, 0xFC, 0xF7, 0xF3, 0xCF, 0x80, 0x07,
  0xC1, 0xFF, 0x3F, 0xE3, 0xFE, 0x7C, 0x27, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x17, 0xFE, 0x3F,
  0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC3, 0x8F, 0x3F, 0xBC, 0xFF, 0xF7, 0xFF, 0xDF,
  0x1F, 0x78, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0x78, 0x7D, 0xE1, 0xF7, 0xEF, 0xDF, 0xFF, 0x3F, 0xBC,
  0x7C, 0xF0, 0x07, 0x80, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x87, 0xBC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x2F, 0xC7, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x07, 0xE1, 0xFC,
  0x7F, 0x8F, 0xE3, 0xE0, 0x7C, 0x0F, 0x81, 0xFE, 0x7F, 0xDF, 0xFB, 0xFF,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x0F, 0x3C, 0xFE,
  0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0x7D, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xF7, 0x87, 0xDF,
  0xFF, 0x7F, 0xFC, 0xFE, 0xF1, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF4,
  0x07, 0x9F, 0xFE, 0x7F, 0xF1, 0xFF, 0xC3, 0xFC, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0xF7, 0xF7,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xC0, 0x77, 0xBF, 0xEF, 0x00, 0x1E, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x0E, 0x1E, 0x1F,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x1E, 0xF0, 0x7D,
  0xE1, 0xF3, 0xC3, 0xC7, 0x8F, 0x8F, 0x3E, 0x1E, 0x78, 0x3D, 0xF0, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xCF, 0x0F, 0x1F, 0x1E, 0x1E,
  0x3C, 0x3E, 0x78, 0x3C, 0xF0, 0x7D, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE1, 0xE3,
  0xDF, 0xDF, 0xCF, 0xFF, 0x7F, 0xBF, 0xFF, 0xFE, 0xF8, 0xFC, 0xFB, 0xE3,
  0xE1, 0xEF, 0x8F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1,
  0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1, 0xFF,
  0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F, 0xC3, 0xE1, 0xFF, 0x0F,
  0x87, 0xC0, 0xE3, 0xC7, 0xBF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0x07, 0xC0, 0x7F,
  0x83, 0xFF, 0x1F, 0xFE, 0x7C, 0x7D, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3D, 0xE1, 0xF7, 0xC7, 0xDF,
  0xBE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0xF3, 0xC3, 0xDF, 0xCF, 0x7F,
  0x3F, 0xFE, 0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xEF, 0x8F, 0xBF, 0xFE, 0xFF,
  0xF3, 0xDF, 0xCF, 0x3E, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x3C, 0xFE, 0xF3, 0xFF,
  0xDF, 0xFF, 0x7C, 0x7D, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xF7, 0x87, 0xDF, 0xFF, 0x7F,
  0xFC, 0xFE, 0xF1, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xE1, 0xFD, 0xEF, 0x7B, 0xFE,
  0xFF, 0xBF, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1F, 0x0F, 0xFD, 0xFF, 0x7F,
  0xEF, 0x05, 0xE0, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFC, 0x00, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xFC, 0xFF, 0xBF, 0xF7, 0xFE, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0x7F, 0xFB, 0xFB, 0xCF,
  0x8E, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xCF, 0x8F,
  0x8F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xF7, 0x81,
  0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x7C, 0x1F, 0xF0, 0xF8, 0x7D, 0xE1, 0xF0, 0xF3, 0xC7, 0xF1,
  0xE7, 0x8E, 0xE3, 0xCF, 0x9D, 0xC7, 0x8F, 0x3B, 0x9F, 0x1E, 0x77, 0x3C,
  0x3C, 0xEE, 0x78, 0x7B, 0x8E, 0xF0, 0xF7, 0x1D, 0xE0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x0F,
  0xC7, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x7D, 0xE1, 0xF7,
  0xC7, 0x8F, 0x3E, 0x3E, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3E,
  0x7C, 0x79, 0xE1, 0xFF, 0x87, 0xC0, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3,
  0xC1, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x3E, 0x78, 0x3D,
  0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFF, 0xDF, 0xFB,
  0xFF, 0x7F, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xE1, 0xFC, 0x3F, 0x87, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF1, 0xFC, 0x3E, 0x07, 0xF0, 0x3F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x3F, 0x87, 0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xF0, 0x3C,
  0x3F, 0x1F, 0x87, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x8F, 0xE3, 0xF0, 0xF8, 0x00, 0x38, 0x07, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFE, 0x03, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Bold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 12, 9, 15, 2, -24 },
  { 30, 16, 24, 17, 1, -24 },
  { 78, 13, 28, 16, 1, -26 },
  { 124, 24, 25, 26, 1, -25 },
  { 199, 18, 25, 19, 1, -25 },
  { 256, 4, 9, 8, 2, -24 },
  { 261, 8, 29, 11, 2, -24 },
  { 290, 9, 29, 11, 0, -24 },
  { 323, 13, 14, 15, 1, -26 },
  { 346, 14, 16, 16, 1, -20 },
  { 374, 6, 8, 8, 1, -4 },
  { 380, 8, 4, 10, 1, -11 },
  { 384, 5, 5, 9, 2, -5 },
  { 388, 14, 25, 14, 0, -25 },
  { 432, 13, 25, 16, 1, -25 },
  { 473, 10, 24, 16, 2, -24 },
  { 503, 13, 25, 16, 1, -25 },
  { 544, 13, 25, 16, 1, -25 },
  { 585, 14, 24, 16, 1, -24 },
  { 627, 12, 24, 16, 2, -24 },
  { 663, 14, 25, 16, 1, -25 },
  { 707, 14, 24, 16, 1, -24 },
  { 749, 14, 25, 16, 1, -25 },
  { 793, 14, 25, 16, 1, -25 },
  { 837, 5, 19, 9, 2, -19 },
  { 849, 6, 23, 9, 1, -19 },
  { 867, 14, 16, 16, 1, -20 },
  { 895, 14, 10, 16, 1, -17 },
  { 913, 14, 16, 16, 1, -20 },
  { 941, 12, 25, 13, 0, -25 },
  { 979, 22, 28, 25, 1, -25 },
  { 1056, 18, 24, 18, 0, -24 },
  { 1110, 15, 24, 18, 2, -24 },
  { 1155, 15, 25, 16, 1, -25 },
  { 1202, 16, 24, 19, 2, -24 },
  { 1250, 11, 24, 15, 2, -24 },
  { 1283, 11, 24, 15, 2, -24 },
  { 1316, 15, 25, 19, 2, -25 },
  { 1363, 16, 24, 20, 2, -24 },
  { 1411, 9, 24, 11, 1, -24 },
  { 1438, 9, 31, 9, -2, -24 },
  { 1473, 16, 24, 18, 2, -24 },
  { 1521, 11, 24, 14, 2, -24 },
  { 1554, 22, 24, 26, 2, -24 },
  { 1620, 17, 24, 21, 2, -24 },
  { 1671, 18, 25, 20, 1, -25 },
  { 1728, 14, 24, 17, 2, -24 },
  { 1770, 18, 31, 20, 1, -25 },
  { 1840, 15, 24, 17, 2, -24 },
  { 1885, 12, 25, 14, 1, -25 },
  { 1923, 14, 24, 15, 0, -24 },
  { 1965, 15, 24, 19, 2, -24 },
  { 2010, 17, 24, 17, 0, -24 },
  { 2061, 26, 24, 25, 0, -24 },
  { 2139, 16, 24, 16, 0, -24 },
  { 2187, 16, 24, 16, 0, -24 },
  { 2235, 14, 24, 14, 0, -24 },
  { 2277, 8, 29, 11, 2, -24 },
  { 2306, 14, 25, 14, 0, -25 },
  { 2350, 8, 29, 11, 1, -24 },
  { 2379, 16, 15, 18, 1, -24 },
  { 2409, 14, 2, 14, 0, 3 },
  { 2413, 8, 5, 11, 1, -26 },
  { 2418, 13, 19, 16, 1, -19 },
  { 2449, 14, 26, 17, 2, -26 },
  { 2495, 12, 19, 14, 1, -19 },
  { 2524, 14, 26, 17, 1, -26 },
  { 2570, 13, 19, 16, 1, -19 },
  { 2601, 11, 26, 10, 0, -26 },
  { 2637, 14, 27, 17, 1, -19 },
  { 2685, 13, 26, 17, 2, -26 },
  { 2728, 5, 26, 8, 2, -26 },
  { 2745, 8, 34, 8, -1, -26 },
  { 2779, 15, 26, 16, 2, -26 },
  { 2828, 4, 26, 8, 2, -26 },
  { 2841, 22, 19, 25, 2, -19 },
  { 2894, 13, 19, 17, 2, -19 },
  { 2925, 14, 19, 17, 1, -19 },
  { 2959, 14, 27, 17, 2, -19 },
  { 3007, 14, 27, 17, 1, -19 },
  { 3055, 10, 19, 12, 2, -19 },
  { 3079, 11, 19, 13, 1, -19 },
  { 3106, 11, 23, 11, 0, -23 },
  { 3138, 13, 19, 17, 2, -19 },
  { 3169, 15, 19, 15, 0, -19 },
  { 3205, 23, 19, 23, 0, -19 },
  { 3260, 14, 19, 14, 0, -19 },
  { 3294, 15, 27, 15, 0, -19 },
  { 3345, 11, 19, 12, 1, -19 },
  { 3372, 11, 29, 12, 0, -24 },
  { 3412, 3, 34, 15, 6, -26 },
  { 3425, 10, 29, 12, 1, -24 },
  { 3462, 14, 6, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Bold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD34PT7B_H_
