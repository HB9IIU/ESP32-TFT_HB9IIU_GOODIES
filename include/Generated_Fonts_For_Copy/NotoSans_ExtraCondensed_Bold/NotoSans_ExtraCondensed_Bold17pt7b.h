#ifndef _NOTOSANS_EXTRACONDENSED_BOLD17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x1F, 0xDF, 0x7C, 0xF2, 0x1A, 0x16, 0x16, 0x7F, 0x7F,
  0x36, 0x34, 0xFF, 0xFF, 0x2C, 0x2C, 0x6C, 0x10, 0xEF, 0xF5, 0xD3, 0x87,
  0x07, 0x1E, 0x7D, 0xFE, 0x10, 0x40, 0xF1, 0x8F, 0x30, 0x93, 0x09, 0x20,
  0x96, 0x0F, 0x7E, 0xFD, 0xA0, 0xDB, 0x09, 0xB1, 0x9B, 0x19, 0xE3, 0x0E,
  0x3C, 0x3F, 0x19, 0x8D, 0xC3, 0xC1, 0xC1, 0xE6, 0xDF, 0xEF, 0x73, 0x9F,
  0xC7, 0xB0, 0xFF, 0x36, 0x6C, 0xCC, 0xCC, 0xCC, 0xC6, 0x66, 0x30, 0xE3,
  0x0C, 0x63, 0x18, 0xE3, 0x39, 0x8C, 0x66, 0x33, 0x00, 0x18, 0x31, 0xFF,
  0xF3, 0xCD, 0xC9, 0x00, 0x18, 0x30, 0x67, 0xFF, 0xE3, 0x06, 0x0C, 0xFF,
  0xFF, 0xFE, 0x7C, 0x06, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x18, 0x20, 0xC1,
  0x86, 0x00, 0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDE, 0x19,
  0xDF, 0xB5, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0xFB, 0xF8, 0xC3, 0x1C, 0x63,
  0x8C, 0x63, 0x0F, 0xFF, 0xFB, 0xF0, 0xC3, 0x19, 0xC7, 0xC3, 0x0E, 0x3F,
  0xFE, 0x0C, 0x1C, 0x1C, 0x3C, 0x3C, 0x6C, 0x6C, 0xCC, 0xFF, 0xFF, 0x0C,
  0x0C, 0xFF, 0xFC, 0x30, 0xF3, 0xF1, 0xC3, 0x0E, 0x3F, 0xFE, 0x1E, 0x7D,
  0x83, 0x07, 0xCF, 0xF9, 0xB3, 0x66, 0xCD, 0xF9, 0xE0, 0xFF, 0xFC, 0x18,
  0x70, 0xC1, 0x87, 0x0C, 0x18, 0x70, 0xC3, 0x80, 0x3C, 0xFD, 0x9B, 0x37,
  0xE7, 0x9F, 0x33, 0xE7, 0xCD, 0xF9, 0xE0, 0x3C, 0xFD, 0x9F, 0x3E, 0x6C,
  0xDF, 0x9B, 0x06, 0x1D, 0xF3, 0xC0, 0xDC, 0x00, 0x17, 0xC0, 0xF8, 0x00,
  0x07, 0xDB, 0x00, 0x02, 0x1C, 0xF7, 0x8F, 0x07, 0x83, 0x81, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0xC1, 0xE0, 0xF0, 0x70, 0xEF, 0x38, 0x40, 0xFB,
  0xF0, 0xC3, 0x1C, 0xE3, 0x0C, 0x00, 0x87, 0x0C, 0x1F, 0x0E, 0x31, 0x83,
  0x67, 0xAD, 0xB7, 0x26, 0xE4, 0xDC, 0x92, 0x9F, 0xDB, 0xB3, 0x00, 0x30,
  0x83, 0xF0, 0x1C, 0x0E, 0x0D, 0x86, 0xC3, 0x61, 0xB1, 0xDC, 0xFE, 0x7F,
  0x31, 0xB8, 0xFC, 0x70, 0xFD, 0xFF, 0x1E, 0x3C, 0xFF, 0xBF, 0xE3, 0xC7,
  0x8F, 0xFF, 0xE0, 0x3E, 0xFB, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC5,
  0xF1, 0xE0, 0xFC, 0xFE, 0xC6, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xCE,
  0xFC, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0xEF, 0xB0, 0xC3, 0x0F, 0xFF, 0xFF,
  0xFC, 0x30, 0xC3, 0xEF, 0xB0, 0xC3, 0x0C, 0x30, 0x3F, 0x7E, 0xE0, 0xE0,
  0xC0, 0xCF, 0xCF, 0xC7, 0xC7, 0xE7, 0x7F, 0x3E, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFB, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x9F, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xFC,
  0xC7, 0xCE, 0xCC, 0xDC, 0xD8, 0xF8, 0xF8, 0xFC, 0xCC, 0xCE, 0xC6, 0xC7,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFD, 0x97, 0xB6, 0xF6, 0xDE, 0xDB, 0xCE, 0x79, 0xCF, 0x39,
  0xE6, 0x30, 0xE3, 0xF9, 0xFC, 0xFE, 0x7D, 0xBE, 0xDF, 0x3F, 0x9F, 0xCF,
  0xE3, 0xF1, 0xF8, 0x70, 0x3E, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xE7, 0x7E, 0x3C, 0xFD, 0xFB, 0x3E, 0x3C, 0xF9, 0xFF, 0x7C, 0xC1,
  0x83, 0x06, 0x00, 0x3E, 0x7E, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE7, 0x7E, 0x3C, 0x0E, 0x06, 0x07, 0xFC, 0xFE, 0xCE, 0xC6, 0xCE, 0xFC,
  0xF8, 0xDC, 0xCC, 0xCE, 0xCE, 0xC7, 0x7F, 0xEC, 0xB0, 0xE3, 0xC3, 0x87,
  0x1E, 0x7F, 0xBC, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC0, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE7,
  0x7E, 0x7C, 0xC3, 0xF1, 0x98, 0xCC, 0x66, 0x63, 0x30, 0xD8, 0x6C, 0x34,
  0x1E, 0x07, 0x03, 0x80, 0xC6, 0x3E, 0x39, 0xF9, 0xCC, 0xCE, 0x66, 0xF3,
  0x36, 0x99, 0xB7, 0xCD, 0xBC, 0x79, 0xE1, 0xCF, 0x0E, 0x38, 0x71, 0xC0,
  0xE7, 0x66, 0x7E, 0x3C, 0x3C, 0x18, 0x3C, 0x3C, 0x3E, 0x66, 0x66, 0xE7,
  0xE7, 0x66, 0x66, 0x7E, 0x3C, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFC, 0x30, 0xE1, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0xFF, 0xF0, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0xC1, 0x81, 0x83, 0x06,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xF0, 0x08, 0x0E, 0x07, 0x06, 0xC3, 0x63, 0x1B, 0x8E, 0xFF, 0xFC,
  0xC6, 0x30, 0x7C, 0x5C, 0x19, 0xF7, 0xEC, 0xF9, 0xBF, 0x76, 0xC1, 0x83,
  0x06, 0x0F, 0xDD, 0xB3, 0xE3, 0xC7, 0x8F, 0x3F, 0xED, 0xC0, 0x7F, 0x71,
  0x8C, 0x63, 0x1F, 0x78, 0x0E, 0x1C, 0x38, 0x77, 0xFF, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3F, 0xF7, 0x60, 0x7B, 0x3C, 0xFF, 0xFF, 0x0C, 0x3F, 0x7C, 0x3D,
  0xE6, 0x18, 0xFB, 0xE6, 0x18, 0x61, 0x86, 0x18, 0x60, 0x77, 0xFF, 0x3E,
  0x7C, 0xF9, 0xF3, 0xFF, 0x7E, 0x1A, 0x37, 0xEF, 0x80, 0xC1, 0x83, 0x06,
  0x0F, 0xDF, 0xB3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xE0, 0xF4, 0xFF, 0xFF,
  0xC0, 0x6C, 0x86, 0xDB, 0x6D, 0xB6, 0xDF, 0xC0, 0xC1, 0x83, 0x06, 0x0C,
  0xF9, 0xB6, 0x7C, 0xF9, 0xF3, 0x36, 0x7C, 0x60, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFD, 0xDF, 0xFF, 0x3B, 0xE6, 0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xCC,
  0x60, 0xFD, 0xFB, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCE, 0x79, 0xDB, 0x36,
  0x7C, 0xF9, 0xF3, 0x7E, 0x78, 0xFD, 0xDB, 0x3E, 0x3C, 0x78, 0xF3, 0xFE,
  0xDD, 0x83, 0x06, 0x0C, 0x00, 0x77, 0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF,
  0x7E, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xF9, 0x8C, 0x63, 0x18, 0xC0, 0x7D,
  0xAE, 0x1C, 0x38, 0x78, 0xFF, 0xF8, 0x23, 0x3F, 0xF6, 0x31, 0x8C, 0x63,
  0xCE, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0x76, 0xE7, 0x66, 0x66,
  0x6C, 0x6C, 0x3C, 0x3C, 0x38, 0x38, 0xCE, 0x7D, 0xCD, 0xBD, 0xB5, 0xB6,
  0xBC, 0xD3, 0x8A, 0x71, 0xCE, 0x39, 0x80, 0xEE, 0xD9, 0xF1, 0xC3, 0x87,
  0x9B, 0x36, 0xE6, 0xE7, 0x66, 0x66, 0x6C, 0x7C, 0x3C, 0x3C, 0x38, 0x18,
  0x18, 0x38, 0x70, 0x60, 0x7D, 0xF1, 0x8E, 0x31, 0xC6, 0x3F, 0xFC, 0x39,
  0xCC, 0x63, 0x1B, 0xDC, 0x31, 0x8C, 0x63, 0x1C, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC7, 0x18, 0xC6, 0x31, 0xE7, 0x63, 0x18, 0xC6, 0x73, 0x00,
  0xFB, 0xBC,
};

const GFXglyph NotoSans_ExtraCondensed_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 6, 4, 8, 1, -12 },
  { 7, 8, 12, 9, 0, -12 },
  { 19, 6, 14, 8, 1, -13 },
  { 30, 12, 12, 13, 1, -12 },
  { 48, 9, 12, 9, 0, -12 },
  { 62, 2, 4, 4, 1, -12 },
  { 63, 4, 15, 5, 1, -12 },
  { 71, 5, 15, 5, 0, -12 },
  { 81, 7, 7, 8, 0, -13 },
  { 88, 7, 8, 8, 0, -10 },
  { 95, 2, 4, 4, 1, -2 },
  { 96, 5, 3, 5, 0, -6 },
  { 98, 2, 3, 4, 1, -3 },
  { 99, 7, 12, 7, 0, -12 },
  { 110, 6, 12, 8, 1, -12 },
  { 119, 5, 12, 8, 1, -12 },
  { 127, 6, 12, 8, 1, -12 },
  { 136, 6, 12, 8, 1, -12 },
  { 145, 8, 12, 8, 0, -12 },
  { 157, 6, 12, 8, 1, -12 },
  { 166, 7, 12, 8, 0, -12 },
  { 177, 7, 12, 8, 0, -12 },
  { 188, 7, 12, 8, 0, -12 },
  { 199, 7, 12, 8, 0, -12 },
  { 210, 3, 9, 4, 1, -9 },
  { 214, 3, 11, 4, 1, -9 },
  { 219, 7, 8, 8, 0, -10 },
  { 226, 7, 6, 8, 0, -9 },
  { 232, 7, 8, 8, 0, -10 },
  { 239, 6, 12, 6, 0, -12 },
  { 248, 11, 13, 12, 1, -12 },
  { 266, 9, 12, 9, 0, -12 },
  { 280, 7, 12, 9, 1, -12 },
  { 291, 7, 12, 8, 1, -12 },
  { 302, 8, 12, 10, 1, -12 },
  { 314, 6, 12, 7, 1, -12 },
  { 323, 6, 12, 7, 1, -12 },
  { 332, 8, 12, 10, 1, -12 },
  { 344, 8, 12, 10, 1, -12 },
  { 356, 5, 12, 5, 0, -12 },
  { 364, 4, 16, 5, -1, -12 },
  { 372, 8, 12, 9, 1, -12 },
  { 384, 6, 12, 7, 1, -12 },
  { 393, 11, 12, 13, 1, -12 },
  { 410, 9, 12, 11, 1, -12 },
  { 424, 8, 12, 10, 1, -12 },
  { 436, 7, 12, 8, 1, -12 },
  { 447, 8, 15, 10, 1, -12 },
  { 462, 8, 12, 9, 1, -12 },
  { 474, 6, 12, 7, 1, -12 },
  { 483, 7, 12, 7, 0, -12 },
  { 494, 8, 12, 10, 1, -12 },
  { 506, 9, 12, 9, 0, -12 },
  { 520, 13, 12, 13, 0, -12 },
  { 540, 8, 12, 8, 0, -12 },
  { 552, 8, 12, 8, 0, -12 },
  { 564, 7, 12, 7, 0, -12 },
  { 575, 4, 15, 5, 1, -12 },
  { 583, 7, 12, 7, 0, -12 },
  { 594, 4, 15, 5, 0, -12 },
  { 602, 9, 7, 9, 0, -12 },
  { 610, 7, 2, 7, 0, 1 },
  { 612, 4, 3, 5, 1, -13 },
  { 614, 7, 9, 8, 0, -9 },
  { 622, 7, 13, 9, 1, -13 },
  { 634, 5, 9, 7, 1, -9 },
  { 640, 7, 13, 9, 1, -13 },
  { 652, 6, 9, 8, 1, -9 },
  { 659, 6, 13, 5, 0, -13 },
  { 669, 7, 13, 9, 1, -9 },
  { 681, 7, 13, 9, 1, -13 },
  { 693, 2, 13, 4, 1, -13 },
  { 697, 3, 17, 4, 0, -13 },
  { 704, 7, 13, 8, 1, -13 },
  { 716, 2, 13, 4, 1, -13 },
  { 720, 11, 9, 13, 1, -9 },
  { 733, 7, 9, 9, 1, -9 },
  { 741, 7, 9, 8, 1, -9 },
  { 749, 7, 13, 9, 1, -9 },
  { 761, 7, 13, 9, 1, -9 },
  { 773, 5, 9, 6, 1, -9 },
  { 779, 6, 9, 6, 0, -9 },
  { 786, 5, 11, 6, 0, -11 },
  { 793, 7, 9, 9, 1, -9 },
  { 801, 8, 9, 8, 0, -9 },
  { 810, 11, 9, 12, 0, -9 },
  { 823, 7, 9, 7, 0, -9 },
  { 831, 8, 13, 8, 0, -9 },
  { 844, 6, 9, 6, 0, -9 },
  { 851, 5, 15, 6, 0, -12 },
  { 861, 2, 17, 7, 3, -13 },
  { 866, 5, 15, 6, 1, -12 },
  { 876, 7, 2, 8, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Bold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD17PT7B_H_
