#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_Bold
// Headers: 67

#include "NotoSans_ExtraCondensed_Bold6pt7b.h"
#include "NotoSans_ExtraCondensed_Bold7pt7b.h"
#include "NotoSans_ExtraCondensed_Bold8pt7b.h"
#include "NotoSans_ExtraCondensed_Bold9pt7b.h"
#include "NotoSans_ExtraCondensed_Bold10pt7b.h"
#include "NotoSans_ExtraCondensed_Bold11pt7b.h"
#include "NotoSans_ExtraCondensed_Bold12pt7b.h"
#include "NotoSans_ExtraCondensed_Bold13pt7b.h"
#include "NotoSans_ExtraCondensed_Bold14pt7b.h"
#include "NotoSans_ExtraCondensed_Bold15pt7b.h"
#include "NotoSans_ExtraCondensed_Bold16pt7b.h"
#include "NotoSans_ExtraCondensed_Bold17pt7b.h"
#include "NotoSans_ExtraCondensed_Bold18pt7b.h"
#include "NotoSans_ExtraCondensed_Bold19pt7b.h"
#include "NotoSans_ExtraCondensed_Bold20pt7b.h"
#include "NotoSans_ExtraCondensed_Bold21pt7b.h"
#include "NotoSans_ExtraCondensed_Bold22pt7b.h"
#include "NotoSans_ExtraCondensed_Bold23pt7b.h"
#include "NotoSans_ExtraCondensed_Bold24pt7b.h"
#include "NotoSans_ExtraCondensed_Bold25pt7b.h"
#include "NotoSans_ExtraCondensed_Bold26pt7b.h"
#include "NotoSans_ExtraCondensed_Bold27pt7b.h"
#include "NotoSans_ExtraCondensed_Bold28pt7b.h"
#include "NotoSans_ExtraCondensed_Bold29pt7b.h"
#include "NotoSans_ExtraCondensed_Bold30pt7b.h"
#include "NotoSans_ExtraCondensed_Bold31pt7b.h"
#include "NotoSans_ExtraCondensed_Bold32pt7b.h"
#include "NotoSans_ExtraCondensed_Bold33pt7b.h"
#include "NotoSans_ExtraCondensed_Bold34pt7b.h"
#include "NotoSans_ExtraCondensed_Bold35pt7b.h"
#include "NotoSans_ExtraCondensed_Bold36pt7b.h"
#include "NotoSans_ExtraCondensed_Bold37pt7b.h"
#include "NotoSans_ExtraCondensed_Bold38pt7b.h"
#include "NotoSans_ExtraCondensed_Bold39pt7b.h"
#include "NotoSans_ExtraCondensed_Bold40pt7b.h"
#include "NotoSans_ExtraCondensed_Bold41pt7b.h"
#include "NotoSans_ExtraCondensed_Bold42pt7b.h"
#include "NotoSans_ExtraCondensed_Bold43pt7b.h"
#include "NotoSans_ExtraCondensed_Bold44pt7b.h"
#include "NotoSans_ExtraCondensed_Bold45pt7b.h"
#include "NotoSans_ExtraCondensed_Bold46pt7b.h"
#include "NotoSans_ExtraCondensed_Bold47pt7b.h"
#include "NotoSans_ExtraCondensed_Bold48pt7b.h"
#include "NotoSans_ExtraCondensed_Bold49pt7b.h"
#include "NotoSans_ExtraCondensed_Bold50pt7b.h"
#include "NotoSans_ExtraCondensed_Bold51pt7b.h"
#include "NotoSans_ExtraCondensed_Bold52pt7b.h"
#include "NotoSans_ExtraCondensed_Bold53pt7b.h"
#include "NotoSans_ExtraCondensed_Bold54pt7b.h"
#include "NotoSans_ExtraCondensed_Bold55pt7b.h"
#include "NotoSans_ExtraCondensed_Bold56pt7b.h"
#include "NotoSans_ExtraCondensed_Bold57pt7b.h"
#include "NotoSans_ExtraCondensed_Bold58pt7b.h"
#include "NotoSans_ExtraCondensed_Bold59pt7b.h"
#include "NotoSans_ExtraCondensed_Bold60pt7b.h"
#include "NotoSans_ExtraCondensed_Bold61pt7b.h"
#include "NotoSans_ExtraCondensed_Bold62pt7b.h"
#include "NotoSans_ExtraCondensed_Bold63pt7b.h"
#include "NotoSans_ExtraCondensed_Bold64pt7b.h"
#include "NotoSans_ExtraCondensed_Bold65pt7b.h"
#include "NotoSans_ExtraCondensed_Bold66pt7b.h"
#include "NotoSans_ExtraCondensed_Bold67pt7b.h"
#include "NotoSans_ExtraCondensed_Bold68pt7b.h"
#include "NotoSans_ExtraCondensed_Bold69pt7b.h"
#include "NotoSans_ExtraCondensed_Bold70pt7b.h"
#include "NotoSans_ExtraCondensed_Bold71pt7b.h"
#include "NotoSans_ExtraCondensed_Bold72pt7b.h"
