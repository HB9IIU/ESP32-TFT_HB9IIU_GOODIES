#ifndef _NOTOSANS_EXTRACONDENSED_BOLD68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0xCF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x3F, 0x81, 0xC0, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xF7,
  0x87, 0x8F, 0xF9, 0xE0, 0x63, 0xFE, 0x78, 0x00, 0xFF, 0x9E, 0x00, 0x3F,
  0xC7, 0x80, 0x0F, 0xF9, 0xE0, 0x03, 0xFE, 0x78, 0x00, 0x7F, 0xDE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xBF, 0xE0, 0x01, 0xE7, 0xF8, 0x00, 0x79,
  0xFF, 0x00, 0x1E, 0x3F, 0xC0, 0x07, 0x9F, 0xF8, 0x01, 0xE7, 0xFB, 0x80,
  0x79, 0xFE, 0xF8, 0x1E, 0xFF, 0xBF, 0xC7, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xE3, 0xF8, 0x3F, 0xE0,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0xFF, 0xF8,
  0x7F, 0x9F, 0xC7, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0x8F, 0xE3, 0xFD, 0xFE, 0x1F, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE,
  0x0F, 0xFF, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0x07, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xC7, 0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0xC7, 0xFC,
  0xFF, 0x8F, 0xF8, 0x3F, 0xEF, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF9,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x81, 0xF8, 0x1C, 0x3E, 0x1F,
  0x87, 0xC3, 0xFD, 0xFB, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC,
  0x3F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x8F,
  0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC,
  0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFE,
  0x7F, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07,
  0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF,
  0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x83, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xF7, 0xFF, 0xFF, 0x3F, 0xE7, 0xF1,
  0xFF, 0x1F, 0x0F, 0xF8, 0x70, 0x7F, 0xC1, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0x87, 0xC0,
  0x1F, 0xF0, 0x70, 0x03, 0xFF, 0x04, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1E, 0x01, 0xFF, 0xC3, 0x80, 0x1F, 0xF8,
  0x20, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0xE0, 0x01, 0xFF, 0xDF, 0xC0, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFB, 0xFE, 0x00, 0x1F, 0xDF,
  0xF0, 0x00, 0xFC, 0xFF, 0x80, 0x0F, 0xE7, 0xFC, 0x00, 0x7E, 0x3F, 0xE0,
  0x07, 0xF1, 0xFF, 0x00, 0x3F, 0x0F, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0x1F,
  0xC3, 0xFE, 0x01, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0xFE, 0x07,
  0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0x0F, 0xF8,
  0x3F, 0x80, 0x7F, 0xC1, 0xFC, 0x03, 0xFE, 0x1F, 0xC0, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFB, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC1, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFB, 0x00, 0x07, 0xFE, 0xF0,
  0x03, 0xFF, 0x3F, 0x87, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x38, 0x01, 0xFE, 0x3F, 0xE0,
  0x3F, 0xCF, 0xFF, 0x0F, 0xFB, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xDF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x1F, 0xFB,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFF, 0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x87, 0xFE, 0x7F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF,
  0x00, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x7F,
  0x9F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFE,
  0x3F, 0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xBF, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFE, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xF8, 0x1F, 0xF3,
  0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00,
  0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0x7F,
  0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xEF,
  0xF1, 0xFF, 0xF9, 0xFE, 0x1F, 0xFF, 0x7F, 0xC1, 0xFF, 0xCF, 0xF0, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x04, 0x03, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFA, 0x00, 0x00, 0x0C, 0x1F, 0xCF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xC1, 0xC0, 0x03, 0x01, 0xFC, 0x1F, 0xE3, 0xFF, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFE, 0x0F, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0x18, 0x01, 0xFF, 0x10,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x10, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0xF8, 0x3F, 0x8F, 0xE0, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7E, 0x7F, 0x03, 0xFF, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFD,
  0xFC, 0x1F, 0xE1, 0xF8, 0x3F, 0xBF, 0x03, 0xF8, 0x3F, 0x03, 0xFF, 0xE0,
  0xFE, 0x07, 0xE0, 0x7F, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xFF, 0x83, 0xF8,
  0x1F, 0x81, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xFF, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0xFE,
  0x07, 0xF0, 0x7F, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xDF, 0x81, 0xFC, 0x3F,
  0xC1, 0xFB, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x7F, 0x07, 0xF9, 0xFF, 0x9F,
  0xCF, 0xE0, 0x7F, 0xFD, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xBF, 0xFE, 0x1F,
  0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0xFF, 0xF7, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF,
  0x80, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00,
  0x7F, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF,
  0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x03,
  0xC1, 0xFF, 0xC0, 0x0C, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x02, 0x1F, 0xFE, 0x00, 0xE1, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x81, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC,
  0x01, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xFB,
  0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x9F,
  0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x78, 0x3F, 0xFC, 0x00, 0x30, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE,
  0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x8F,
  0xFC, 0x01, 0xFF, 0x1F, 0xFC, 0x03, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xE3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xE8, 0x3F, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x80, 0x7F, 0xC7, 0xFE,
  0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x7F, 0xF0, 0x03, 0xFE, 0xFF, 0xC0,
  0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x01,
  0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x07,
  0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFB, 0xF8, 0x01, 0xFD, 0xFF, 0xFF, 0x7F, 0x00, 0x3F,
  0xBF, 0xFF, 0xEF, 0xF0, 0x07, 0xF7, 0xFF, 0xFD, 0xFE, 0x01, 0xFE, 0xFF,
  0xFF, 0x9F, 0xC0, 0x3F, 0x9F, 0xFF, 0xF3, 0xF8, 0x07, 0xF3, 0xFF, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xCF, 0xF0, 0x3F, 0xCF, 0xFF, 0xF8, 0xFE,
  0x07, 0xF1, 0xFF, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0xFF, 0xE3, 0xFC, 0x3F,
  0xC7, 0xFF, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFC, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x9F, 0xC1, 0xFF, 0xFF, 0x07,
  0xF7, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xCF, 0xF0, 0x1F,
  0xFF, 0xE7, 0xFC, 0x0F, 0xFF, 0xF3, 0xFE, 0x07, 0xFF, 0xF8, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8,
  0x7F, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF,
  0x8F, 0xFF, 0xF0, 0x3F, 0xE7, 0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0xFC, 0x07,
  0xF9, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80,
  0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xFF, 0xDF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8,
  0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x03,
  0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC,
  0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xF8, 0xFE, 0x3F, 0xF0,
  0x0F, 0x1F, 0xF0, 0x01, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFB, 0x80, 0x07, 0xFD, 0xF0, 0x07, 0xFE, 0xFE,
  0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F,
  0xF0, 0x1F, 0xFC, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFB, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xDF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0xFE, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xBF, 0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFD, 0xFC, 0x0F,
  0xF8, 0x07, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFE, 0x7F,
  0x87, 0xFC, 0x00, 0xFF, 0x07, 0xF1, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF8, 0x01, 0xFF,
  0x1F, 0xE3, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x1F, 0xE7, 0xFC, 0x00,
  0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0x83, 0xF9, 0xFF,
  0x00, 0x0F, 0xF3, 0xFC, 0x1F, 0xCF, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0xFE, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF0,
  0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0xFF, 0xFF, 0x00, 0x03, 0xFD,
  0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0x7F, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03,
  0xFE, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0x8F, 0xFE, 0x07, 0x00, 0xFF,
  0x81, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFC, 0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xF3, 0xFF, 0xFB,
  0xFC, 0xFF, 0xFC, 0x7F, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF, 0x07, 0xF0, 0x1E,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x83, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x9F,
  0xFE, 0x0F, 0xFB, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC,
  0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFC,
  0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x0F, 0xF3, 0xFF, 0xE0, 0xFE, 0x1F, 0xFC,
  0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1C, 0x3F,
  0xF0, 0x04, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x02, 0x3F,
  0xF0, 0x06, 0x3F, 0xF8, 0x1E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7C, 0x1F, 0xF0, 0x1F, 0xF1,
  0xFF, 0x07, 0xFF, 0x9F, 0xF0, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xEF, 0xF1,
  0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0,
  0x7F, 0xF3, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xF3,
  0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xF0, 0x7F, 0xFC, 0xFF,
  0x03, 0xFF, 0x87, 0xF0, 0x1F, 0xF0, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC7, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0xFF,
  0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0,
  0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0x0F, 0xFC, 0x00, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFC, 0x10,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x7F, 0xFC, 0xFF,
  0x0F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xF3, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F,
  0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xEF,
  0xF0, 0x7F, 0xFD, 0xFF, 0x07, 0xFF, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF, 0x00,
  0x38, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x20, 0x00, 0x3F, 0xE3,
  0xC0, 0x07, 0xFE, 0x3F, 0xC7, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3E, 0x03, 0xFE, 0x3F, 0xF0, 0xFF,
  0x3F, 0xFE, 0x3F, 0xCF, 0xFF, 0xCF, 0xF7, 0xFF, 0xF3, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x1E, 0x0F, 0xE7, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD,
  0xFF, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xED, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFC,
  0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xF3, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0,
  0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC1,
  0xFF, 0x80, 0xFF, 0xC3, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFF,
  0x0F, 0xE3, 0xFF, 0xE3, 0xF8, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC,
  0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xE0, 0xFF, 0x80, 0xFE, 0x1F, 0xFE, 0x0F, 0xF3, 0xFF, 0xF0, 0xFF, 0x7F,
  0xFF, 0x0F, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0,
  0x7F, 0xEF, 0xFE, 0x07, 0xFC, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x0F, 0xF3,
  0xFF, 0xE0, 0xFF, 0x9F, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x81, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x07, 0xFF, 0x8F, 0xF0, 0x7F, 0xFC, 0xFF, 0x0F, 0xFF, 0xEF, 0xF1, 0xFF,
  0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F,
  0xF3, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF,
  0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE,
  0x07, 0xFF, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xFC, 0xFF, 0x07,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0x38, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xF1, 0xFC, 0xFF, 0x80, 0xE3, 0xFE, 0x00,
  0x8F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xEF, 0x81, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xE7, 0xF3, 0xFF, 0xF1, 0xFC, 0x7F, 0xF8,
  0x7F, 0x07, 0xFC, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFD,
  0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xE7, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xE3, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFC, 0x3F, 0xE0, 0x7F, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xC1, 0xFE, 0x0F, 0xCF, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0x3F, 0x07, 0xF8,
  0x1F, 0xF0, 0xFC, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xF3, 0xF0, 0xFF, 0x80,
  0xFF, 0x0F, 0xC7, 0xE3, 0xFE, 0x03, 0xFC, 0x7E, 0x1F, 0x8F, 0xF0, 0x0F,
  0xF9, 0xF8, 0x7E, 0x3F, 0xC0, 0x3F, 0xE7, 0xE1, 0xF8, 0xFF, 0x00, 0xFF,
  0x9F, 0x87, 0xE7, 0xFC, 0x01, 0xFE, 0x7E, 0x1F, 0x9F, 0xE0, 0x07, 0xF9,
  0xF8, 0x3F, 0x7F, 0x80, 0x1F, 0xEF, 0xC0, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0x03, 0xF7, 0xF8, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xE0, 0x03, 0xFB, 0xF0,
  0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE3,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xEF, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xEF, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01,
  0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x11,
  0xFF, 0x00, 0x01, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x80, 0x01, 0xFF, 0x88, 0x00,
  0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Bold68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 50, 17, 3, -49 },
  { 70, 24, 18, 30, 3, -49 },
  { 124, 32, 48, 34, 1, -48 },
  { 316, 26, 56, 32, 3, -52 },
  { 498, 48, 50, 52, 2, -49 },
  { 798, 36, 50, 38, 2, -49 },
  { 1023, 10, 18, 16, 3, -49 },
  { 1046, 17, 60, 21, 3, -49 },
  { 1174, 17, 60, 21, 1, -49 },
  { 1302, 28, 28, 30, 1, -52 },
  { 1400, 28, 32, 32, 2, -40 },
  { 1512, 12, 17, 17, 2, -8 },
  { 1538, 17, 9, 21, 2, -23 },
  { 1558, 11, 11, 17, 3, -10 },
  { 1574, 26, 49, 27, 1, -49 },
  { 1734, 27, 50, 31, 2, -49 },
  { 1903, 21, 49, 31, 3, -49 },
  { 2032, 27, 49, 31, 2, -49 },
  { 2198, 27, 50, 31, 2, -49 },
  { 2367, 29, 49, 31, 1, -49 },
  { 2545, 26, 50, 31, 3, -49 },
  { 2708, 27, 50, 31, 2, -49 },
  { 2877, 28, 49, 31, 1, -49 },
  { 3049, 27, 50, 31, 2, -49 },
  { 3218, 27, 50, 31, 2, -49 },
  { 3387, 10, 39, 18, 4, -38 },
  { 3436, 12, 47, 18, 2, -38 },
  { 3507, 28, 33, 32, 2, -41 },
  { 3623, 28, 20, 32, 2, -34 },
  { 3693, 28, 33, 32, 2, -41 },
  { 3809, 24, 50, 25, 0, -49 },
  { 3959, 43, 54, 49, 3, -49 },
  { 4250, 36, 49, 36, 0, -49 },
  { 4471, 29, 49, 36, 4, -49 },
  { 4649, 28, 50, 33, 3, -49 },
  { 4824, 31, 49, 38, 4, -49 },
  { 5014, 21, 49, 30, 5, -49 },
  { 5143, 21, 49, 29, 5, -49 },
  { 5272, 31, 50, 38, 3, -49 },
  { 5466, 30, 49, 40, 5, -49 },
  { 5650, 18, 49, 21, 2, -49 },
  { 5761, 18, 63, 19, -4, -49 },
  { 5903, 31, 49, 35, 5, -49 },
  { 6093, 23, 49, 28, 4, -49 },
  { 6234, 43, 49, 53, 5, -49 },
  { 6498, 33, 49, 43, 5, -49 },
  { 6701, 34, 50, 40, 3, -49 },
  { 6914, 27, 49, 33, 4, -49 },
  { 7080, 34, 61, 40, 3, -49 },
  { 7340, 31, 49, 35, 4, -49 },
  { 7530, 25, 50, 29, 2, -49 },
  { 7687, 27, 49, 29, 1, -49 },
  { 7853, 30, 50, 39, 4, -49 },
  { 8041, 34, 49, 34, 0, -49 },
  { 8250, 53, 49, 51, -1, -49 },
  { 8575, 32, 49, 32, 0, -49 },
  { 8771, 32, 49, 32, 0, -49 },
  { 8967, 26, 49, 28, 1, -49 },
  { 9127, 16, 60, 21, 4, -49 },
  { 9247, 26, 49, 27, 1, -49 },
  { 9407, 15, 60, 21, 2, -49 },
  { 9520, 32, 30, 36, 2, -49 },
  { 9640, 28, 5, 28, 0, 6 },
  { 9658, 15, 11, 21, 3, -52 },
  { 9679, 26, 39, 32, 2, -38 },
  { 9806, 28, 53, 34, 4, -52 },
  { 9992, 24, 39, 27, 2, -38 },
  { 10109, 28, 53, 34, 2, -52 },
  { 10295, 27, 39, 31, 2, -38 },
  { 10427, 22, 52, 20, 1, -52 },
  { 10570, 28, 54, 34, 2, -38 },
  { 10759, 26, 52, 34, 4, -52 },
  { 10928, 10, 52, 17, 3, -52 },
  { 10993, 15, 68, 17, -2, -52 },
  { 11121, 29, 52, 33, 4, -52 },
  { 11310, 9, 52, 16, 4, -52 },
  { 11369, 43, 38, 51, 4, -38 },
  { 11574, 26, 38, 34, 4, -38 },
  { 11698, 29, 39, 33, 2, -38 },
  { 11840, 28, 54, 34, 4, -38 },
  { 12029, 28, 54, 34, 2, -38 },
  { 12218, 19, 38, 24, 4, -38 },
  { 12309, 22, 39, 25, 2, -38 },
  { 12417, 20, 46, 22, 1, -45 },
  { 12532, 26, 38, 34, 4, -37 },
  { 12656, 30, 37, 30, 0, -37 },
  { 12795, 46, 37, 46, 0, -37 },
  { 13008, 29, 37, 29, 0, -37 },
  { 13143, 30, 53, 30, 0, -37 },
  { 13342, 22, 37, 24, 1, -37 },
  { 13444, 20, 60, 24, 1, -49 },
  { 13594, 8, 68, 30, 11, -52 },
  { 13662, 21, 60, 24, 2, -49 },
  { 13820, 28, 12, 32, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Bold68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD68PT7B_H_
