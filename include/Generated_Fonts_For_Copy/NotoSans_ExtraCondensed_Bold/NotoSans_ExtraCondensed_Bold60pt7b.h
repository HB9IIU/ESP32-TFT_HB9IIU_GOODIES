#ifndef _NOTOSANS_EXTRACONDENSED_BOLD60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xC1, 0x80, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFB, 0xFC, 0x1F, 0xDF, 0xE0, 0xFE,
  0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0,
  0x7F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x0F, 0xC3, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFF, 0xEF, 0xE7, 0xF9, 0xC3, 0x8F, 0xE3, 0x81, 0x1F, 0xC7, 0x00, 0x3F,
  0x8E, 0x00, 0x7F, 0x1C, 0x00, 0xFF, 0x38, 0x01, 0xFF, 0x70, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0x7F, 0x80, 0x0E, 0x7F,
  0x00, 0x1C, 0xFF, 0x00, 0x39, 0xFF, 0x00, 0x73, 0xFF, 0x80, 0xEF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7F, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x7F,
  0x3F, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xC7, 0xFF, 0xE3, 0xFF, 0xE3, 0xF3,
  0xF9, 0xF8, 0xFF, 0xF1, 0xF8, 0xFC, 0x7F, 0x1F, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC1, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x00,
  0x03, 0xF1, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x01, 0xFE, 0x0F,
  0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0xC1, 0xFE, 0x1F, 0xFF, 0xC1, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFE, 0x7F, 0xDF, 0xF3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F,
  0x87, 0xFB, 0xFC, 0x7F, 0x87, 0xFF, 0xF8, 0xFF, 0x83, 0xFF, 0xF8, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFB, 0xFE, 0x07, 0xFF, 0xF3, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x7E, 0x06,
  0x3C, 0x3E, 0x3E, 0x7F, 0xBE, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xF8,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x0F, 0xC1, 0xF8, 0x07, 0x81, 0xE0,
  0x01, 0x80, 0xC0, 0x00, 0x80, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xFF, 0xFD, 0xFE, 0xFF, 0xFF, 0x3F, 0xDF, 0x8F, 0xF3, 0xC3, 0xFC,
  0x60, 0xFF, 0x08, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0x03, 0xFE, 0x3C, 0x03, 0xFC, 0x30, 0x07, 0xF8, 0x40, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x81, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x8F, 0xEF, 0xFF, 0x1E, 0x03, 0xFE, 0x10, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFB, 0xFC, 0x00, 0x7E, 0xFF, 0x00,
  0x1F, 0x3F, 0xC0, 0x0F, 0xCF, 0xF0, 0x03, 0xF3, 0xFC, 0x01, 0xF8, 0xFF,
  0x00, 0x7E, 0x3F, 0xC0, 0x3F, 0x0F, 0xF0, 0x0F, 0xC3, 0xFC, 0x07, 0xE0,
  0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x1F,
  0x80, 0xFF, 0x07, 0xE0, 0x3F, 0xC3, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x88, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x03,
  0xFE, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xBC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0xFE,
  0x3F, 0xE0, 0xFE, 0x7F, 0xF0, 0xFE, 0xFF, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F,
  0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F,
  0xC7, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0x83, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0x87, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFE, 0xFE, 0x1F, 0xFE, 0xFE, 0x0F, 0xFC, 0xFE, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x20, 0x7F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x3F, 0x06, 0x00, 0x1F, 0x8F, 0xF3, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF3, 0xFC, 0xFF, 0x1F, 0x83, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x9F, 0xE7,
  0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0x81, 0xFF, 0x10, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x03, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0xFF, 0x8F,
  0xC7, 0xE0, 0x7F, 0xFF, 0x1F, 0x8F, 0xC1, 0xFF, 0xFC, 0x3F, 0x1F, 0x03,
  0xFF, 0xF8, 0x3E, 0x7E, 0x0F, 0xE3, 0xF0, 0x7E, 0xFC, 0x1F, 0x87, 0xE0,
  0xFD, 0xF8, 0x7E, 0x0F, 0xC1, 0xFB, 0xF0, 0xFC, 0x1F, 0x83, 0xF7, 0xC1,
  0xF8, 0x3F, 0x07, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0x0F, 0xE0, 0xFC,
  0x1F, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0xF8,
  0x7E, 0x07, 0xE0, 0xFF, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0, 0xFC, 0x1F,
  0x83, 0xEF, 0xC1, 0xF8, 0x7F, 0x07, 0xCF, 0x83, 0xF0, 0xFE, 0x1F, 0x9F,
  0x87, 0xF1, 0xFC, 0x3E, 0x3F, 0x07, 0xFF, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF,
  0x7F, 0xF0, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0xFC, 0x0F, 0xF0, 0xFF, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x02, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFE, 0x07, 0xFE, 0xFF, 0x01, 0xFF, 0x7F,
  0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7,
  0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x03, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0x03,
  0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x3C, 0x3F,
  0xF0, 0x04, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x87,
  0xFF, 0x01, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0xF8, 0xFF, 0x03, 0xFF, 0x9F, 0xE0,
  0x1F, 0xF3, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD,
  0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F,
  0xF7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x3F, 0xF3, 0xFC,
  0x0F, 0xFC, 0x7F, 0x87, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x1C, 0x3F,
  0xF8, 0x00, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF,
  0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0,
  0x1E, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF,
  0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x03, 0xFE, 0x3F, 0xC0,
  0x7F, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0xFF, 0x83,
  0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xE0, 0x3F, 0xCF, 0xF8, 0x07, 0xFB, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x1F,
  0xEF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xC7, 0xF8,
  0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x3F, 0xC0,
  0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xBF, 0x00, 0x3F, 0x7F, 0xFE, 0xFC, 0x00, 0xFD,
  0xFF, 0xFB, 0xF8, 0x07, 0xF7, 0xFF, 0xEF, 0xE0, 0x1F, 0xDF, 0xFF, 0xDF,
  0x80, 0x7E, 0x7F, 0xFF, 0x7E, 0x01, 0xF9, 0xFF, 0xFD, 0xFC, 0x0F, 0xE7,
  0xFF, 0xF7, 0xF0, 0x3F, 0xBF, 0xFF, 0xCF, 0xC0, 0xFC, 0xFF, 0xFF, 0x3F,
  0x07, 0xF3, 0xFF, 0xFC, 0xFE, 0x1F, 0xCF, 0xFF, 0xF3, 0xF8, 0x7E, 0x3F,
  0xFF, 0xC7, 0xE1, 0xF8, 0xFF, 0xFF, 0x1F, 0x8F, 0xE3, 0xFF, 0xFC, 0x7F,
  0x3F, 0x8F, 0xFF, 0xF1, 0xFC, 0xFC, 0x3F, 0xFF, 0xC3, 0xF3, 0xF0, 0xFF,
  0xFF, 0x0F, 0xDF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0x9F, 0xC0, 0xFF,
  0xFE, 0x7F, 0x83, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xF3, 0xFC, 0x3F, 0xFF,
  0xCF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xF0,
  0xFE, 0x3F, 0xFF, 0xC3, 0xFC, 0xFF, 0xFF, 0x0F, 0xF3, 0xFF, 0xFC, 0x1F,
  0xEF, 0xFF, 0xF0, 0x7F, 0xBF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F,
  0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF9, 0xFF, 0x00,
  0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x0F, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03,
  0xFE, 0x7F, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F,
  0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE,
  0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x8F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xF0, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F,
  0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F,
  0xFB, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x1F, 0xF0, 0xFC, 0x7F, 0x80, 0x73, 0xFE, 0x00, 0x4F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFB,
  0x00, 0x1F, 0xEF, 0x00, 0x7F, 0xBF, 0x03, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x03, 0xFF,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF0,
  0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x03,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x03, 0xFD, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xDF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF0, 0x03,
  0xFD, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE3, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x07,
  0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF0, 0x7F,
  0x81, 0xFB, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xEF, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xBF, 0x07, 0xF8, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xE0, 0x3F, 0x83,
  0xFB, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xEF, 0xC1, 0xFE, 0x03, 0xFC, 0x3F,
  0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0xFC, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF1,
  0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC7, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x1F,
  0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xE1, 0xFC,
  0xFF, 0x00, 0x7F, 0x9F, 0x83, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x0F, 0xDF,
  0xE0, 0x03, 0xFB, 0xF8, 0x3F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0xFD, 0xFE,
  0x00, 0x3F, 0xBF, 0x03, 0xF7, 0xF8, 0x00, 0xFE, 0xFC, 0x07, 0xDF, 0xC0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xDF,
  0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xE0,
  0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x83, 0xC1, 0xFF, 0x06, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xCF, 0xFF, 0x3F,
  0x9F, 0xFC, 0x7F, 0x1F, 0xF0, 0x7E, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0xFF, 0xC1, 0xFE, 0xFF, 0xF0, 0xFF,
  0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFE, 0x7F, 0xCF,
  0xFC, 0x1F, 0xF7, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFB, 0xFF, 0x07, 0xFD, 0xFF,
  0xC7, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xCF, 0xFF, 0x0F, 0xE3, 0xFF, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xCF, 0x87, 0xF8, 0x04, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x13, 0xFE, 0x01, 0x8F, 0xFC, 0x3C, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F,
  0xC3, 0xFC, 0x1F, 0xF9, 0xFE, 0x1F, 0xFE, 0xFF, 0x1F, 0xFF, 0x7F, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFC, 0xFF, 0xF7, 0xFC, 0x1F, 0xFB,
  0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8,
  0x0F, 0xFB, 0xFC, 0x07, 0xFD, 0xFF, 0x07, 0xFE, 0x7F, 0xC7, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xE7, 0xF0,
  0xFF, 0xE3, 0xF8, 0x1F, 0xE1, 0xFC, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x04, 0x3F, 0xE0, 0x1C, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x84, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF,
  0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0x83, 0xFF, 0x1F, 0xC3,
  0xFF, 0xCF, 0xE3, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xDF, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F,
  0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF,
  0xE0, 0xFF, 0xDF, 0xF8, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFB, 0xFC, 0x3F, 0xFD, 0xFE, 0x1F, 0xFC, 0xFF, 0x03, 0xFC, 0x7F,
  0x80, 0x20, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF9, 0x00, 0x03, 0xFC, 0x60, 0x03, 0xFC, 0x3F, 0x0F,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0xFF, 0x3F, 0xF8, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x1C, 0x3F, 0xBF, 0xDF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF,
  0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xF8, 0x00, 0xE0, 0x0F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xFB, 0x7F, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F,
  0xFC, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFD, 0xFC, 0x03, 0xFC, 0xFE, 0x03, 0xFE, 0x7F, 0x01, 0xFE, 0x3F,
  0x81, 0xFE, 0x1F, 0xC1, 0xFF, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80,
  0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xC0, 0x7F, 0xCF,
  0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x7F,
  0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x7F, 0xF0, 0xFF, 0xE3, 0xF9,
  0xFF, 0xE3, 0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xE1, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0x03, 0xFD, 0xFF, 0x03, 0xFE,
  0x07, 0xFB, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0x00,
  0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xF8,
  0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0x80,
  0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x7F,
  0x1F, 0xF8, 0x3F, 0x9F, 0xFE, 0x1F, 0xCF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0x8F, 0xF9, 0xFF, 0x83, 0xFE, 0xFF, 0x80, 0xFF,
  0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFE, 0xFF,
  0x80, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xF8, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFB, 0xFF, 0xE3, 0xFD, 0xFF, 0xE1, 0xFE, 0x7F, 0xF0,
  0xFF, 0x1F, 0xE0, 0x7F, 0x81, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x3F, 0x83, 0xFF, 0x1F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF, 0xEF, 0xF1,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x9F, 0xFE, 0xFF, 0x83, 0xFF,
  0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFD, 0xFE, 0x03, 0xFE, 0xFF,
  0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0xFF, 0xDF, 0xF8, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFB, 0xFC, 0x3F, 0xFD, 0xFE,
  0x1F, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0x20, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3F, 0xC1, 0xE7, 0xF0, 0x0C, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x31, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x30, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x83,
  0xFF, 0x7F, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0x7F, 0x3F, 0xFE, 0x7F, 0x1F, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x00, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8,
  0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x7F,
  0x00, 0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFF,
  0xC0, 0xFE, 0x7F, 0x81, 0xFF, 0xC0, 0xFE, 0x3F, 0x81, 0xFF, 0xC0, 0xFE,
  0x3F, 0xC1, 0xFF, 0xC1, 0xFE, 0x3F, 0xC3, 0xF7, 0xC1, 0xFE, 0x3F, 0xC3,
  0xF7, 0xC1, 0xFC, 0x1F, 0xC3, 0xF7, 0xE1, 0xFC, 0x1F, 0xC3, 0xE7, 0xE3,
  0xFC, 0x1F, 0xE3, 0xE3, 0xE3, 0xFC, 0x1F, 0xE3, 0xE3, 0xE3, 0xF8, 0x1F,
  0xE7, 0xE3, 0xE3, 0xF8, 0x0F, 0xE7, 0xE3, 0xE3, 0xF8, 0x0F, 0xE7, 0xC3,
  0xF7, 0xF8, 0x0F, 0xE7, 0xC3, 0xF7, 0xF8, 0x0F, 0xE7, 0xC1, 0xF7, 0xF0,
  0x07, 0xF7, 0xC1, 0xF7, 0xF0, 0x07, 0xF7, 0xC1, 0xF7, 0xF0, 0x07, 0xF7,
  0xC1, 0xF7, 0xF0, 0x07, 0xFF, 0xC1, 0xF7, 0xE0, 0x07, 0xFF, 0x81, 0xF7,
  0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xBF, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF,
  0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF9, 0xFE, 0x03, 0xFC, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFC, 0x00, 0xA0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x9F, 0xFC,
  0x00, 0x5F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x40,
  0x00, 0x3C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 44, 15, 3, -43 },
  { 51, 21, 16, 27, 3, -43 },
  { 93, 28, 43, 30, 1, -43 },
  { 244, 23, 49, 28, 2, -46 },
  { 385, 42, 43, 46, 2, -43 },
  { 611, 32, 44, 33, 1, -43 },
  { 787, 8, 16, 14, 3, -43 },
  { 803, 15, 52, 19, 3, -43 },
  { 901, 15, 52, 19, 1, -43 },
  { 999, 24, 25, 27, 1, -46 },
  { 1074, 24, 29, 28, 2, -36 },
  { 1161, 10, 15, 15, 2, -7 },
  { 1180, 15, 8, 18, 2, -20 },
  { 1195, 9, 10, 15, 3, -9 },
  { 1207, 23, 43, 24, 1, -43 },
  { 1331, 24, 45, 28, 2, -44 },
  { 1466, 18, 43, 28, 3, -43 },
  { 1563, 23, 43, 28, 2, -43 },
  { 1687, 23, 44, 28, 2, -43 },
  { 1814, 26, 43, 28, 1, -43 },
  { 1954, 22, 44, 28, 3, -43 },
  { 2075, 24, 44, 28, 2, -43 },
  { 2207, 25, 43, 28, 1, -43 },
  { 2342, 24, 44, 28, 2, -43 },
  { 2474, 24, 44, 28, 2, -43 },
  { 2606, 9, 34, 16, 3, -33 },
  { 2645, 10, 41, 16, 2, -33 },
  { 2697, 25, 29, 28, 1, -36 },
  { 2788, 24, 18, 28, 2, -30 },
  { 2842, 24, 29, 28, 2, -36 },
  { 2929, 21, 44, 22, 0, -43 },
  { 3045, 39, 48, 43, 2, -43 },
  { 3279, 32, 43, 32, 0, -43 },
  { 3451, 25, 43, 32, 4, -43 },
  { 3586, 25, 44, 29, 3, -43 },
  { 3724, 27, 43, 34, 4, -43 },
  { 3870, 19, 43, 26, 4, -43 },
  { 3973, 19, 43, 26, 4, -43 },
  { 4076, 27, 44, 34, 3, -43 },
  { 4225, 27, 43, 35, 4, -43 },
  { 4371, 16, 43, 19, 1, -43 },
  { 4457, 15, 56, 16, -3, -43 },
  { 4562, 27, 43, 31, 4, -43 },
  { 4708, 19, 43, 24, 4, -43 },
  { 4811, 38, 43, 46, 4, -43 },
  { 5016, 30, 43, 38, 4, -43 },
  { 5178, 30, 45, 36, 3, -44 },
  { 5347, 24, 43, 29, 4, -43 },
  { 5476, 30, 54, 36, 3, -44 },
  { 5679, 27, 43, 31, 4, -43 },
  { 5825, 22, 44, 25, 2, -43 },
  { 5946, 24, 43, 26, 1, -43 },
  { 6075, 26, 44, 34, 4, -43 },
  { 6218, 30, 43, 30, 0, -43 },
  { 6380, 46, 43, 45, -1, -43 },
  { 6628, 28, 43, 28, 0, -43 },
  { 6779, 28, 43, 28, 0, -43 },
  { 6930, 23, 43, 25, 1, -43 },
  { 7054, 14, 53, 19, 3, -43 },
  { 7147, 24, 43, 24, 0, -43 },
  { 7276, 14, 53, 19, 1, -43 },
  { 7369, 29, 26, 32, 1, -43 },
  { 7464, 25, 4, 24, 0, 5 },
  { 7477, 14, 10, 19, 2, -46 },
  { 7495, 23, 34, 28, 2, -33 },
  { 7593, 25, 47, 30, 3, -46 },
  { 7740, 21, 34, 24, 2, -33 },
  { 7830, 25, 47, 30, 2, -46 },
  { 7977, 24, 34, 27, 2, -33 },
  { 8079, 19, 46, 18, 1, -46 },
  { 8189, 25, 47, 30, 2, -33 },
  { 8336, 24, 46, 30, 3, -46 },
  { 8474, 9, 46, 15, 3, -46 },
  { 8526, 14, 60, 15, -2, -46 },
  { 8631, 25, 46, 29, 4, -46 },
  { 8775, 8, 46, 15, 3, -46 },
  { 8821, 39, 33, 45, 3, -33 },
  { 8982, 24, 33, 30, 3, -33 },
  { 9081, 25, 34, 29, 2, -33 },
  { 9188, 25, 47, 30, 3, -33 },
  { 9335, 25, 47, 30, 2, -33 },
  { 9482, 17, 33, 21, 3, -33 },
  { 9553, 19, 34, 22, 2, -33 },
  { 9634, 18, 41, 20, 1, -40 },
  { 9727, 24, 34, 30, 3, -33 },
  { 9829, 26, 33, 27, 0, -33 },
  { 9937, 40, 33, 41, 0, -33 },
  { 10102, 25, 33, 25, 0, -33 },
  { 10206, 26, 47, 27, 0, -33 },
  { 10359, 20, 33, 22, 1, -33 },
  { 10442, 18, 53, 21, 1, -43 },
  { 10562, 7, 60, 26, 10, -46 },
  { 10615, 18, 53, 21, 2, -43 },
  { 10735, 25, 10, 28, 1, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Bold60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD60PT7B_H_
