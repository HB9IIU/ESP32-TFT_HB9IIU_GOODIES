#ifndef _NOTOSANS_EXTRACONDENSED_BOLD47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x08,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xEF, 0xE3, 0xF3, 0xF1,
  0xF9, 0xF0, 0xFC, 0xF8, 0x7E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00,
  0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x7C, 0x78, 0x01, 0xF1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1E, 0x00,
  0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07,
  0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xB1,
  0xCF, 0xCC, 0x13, 0xF3, 0x00, 0xFC, 0xC0, 0x3F, 0x30, 0x07, 0xEC, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0x7F, 0x00, 0xCF, 0xC0, 0x33,
  0xF8, 0x0C, 0xFF, 0x03, 0x3F, 0xF8, 0xDF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xF8,
  0x01, 0xE0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x7E,
  0xF8, 0x0F, 0x00, 0x1F, 0x3E, 0x07, 0xC0, 0x07, 0xC7, 0x81, 0xF0, 0x01,
  0xE1, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x0F, 0x00,
  0x0F, 0x87, 0xC7, 0xC0, 0x03, 0xE1, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x78,
  0x00, 0x1E, 0x1F, 0x3E, 0x0E, 0x07, 0x87, 0x8F, 0x0F, 0xE1, 0xF3, 0xE7,
  0xC7, 0xFC, 0x7E, 0xF9, 0xF3, 0xFF, 0x0F, 0xFC, 0x79, 0xFF, 0xE3, 0xFF,
  0x3E, 0x7C, 0xF8, 0x7F, 0x8F, 0x9F, 0x1E, 0x07, 0xC7, 0xC7, 0x87, 0xC0,
  0x01, 0xF1, 0xE1, 0xF0, 0x00, 0x78, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x1F,
  0x00, 0x0F, 0x8F, 0x87, 0xC0, 0x03, 0xC1, 0xE1, 0xF0, 0x01, 0xF0, 0x78,
  0x7C, 0x00, 0x78, 0x1E, 0x1F, 0x00, 0x3E, 0x07, 0xC7, 0x80, 0x0F, 0x81,
  0xF3, 0xE0, 0x03, 0xC0, 0x3F, 0xF8, 0x01, 0xF0, 0x0F, 0xFC, 0x00, 0x78,
  0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F,
  0x87, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F,
  0x0F, 0xFC, 0x1F, 0x8F, 0xFF, 0x0F, 0xCF, 0xFF, 0xCF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xF3, 0xFB, 0xF3, 0xF8, 0xFF, 0xF9, 0xF8, 0x3F, 0xF8, 0xFC, 0x1F,
  0xFC, 0x7F, 0x07, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF8,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0x7F, 0x03, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xE3, 0xE3,
  0x9F, 0x7F, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x7C, 0x07, 0xEF, 0xC1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x01, 0xC1, 0xC0, 0x18, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E, 0x08, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE3, 0xF9, 0xF8, 0x7E,
  0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xE1, 0xF9, 0xF8, 0x7E, 0x7F, 0x3F, 0x9F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFF, 0xFD, 0xFD, 0xFB, 0xF9, 0xE7, 0xF1, 0x8F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFE, 0xFF, 0x8F, 0x07, 0xF0, 0x80, 0x7E, 0x10, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7C, 0xFF, 0x8E, 0x07, 0xF0, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF7, 0x03, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3D, 0xF8, 0x03, 0xDF,
  0x80, 0x7D, 0xF8, 0x07, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0x1F, 0x81, 0xF1,
  0xF8, 0x1E, 0x1F, 0x83, 0xE1, 0xF8, 0x3C, 0x1F, 0x87, 0xC1, 0xF8, 0x78,
  0x1F, 0x8F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE3, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFA, 0x00,
  0xFE, 0xF0, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xF1, 0x87, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0xC0, 0xF9, 0xFE,
  0x1F, 0x7F, 0xE3, 0xEF, 0xFE, 0xFF, 0xFF, 0xDF, 0xF7, 0xFB, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x87, 0xF3, 0xF9, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x3F, 0x9F,
  0x83, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x3F, 0x1F,
  0x87, 0xE3, 0xF9, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC, 0xFC,
  0x1F, 0x9F, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xF7, 0xE0, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x7F, 0x1F, 0xC7, 0xF3, 0xF0,
  0x7E, 0xFE, 0x0F, 0xDF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0x7F, 0x7F, 0x1F, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0x7E, 0x1F, 0xCF, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFC, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x7E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0x7F, 0xFF, 0x7F, 0x7E, 0x7E, 0x08, 0x3C, 0x7E, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC,
  0xF8, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF7, 0xF8, 0xC0, 0xFC, 0x40, 0x7F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x1F, 0xE3, 0xE7, 0xC1, 0xFF, 0xC7,
  0x9F, 0x0F, 0xFF, 0x1F, 0x78, 0x7F, 0xFC, 0x7D, 0xE1, 0xF1, 0xF1, 0xFF,
  0x8F, 0x87, 0xC3, 0xFE, 0x3E, 0x1F, 0x0F, 0xF8, 0xF8, 0x7C, 0x3F, 0xC3,
  0xE1, 0xF0, 0xFF, 0x0F, 0x07, 0xC3, 0xFC, 0x3C, 0x1F, 0x0F, 0xF0, 0xF0,
  0x7C, 0x7F, 0xC3, 0xC1, 0xE1, 0xFF, 0x0F, 0x8F, 0x87, 0xBE, 0x3E, 0x3F,
  0x1E, 0xF8, 0xFD, 0xFC, 0xFB, 0xE1, 0xFF, 0x7F, 0xC7, 0x87, 0xFD, 0xFE,
  0x1F, 0x0F, 0xE3, 0xF0, 0x7C, 0x0E, 0x03, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x00, 0x3F,
  0xC0, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x07,
  0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x1F, 0xEF, 0xC0,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC,
  0x0F, 0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFE, 0xFC, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xC0, 0xC3,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x02, 0x3F, 0xE1, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF0,
  0x7F, 0x9F, 0x81, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07,
  0xF7, 0xE0, 0x3F, 0xBF, 0x03, 0xFD, 0xF8, 0x3F, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xF7, 0xE3, 0xFE, 0x03, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F,
  0xDF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0xC1, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8,
  0xFF, 0x0F, 0xC0, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0x7E,
  0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x7C,
  0x0F, 0xBF, 0xFD, 0xF0, 0x3E, 0xFF, 0xF7, 0xC0, 0xFB, 0xFF, 0xDF, 0x87,
  0xEF, 0xFF, 0x3E, 0x1F, 0x3F, 0xFC, 0xF8, 0x7C, 0xFF, 0xF3, 0xE1, 0xF3,
  0xFF, 0xCF, 0xCF, 0x8F, 0xFF, 0x1F, 0x3E, 0x3F, 0xFC, 0x7C, 0xF8, 0xFF,
  0xF1, 0xF3, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x07,
  0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC,
  0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3E, 0x03,
  0xF0, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xDF, 0x87, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F, 0x1F, 0xFE, 0x7E, 0x3F, 0xFC,
  0x7E, 0x7F, 0xF8, 0xFC, 0xFF, 0xF1, 0xF8, 0xFF, 0xE1, 0xF9, 0xFF, 0xC3,
  0xF3, 0xFF, 0x83, 0xF7, 0xFF, 0x07, 0xEF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC,
  0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x3F, 0x81, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF,
  0x0F, 0xF7, 0xE0, 0xFE, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0xFE, 0xFC,
  0x7F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE3, 0xF0, 0xFF, 0x1F, 0x81, 0xFC, 0xFC, 0x0F, 0xE7,
  0xE0, 0x7F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07,
  0xE3, 0xF0, 0x7F, 0x1F, 0x8F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x80, 0xFE,
  0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xF9, 0xFC, 0x1C, 0xFC, 0x02, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE7, 0xF8, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF,
  0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0x1F,
  0x87, 0xE0, 0x7F, 0xC0, 0xFC, 0x3F, 0x03, 0xFE, 0x07, 0xE1, 0xF8, 0x1F,
  0xF0, 0x3F, 0x0F, 0xC0, 0xF7, 0x83, 0xF8, 0x3F, 0x07, 0xBC, 0x1F, 0x81,
  0xF8, 0x7D, 0xF0, 0xFC, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0x7E, 0x1F, 0x7C,
  0x3F, 0x03, 0xF0, 0xFB, 0xE3, 0xF8, 0x0F, 0xC7, 0xDF, 0x1F, 0x80, 0x7E,
  0x7E, 0x7C, 0xFC, 0x03, 0xF3, 0xE3, 0xE7, 0xE0, 0x1F, 0x9F, 0x1F, 0x3F,
  0x00, 0xFC, 0xF8, 0xF9, 0xF8, 0x03, 0xE7, 0xC7, 0xDF, 0xC0, 0x1F, 0x7E,
  0x1E, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xE3,
  0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x0F, 0xEF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3F,
  0x87, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7E, 0x01,
  0xFF, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F,
  0x9F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x07,
  0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0F, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x01,
  0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x7C,
  0x01, 0xF1, 0xF8, 0x03, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xFC, 0x07, 0xFF, 0xC3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0x07, 0xF0, 0x80, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF7, 0xF8, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xDF, 0xF7, 0xFF, 0xFD, 0xFF, 0xDF,
  0x3F, 0xE7, 0xC7, 0xF0, 0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x7E, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF8, 0xFE, 0xFE, 0x1F, 0xDF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFD, 0xFC, 0x1F, 0xBF, 0x87, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0x7F, 0xF3, 0xE7, 0xFC, 0x7C, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x0C, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0x7F,
  0x06, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x3F,
  0x1F, 0x8F, 0xF3, 0xF3, 0xFF, 0x7E, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xF9,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xDF, 0x87,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xDF, 0x87, 0xF1,
  0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0x80,
  0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xEC,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x7F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC3, 0xE3, 0xFC, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF7,
  0xF1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xBF, 0x1F, 0xE7, 0xE1,
  0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x90,
  0x03, 0xF3, 0x81, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xCF, 0xC3, 0xF7, 0xFC, 0xFB, 0xFF, 0x3E, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0x38, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x01, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x07, 0x03, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F,
  0xC7, 0xFF, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF,
  0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFD, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xC3, 0xE7, 0xFC, 0x7F,
  0x8F, 0xBF, 0xF3, 0xFF, 0x3E, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFC, 0xFF, 0xCF, 0xEF, 0xE1, 0xFE, 0x1F, 0xBF, 0x07, 0xF0, 0x7F, 0xFC,
  0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0x03,
  0xF0, 0x7F, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xC0, 0xFC,
  0x1F, 0xFF, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x07,
  0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xC1, 0xFF,
  0xF0, 0x3F, 0x07, 0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0x03, 0xF0, 0x7F, 0xFC,
  0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0xF0, 0xFC, 0x3E, 0x7F, 0xCF,
  0xBF, 0xF3, 0xEF, 0xFE, 0xFF, 0xFF, 0xBF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x83, 0xF7, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xBF, 0x07, 0xE7, 0xF1, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0xF8, 0xFC, 0x1F, 0x3F,
  0xC3, 0xEF, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xF9, 0xFE, 0x3F, 0xBF, 0x83,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7F, 0x07, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFD, 0xFF, 0x1F, 0x9F, 0xC3, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC3, 0xE3, 0xFC, 0xFC, 0xFF, 0xDF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF7,
  0xF1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xBF, 0x1F, 0xE7, 0xE1,
  0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0xF0, 0x7F, 0xCF, 0xFE, 0x7F, 0xF7, 0xFF, 0xBF,
  0xFF, 0xFB, 0xFF, 0x5F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xF8, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xDF, 0xC3, 0xBF, 0x01,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE7, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE3, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x13, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xDF, 0x3F, 0xE7, 0xC7, 0xF1, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xF0, 0x7E, 0x7E,
  0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E,
  0x0F, 0xF0, 0x7E, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F,
  0x1E, 0x78, 0xFC, 0x3F, 0x1E, 0x78, 0xFC, 0x3F, 0x1E, 0x78, 0xF8, 0x1F,
  0x9E, 0x79, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBC, 0x3D, 0xF8, 0x1F,
  0xBC, 0x3D, 0xF8, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F,
  0xBC, 0x3F, 0xF0, 0x0F, 0xBC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x9F, 0xC1,
  0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xF9,
  0xF8, 0x1F, 0x9F, 0x83, 0xF1, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFE, 0x7E,
  0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x9F, 0x80, 0xFC,
  0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x80,
  0xF8, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0xFB, 0xF0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x08, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x01, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0x17, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 35, 12, 2, -34 },
  { 36, 17, 13, 21, 2, -34 },
  { 64, 22, 34, 24, 1, -34 },
  { 158, 18, 39, 22, 2, -36 },
  { 246, 34, 34, 36, 1, -34 },
  { 391, 25, 34, 26, 1, -34 },
  { 498, 7, 13, 11, 2, -34 },
  { 510, 12, 41, 15, 2, -34 },
  { 572, 12, 41, 15, 1, -34 },
  { 634, 19, 19, 21, 1, -36 },
  { 680, 19, 23, 22, 1, -28 },
  { 735, 9, 11, 12, 1, -5 },
  { 748, 12, 6, 14, 1, -16 },
  { 757, 8, 8, 12, 2, -7 },
  { 765, 19, 34, 19, 0, -34 },
  { 846, 18, 34, 22, 2, -34 },
  { 923, 15, 34, 22, 2, -34 },
  { 987, 19, 34, 22, 1, -34 },
  { 1068, 19, 34, 22, 1, -34 },
  { 1149, 20, 34, 22, 1, -34 },
  { 1234, 18, 34, 22, 2, -34 },
  { 1311, 19, 34, 22, 1, -34 },
  { 1392, 19, 34, 22, 1, -34 },
  { 1473, 19, 34, 22, 1, -34 },
  { 1554, 19, 34, 22, 1, -34 },
  { 1635, 8, 27, 12, 2, -26 },
  { 1662, 8, 32, 12, 2, -26 },
  { 1694, 19, 22, 22, 1, -28 },
  { 1747, 20, 15, 22, 1, -24 },
  { 1785, 20, 22, 22, 1, -28 },
  { 1840, 17, 35, 17, 0, -34 },
  { 1915, 30, 38, 34, 2, -34 },
  { 2058, 25, 34, 25, 0, -34 },
  { 2165, 20, 34, 25, 3, -34 },
  { 2250, 20, 34, 23, 2, -34 },
  { 2335, 21, 34, 26, 3, -34 },
  { 2425, 15, 34, 20, 3, -34 },
  { 2489, 15, 34, 20, 3, -34 },
  { 2553, 22, 34, 26, 2, -34 },
  { 2647, 21, 34, 28, 3, -34 },
  { 2737, 13, 34, 15, 1, -34 },
  { 2793, 12, 44, 13, -2, -34 },
  { 2859, 22, 34, 24, 3, -34 },
  { 2953, 15, 34, 19, 3, -34 },
  { 3017, 30, 34, 36, 3, -34 },
  { 3145, 23, 34, 30, 3, -34 },
  { 3243, 24, 34, 28, 2, -34 },
  { 3345, 19, 34, 23, 3, -34 },
  { 3426, 24, 42, 28, 2, -34 },
  { 3552, 21, 34, 24, 3, -34 },
  { 3642, 17, 34, 20, 1, -34 },
  { 3715, 19, 34, 20, 1, -34 },
  { 3796, 21, 34, 27, 3, -34 },
  { 3886, 24, 34, 24, 0, -34 },
  { 3988, 37, 34, 35, -1, -34 },
  { 4146, 22, 34, 22, 0, -34 },
  { 4240, 22, 34, 22, 0, -34 },
  { 4334, 18, 34, 19, 1, -34 },
  { 4411, 11, 41, 15, 3, -34 },
  { 4468, 19, 34, 19, 0, -34 },
  { 4549, 11, 41, 15, 1, -34 },
  { 4606, 23, 21, 25, 1, -34 },
  { 4667, 19, 3, 19, 0, 4 },
  { 4675, 11, 8, 15, 2, -36 },
  { 4686, 18, 26, 22, 1, -26 },
  { 4745, 19, 36, 24, 3, -36 },
  { 4831, 16, 26, 19, 2, -26 },
  { 4883, 19, 36, 24, 2, -36 },
  { 4969, 18, 26, 21, 2, -26 },
  { 5028, 16, 36, 14, 0, -36 },
  { 5100, 19, 37, 24, 2, -26 },
  { 5188, 18, 36, 24, 3, -36 },
  { 5269, 7, 36, 11, 2, -36 },
  { 5301, 10, 47, 11, -1, -36 },
  { 5360, 20, 36, 23, 3, -36 },
  { 5450, 6, 36, 11, 3, -36 },
  { 5477, 30, 26, 35, 3, -26 },
  { 5575, 18, 26, 24, 3, -26 },
  { 5634, 19, 26, 23, 2, -26 },
  { 5696, 19, 37, 24, 3, -26 },
  { 5784, 19, 37, 24, 2, -26 },
  { 5872, 13, 26, 16, 3, -26 },
  { 5915, 15, 26, 18, 1, -26 },
  { 5964, 14, 31, 16, 1, -31 },
  { 6019, 18, 26, 24, 3, -26 },
  { 6078, 21, 26, 21, 0, -26 },
  { 6147, 32, 26, 32, 0, -26 },
  { 6251, 20, 26, 20, 0, -26 },
  { 6316, 21, 37, 21, 0, -26 },
  { 6414, 15, 26, 17, 1, -26 },
  { 6463, 15, 41, 16, 0, -34 },
  { 6540, 5, 47, 21, 8, -36 },
  { 6570, 14, 41, 16, 2, -34 },
  { 6642, 20, 7, 22, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Bold47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD47PT7B_H_
