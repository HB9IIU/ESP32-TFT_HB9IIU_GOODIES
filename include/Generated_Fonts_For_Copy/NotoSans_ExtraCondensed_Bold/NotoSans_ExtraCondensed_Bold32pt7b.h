#ifndef _NOTOSANS_EXTRACONDENSED_BOLD32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x00,
  0x1D, 0xEF, 0xFB, 0xC0, 0xF9, 0xF7, 0x9F, 0x79, 0xF7, 0x9E, 0x79, 0xE7,
  0x8E, 0x78, 0xE7, 0x8E, 0x07, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0x73, 0x80,
  0xE7, 0x01, 0xCE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xE0, 0x73,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC,
  0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0x70, 0x00,
  0x02, 0x00, 0x20, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0xFF, 0x7A, 0x2F, 0x20,
  0x7A, 0x07, 0xA0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x2F,
  0x02, 0x78, 0x27, 0xE2, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x3E, 0x03, 0x80, 0xFE, 0x07, 0x01, 0xFC, 0x1C, 0x07,
  0xBC, 0x38, 0x0E, 0x38, 0xF0, 0x1C, 0x71, 0xC0, 0x38, 0xE3, 0x80, 0x71,
  0xCE, 0x00, 0xE3, 0x9C, 0x01, 0xC7, 0x39, 0xE3, 0xDE, 0xE7, 0xE3, 0xF9,
  0xDF, 0xE7, 0xF7, 0xB9, 0xC7, 0xCE, 0x73, 0x80, 0x1C, 0xE7, 0x80, 0x71,
  0xCF, 0x00, 0xE3, 0x9E, 0x03, 0xC7, 0x3C, 0x07, 0x0E, 0x78, 0x0E, 0x1C,
  0xE0, 0x38, 0x3F, 0xC0, 0x70, 0x3F, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xBE, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xF1, 0xE7,
  0xF8, 0xF7, 0xFE, 0xFB, 0xCF, 0xF9, 0xE3, 0xFC, 0xF1, 0xFE, 0x78, 0x7E,
  0x3E, 0x1F, 0x1F, 0xBF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFE, 0x3E, 0xFB,
  0xDE, 0xF7, 0xBD, 0xEF, 0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x78, 0xF0,
  0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0xF0, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xC1, 0xCE, 0xEF, 0xFF,
  0x7F, 0xF9, 0xFF, 0xA3, 0xF0, 0x3F, 0xC1, 0xEF, 0x1E, 0x78, 0x61, 0x81,
  0x08, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x7D, 0xE7, 0x9E, 0x7B, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0x77, 0xBF, 0xEF, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xFE, 0x0F, 0xF8,
  0xFF, 0xC7, 0x8F, 0x3C, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1E, 0xF8, 0xF3, 0xC7,
  0x9E, 0x3C, 0xFF, 0xE3, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x03, 0xC1, 0xF0,
  0x7C, 0x3F, 0x1F, 0xCF, 0xFF, 0xBD, 0xCF, 0x23, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1F, 0x87, 0xFC, 0xFF, 0xEF, 0xFF, 0x61, 0xF2, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x87, 0xFF, 0x3F, 0xF8, 0xFF, 0xE6, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0xFF, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x7D, 0xE7, 0xEF, 0xFE, 0x7F,
  0xF1, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xBC, 0x0E, 0xF0, 0x73, 0xC1, 0xCF, 0x0E, 0x3C,
  0x38, 0xF1, 0xE3, 0xC7, 0x0F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0x03, 0xFE,
  0x1F, 0xF8, 0xFF, 0xE2, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF0,
  0x07, 0xA0, 0x7D, 0xEF, 0xEF, 0xFE, 0x7F, 0xE1, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x87, 0xFC, 0x7F, 0xE7, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF3,
  0xC7, 0xBF, 0x3F, 0xFD, 0xFF, 0xEF, 0x8F, 0x78, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC7, 0xDE, 0x3C, 0xFB, 0xE3, 0xFF, 0x1F, 0xF0, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFC, 0xF3, 0xEF, 0x8F, 0x78, 0x79,
  0xE3, 0xCF, 0x1E, 0x7D, 0xF1, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFE, 0x3E,
  0xFB, 0xE3, 0xDE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xF1, 0xE7, 0xFF,
  0x3F, 0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF, 0xCF, 0x8F,
  0x78, 0x7B, 0xC3, 0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xF7,
  0xFF, 0xBF, 0xBC, 0xF9, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x9F,
  0xC7, 0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x67, 0xBF, 0xFF, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x3B, 0xDF, 0xFF, 0x80, 0x31, 0xE7, 0xDF, 0x78, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x79, 0xE7, 0x9C, 0xF3, 0xC0, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x03, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x3F, 0x8F, 0xFB, 0xFF, 0xBF, 0xF4,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x01, 0xF0, 0x3C,
  0x07, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3C, 0x03,
  0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x78, 0xE1, 0xF9, 0xCE, 0x3F, 0xCE, 0x71,
  0xEE, 0x3B, 0x9E, 0x71, 0xFC, 0xE3, 0x8F, 0xC7, 0x1C, 0x7E, 0x38, 0xE3,
  0xF1, 0xC7, 0x1F, 0x8E, 0x38, 0xFC, 0x73, 0xCE, 0xF3, 0xDF, 0x73, 0x8F,
  0xFF, 0x1C, 0x7C, 0xF0, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x0C, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0x1F, 0x07, 0xCF, 0x03, 0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x3E,
  0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0xF3, 0xC3,
  0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBF, 0xFE, 0xFF,
  0xF3, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE,
  0x3E, 0x09, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x0F, 0x9E, 0x0F, 0xBC, 0x1F, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xFF, 0x03, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xE0, 0xFB, 0xC3, 0xE7, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x80, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE3,
  0xE0, 0x4F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xEF, 0x1F, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E,
  0xF8, 0x3C, 0xF0, 0x79, 0xFB, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F,
  0xBF, 0xDF, 0xCF, 0xE3, 0xC0, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7,
  0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFF, 0xC1, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF8, 0x7C, 0xF0, 0xF9,
  0xF1, 0xF1, 0xE3, 0xE3, 0xE7, 0xC7, 0xCF, 0x87, 0xDF, 0x0F, 0xBE, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1D, 0xFE, 0xE0, 0xFF, 0xF7, 0x0F, 0xFF, 0xBC, 0x77, 0xFD,
  0xE3, 0xBF, 0xE7, 0x3D, 0xFF, 0x39, 0xEF, 0xF9, 0xEE, 0x7F, 0xCF, 0x73,
  0xFE, 0x3F, 0x9F, 0xF1, 0xFC, 0xFF, 0x8F, 0xC7, 0xFC, 0x7E, 0x3F, 0xE1,
  0xF1, 0xFF, 0x0F, 0x0F, 0xF8, 0x78, 0x7F, 0xC3, 0xC3, 0xE0, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0F, 0xF7, 0x8F, 0xF7, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xEF,
  0xF1, 0xEF, 0xF1, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0x07, 0xF0, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0, 0x7C, 0xF0,
  0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3E, 0x0F, 0x8F, 0x07,
  0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF,
  0x3F, 0xF9, 0xFF, 0xEF, 0x1F, 0x78, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x7D, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF9,
  0xE0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3E,
  0x0F, 0x8F, 0x07, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0xFF,
  0x03, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xF1, 0xFB, 0xC3, 0xEF, 0x0F, 0xBC,
  0x3E, 0xF0, 0xFB, 0xC3, 0xCF, 0x3F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F,
  0x3C, 0x3C, 0xF8, 0xF1, 0xE3, 0xC7, 0xCF, 0x0F, 0x3C, 0x3E, 0xF0, 0xFB,
  0xC1, 0xFF, 0x07, 0xC0, 0x1F, 0xC3, 0xFF, 0x7F, 0xE7, 0xFE, 0xF8, 0x6F,
  0x80, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1E, 0x01, 0xF8, 0x1E, 0xC1, 0xEF, 0xFE, 0xFF, 0xCF,
  0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x87, 0xDF, 0xFF, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF8, 0x7E, 0x1E, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0xFE, 0x3E, 0x7C,
  0xFF, 0x3C, 0x3C, 0xEF, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3D,
  0xE7, 0x7C, 0x3D, 0xE7, 0xF8, 0x1D, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xF1, 0xE3,
  0xC3, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x1E,
  0xF0, 0x7D, 0xF0, 0xF1, 0xE1, 0xE3, 0xE7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F,
  0x80, 0xF8, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F,
  0x0F, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0xF0,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0x78, 0x78, 0xF1, 0xE0, 0xE3,
  0xC1, 0xEF, 0x01, 0xDE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C,
  0x3C, 0x1E, 0x0E, 0x07, 0x0F, 0x87, 0xFE, 0x3F, 0xE3, 0xFF, 0x20, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF9, 0xFF, 0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xCE, 0x1E, 0xFC, 0xFF, 0xE7, 0xFF, 0xBE,
  0x3D, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xFC, 0x3F, 0xF1, 0xEF, 0x9F, 0x7F, 0xFB, 0xFF, 0x9C, 0xF8, 0x07, 0x83,
  0xFC, 0xFF, 0xBF, 0xE7, 0xC4, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x5F, 0x1B, 0xFF, 0x3F, 0xE3, 0xF8, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x39, 0xE7, 0xEF,
  0x3F, 0xFB, 0xFF, 0xDE, 0x3F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1E, 0xF1, 0xF7, 0xCF, 0xBF, 0xFC, 0xFF,
  0xE3, 0xE7, 0x0F, 0x00, 0xFE, 0x0F, 0xF8, 0xFB, 0xE7, 0x8F, 0x38, 0x3B,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0xCF, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0x23, 0xE0, 0x78, 0x0F, 0x03, 0xFC, 0xFF, 0x9F, 0xF0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x0E, 0x39, 0xFB, 0xCF, 0xFE, 0xFF, 0xF7,
  0x8F, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0,
  0xFF, 0x87, 0xBC, 0x7D, 0xF7, 0xEF, 0xFF, 0x3F, 0xF8, 0xFB, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xB0, 0x7D, 0xFF, 0xCF, 0xFC, 0x7F, 0xC0, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0x8F, 0x7E,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79,
  0xFF, 0xFF, 0xBF, 0x38, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x3E, 0xF0, 0xF3, 0xC7, 0x8F, 0x3E, 0x3C,
  0xF0, 0xF7, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xEF, 0x0F,
  0x1E, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC3,
  0xCE, 0x7E, 0x7E, 0xEF, 0xEF, 0xEF, 0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xE3, 0x8E, 0x7E, 0xEF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x07, 0x80,
  0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0xBC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xBC, 0x3D, 0xF3, 0xC7, 0xFE,
  0x3F, 0xE0, 0x7E, 0x00, 0xE3, 0x87, 0x3F, 0x3F, 0xF9, 0xFF, 0xEF, 0x8F,
  0x78, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF,
  0x0F, 0xFC, 0x7B, 0xE7, 0xDF, 0xFE, 0xFF, 0xE7, 0xBE, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0E,
  0x39, 0xFB, 0xCF, 0xFE, 0xFF, 0xF7, 0x8F, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xF3, 0xEF,
  0xFF, 0x3F, 0xF8, 0xFB, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xE3, 0xF3, 0xFB, 0xFF, 0xFF, 0xF7,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x00, 0x1E, 0x1F, 0xF7, 0xFF, 0xFE, 0xF0, 0xBC, 0x0F, 0x83,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x03, 0xE0, 0xFE, 0x7F, 0xFF, 0xFF,
  0xBF, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x93, 0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x1F, 0xFB, 0xFF, 0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x3F, 0xE0, 0xF7,
  0x87, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0x73, 0xC1, 0xEE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0xF0, 0xF8, 0x7D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7,
  0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0xF1, 0xF7, 0x73, 0xC3, 0xDC, 0xCF, 0x0F,
  0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0xF7, 0x3F, 0x81, 0xD8, 0xFE, 0x07, 0x63,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0xF8, 0xFB, 0xC7, 0x8F, 0x3C, 0x7B, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0xC3, 0xDE,
  0x1E, 0x79, 0xE3, 0xCF, 0x1F, 0xF8, 0x78, 0xF0, 0x3F, 0xE0, 0xF7, 0x87,
  0xDE, 0x1E, 0x78, 0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0x7B,
  0xC1, 0xEE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x07, 0xF0, 0x1F,
  0x80, 0x7C, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0xFE, 0x3F, 0x0F, 0xC3, 0xF8,
  0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xF0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3F, 0x0F, 0xC1, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0xC3,
  0xF0, 0xFC, 0x7F, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 23, 8, 2, -23 },
  { 16, 12, 8, 14, 1, -23 },
  { 28, 15, 23, 16, 1, -23 },
  { 72, 12, 26, 15, 1, -24 },
  { 111, 23, 23, 25, 1, -23 },
  { 178, 17, 23, 18, 1, -23 },
  { 227, 5, 8, 8, 1, -23 },
  { 232, 8, 28, 10, 2, -23 },
  { 260, 9, 28, 10, 0, -23 },
  { 292, 13, 13, 14, 1, -24 },
  { 314, 13, 15, 15, 1, -19 },
  { 339, 6, 8, 8, 1, -4 },
  { 345, 8, 4, 10, 1, -11 },
  { 349, 5, 5, 8, 2, -5 },
  { 353, 13, 23, 13, 0, -23 },
  { 391, 13, 23, 15, 1, -23 },
  { 429, 10, 23, 15, 1, -23 },
  { 458, 12, 23, 15, 1, -23 },
  { 493, 13, 23, 15, 1, -23 },
  { 531, 14, 23, 15, 0, -23 },
  { 572, 13, 23, 15, 1, -23 },
  { 610, 13, 23, 15, 1, -23 },
  { 648, 13, 23, 15, 1, -23 },
  { 686, 13, 23, 15, 1, -23 },
  { 724, 13, 23, 15, 1, -23 },
  { 762, 5, 18, 8, 2, -18 },
  { 774, 6, 22, 8, 1, -18 },
  { 791, 13, 15, 15, 1, -19 },
  { 816, 13, 10, 15, 1, -16 },
  { 833, 13, 15, 15, 1, -19 },
  { 858, 11, 23, 12, 0, -23 },
  { 890, 21, 26, 23, 1, -23 },
  { 959, 17, 23, 17, 0, -23 },
  { 1008, 14, 23, 17, 2, -23 },
  { 1049, 14, 23, 15, 1, -23 },
  { 1090, 15, 23, 18, 2, -23 },
  { 1134, 10, 23, 14, 2, -23 },
  { 1163, 10, 23, 14, 2, -23 },
  { 1192, 15, 23, 18, 1, -23 },
  { 1236, 15, 23, 19, 2, -23 },
  { 1280, 8, 23, 10, 1, -23 },
  { 1303, 9, 30, 9, -2, -23 },
  { 1337, 15, 23, 16, 2, -23 },
  { 1381, 11, 23, 13, 2, -23 },
  { 1413, 21, 23, 25, 2, -23 },
  { 1474, 16, 23, 20, 2, -23 },
  { 1520, 17, 23, 19, 1, -23 },
  { 1569, 13, 23, 16, 2, -23 },
  { 1607, 17, 28, 19, 1, -23 },
  { 1667, 14, 23, 16, 2, -23 },
  { 1708, 12, 23, 14, 1, -23 },
  { 1743, 13, 23, 14, 0, -23 },
  { 1781, 14, 23, 18, 2, -23 },
  { 1822, 16, 23, 16, 0, -23 },
  { 1868, 24, 23, 24, 0, -23 },
  { 1937, 15, 23, 15, 0, -23 },
  { 1981, 15, 23, 15, 0, -23 },
  { 2025, 13, 23, 13, 0, -23 },
  { 2063, 7, 28, 10, 2, -23 },
  { 2088, 13, 23, 13, 0, -23 },
  { 2126, 7, 28, 10, 1, -23 },
  { 2151, 15, 14, 17, 1, -23 },
  { 2178, 13, 2, 13, 0, 3 },
  { 2182, 8, 6, 10, 1, -25 },
  { 2188, 12, 18, 15, 1, -18 },
  { 2215, 13, 24, 16, 2, -24 },
  { 2254, 11, 18, 13, 1, -18 },
  { 2279, 13, 24, 16, 1, -24 },
  { 2318, 13, 18, 15, 1, -18 },
  { 2348, 11, 24, 10, 0, -24 },
  { 2381, 13, 26, 16, 1, -18 },
  { 2424, 12, 24, 16, 2, -24 },
  { 2460, 4, 24, 8, 2, -24 },
  { 2472, 7, 32, 8, -1, -24 },
  { 2500, 14, 24, 15, 2, -24 },
  { 2542, 4, 24, 8, 2, -24 },
  { 2554, 20, 18, 24, 2, -18 },
  { 2599, 12, 18, 16, 2, -18 },
  { 2626, 13, 18, 16, 1, -18 },
  { 2656, 13, 26, 16, 2, -18 },
  { 2699, 13, 26, 16, 1, -18 },
  { 2742, 9, 18, 11, 2, -18 },
  { 2763, 10, 18, 12, 1, -18 },
  { 2786, 10, 21, 11, 0, -21 },
  { 2813, 12, 18, 16, 2, -18 },
  { 2840, 14, 18, 14, 0, -18 },
  { 2872, 22, 17, 22, 0, -17 },
  { 2919, 13, 17, 14, 0, -17 },
  { 2947, 14, 26, 14, 0, -18 },
  { 2993, 10, 18, 12, 1, -18 },
  { 3016, 10, 28, 11, 0, -23 },
  { 3051, 4, 31, 14, 5, -24 },
  { 3067, 10, 28, 11, 1, -23 },
  { 3102, 13, 5, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Bold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD32PT7B_H_
