#ifndef _NOTOSANS_EXTRACONDENSED_BOLD56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xEF, 0xE0,
  0xFC, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xEE, 0x3C, 0x7F,
  0x38, 0x11, 0xFC, 0xE0, 0x07, 0xE3, 0x80, 0x1F, 0xCE, 0x00, 0x7F, 0x38,
  0x01, 0xFE, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3B, 0xF8, 0x00, 0xE7,
  0xF0, 0x03, 0x9F, 0xE0, 0x0E, 0x7F, 0xE0, 0x39, 0xFB, 0xE0, 0xEF, 0xEF,
  0xF3, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xFC,
  0x01, 0xF0, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x7E, 0x03, 0xF0,
  0x00, 0xFC, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x3E, 0x07, 0xE0, 0x00, 0xF8,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x0F,
  0xC0, 0x00, 0xF8, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x1F, 0x80, 0x00,
  0xF8, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x3F, 0x03, 0x80, 0xFC, 0x3E,
  0x3F, 0x0F, 0xE0, 0xFC, 0x7E, 0x3E, 0x3F, 0xF0, 0x7C, 0x7E, 0x7E, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x7F, 0xFC, 0x3F,
  0xF8, 0xFC, 0xFC, 0x7E, 0x1F, 0xF8, 0xF8, 0xFC, 0x7E, 0x0F, 0xE1, 0xF8,
  0xFC, 0x7E, 0x01, 0x81, 0xF8, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x7E, 0x00,
  0x0F, 0x80, 0xFC, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x7E, 0x00, 0x1F, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x03, 0xF8, 0x7F, 0xFC, 0x1F, 0xE3, 0xFF, 0xF8, 0x7F,
  0x8F, 0xFF, 0xF1, 0xFE, 0x7F, 0xBF, 0xC7, 0xF1, 0xFE, 0x7F, 0xBF, 0xC7,
  0xF0, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0xE3, 0xFC,
  0x0F, 0xFF, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x00,
  0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xF1, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x0C,
  0x1F, 0x06, 0x3F, 0x3E, 0x7E, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x3F, 0xC0, 0xF8, 0x3E, 0x00, 0x60, 0x70, 0x00, 0x40, 0x40,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x9F, 0xCF, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC,
  0xFE, 0x7E, 0x7F, 0x3F, 0x9F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xE7,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x07, 0xF9, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xBF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xE7, 0xF9, 0xE3, 0xFC, 0x61, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0x83, 0xFC, 0x3C, 0x07, 0xF8, 0xC0, 0x1F, 0xE1, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0x03, 0xFE, 0x30, 0x07, 0xF8, 0x80,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFA, 0x00, 0x1F, 0xEF, 0x01, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xF0, 0x01, 0xF7, 0xF0, 0x03, 0xF7, 0xF0,
  0x03, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0,
  0x0F, 0x87, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0x07, 0xF0, 0x3F, 0x07, 0xF0,
  0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0xFC, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x80, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x18, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x80, 0x1F, 0xF7, 0x81, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x3F,
  0x9F, 0xF0, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0xCF, 0xFB, 0xFE, 0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x83,
  0xF9, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0xE7, 0xF0,
  0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xF3, 0xFC,
  0x7F, 0x87, 0xFB, 0xFC, 0x1F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x03,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0x7F, 0x01, 0xFE,
  0xFE, 0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFE, 0x3F, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x8F, 0xFF, 0x7F, 0x0F, 0xFC, 0xFC, 0x07,
  0xF1, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x3F, 0xBF,
  0xDF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xFC,
  0xFF, 0x7F, 0xBF, 0xFF, 0xFF, 0xF7, 0xF9, 0xF8, 0x10, 0x1F, 0x0F, 0xE7,
  0xF9, 0xFF, 0x7F, 0xDF, 0xF7, 0xF8, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xF9,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x87,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xC1, 0xFF,
  0x30, 0x0F, 0xF2, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0xFF, 0x07, 0xE3, 0xF0, 0x3F, 0xFE, 0x3E, 0x3F, 0x07, 0xFF, 0xC3, 0xE3,
  0xE0, 0xFF, 0xFC, 0x3F, 0x7E, 0x0F, 0xEF, 0xC3, 0xF7, 0xC1, 0xF8, 0x7C,
  0x1F, 0x7C, 0x1F, 0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0x7C, 0x1F, 0xFC, 0x3F,
  0x07, 0xC1, 0xFF, 0xC3, 0xE0, 0x7C, 0x1F, 0xFC, 0x3E, 0x07, 0xC1, 0xFF,
  0xC3, 0xE0, 0xFC, 0x1F, 0xFC, 0x3E, 0x0F, 0xC1, 0xFF, 0xC3, 0xE0, 0xFC,
  0x1F, 0xFC, 0x3E, 0x0F, 0xC1, 0xFF, 0xC3, 0xE0, 0xFC, 0x3F, 0xFC, 0x3E,
  0x0F, 0xC3, 0xEF, 0xC3, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x1F, 0xE7, 0xE7,
  0xC1, 0xFF, 0xDF, 0xFC, 0x7C, 0x1F, 0xFD, 0xFF, 0xC7, 0xE0, 0xFF, 0x8F,
  0xF8, 0x7E, 0x07, 0xF0, 0xFF, 0x03, 0xF0, 0x0C, 0x01, 0x80, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x80, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x3F,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x9F, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xBF, 0x83, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x03,
  0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F,
  0xBF, 0x80, 0xFF, 0x7F, 0x03, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0x83, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF0, 0x0C, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x06, 0x1F, 0xFC, 0x3E,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xFC, 0xFE, 0x03,
  0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F,
  0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x07,
  0xFC, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xF8, 0x3E, 0x3F, 0xF0, 0x02, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFD,
  0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F,
  0xCF, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xE3, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFC, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF,
  0x80, 0x7F, 0xDF, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xE7, 0xF0, 0x1F, 0xE3,
  0xF8, 0x1F, 0xF1, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF8,
  0x3F, 0x87, 0xF8, 0x1F, 0xC7, 0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xF3, 0xFE,
  0x03, 0xFB, 0xFE, 0x01, 0xFD, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F,
  0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x7F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC,
  0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F,
  0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFD, 0xF8, 0x0F, 0xDF, 0xFF, 0xBF, 0x01, 0xFB, 0xFF, 0xF7, 0xE0,
  0x3F, 0x7F, 0xFE, 0xFC, 0x0F, 0xEF, 0xFF, 0xCF, 0xC1, 0xF9, 0xFF, 0xF9,
  0xF8, 0x3F, 0x3F, 0xFF, 0x3F, 0x07, 0xE7, 0xFF, 0xE7, 0xE1, 0xF8, 0xFF,
  0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0x8F, 0xC7, 0xE3, 0xFF, 0xF1, 0xF8, 0xFC,
  0x7F, 0xFE, 0x3F, 0x3F, 0x0F, 0xFF, 0xC3, 0xF7, 0xE1, 0xFF, 0xF8, 0x7E,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFC, 0x07,
  0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF,
  0x83, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x7F, 0x0F, 0xFF, 0xCF, 0xE1, 0xFF,
  0xF9, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE3, 0xFC, 0xFF, 0xFC, 0x3F,
  0x9F, 0xFF, 0x87, 0xF3, 0xFF, 0xF0, 0x7F, 0x3F, 0xFE, 0x0F, 0xE7, 0xFF,
  0xC1, 0xFE, 0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE,
  0x7F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0x83, 0xFE, 0xFE, 0x07, 0xFB,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFB, 0xF8, 0x1F,
  0xEF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFC, 0x1F, 0xF8, 0xFE, 0x07, 0xFC, 0x7F, 0x01,
  0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0,
  0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0x7F,
  0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07,
  0xF8, 0x7F, 0x03, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFF, 0x00,
  0x20, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x81, 0xCF, 0xF0, 0x04,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFE,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x7F, 0xC3, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xBF, 0x80, 0x1F, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xF0, 0x07, 0xF1, 0xFC,
  0x03, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F,
  0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0xF0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFF, 0xE0, 0xFF,
  0x07, 0xF0, 0x3E, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xDF, 0x83, 0xF8, 0x0F,
  0xE1, 0xF9, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x3F, 0x0F, 0xE0, 0x3F, 0x87,
  0xE7, 0xE3, 0xFC, 0x07, 0xF0, 0xFC, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0x9F,
  0x8F, 0xE0, 0x0F, 0xE7, 0xE3, 0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x3E, 0x3F,
  0x80, 0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0xFD, 0xFE, 0x00,
  0xFE, 0x7E, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x83, 0xF7, 0xF0, 0x01, 0xFB,
  0xF0, 0x7E, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xDF, 0xC0, 0x07, 0xFF, 0xC0,
  0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x9F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF,
  0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xF1,
  0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x1F,
  0xC0, 0x3F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE7,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xE0, 0x07,
  0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F,
  0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x78, 0x3F, 0xC1, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0x87, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFB, 0xF7, 0xFF, 0x9F, 0x9F, 0xF8, 0xFC, 0x7F, 0x87, 0xE0, 0x60, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE1,
  0xF8, 0x1F, 0xC7, 0xFC, 0x3F, 0x9F, 0xFC, 0x7F, 0x7F, 0xF8, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0x1F, 0xF7, 0xFC, 0x1F, 0xEF, 0xF0, 0x1F,
  0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xF7, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xDF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFE, 0xFF, 0xF1, 0xFC, 0xFF,
  0xC3, 0xF0, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xF8, 0x73,
  0xFC, 0x02, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x01, 0x7F, 0xC0, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x0F,
  0xE1, 0xFF, 0x1F, 0xC7, 0xFF, 0x3F, 0x8F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFB, 0xFC, 0x1F, 0xF7, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFE, 0x1F, 0xF8, 0xFC,
  0x1F, 0xE1, 0xF8, 0x02, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF8,
  0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x07, 0xEF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x02,
  0x7F, 0x80, 0x30, 0xFF, 0xC7, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x1F, 0xF9, 0xFC, 0x7F,
  0xF3, 0xF8, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xF1,
  0xFF, 0xBF, 0xC1, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0xBF,
  0xC1, 0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xF7, 0xF1, 0xFF, 0xEF, 0xE1, 0xFF, 0x9F, 0xC1, 0xFE, 0x3F, 0x80, 0x40,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE6, 0x00, 0x3F, 0xCF, 0x00, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0x83,
  0xF9, 0xFF, 0x8F, 0xEF, 0xFF, 0x3F, 0xBF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x18,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x00, 0x00, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0xC0, 0x1F, 0x81, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03,
  0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xC0, 0xFF, 0x9F,
  0xC0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC7, 0xFE, 0x1F, 0xF8, 0xFC, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xFF, 0x3F, 0xEF, 0xF8, 0x7F, 0xE1, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0xFC, 0x1F, 0x83, 0xF1,
  0xFF, 0x8F, 0xCF, 0xFF, 0x3F, 0xBF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0,
  0x3F, 0xDF, 0xC0, 0x7F, 0x3F, 0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0xFF, 0xC3,
  0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xF1, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0x7F, 0xC1, 0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7,
  0xF7, 0xFF, 0xCF, 0xEF, 0xFF, 0x1F, 0xCF, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F,
  0x01, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x1F, 0xF9, 0xFC, 0x7F, 0xF3, 0xF8, 0xFF, 0xF7,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xBF, 0xC1, 0xFF,
  0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0xBF, 0xC1, 0xFF, 0x7F, 0x83,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xF7, 0xF1, 0xFF, 0xEF,
  0xE1, 0xFF, 0x9F, 0xC1, 0xFE, 0x3F, 0x80, 0x40, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8,
  0x1D, 0xFC, 0x04, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE7,
  0xFF, 0xE1, 0xFF, 0xE0, 0x02, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC1, 0x1F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x20, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFC, 0xFC, 0x7F, 0xE3, 0xF0, 0xFF, 0x0F, 0xC0,
  0x20, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF8, 0x0F,
  0xF7, 0xF0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0xC0, 0xFE, 0x7F, 0x03,
  0xFF, 0x03, 0xF9, 0xFE, 0x0F, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xFE, 0x1F,
  0x3E, 0x1F, 0xC1, 0xFC, 0x7C, 0xF8, 0x7E, 0x07, 0xF1, 0xF3, 0xE3, 0xF8,
  0x1F, 0xC7, 0xCF, 0x8F, 0xE0, 0x7F, 0x1F, 0x3E, 0x3F, 0x81, 0xFC, 0xF8,
  0x7C, 0xFE, 0x03, 0xF3, 0xE1, 0xF7, 0xF0, 0x0F, 0xEF, 0x87, 0xDF, 0xC0,
  0x3F, 0xBE, 0x1F, 0x7F, 0x00, 0xFE, 0xF8, 0x7D, 0xFC, 0x01, 0xFB, 0xE1,
  0xF7, 0xE0, 0x07, 0xEF, 0x03, 0xDF, 0x80, 0x1F, 0xBC, 0x0F, 0x7E, 0x00,
  0x7E, 0xF0, 0x3D, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC7,
  0xF8, 0x1F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xC7,
  0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x7F,
  0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xC0, 0x0F, 0xFC, 0x80, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 41, 14, 3, -40 },
  { 42, 19, 14, 25, 3, -40 },
  { 76, 26, 40, 28, 1, -40 },
  { 206, 22, 46, 26, 2, -43 },
  { 333, 40, 41, 43, 2, -41 },
  { 538, 30, 42, 31, 1, -41 },
  { 696, 8, 14, 13, 3, -40 },
  { 710, 14, 49, 18, 3, -40 },
  { 796, 14, 49, 18, 1, -40 },
  { 882, 23, 23, 25, 1, -43 },
  { 949, 22, 27, 26, 2, -33 },
  { 1024, 9, 13, 14, 2, -6 },
  { 1039, 14, 7, 17, 2, -19 },
  { 1052, 8, 10, 14, 3, -9 },
  { 1062, 22, 40, 23, 0, -40 },
  { 1172, 22, 42, 26, 2, -41 },
  { 1288, 17, 40, 26, 3, -40 },
  { 1373, 22, 41, 26, 2, -41 },
  { 1486, 22, 42, 26, 2, -41 },
  { 1602, 24, 40, 26, 1, -40 },
  { 1722, 21, 41, 26, 3, -40 },
  { 1830, 22, 41, 26, 2, -40 },
  { 1943, 23, 40, 26, 1, -40 },
  { 2058, 22, 41, 26, 2, -40 },
  { 2171, 23, 41, 26, 1, -40 },
  { 2289, 9, 32, 15, 3, -31 },
  { 2325, 10, 38, 15, 2, -31 },
  { 2373, 23, 26, 26, 1, -33 },
  { 2448, 23, 17, 26, 1, -28 },
  { 2497, 23, 26, 26, 2, -33 },
  { 2572, 20, 42, 21, 0, -41 },
  { 2677, 36, 44, 40, 2, -40 },
  { 2875, 29, 40, 29, 0, -40 },
  { 3020, 23, 40, 29, 4, -40 },
  { 3135, 24, 42, 27, 2, -41 },
  { 3261, 25, 40, 31, 4, -40 },
  { 3386, 18, 40, 24, 4, -40 },
  { 3476, 18, 40, 24, 4, -40 },
  { 3566, 25, 42, 32, 3, -41 },
  { 3698, 25, 40, 33, 4, -40 },
  { 3823, 15, 40, 18, 1, -40 },
  { 3898, 14, 52, 15, -3, -40 },
  { 3989, 25, 40, 29, 4, -40 },
  { 4114, 18, 40, 23, 4, -40 },
  { 4204, 35, 40, 43, 4, -40 },
  { 4379, 27, 40, 35, 4, -40 },
  { 4514, 29, 42, 33, 2, -41 },
  { 4667, 22, 40, 27, 4, -40 },
  { 4777, 29, 51, 33, 2, -41 },
  { 4962, 25, 40, 29, 4, -40 },
  { 5087, 20, 42, 24, 2, -41 },
  { 5192, 22, 40, 24, 1, -40 },
  { 5302, 24, 41, 32, 4, -40 },
  { 5425, 28, 40, 28, 0, -40 },
  { 5565, 43, 40, 42, -1, -40 },
  { 5780, 26, 40, 26, 0, -40 },
  { 5910, 27, 40, 27, 0, -40 },
  { 6045, 21, 40, 23, 1, -40 },
  { 6150, 13, 49, 17, 3, -40 },
  { 6230, 22, 40, 23, 0, -40 },
  { 6340, 13, 49, 17, 1, -40 },
  { 6420, 27, 24, 30, 1, -40 },
  { 6501, 23, 4, 23, 0, 5 },
  { 6513, 13, 9, 17, 2, -43 },
  { 6528, 21, 32, 26, 2, -31 },
  { 6612, 23, 44, 28, 3, -43 },
  { 6739, 19, 32, 22, 2, -31 },
  { 6815, 23, 44, 28, 2, -43 },
  { 6942, 22, 32, 26, 2, -31 },
  { 7030, 19, 43, 17, 0, -43 },
  { 7133, 23, 44, 28, 2, -31 },
  { 7260, 22, 43, 28, 3, -43 },
  { 7379, 8, 43, 14, 3, -43 },
  { 7422, 13, 56, 14, -2, -43 },
  { 7513, 24, 43, 27, 3, -43 },
  { 7642, 7, 43, 14, 3, -43 },
  { 7680, 36, 31, 42, 3, -31 },
  { 7820, 22, 31, 28, 3, -31 },
  { 7906, 23, 32, 27, 2, -31 },
  { 7998, 23, 44, 28, 3, -31 },
  { 8125, 23, 44, 28, 2, -31 },
  { 8252, 16, 31, 19, 3, -31 },
  { 8314, 17, 32, 21, 2, -31 },
  { 8382, 16, 38, 18, 1, -37 },
  { 8458, 22, 32, 28, 3, -31 },
  { 8546, 25, 31, 25, 0, -31 },
  { 8643, 38, 31, 38, 0, -31 },
  { 8791, 24, 31, 24, 0, -31 },
  { 8884, 25, 44, 25, 0, -31 },
  { 9022, 18, 31, 20, 1, -31 },
  { 9092, 16, 49, 19, 1, -40 },
  { 9190, 7, 56, 25, 9, -43 },
  { 9239, 17, 49, 19, 2, -40 },
  { 9344, 24, 9, 26, 1, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Bold56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD56PT7B_H_
