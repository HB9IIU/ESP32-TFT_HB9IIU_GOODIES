#ifndef _NOTOSANS_EXTRACONDENSED_BOLD20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xEF, 0xDF, 0xBF, 0x7C, 0xE0,
  0x19, 0x86, 0xC1, 0xB0, 0x6C, 0x7F, 0xDF, 0xF1, 0x30, 0xCC, 0xFF, 0xBF,
  0xE3, 0x60, 0xD8, 0x36, 0x09, 0x80, 0x10, 0x79, 0xFF, 0xBD, 0x1E, 0x3C,
  0x3E, 0x1E, 0x2C, 0x5C, 0xBF, 0xEF, 0x84, 0x08, 0xF0, 0xC3, 0x63, 0x0D,
  0x98, 0x36, 0x60, 0xD9, 0x83, 0x6C, 0xCD, 0xB7, 0xBD, 0xB3, 0x06, 0xCC,
  0x1B, 0x30, 0xCC, 0xC3, 0x33, 0x0C, 0x78, 0x61, 0xE0, 0x3E, 0x07, 0xE1,
  0xCC, 0x1B, 0x83, 0x70, 0x7C, 0x0F, 0x3B, 0xE7, 0x6E, 0xDC, 0xFB, 0x8E,
  0x39, 0xC7, 0xFC, 0x7D, 0xC0, 0xFF, 0xFC, 0x39, 0x9C, 0xCE, 0x73, 0x18,
  0xC6, 0x31, 0xCE, 0x31, 0xC6, 0x38, 0xE3, 0x8C, 0x73, 0x8C, 0x63, 0x18,
  0xC6, 0x33, 0x98, 0xCE, 0xE0, 0x1C, 0x18, 0x6B, 0xFF, 0x1C, 0x36, 0x77,
  0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0x6C, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x10, 0x7C, 0x7E, 0xEE, 0xE6,
  0xC6, 0xC6, 0xC7, 0xC7, 0xC6, 0xC6, 0xE6, 0xEE, 0x7E, 0x7C, 0x1C, 0xF7,
  0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x7D, 0xFF, 0x38,
  0x30, 0xE1, 0xC3, 0x0E, 0x38, 0xE1, 0x87, 0x0F, 0xFF, 0xC0, 0xFD, 0xFE,
  0x38, 0x30, 0xE3, 0x9E, 0x3F, 0x0E, 0x0C, 0x1C, 0x7F, 0xFF, 0x80, 0x07,
  0x07, 0x83, 0xC3, 0xE1, 0x71, 0xB8, 0xDC, 0xCE, 0x67, 0x7F, 0xFF, 0xE0,
  0xE0, 0x70, 0x38, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xBF, 0xC7, 0x06, 0x0C,
  0x1C, 0x7F, 0xFF, 0x80, 0x3E, 0x7E, 0xE0, 0xE0, 0xC0, 0xDC, 0xFE, 0xE6,
  0xC7, 0xC7, 0xC7, 0xEE, 0x7E, 0x3C, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0x7C, 0xFE,
  0xE6, 0xC6, 0xEE, 0x7C, 0x38, 0x7C, 0xEE, 0xC7, 0xC7, 0xC6, 0xFE, 0x7C,
  0x7C, 0xFE, 0xEE, 0xC6, 0xC7, 0xC7, 0xEF, 0xFE, 0x76, 0x06, 0x0E, 0x0E,
  0xFC, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xFD,
  0x80, 0x00, 0x81, 0xC3, 0xE7, 0x8F, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0x80,
  0x40, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3E, 0x0F,
  0x1F, 0x7C, 0xF0, 0xC0, 0x80, 0xFD, 0xFD, 0x38, 0x70, 0xE3, 0x87, 0x1C,
  0x30, 0x00, 0x01, 0x83, 0x87, 0x00, 0x1F, 0xC1, 0xC7, 0x18, 0x0C, 0xCE,
  0x6C, 0xF9, 0x66, 0xCF, 0x66, 0x7B, 0x33, 0xD9, 0x96, 0xCD, 0xB3, 0xFD,
  0x8C, 0xC6, 0x00, 0x38, 0x20, 0xFF, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x7C,
  0x0F, 0x83, 0xB0, 0x76, 0x0C, 0xE1, 0x9C, 0x7F, 0x8F, 0xF1, 0xFF, 0x30,
  0xEE, 0x1D, 0xC3, 0xC0, 0xFE, 0x7F, 0xB9, 0xDC, 0x6E, 0x37, 0xFB, 0xF9,
  0xFE, 0xE3, 0xF1, 0xF8, 0xFC, 0xEF, 0xF7, 0xF0, 0x3F, 0x7F, 0x71, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x71, 0x7F, 0x3F, 0xFE, 0x7F,
  0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFD, 0xEF,
  0xF7, 0xE0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xBF, 0x7E, 0xE1, 0xC3, 0x87,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0x7E, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x00, 0x3F, 0xBF, 0xDC, 0x3C, 0x0E, 0x07, 0x03, 0x9F,
  0xCF, 0xE3, 0xF1, 0xF8, 0xEE, 0x77, 0xF9, 0xFC, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C,
  0xFD, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x7F, 0xF0, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0x80, 0xE3,
  0xF3, 0xB9, 0xDD, 0xCE, 0xE7, 0xE3, 0xF1, 0xFC, 0xFE, 0x73, 0x39, 0xDC,
  0xEE, 0x3F, 0x1C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0F, 0xFF, 0xC0, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xBF, 0x8D,
  0xFE, 0x6F, 0xB3, 0xFD, 0xB7, 0xED, 0xBF, 0x7D, 0xF9, 0xEF, 0xCE, 0x7E,
  0x73, 0xF3, 0x9C, 0xF0, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0x3E, 0xCF,
  0xBB, 0xE6, 0xF9, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x70, 0x08, 0x0F, 0xC7,
  0xF9, 0xCE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0x73, 0x9F, 0xE3, 0xF0, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xFE,
  0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x08, 0x0F, 0xC7, 0xF9, 0xCE, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE3,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0xFE, 0x7F, 0xB9, 0xDC, 0xEE, 0x77, 0x3B,
  0xFD, 0xFC, 0xEE, 0x77, 0x39, 0xDC, 0xEE, 0x3F, 0x1C, 0x7F, 0xFF, 0x96,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3E, 0x7F, 0xDF, 0x00, 0xFF, 0xFF,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xEE, 0x77, 0xF1, 0xF0, 0xE1, 0xF8, 0x76, 0x19, 0x86, 0x73, 0x9C, 0xE3,
  0x30, 0xCC, 0x3B, 0x0F, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE3, 0x8F,
  0xC7, 0x1F, 0x8E, 0x3B, 0x1C, 0x66, 0x6C, 0xCC, 0xDB, 0x9D, 0xB7, 0x3B,
  0x6E, 0x76, 0xD8, 0x7D, 0xB0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E,
  0x00, 0xE3, 0xB9, 0x9D, 0xC6, 0xE3, 0xE0, 0xF0, 0x70, 0x3C, 0x3E, 0x1F,
  0x0D, 0xCE, 0x66, 0x3F, 0x1C, 0xE3, 0xB1, 0xDC, 0xCE, 0xE3, 0x71, 0xF0,
  0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xFF, 0xFF, 0x06,
  0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0xFF, 0xFF, 0xFF,
  0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xF8, 0xE0, 0x60,
  0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x0C,
  0x03, 0x81, 0xE0, 0x7C, 0x3B, 0x0C, 0xE7, 0x1B, 0x87, 0xFF, 0xE7, 0x30,
  0xFC, 0xFD, 0x38, 0x33, 0xFF, 0xF9, 0xE3, 0xCF, 0xFF, 0xD8, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFE, 0xFF, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xE7, 0xFF,
  0xDE, 0x3E, 0xFB, 0x97, 0x0C, 0x18, 0x30, 0x70, 0xE2, 0xF9, 0xF0, 0x07,
  0x07, 0x07, 0x07, 0x7F, 0xFF, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7,
  0xFF, 0x7B, 0x3C, 0x7E, 0xE6, 0xC6, 0xFE, 0xFF, 0xC0, 0xC0, 0xE2, 0x7E,
  0x3E, 0x3E, 0x79, 0xC3, 0x87, 0xDF, 0x9C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x00, 0x7B, 0x7F, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7,
  0xFF, 0x7F, 0x07, 0x07, 0xCE, 0xFE, 0x78, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE,
  0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFD, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xC4, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x3F, 0xFD, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F, 0x3B,
  0xB9, 0xD8, 0xFC, 0x7E, 0x3F, 0x1D, 0xCE, 0x67, 0x3B, 0x8E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xDE, 0xF7, 0xFF, 0xF9, 0xCF, 0xCE, 0x7E, 0x73,
  0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCE, 0xDE, 0xFF,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x7E, 0xE7,
  0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7, 0x7E, 0x3C, 0xDE, 0xFF, 0xE7, 0xE7,
  0xE3, 0xE3, 0xE3, 0xE7, 0xE7, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x7B, 0x7F, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7, 0xFF, 0x7F, 0x07,
  0x07, 0x07, 0x07, 0x07, 0xDF, 0x7F, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x00, 0x7B, 0xFC, 0xB0, 0xF1, 0xE3, 0xC7, 0x9F, 0xFF, 0x80, 0x30, 0xC7,
  0xFF, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x3C, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0xE3, 0xF1, 0x98, 0xCC, 0xE7,
  0x71, 0xB0, 0xD8, 0x6C, 0x3E, 0x0E, 0x07, 0x00, 0xE7, 0x1F, 0x3C, 0xD9,
  0xEE, 0xCF, 0x77, 0x5B, 0x3E, 0xD8, 0xF2, 0xC7, 0x96, 0x3C, 0xF1, 0xE7,
  0x0E, 0x38, 0xE7, 0x67, 0x76, 0x3E, 0x3C, 0x1C, 0x3C, 0x3E, 0x76, 0x67,
  0xE7, 0xE3, 0xF1, 0x98, 0xCE, 0xE7, 0x71, 0xB0, 0xD8, 0x7C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0x83, 0xC1, 0xE0, 0xC0, 0x7E, 0xFC, 0x30, 0xE1, 0x87,
  0x0C, 0x38, 0x71, 0xFF, 0xF8, 0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0xBC, 0xE3,
  0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x1D, 0xE7, 0x1C, 0x71,
  0xC7, 0x3C, 0xE0, 0x30, 0xFF, 0xF7, 0xF0, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 10, 14, 10, 0, -14 },
  { 30, 7, 16, 9, 1, -15 },
  { 44, 14, 14, 15, 1, -14 },
  { 69, 11, 14, 11, 0, -14 },
  { 89, 3, 5, 5, 1, -14 },
  { 91, 5, 17, 6, 1, -14 },
  { 102, 5, 17, 6, 0, -14 },
  { 113, 8, 8, 9, 0, -15 },
  { 121, 8, 10, 9, 1, -12 },
  { 131, 3, 5, 5, 1, -2 },
  { 133, 5, 3, 6, 1, -7 },
  { 135, 3, 3, 5, 1, -3 },
  { 137, 8, 14, 8, 0, -14 },
  { 151, 8, 15, 9, 1, -15 },
  { 166, 6, 14, 9, 1, -14 },
  { 177, 7, 14, 9, 1, -14 },
  { 190, 7, 14, 9, 1, -14 },
  { 203, 9, 14, 9, 0, -14 },
  { 219, 7, 14, 9, 1, -14 },
  { 232, 8, 14, 9, 1, -14 },
  { 246, 9, 14, 9, 0, -14 },
  { 262, 8, 14, 9, 1, -14 },
  { 276, 8, 14, 9, 1, -14 },
  { 290, 3, 11, 5, 1, -11 },
  { 295, 3, 14, 5, 1, -11 },
  { 301, 9, 10, 9, 0, -12 },
  { 313, 8, 6, 9, 1, -10 },
  { 319, 8, 10, 9, 1, -12 },
  { 329, 7, 14, 7, 0, -14 },
  { 342, 13, 16, 14, 1, -14 },
  { 368, 11, 14, 11, 0, -14 },
  { 388, 9, 14, 11, 1, -14 },
  { 404, 8, 14, 10, 1, -14 },
  { 418, 9, 14, 11, 1, -14 },
  { 434, 7, 14, 9, 1, -14 },
  { 447, 7, 14, 9, 1, -14 },
  { 460, 9, 14, 11, 1, -14 },
  { 476, 9, 14, 12, 1, -14 },
  { 492, 6, 14, 6, 0, -14 },
  { 503, 5, 18, 5, -1, -14 },
  { 515, 9, 14, 10, 1, -14 },
  { 531, 7, 14, 8, 1, -14 },
  { 544, 13, 14, 15, 1, -14 },
  { 567, 10, 14, 13, 1, -14 },
  { 585, 10, 15, 12, 1, -15 },
  { 604, 8, 14, 10, 1, -14 },
  { 618, 10, 18, 12, 1, -15 },
  { 641, 9, 14, 10, 1, -14 },
  { 657, 7, 14, 8, 1, -14 },
  { 670, 8, 14, 9, 0, -14 },
  { 684, 9, 14, 11, 1, -14 },
  { 700, 10, 14, 10, 0, -14 },
  { 718, 15, 14, 15, 0, -14 },
  { 745, 9, 14, 9, 0, -14 },
  { 761, 9, 14, 9, 0, -14 },
  { 777, 8, 14, 8, 0, -14 },
  { 791, 5, 17, 6, 1, -14 },
  { 802, 8, 14, 8, 0, -14 },
  { 816, 5, 17, 6, 0, -14 },
  { 827, 10, 8, 11, 0, -14 },
  { 837, 8, 1, 8, 0, 2 },
  { 838, 4, 3, 6, 1, -15 },
  { 840, 7, 11, 9, 1, -11 },
  { 850, 8, 15, 10, 1, -15 },
  { 865, 7, 11, 8, 1, -11 },
  { 875, 8, 15, 10, 1, -15 },
  { 890, 8, 11, 9, 1, -11 },
  { 901, 7, 15, 6, 0, -15 },
  { 915, 8, 16, 10, 1, -11 },
  { 931, 8, 15, 10, 1, -15 },
  { 946, 3, 15, 5, 1, -15 },
  { 952, 5, 20, 5, -1, -15 },
  { 965, 9, 15, 10, 1, -15 },
  { 982, 3, 15, 5, 1, -15 },
  { 988, 13, 11, 15, 1, -11 },
  { 1006, 8, 11, 10, 1, -11 },
  { 1017, 8, 11, 10, 1, -11 },
  { 1028, 8, 16, 10, 1, -11 },
  { 1044, 8, 16, 10, 1, -11 },
  { 1060, 6, 11, 7, 1, -11 },
  { 1069, 6, 11, 7, 1, -11 },
  { 1078, 6, 13, 7, 0, -13 },
  { 1088, 8, 11, 10, 1, -11 },
  { 1099, 9, 11, 9, 0, -11 },
  { 1112, 13, 11, 14, 0, -11 },
  { 1130, 8, 11, 8, 0, -11 },
  { 1141, 9, 16, 9, 0, -11 },
  { 1159, 7, 11, 7, 0, -11 },
  { 1169, 6, 17, 7, 0, -14 },
  { 1182, 3, 20, 9, 3, -15 },
  { 1190, 6, 17, 7, 1, -14 },
  { 1203, 9, 4, 9, 0, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Bold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD20PT7B_H_
