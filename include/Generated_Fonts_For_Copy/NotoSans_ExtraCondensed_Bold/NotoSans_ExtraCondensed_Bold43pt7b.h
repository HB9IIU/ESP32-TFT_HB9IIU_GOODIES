#ifndef _NOTOSANS_EXTRACONDENSED_BOLD43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x10, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xBE, 0x3F, 0x7C, 0x3E, 0xF8, 0x79,
  0xE0, 0xF0, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0x8F,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x3C, 0x78, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0xFF, 0x9E, 0xFD, 0x82, 0xF9, 0x80, 0xF9, 0x80, 0xFD, 0x80, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F, 0x01, 0x9F, 0x81, 0x9F, 0xE1, 0xBF,
  0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xE0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x80, 0x3C, 0x00, 0xFF, 0x80, 0xF8, 0x03, 0xFF, 0x01, 0xE0, 0x07,
  0x9F, 0x03, 0xC0, 0x0F, 0x1E, 0x0F, 0x80, 0x3E, 0x3C, 0x1E, 0x00, 0x7C,
  0x78, 0x3C, 0x00, 0xF8, 0xF0, 0xF0, 0x01, 0xF1, 0xF1, 0xE0, 0x03, 0xE3,
  0xC7, 0xC0, 0x07, 0xC7, 0x8F, 0x00, 0x0F, 0x8F, 0x1E, 0x1E, 0x0F, 0x1E,
  0x7C, 0xFE, 0x1E, 0x7C, 0xF3, 0xFE, 0x3F, 0xF3, 0xE7, 0xFE, 0x3F, 0xE7,
  0x9F, 0x3C, 0x3F, 0x8F, 0x3C, 0x78, 0x3E, 0x3E, 0x78, 0xF8, 0x00, 0x78,
  0xF1, 0xF0, 0x00, 0xF1, 0xE3, 0xE0, 0x03, 0xC3, 0xC7, 0xC0, 0x07, 0x87,
  0x8F, 0x80, 0x1F, 0x0F, 0x1F, 0x00, 0x3C, 0x1E, 0x3E, 0x00, 0x78, 0x3C,
  0x7C, 0x01, 0xE0, 0x7C, 0xF0, 0x03, 0xC0, 0x7F, 0xE0, 0x0F, 0x80, 0xFF,
  0x80, 0x1E, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07,
  0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x7E, 0x3F, 0xF0, 0xFC, 0xFF, 0xF1,
  0xF9, 0xFB, 0xF3, 0xE7, 0xE3, 0xFF, 0xCF, 0xC7, 0xFF, 0x9F, 0x87, 0xFE,
  0x3F, 0x07, 0xFC, 0x7E, 0x0F, 0xF0, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x83,
  0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0x80,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x04, 0x3E, 0x13, 0x8F, 0x39, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0x01,
  0xF7, 0xC1, 0xFB, 0xF1, 0xF8, 0xFC, 0x3C, 0x7C, 0x0C, 0x18, 0x02, 0x08,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0x7C, 0xFC,
  0x3F, 0x7E, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xFC, 0x3F, 0x7E,
  0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFB, 0xE7, 0xCE, 0x3E, 0x23, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x9F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xE1, 0xF8, 0xC0, 0x7C, 0x20, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xC1, 0xF8,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xE7, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x07, 0x8F,
  0x81, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x1E, 0x0F, 0x87, 0x83, 0xE3,
  0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7D, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x79,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x9F, 0x07, 0xDF, 0xE7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x1F, 0xBF, 0x0F,
  0xCF, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE7, 0xC1,
  0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF0, 0xFC, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x87, 0xF3, 0xF1, 0xF8, 0x7E, 0x7C, 0x1F, 0xBF, 0x03, 0xEF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xBF, 0x03, 0xE7, 0xE3, 0xF9, 0xFF, 0xFC,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFD, 0xF8, 0x7E, 0xFE, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFB, 0xE1,
  0xF9, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x0C, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x31, 0xF7, 0xFF, 0xFF, 0xDF, 0xBE, 0x1C, 0x3E,
  0x3F, 0x7F, 0x7F, 0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x30, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEE, 0x0F, 0xC8, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0xFC,
  0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3E,
  0x3C, 0x0F, 0xC3, 0xCF, 0x07, 0xFE, 0x7D, 0xE1, 0xFF, 0xC7, 0xFC, 0x7E,
  0xF8, 0xFF, 0x0F, 0x0F, 0x1F, 0xE3, 0xE3, 0xE3, 0xFC, 0x7C, 0x7C, 0x7F,
  0x8F, 0x0F, 0x8F, 0xF1, 0xE1, 0xF1, 0xFE, 0x3C, 0x3E, 0x3F, 0xC7, 0x87,
  0xC7, 0xF8, 0xF0, 0xF0, 0xFF, 0x1E, 0x1E, 0x1F, 0xE3, 0xE7, 0xE7, 0xBC,
  0x3F, 0xFD, 0xF7, 0x87, 0xFB, 0xFC, 0xF8, 0x7F, 0x3F, 0x8F, 0x07, 0xC3,
  0xC1, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x10, 0x03, 0xF8, 0x1E, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x3F, 0x00,
  0x3E, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07,
  0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0x7E, 0xFC, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0x1F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0xC3, 0xF0, 0x11,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x63, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF9, 0xFF, 0x3F, 0x07, 0xF7, 0xE0,
  0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0x9F, 0x8F, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFC,
  0x0C, 0x3F, 0x80, 0x47, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x03,
  0xF3, 0xF8, 0x3F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xFA, 0x7F, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xC7, 0xE0,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9,
  0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x83,
  0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xFF,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0x78, 0x0F, 0x7F, 0xEF, 0x83, 0xEF, 0xFD, 0xF0,
  0x7D, 0xFF, 0xBE, 0x0F, 0xBF, 0xF3, 0xC1, 0xE7, 0xFE, 0x7C, 0x7C, 0xFF,
  0xCF, 0x8F, 0x9F, 0xF9, 0xF1, 0xE3, 0xFF, 0x1E, 0x3C, 0x7F, 0xE3, 0xEF,
  0x8F, 0xFC, 0x7D, 0xF1, 0xFF, 0x8F, 0xBC, 0x3F, 0xF0, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0x83, 0xFF, 0x07, 0xF0,
  0x7F, 0xE0, 0xFE, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x3F, 0xF0,
  0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xF8, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFE, 0xF8, 0x3F, 0xF7,
  0xE1, 0xFF, 0x9F, 0x0F, 0xFC, 0xF8, 0x7F, 0xE7, 0xE3, 0xFF, 0x1F, 0x1F,
  0xF8, 0xFC, 0xFF, 0xC3, 0xE7, 0xFE, 0x1F, 0xBF, 0xF0, 0xFD, 0xFF, 0x83,
  0xEF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F,
  0x80, 0xFE, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7F, 0x03,
  0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE7, 0xFB, 0xF0, 0xFD, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFB,
  0xF1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFE, 0x7E, 0x01,
  0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7F, 0x03, 0xF0, 0xFE, 0x1F, 0xC3,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF9, 0xFE, 0x3F,
  0x0F, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x3E, 0x7E,
  0x04, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x3F, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x7D, 0xF0,
  0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x01, 0xF0, 0x0F, 0xDF, 0x00, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x1F, 0x8F, 0x80, 0xFE, 0x07,
  0xE3, 0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x1F, 0xE0, 0xFC, 0x3F, 0x07, 0xF8,
  0x3F, 0x0F, 0xC1, 0xFE, 0x0F, 0xC1, 0xF0, 0x7F, 0xC3, 0xF0, 0x7C, 0x3F,
  0xF0, 0xF8, 0x1F, 0x0F, 0xFC, 0x3E, 0x07, 0xE3, 0xCF, 0x1F, 0x81, 0xF8,
  0xF3, 0xC7, 0xE0, 0x7E, 0x7C, 0xF1, 0xF8, 0x0F, 0x9F, 0x3E, 0x7C, 0x03,
  0xE7, 0xCF, 0x9F, 0x00, 0xF9, 0xF3, 0xEF, 0xC0, 0x3F, 0x78, 0x7B, 0xF0,
  0x0F, 0xDE, 0x1E, 0xFC, 0x01, 0xFF, 0x87, 0xBE, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7E,
  0x07, 0xF7, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF8, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0xFD, 0xF0, 0x0F, 0xDF, 0x81, 0xF9, 0xF8, 0x1F,
  0x8F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7F, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0,
  0xFC, 0x1F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFD, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x7C, 0x03, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0,
  0xC1, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0xC3, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFD, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xF7, 0xFF, 0xFB, 0xFF, 0x7C,
  0xFF, 0x3E, 0x3F, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x1E, 0x0F, 0xDF, 0xE3, 0xF7, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF,
  0xF1, 0xFB, 0xF8, 0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFB, 0xF8, 0x7E, 0xFF, 0xBF, 0xBF, 0xFF, 0xCF,
  0xFF, 0xF3, 0xE7, 0xF8, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xF3, 0xFF,
  0xCF, 0xFF, 0x7F, 0xF9, 0xF8, 0x2F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x5F, 0xCF, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3,
  0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xC7, 0xC7, 0xF3,
  0xE7, 0xFD, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87,
  0xF7, 0xF7, 0xFB, 0xFF, 0xFD, 0xFF, 0xBE, 0x7F, 0xDF, 0x1F, 0xCF, 0x80,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3E,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x02, 0x7F, 0x0E, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC,
  0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7E, 0x21, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x8F,
  0x8F, 0xE7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xEF, 0xEF, 0xF7, 0xFF, 0xFB, 0xFF, 0x7C, 0xFF, 0x3E, 0x3F,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF4, 0x03, 0xF3,
  0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x3C, 0x3F, 0x7F, 0x9F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0x39, 0xFF,
  0xFF, 0xFD, 0xF1, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x08, 0x00, 0x00, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x3F, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x81,
  0xFB, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xF0,
  0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xE0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x87,
  0xE3, 0xE1, 0xF8, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x7E,
  0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7C, 0x1F, 0x0F, 0x9F, 0xE3, 0xFC, 0xFB,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xF3, 0xFC,
  0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x78, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF,
  0xE7, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0xF8, 0x78,
  0x3E, 0x7F, 0x8F, 0x9F, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xEF,
  0xE1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x83, 0xEF, 0xE1, 0xFB, 0xFE, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF,
  0xDF, 0xE3, 0xF3, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x8F, 0x8F, 0xE7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xEF, 0xEF, 0xF7, 0xFF, 0xFB,
  0xFF, 0x7C, 0xFF, 0x3E, 0x3F, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x7F, 0xC7, 0xBE, 0x7D, 0xF7, 0xEF, 0xFF,
  0x7F, 0xFB, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF,
  0xDF, 0xFE, 0xFF, 0xFB, 0xF0, 0x4F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F,
  0xF8, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03,
  0xFB, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x8F, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xBE, 0x3F, 0x8F, 0xFC, 0x07,
  0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F,
  0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x1F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFB, 0xE0,
  0xFE, 0x0F, 0xDF, 0x07, 0xF0, 0x7C, 0xFC, 0x3F, 0x83, 0xE7, 0xE1, 0xFE,
  0x3F, 0x1F, 0x1E, 0xF1, 0xF8, 0xF8, 0xF7, 0x8F, 0x87, 0xC7, 0xBC, 0x7C,
  0x3F, 0x3D, 0xE3, 0xE1, 0xF9, 0xE7, 0xBF, 0x07, 0xDE, 0x3D, 0xF8, 0x3E,
  0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C, 0x0F, 0xBC, 0x7B, 0xE0, 0x3D, 0xE1,
  0xDF, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xDF, 0x87, 0xE3,
  0xF1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xEF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xCF, 0xC3,
  0xF3, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x9F, 0x87, 0xEF, 0xC0, 0xFC, 0xFC,
  0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x7C,
  0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7C, 0x0F, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x1F, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xF0,
  0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFC, 0x0F, 0x00, 0x1C, 0x00, 0x5F, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 31, 11, 2, -31 },
  { 29, 15, 11, 19, 2, -31 },
  { 50, 20, 31, 22, 1, -31 },
  { 128, 16, 36, 20, 2, -33 },
  { 200, 31, 31, 33, 1, -31 },
  { 321, 23, 31, 24, 1, -31 },
  { 411, 6, 11, 10, 2, -31 },
  { 420, 11, 38, 14, 2, -31 },
  { 473, 11, 38, 14, 1, -31 },
  { 526, 17, 18, 19, 1, -33 },
  { 565, 18, 21, 20, 1, -26 },
  { 613, 8, 11, 11, 1, -5 },
  { 624, 11, 5, 13, 1, -14 },
  { 631, 7, 7, 11, 2, -7 },
  { 638, 17, 31, 17, 0, -31 },
  { 704, 17, 31, 20, 1, -31 },
  { 770, 13, 31, 20, 2, -31 },
  { 821, 17, 31, 20, 1, -31 },
  { 887, 17, 31, 20, 1, -31 },
  { 953, 18, 31, 20, 1, -31 },
  { 1023, 16, 31, 20, 2, -31 },
  { 1085, 17, 31, 20, 1, -31 },
  { 1151, 18, 31, 20, 1, -31 },
  { 1221, 18, 31, 20, 1, -31 },
  { 1291, 17, 31, 20, 1, -31 },
  { 1357, 7, 24, 11, 2, -24 },
  { 1378, 8, 30, 11, 1, -24 },
  { 1408, 18, 21, 20, 1, -26 },
  { 1456, 18, 13, 20, 1, -22 },
  { 1486, 18, 21, 20, 1, -26 },
  { 1534, 15, 31, 16, 0, -31 },
  { 1593, 27, 34, 31, 2, -31 },
  { 1708, 23, 31, 23, 0, -31 },
  { 1798, 18, 31, 23, 3, -31 },
  { 1868, 18, 31, 21, 2, -31 },
  { 1938, 19, 31, 24, 3, -31 },
  { 2012, 14, 31, 19, 3, -31 },
  { 2067, 14, 31, 19, 3, -31 },
  { 2122, 20, 31, 24, 2, -31 },
  { 2200, 19, 31, 25, 3, -31 },
  { 2274, 12, 31, 14, 1, -31 },
  { 2321, 11, 40, 12, -2, -31 },
  { 2376, 19, 31, 22, 3, -31 },
  { 2450, 14, 31, 17, 3, -31 },
  { 2505, 27, 31, 33, 3, -31 },
  { 2610, 21, 31, 27, 3, -31 },
  { 2692, 22, 31, 26, 2, -31 },
  { 2778, 17, 31, 21, 3, -31 },
  { 2844, 22, 38, 26, 2, -31 },
  { 2949, 19, 31, 22, 3, -31 },
  { 3023, 16, 31, 18, 1, -31 },
  { 3085, 17, 31, 18, 1, -31 },
  { 3151, 19, 31, 25, 3, -31 },
  { 3225, 22, 31, 22, 0, -31 },
  { 3311, 34, 31, 32, -1, -31 },
  { 3443, 20, 31, 20, 0, -31 },
  { 3521, 20, 31, 20, 0, -31 },
  { 3599, 16, 31, 18, 1, -31 },
  { 3661, 10, 38, 13, 2, -31 },
  { 3709, 17, 31, 17, 0, -31 },
  { 3775, 10, 38, 13, 1, -31 },
  { 3823, 21, 19, 23, 1, -31 },
  { 3873, 18, 3, 18, 0, 4 },
  { 3880, 10, 7, 13, 2, -33 },
  { 3889, 17, 24, 20, 1, -24 },
  { 3940, 18, 33, 22, 2, -33 },
  { 4015, 14, 24, 17, 2, -24 },
  { 4057, 17, 33, 22, 2, -33 },
  { 4128, 16, 24, 20, 2, -24 },
  { 4176, 14, 33, 13, 0, -33 },
  { 4234, 17, 34, 22, 2, -24 },
  { 4307, 17, 33, 22, 2, -33 },
  { 4378, 6, 33, 10, 2, -33 },
  { 4403, 9, 43, 10, -1, -33 },
  { 4452, 18, 33, 21, 3, -33 },
  { 4527, 6, 33, 10, 2, -33 },
  { 4552, 28, 24, 32, 2, -24 },
  { 4636, 17, 24, 22, 2, -24 },
  { 4687, 17, 24, 21, 2, -24 },
  { 4738, 18, 34, 22, 2, -24 },
  { 4815, 17, 34, 22, 2, -24 },
  { 4888, 13, 24, 15, 2, -24 },
  { 4927, 14, 24, 16, 1, -24 },
  { 4969, 12, 28, 14, 1, -28 },
  { 5011, 17, 24, 22, 2, -24 },
  { 5062, 19, 24, 19, 0, -24 },
  { 5119, 29, 23, 29, 0, -23 },
  { 5203, 18, 23, 18, 0, -23 },
  { 5255, 19, 34, 19, 0, -24 },
  { 5336, 14, 24, 15, 1, -24 },
  { 5378, 13, 38, 15, 0, -31 },
  { 5440, 5, 43, 19, 7, -33 },
  { 5467, 12, 38, 15, 2, -31 },
  { 5524, 18, 7, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Bold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD43PT7B_H_
