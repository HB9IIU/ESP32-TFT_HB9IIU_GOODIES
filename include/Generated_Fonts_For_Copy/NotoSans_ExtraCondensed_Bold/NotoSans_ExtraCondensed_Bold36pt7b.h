#ifndef _NOTOSANS_EXTRACONDENSED_BOLD36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B,
  0xC0, 0x02, 0x7F, 0xFF, 0xFF, 0xC0, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x07, 0x9C, 0x03,
  0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x3C, 0xF0,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xC7, 0x00, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC3, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x79, 0xC0,
  0x38, 0xE0, 0x1C, 0x70, 0x00, 0x01, 0x00, 0x04, 0x00, 0x3C, 0x07, 0xFE,
  0x3F, 0xFD, 0xFF, 0xE7, 0xD3, 0x9E, 0x42, 0x79, 0x01, 0xE4, 0x07, 0xD0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x05,
  0xF0, 0x13, 0xE0, 0x4F, 0xC1, 0x3F, 0xE7, 0xFF, 0xFF, 0xBF, 0xFC, 0x3F,
  0xE0, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x1E, 0x00, 0xF0, 0x0F,
  0xE0, 0x38, 0x07, 0xF8, 0x1E, 0x01, 0xEF, 0x07, 0x00, 0xF3, 0xC3, 0xC0,
  0x3C, 0xF0, 0xF0, 0x0F, 0x1C, 0x38, 0x03, 0xC7, 0x1E, 0x00, 0xF1, 0xC7,
  0x00, 0x3C, 0x73, 0xC0, 0x0F, 0x3C, 0xF1, 0xC3, 0xCF, 0x39, 0xFC, 0x7B,
  0xDE, 0x7F, 0x1F, 0xE7, 0xBF, 0xE3, 0xF9, 0xCF, 0x38, 0x78, 0xF3, 0x8E,
  0x00, 0x38, 0xE3, 0xC0, 0x1E, 0x78, 0xF0, 0x07, 0x9E, 0x3C, 0x01, 0xC7,
  0x8F, 0x00, 0xF0, 0xE3, 0xC0, 0x38, 0x38, 0xE0, 0x1E, 0x0F, 0x78, 0x07,
  0x83, 0xFE, 0x01, 0xC0, 0x7F, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xF8, 0x3C, 0x7F, 0x8F, 0x9F, 0xF9, 0xF7, 0xFF, 0x3E, 0xF9,
  0xF7, 0x9F, 0x1F, 0xF3, 0xE3, 0xFE, 0x7C, 0x3F, 0x8F, 0x83, 0xF1, 0xF8,
  0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF7, 0xC3, 0xFC, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0x80, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1,
  0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E,
  0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x11, 0xE2, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8,
  0x0F, 0xC0, 0x7F, 0x83, 0xCF, 0x1F, 0x3E, 0x38, 0x70, 0x21, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0xBC, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x27, 0xFF, 0xFF, 0xFC,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x7C, 0xF9, 0xF1, 0xE7, 0x87, 0xDE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0xDE, 0x1F, 0x7C, 0x7D, 0xF3,
  0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0x01, 0xE0, 0x7C, 0x1F,
  0x87, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xDF, 0x73, 0xE4, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xFF, 0x87,
  0xFF, 0x3F, 0xFE, 0x78, 0xF8, 0x81, 0xF2, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFE, 0x70, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x3F, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF1, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0E, 0xF8, 0x3D, 0xF0, 0x73,
  0xE1, 0xE7, 0xC3, 0x8F, 0x8F, 0x1F, 0x1C, 0x3E, 0x78, 0x7C, 0xF0, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF1, 0xFF,
  0xCF, 0xFF, 0x7F, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE7, 0x8F, 0xBF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0x7C,
  0x7D, 0xF1, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1F,
  0x3C, 0x3E, 0x7C, 0x7C, 0xFD, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x03,
  0xFE, 0x0F, 0xFE, 0x3E, 0x7C, 0x78, 0x7D, 0xF0, 0xFB, 0xE0, 0xF7, 0xC1,
  0xFF, 0x83, 0xDF, 0x0F, 0xBF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFD, 0xFF,
  0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xE7, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0x77, 0xFF,
  0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9F, 0xFF, 0xFE, 0xF0, 0x39,
  0xF7, 0xDF, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D,
  0xF7, 0xDF, 0x7D, 0xE7, 0xBC, 0xF0, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x1F,
  0x80, 0x3C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x1F, 0x83, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE7, 0x1F, 0xA0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xC1, 0xF8, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x3C,
  0x3F, 0x9E, 0x78, 0x7F, 0x8E, 0x78, 0xFF, 0x8E, 0x71, 0xE3, 0x8E, 0x71,
  0xE3, 0x8F, 0x71, 0xC3, 0x8F, 0xF1, 0xC7, 0x8F, 0xF3, 0xC7, 0x8F, 0xF3,
  0xC7, 0x8E, 0xF1, 0xC7, 0x8E, 0xF1, 0xC7, 0x8E, 0x71, 0xE7, 0x9E, 0x71,
  0xFD, 0xFC, 0x78, 0xFD, 0xF8, 0x78, 0x78, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x20, 0x0F, 0x81, 0xE0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D, 0xE0,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0x78, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xC0, 0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x00, 0x7C, 0xFF, 0x80, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFC, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xF1, 0xCF, 0xC0, 0x9F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC1, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC3,
  0xF3, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0x87, 0xE7, 0xC7, 0xF3, 0xFF,
  0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x01, 0xFC, 0x07, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x86, 0x7E, 0x02, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0x7C, 0x1F, 0x7E, 0x1F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xF3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x38,
  0x00, 0xF0, 0x3F, 0xF0, 0x3E, 0xF0, 0x7E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1,
  0xF8, 0xF1, 0xF0, 0xF3, 0xF0, 0xF3, 0xE0, 0xF7, 0xE0, 0xF7, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFB, 0xF0, 0xF1,
  0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0,
  0x7E, 0xF0, 0x3E, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xBF, 0xDE, 0x1E, 0xFF,
  0x78, 0x7B, 0xFD, 0xE1, 0xCF, 0xF7, 0x8F, 0x3F, 0xCF, 0x3C, 0xFF, 0x3C,
  0xF3, 0xFC, 0xF7, 0x8F, 0xF3, 0xDE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0x83, 0xFC,
  0x3E, 0x0F, 0xF0, 0xF8, 0x3F, 0xC1, 0xE0, 0xF0, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x87, 0xFB, 0xC3, 0xFD, 0xF1, 0xFE, 0xF8, 0xFF, 0x3C, 0x7F,
  0x9F, 0x3F, 0xC7, 0x9F, 0xE3, 0xEF, 0xF1, 0xF7, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x07, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xF0,
  0x3E, 0x7C, 0x1F, 0x9F, 0x8F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF,
  0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7,
  0xC3, 0xEF, 0x9F, 0xDF, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0x81, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7E, 0x3F, 0x1F, 0x07, 0xEF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xF0,
  0x3E, 0x7C, 0x1F, 0x9F, 0x8F, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFB, 0xFC, 0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xE0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0x0F, 0xC0, 0xFF, 0xCF,
  0xFE, 0xFF, 0xF7, 0xEF, 0x7E, 0x0B, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF,
  0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF8, 0x03, 0xFE, 0x01,
  0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x7C, 0x07, 0x9F, 0x03, 0xE3, 0xC0, 0xF8,
  0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0x7B, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF0, 0x1F, 0x03, 0xFF, 0x03,
  0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x3C,
  0xF0, 0x7F, 0x0F, 0x9E, 0x0F, 0xE1, 0xF3, 0xE1, 0xFC, 0x3E, 0x7C, 0x3B,
  0x87, 0xCF, 0x87, 0x70, 0xF0, 0xF1, 0xEE, 0x1E, 0x1E, 0x3D, 0xE7, 0xC3,
  0xE7, 0xBC, 0xF8, 0x7C, 0xF7, 0x9F, 0x0F, 0xBC, 0xF3, 0xE0, 0xF7, 0x8E,
  0x78, 0x1E, 0xF1, 0xFF, 0x03, 0xDE, 0x3F, 0xE0, 0x7B, 0xC7, 0xFC, 0x0F,
  0xF0, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0x87, 0xC7, 0xC3, 0xE3, 0xE0, 0xF3, 0xE0,
  0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xFE, 0x07, 0xDF,
  0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x78,
  0x1F, 0x7C, 0x0F, 0xBE, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1E, 0xF0, 0x1F, 0x7C, 0x0F, 0x1E,
  0x0F, 0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x3E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x10, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xFD, 0xFD, 0xFE, 0xF7, 0xFB, 0xCF,
  0xCF, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0xF0, 0xFB, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xE3, 0xEF,
  0x87, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xDF, 0x0F, 0xBF, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9,
  0xEF, 0xF3, 0xCF, 0xC0, 0x07, 0xE0, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xE2,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x82, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x87, 0x9F, 0x1F, 0xBE, 0x7F, 0xFD, 0xFF, 0xFB, 0xE3, 0xF7,
  0xC3, 0xEF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0x87, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE,
  0x7F, 0xBC, 0x7E, 0x78, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7C,
  0x7D, 0xE0, 0xF7, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x01, 0x7F, 0x78, 0xFF, 0xE1,
  0xFF, 0x83, 0xFE, 0x01, 0x00, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0xE7, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x1E, 0x3F,
  0x3C, 0xFF, 0x7B, 0xFF, 0xF7, 0xC7, 0xEF, 0x87, 0xDE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xDF,
  0x0F, 0xBE, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0xFD, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xA0, 0x3E, 0x7D, 0xFC, 0xFF, 0xF1, 0xFF, 0xE1,
  0xFF, 0x00, 0x70, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x78, 0xFF, 0xFB, 0xDF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xC0, 0xFF, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x1F, 0x1F,
  0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xBF, 0xFE, 0xFE, 0xFC, 0x70, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0xF9, 0xF0, 0xFB,
  0xE0, 0xFB, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFD,
  0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x3E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF1, 0xE0, 0xF1, 0xEF,
  0xF7, 0xFB, 0xDF, 0xEF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xE7, 0xFF, 0x0F,
  0x87, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8,
  0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87,
  0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F,
  0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xF0, 0xF1, 0xE3, 0xDF, 0xEF, 0x7F, 0xBF,
  0xFF, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF,
  0xE7, 0xC7, 0xCF, 0x87, 0xDE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x07, 0xDF, 0x0F, 0xBE, 0x3E, 0x3F,
  0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x00, 0xF1, 0xE1, 0xE7, 0xE3, 0xDF,
  0xE7, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xBE, 0x1F, 0x7E,
  0x3E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xDF, 0x8F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x0F, 0x1E, 0x3F, 0x3C, 0xFF, 0x7B, 0xFF, 0xF7, 0xC7, 0xEF,
  0x87, 0xDE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xDF, 0x0F, 0xBE, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF8, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xF1, 0xFC, 0xFF,
  0x7F, 0xDF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x1F, 0x87,
  0xFD, 0xFF, 0xFF, 0xFF, 0x85, 0xF0, 0x3E, 0x07, 0xE0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x07, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xC0, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xF7, 0xFB, 0xCF, 0xCF, 0xF8, 0x1F,
  0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0xF8, 0x7E, 0x1F, 0x78, 0x7E, 0x1F, 0x78,
  0x7E, 0x1F, 0x7C, 0x7F, 0x1E, 0x7C, 0x7F, 0x1E, 0x3C, 0xF7, 0x3E, 0x3C,
  0xF7, 0x3E, 0x3E, 0xE7, 0x3C, 0x3E, 0xE7, 0x3C, 0x3E, 0xE7, 0xBC, 0x1E,
  0xE3, 0xFC, 0x1E, 0xE3, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0xF8, 0x3E, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xEF, 0x83,
  0xDF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFF, 0x03, 0xFE, 0x07, 0xBE, 0x1F, 0x7C, 0x3C, 0x7C, 0xF8, 0xF9,
  0xF1, 0xF7, 0xC1, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0xFC, 0x1F, 0x87, 0xF0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x3E, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFE, 0x0F, 0xC1,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x83, 0xF8,
  0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x3E, 0x03, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x06, 0x00, 0x18, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xF0, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 12, 10, 16, 2, -26 },
  { 33, 17, 26, 18, 1, -26 },
  { 89, 14, 29, 17, 1, -27 },
  { 140, 26, 26, 28, 1, -26 },
  { 225, 19, 26, 20, 1, -26 },
  { 287, 5, 10, 8, 2, -26 },
  { 294, 9, 32, 11, 2, -26 },
  { 330, 10, 32, 11, 0, -26 },
  { 370, 14, 14, 16, 1, -27 },
  { 395, 15, 17, 17, 1, -21 },
  { 427, 6, 9, 9, 1, -4 },
  { 434, 9, 5, 11, 1, -12 },
  { 440, 5, 6, 9, 2, -6 },
  { 444, 14, 26, 15, 0, -26 },
  { 490, 14, 26, 17, 1, -26 },
  { 536, 11, 26, 17, 2, -26 },
  { 572, 14, 26, 17, 1, -26 },
  { 618, 14, 26, 17, 1, -26 },
  { 664, 15, 26, 17, 1, -26 },
  { 713, 13, 26, 17, 2, -26 },
  { 756, 14, 26, 17, 1, -26 },
  { 802, 15, 26, 17, 1, -26 },
  { 851, 15, 26, 17, 1, -26 },
  { 900, 14, 26, 17, 1, -26 },
  { 946, 5, 20, 9, 2, -20 },
  { 959, 6, 25, 9, 1, -20 },
  { 978, 15, 17, 17, 1, -21 },
  { 1010, 15, 11, 17, 1, -18 },
  { 1031, 15, 17, 17, 1, -21 },
  { 1063, 13, 26, 13, 0, -26 },
  { 1106, 24, 29, 26, 1, -26 },
  { 1193, 19, 26, 19, 0, -26 },
  { 1255, 16, 26, 19, 2, -26 },
  { 1307, 15, 26, 17, 2, -26 },
  { 1356, 17, 26, 20, 2, -26 },
  { 1412, 11, 26, 16, 3, -26 },
  { 1448, 11, 26, 16, 3, -26 },
  { 1484, 16, 26, 20, 2, -26 },
  { 1536, 16, 26, 21, 3, -26 },
  { 1588, 9, 26, 11, 1, -26 },
  { 1618, 9, 34, 10, -2, -26 },
  { 1657, 16, 26, 19, 3, -26 },
  { 1709, 12, 26, 15, 2, -26 },
  { 1748, 22, 26, 28, 3, -26 },
  { 1820, 17, 26, 23, 3, -26 },
  { 1876, 18, 26, 21, 2, -26 },
  { 1935, 15, 26, 18, 2, -26 },
  { 1984, 18, 32, 21, 2, -26 },
  { 2056, 16, 26, 18, 2, -26 },
  { 2108, 13, 26, 15, 1, -26 },
  { 2151, 15, 26, 15, 0, -26 },
  { 2200, 16, 26, 21, 2, -26 },
  { 2252, 18, 26, 18, 0, -26 },
  { 2311, 27, 26, 27, 0, -26 },
  { 2399, 17, 26, 17, 0, -26 },
  { 2455, 17, 26, 17, 0, -26 },
  { 2511, 14, 26, 15, 0, -26 },
  { 2557, 8, 32, 11, 2, -26 },
  { 2589, 14, 26, 15, 0, -26 },
  { 2635, 8, 32, 11, 1, -26 },
  { 2667, 17, 16, 19, 1, -26 },
  { 2701, 15, 3, 15, 0, 3 },
  { 2707, 9, 6, 11, 1, -28 },
  { 2714, 14, 20, 17, 1, -20 },
  { 2749, 15, 27, 18, 2, -27 },
  { 2800, 13, 20, 14, 1, -20 },
  { 2833, 15, 27, 18, 1, -27 },
  { 2884, 14, 20, 16, 1, -20 },
  { 2919, 12, 28, 11, 0, -28 },
  { 2961, 15, 29, 18, 1, -20 },
  { 3016, 14, 27, 18, 2, -27 },
  { 3064, 5, 27, 9, 2, -27 },
  { 3081, 8, 36, 9, -1, -27 },
  { 3117, 16, 27, 17, 2, -27 },
  { 3171, 5, 27, 9, 2, -27 },
  { 3188, 23, 20, 27, 2, -20 },
  { 3246, 14, 20, 18, 2, -20 },
  { 3281, 15, 20, 18, 1, -20 },
  { 3319, 15, 29, 18, 2, -20 },
  { 3374, 15, 29, 18, 1, -20 },
  { 3429, 10, 20, 12, 2, -20 },
  { 3454, 11, 20, 13, 1, -20 },
  { 3482, 11, 24, 12, 0, -24 },
  { 3515, 14, 20, 18, 2, -20 },
  { 3550, 16, 20, 16, 0, -20 },
  { 3590, 24, 20, 24, 0, -20 },
  { 3650, 15, 20, 15, 0, -20 },
  { 3688, 16, 29, 16, 0, -20 },
  { 3746, 11, 20, 13, 1, -20 },
  { 3774, 11, 32, 12, 0, -26 },
  { 3818, 4, 36, 16, 6, -28 },
  { 3836, 11, 32, 12, 1, -26 },
  { 3880, 15, 6, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Bold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD36PT7B_H_
