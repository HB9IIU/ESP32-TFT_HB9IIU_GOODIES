#ifndef _NOTOSANS_EXTRACONDENSED_BOLD12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xBB, 0xBB, 0x28, 0xA2, 0x9F, 0x3B, 0xFF, 0xD4, 0x50,
  0x23, 0xDA, 0xC7, 0x0E, 0xBF, 0x21, 0x00, 0x62, 0x3A, 0x35, 0x1B, 0x87,
  0xB3, 0x54, 0x7A, 0x25, 0x33, 0x00, 0x30, 0xF1, 0x63, 0x86, 0x5E, 0xB7,
  0x6E, 0x76, 0xF0, 0x6B, 0x49, 0x24, 0x99, 0x80, 0xC9, 0x92, 0x49, 0x6B,
  0x00, 0x27, 0xDC, 0xB5, 0x00, 0x21, 0x3E, 0x42, 0x10, 0x5C, 0xFC, 0xC0,
  0x18, 0x84, 0x62, 0x31, 0x08, 0xC0, 0x33, 0xD7, 0xBC, 0xE5, 0x6B, 0x70,
  0x2F, 0xD2, 0x49, 0x20, 0x37, 0xD6, 0x31, 0x19, 0x88, 0xF8, 0x77, 0xC6,
  0x36, 0x0C, 0x73, 0xF0, 0x19, 0xCE, 0xF5, 0xEF, 0xE3, 0x18, 0xFF, 0x88,
  0xF3, 0x3B, 0xE0, 0x1B, 0xD1, 0xAF, 0xE7, 0x2B, 0x70, 0xFF, 0xC6, 0x31,
  0x18, 0xC4, 0x60, 0x33, 0xD6, 0xB3, 0x2F, 0x3B, 0x70, 0x33, 0xF7, 0x9D,
  0xB4, 0x63, 0x70, 0xC6, 0x48, 0x00, 0x52, 0xC0, 0x09, 0xF8, 0xE1, 0x84,
  0xF8, 0x3F, 0xF0, 0xC3, 0x86, 0x6C, 0x40, 0x6F, 0x13, 0x26, 0x06, 0x60,
  0x1C, 0x32, 0x41, 0x5D, 0x55, 0xF5, 0x55, 0x5A, 0x62, 0x3E, 0x30, 0xC3,
  0x9E, 0x69, 0x27, 0xF3, 0xCC, 0xE7, 0xA7, 0x3F, 0x4E, 0x73, 0xF0, 0x3F,
  0xB1, 0x08, 0x42, 0x1A, 0x70, 0xE7, 0xA7, 0x39, 0xCE, 0x77, 0xF0, 0xFF,
  0x88, 0xE8, 0x88, 0xF0, 0xFF, 0x88, 0xEE, 0x88, 0x80, 0x37, 0xF1, 0x0B,
  0xDE, 0x7B, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xED, 0xB6, 0xDB,
  0xE0, 0x24, 0x92, 0x49, 0x27, 0xA0, 0x9C, 0xED, 0x6E, 0x7A, 0xD3, 0x98,
  0x88, 0x88, 0x88, 0x88, 0xF0, 0xC7, 0x8F, 0x9D, 0x7A, 0xB5, 0x6E, 0xCD,
  0x92, 0xCF, 0x3E, 0xEB, 0xAE, 0xF9, 0xE7, 0x8C, 0x73, 0xEC, 0xA3, 0x8E,
  0x38, 0xB6, 0x70, 0xE7, 0xA5, 0x3B, 0x7A, 0x10, 0x80, 0x73, 0xEC, 0xA3,
  0x8E, 0x38, 0xB6, 0x70, 0x61, 0x80, 0xE7, 0xA7, 0x3F, 0x72, 0xD2, 0x98,
  0x33, 0xF0, 0x87, 0x18, 0x7B, 0xF0, 0xFF, 0xC8, 0x42, 0x10, 0x84, 0x20,
  0x9C, 0xE7, 0x39, 0xCE, 0x7B, 0x70, 0xC7, 0x34, 0xD2, 0x49, 0xE3, 0x8C,
  0x30, 0x89, 0xE4, 0xF7, 0x7A, 0xA5, 0x52, 0xA9, 0x5C, 0xEE, 0x67, 0x00,
  0xC9, 0x67, 0x9C, 0x30, 0xC7, 0x96, 0xCC, 0xCF, 0x25, 0x9E, 0x30, 0xC3,
  0x0C, 0x30, 0xFF, 0xC4, 0x62, 0x31, 0x18, 0xF8, 0xFA, 0xAA, 0xAC, 0xC2,
  0x10, 0xC2, 0x10, 0xC2, 0x18, 0xFC, 0x92, 0x49, 0x27, 0x80, 0x10, 0xC3,
  0x9A, 0x4F, 0x10, 0xF8, 0xE4, 0x33, 0xC6, 0xFD, 0xED, 0xA0, 0x84, 0x29,
  0xE9, 0x4E, 0x7A, 0xF0, 0x3B, 0x91, 0x8C, 0x25, 0xC0, 0x08, 0x4A, 0xF4,
  0xE7, 0x2B, 0x78, 0x33, 0xD3, 0xFC, 0x25, 0xE0, 0x74, 0x7F, 0x44, 0x44,
  0x40, 0x2B, 0xD3, 0x9C, 0xAD, 0xE1, 0x5B, 0x80, 0x88, 0xAF, 0x99, 0x99,
  0x90, 0xFF, 0x80, 0x55, 0x55, 0x5F, 0x84, 0x27, 0x6A, 0x73, 0xD6, 0x98,
  0xFF, 0x80, 0xA5, 0xFE, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xAF, 0x99, 0x99,
  0x90, 0x33, 0xD3, 0x9C, 0xAD, 0xE0, 0xA7, 0xA5, 0x39, 0xEB, 0xD0, 0x84,
  0x00, 0x2B, 0xD3, 0x9C, 0xAD, 0xE1, 0x08, 0x40, 0xBE, 0x49, 0x20, 0x6F,
  0xC6, 0x39, 0xF0, 0x47, 0xF4, 0x44, 0x47, 0x99, 0x99, 0x9B, 0xF0, 0xCE,
  0xD6, 0xA7, 0x38, 0xC0, 0xD9, 0xDB, 0x5B, 0x5A, 0x56, 0x66, 0x66, 0xDA,
  0xDC, 0x67, 0x2B, 0x60, 0xCE, 0xD6, 0xA7, 0x18, 0xC4, 0xE6, 0x00, 0xFF,
  0x36, 0x6C, 0xF0, 0x17, 0x66, 0x6C, 0x66, 0x66, 0x30, 0xFF, 0xF0, 0xCE,
  0x66, 0x63, 0x66, 0x66, 0xC0, 0xFC, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 4, 4, 5, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 5, 10, 6, 0, -9 },
  { 19, 9, 9, 9, 0, -9 },
  { 30, 7, 9, 7, 0, -9 },
  { 38, 1, 4, 3, 1, -9 },
  { 39, 3, 11, 4, 1, -9 },
  { 44, 3, 11, 4, 0, -9 },
  { 49, 5, 5, 5, 0, -9 },
  { 53, 5, 6, 6, 0, -7 },
  { 57, 2, 3, 3, 0, -1 },
  { 58, 3, 2, 4, 0, -4 },
  { 59, 1, 2, 3, 1, -2 },
  { 60, 5, 9, 5, 0, -9 },
  { 66, 5, 9, 6, 0, -9 },
  { 72, 3, 9, 6, 1, -9 },
  { 76, 5, 9, 6, 0, -9 },
  { 82, 5, 9, 6, 0, -9 },
  { 88, 5, 9, 6, 0, -9 },
  { 94, 4, 9, 6, 1, -9 },
  { 99, 5, 9, 6, 0, -9 },
  { 105, 5, 9, 6, 0, -9 },
  { 111, 5, 9, 6, 0, -9 },
  { 117, 5, 9, 6, 0, -9 },
  { 123, 1, 7, 3, 1, -7 },
  { 124, 3, 9, 3, 0, -7 },
  { 128, 5, 6, 6, 0, -7 },
  { 132, 5, 4, 6, 0, -6 },
  { 135, 5, 6, 6, 0, -7 },
  { 139, 4, 9, 4, 0, -9 },
  { 144, 8, 10, 9, 0, -9 },
  { 154, 6, 9, 6, 0, -9 },
  { 161, 5, 9, 6, 1, -9 },
  { 167, 5, 9, 6, 1, -9 },
  { 173, 5, 9, 7, 1, -9 },
  { 179, 4, 9, 5, 1, -9 },
  { 184, 4, 9, 5, 1, -9 },
  { 189, 5, 9, 7, 1, -9 },
  { 195, 5, 9, 7, 1, -9 },
  { 201, 3, 9, 4, 0, -9 },
  { 205, 3, 12, 3, -1, -9 },
  { 210, 5, 9, 6, 1, -9 },
  { 216, 4, 9, 5, 1, -9 },
  { 221, 7, 9, 9, 1, -9 },
  { 229, 6, 9, 8, 1, -9 },
  { 236, 6, 9, 7, 1, -9 },
  { 243, 5, 9, 6, 1, -9 },
  { 249, 6, 11, 7, 1, -9 },
  { 258, 5, 9, 6, 1, -9 },
  { 264, 5, 9, 5, 0, -9 },
  { 270, 5, 9, 5, 0, -9 },
  { 276, 5, 9, 7, 1, -9 },
  { 282, 6, 9, 6, 0, -9 },
  { 289, 9, 9, 9, 0, -9 },
  { 300, 6, 9, 6, 0, -9 },
  { 307, 6, 9, 6, 0, -9 },
  { 314, 5, 9, 5, 0, -9 },
  { 320, 2, 11, 4, 1, -9 },
  { 323, 5, 9, 5, 0, -9 },
  { 329, 3, 11, 4, 0, -9 },
  { 334, 6, 6, 6, 0, -9 },
  { 339, 5, 1, 5, 0, 1 },
  { 340, 3, 2, 4, 0, -9 },
  { 341, 5, 7, 6, 0, -7 },
  { 346, 5, 9, 6, 1, -9 },
  { 352, 5, 7, 5, 0, -7 },
  { 357, 5, 9, 6, 0, -9 },
  { 363, 5, 7, 5, 0, -7 },
  { 368, 4, 9, 4, 0, -9 },
  { 373, 5, 10, 6, 0, -7 },
  { 380, 4, 9, 6, 1, -9 },
  { 385, 1, 9, 3, 1, -9 },
  { 387, 2, 12, 3, 0, -9 },
  { 390, 5, 9, 6, 1, -9 },
  { 396, 1, 9, 3, 1, -9 },
  { 398, 7, 7, 9, 1, -7 },
  { 405, 4, 7, 6, 1, -7 },
  { 409, 5, 7, 6, 0, -7 },
  { 414, 5, 10, 6, 1, -7 },
  { 421, 5, 10, 6, 0, -7 },
  { 428, 3, 7, 4, 1, -7 },
  { 431, 4, 7, 4, 0, -7 },
  { 435, 4, 8, 4, 0, -8 },
  { 439, 4, 7, 6, 1, -7 },
  { 443, 5, 7, 5, 0, -7 },
  { 448, 8, 7, 8, 0, -7 },
  { 455, 5, 7, 5, 0, -7 },
  { 460, 5, 10, 5, 0, -7 },
  { 467, 4, 7, 4, 0, -7 },
  { 471, 4, 11, 4, 0, -9 },
  { 477, 1, 12, 5, 2, -9 },
  { 479, 4, 11, 4, 0, -9 },
  { 485, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Bold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD12PT7B_H_
