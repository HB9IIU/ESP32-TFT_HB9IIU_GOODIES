#ifndef _NOTOSANS_EXTRACONDENSED_BOLD55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0x7E,
  0xFE, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xE0, 0xFC,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x03, 0xF1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07, 0xC7,
  0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xEC, 0xFC, 0xFE, 0x60, 0xC7, 0xF3, 0x00, 0x3F, 0x18, 0x01, 0xF8,
  0xC0, 0x0F, 0xE6, 0x00, 0x7F, 0xB0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0D, 0xFE, 0x00, 0x67, 0xF0,
  0x03, 0x3F, 0x80, 0x18, 0xFE, 0x00, 0xC7, 0xF8, 0x06, 0x7F, 0xF0, 0x33,
  0xFF, 0xF1, 0xBF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x01,
  0xFF, 0xC0, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0xDF, 0x80,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x3F, 0x03, 0xF0, 0x00,
  0xF8, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE1, 0xF8, 0x00,
  0x1F, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F,
  0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x3E, 0x0F, 0xC1, 0xF8, 0xFC, 0x7C, 0x7F,
  0xC3, 0xF1, 0xF9, 0xF9, 0xFF, 0xC3, 0xF7, 0xE3, 0xE3, 0xFF, 0xC7, 0xFF,
  0xCF, 0xCF, 0xFF, 0x87, 0xFF, 0x1F, 0x1F, 0x9F, 0x8F, 0xFE, 0x3E, 0x3E,
  0x1F, 0x0F, 0xF8, 0xFC, 0xFC, 0x3E, 0x07, 0xC1, 0xF1, 0xF8, 0x7C, 0x00,
  0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x00, 0x1F, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x0F, 0x81,
  0xF8, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x03, 0xF3, 0xF0,
  0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x7F, 0xFC, 0x1F, 0xC3, 0xFF,
  0xF8, 0x7F, 0x1F, 0xEF, 0xF3, 0xFC, 0x7F, 0x9F, 0xCF, 0xE1, 0xFC, 0x7F,
  0xBF, 0x8F, 0xF0, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0xF0, 0xFF, 0x07, 0xFF,
  0xC3, 0xFC, 0x0F, 0xFF, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFC, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x01, 0x01, 0xF0, 0x27, 0x87, 0xC7, 0x9F, 0xDF, 0x7E, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F,
  0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x07, 0x03, 0xC0, 0x0C, 0x04, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x9F, 0xCF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7E, 0x7F, 0x3F, 0x9F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xF1, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFD,
  0xFC, 0x1F, 0xEF, 0xE0, 0xFE, 0x7F, 0x87, 0xF1, 0xFC, 0x7F, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C, 0x7F, 0x38, 0x7F, 0x10, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0x81, 0xFE, 0x38, 0x07, 0xF0, 0x80,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC7, 0x01, 0xFE, 0x30, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xF7, 0xF0, 0x01, 0xF7, 0xF0, 0x03, 0xF7, 0xF0, 0x03,
  0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F,
  0x87, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3E,
  0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x38, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFE, 0xF0, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0xC0, 0x3F, 0x9F, 0xE0, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xDF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xEF, 0xF0, 0x3F,
  0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFE, 0x7F, 0x07, 0xF9, 0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xF1, 0xFE, 0x1F, 0xC1, 0xFE, 0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F,
  0xF1, 0xFE, 0x0F, 0xF7, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x1F, 0xF7, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x07, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x0F, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xBF, 0x80, 0x7F, 0x7F, 0x01, 0xFE, 0xFF, 0x03, 0xF9, 0xFF, 0x9F, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F,
  0x7F, 0x80, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFD, 0xFE, 0x0F, 0xFB,
  0xFC, 0x3F, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xBF, 0x0F,
  0xFF, 0x7E, 0x0F, 0xFC, 0xFC, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x3F, 0x1F,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x7E, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F,
  0x3F, 0x9F, 0x8F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xC0, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF9, 0xC0, 0xFF, 0x30, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x30, 0x0F, 0xC3,
  0xF0, 0x1F, 0xF8, 0x7C, 0x3F, 0x07, 0xFF, 0xC7, 0xE3, 0xE0, 0xFF, 0xFC,
  0x7E, 0x7E, 0x0F, 0xFF, 0xC3, 0xE7, 0xC1, 0xF8, 0xFC, 0x3E, 0x7C, 0x1F,
  0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0xFC, 0x3E, 0xFC, 0x3E, 0x0F, 0xC3, 0xFF,
  0xC3, 0xE0, 0xFC, 0x3F, 0xFC, 0x3E, 0x0F, 0xC3, 0xFF, 0x87, 0xE0, 0xFC,
  0x3F, 0xF8, 0x7E, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0xFC, 0x3E, 0xF8, 0x7E,
  0x0F, 0x83, 0xEF, 0x87, 0xE0, 0xF8, 0x3E, 0xFC, 0x3E, 0x0F, 0x83, 0xEF,
  0xC3, 0xE1, 0xFC, 0x7C, 0xFC, 0x3F, 0x1F, 0xC7, 0xC7, 0xC3, 0xFF, 0xFF,
  0xFC, 0x7C, 0x1F, 0xFB, 0xFF, 0x87, 0xE0, 0xFF, 0x9F, 0xF0, 0x7E, 0x07,
  0xF0, 0xFE, 0x03, 0xE0, 0x1C, 0x03, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0x00, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0x7F, 0x01,
  0xFE, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F,
  0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x0F, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x01, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x0F,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xF8, 0x0E, 0x1F, 0xE0, 0x08, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x04, 0x3F, 0xF0, 0x78, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFE,
  0x1F, 0xFC, 0xFE, 0x07, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFE,
  0x03, 0xFC, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xF0,
  0x1C, 0x3F, 0xE0, 0x02, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xF0, 0x3F, 0xC7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0xF1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xE3, 0xFE, 0x01, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0xCF, 0xE0, 0x3F, 0xC7, 0xF0,
  0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xF0, 0x7F,
  0x0F, 0xF0, 0x3F, 0x8F, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xE7, 0xFC, 0x07,
  0xF3, 0xFC, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE,
  0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF,
  0xE0, 0x1F, 0xF7, 0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFE, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xE0, 0x0F,
  0xBF, 0xFE, 0xFC, 0x03, 0xF7, 0xFF, 0xDF, 0x80, 0x7E, 0xFF, 0xFD, 0xF8,
  0x0F, 0xDF, 0xFF, 0xBF, 0x03, 0xF3, 0xFF, 0xF7, 0xE0, 0x7E, 0x7F, 0xFE,
  0xFC, 0x0F, 0xCF, 0xFF, 0xCF, 0xC1, 0xF9, 0xFF, 0xF9, 0xF8, 0x7E, 0x3F,
  0xFF, 0x3F, 0x0F, 0xC7, 0xFF, 0xE7, 0xE1, 0xF8, 0xFF, 0xFC, 0x7E, 0x3E,
  0x1F, 0xFF, 0x8F, 0xCF, 0xC3, 0xFF, 0xF1, 0xF9, 0xF8, 0x7F, 0xFE, 0x3F,
  0x3F, 0x0F, 0xFF, 0xC7, 0xEF, 0xC1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF,
  0x80, 0xFC, 0x03, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0xC0, 0xFF,
  0xFB, 0xF8, 0x1F, 0xFF, 0x3F, 0x83, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x7F,
  0x0F, 0xFF, 0xCF, 0xE1, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF,
  0xE3, 0xF8, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0x87, 0xF3, 0xFF, 0xF0, 0x7F,
  0x7F, 0xFE, 0x0F, 0xEF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF8, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xF8, 0x7C, 0xFF, 0x00, 0xCF, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xEC, 0x00, 0xFE, 0xF0, 0x1F, 0xEF, 0xE3,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F,
  0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xF0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xE1, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0xC0, 0x3F,
  0x87, 0xF0, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0x0F,
  0xE0, 0x7D, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xBE, 0x07, 0xF0, 0x3F, 0x81,
  0xF7, 0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xDF,
  0x87, 0xF8, 0x0F, 0xE1, 0xFB, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x7E, 0x1F,
  0xC0, 0x3F, 0x87, 0xC7, 0xC3, 0xF8, 0x07, 0xF1, 0xF8, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0x1F, 0x9F, 0xE0, 0x0F, 0xC7, 0xE3, 0xF3, 0xF8, 0x01, 0xFC,
  0xFC, 0x7E, 0x7F, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE0, 0x07, 0xF7, 0xE0,
  0xF9, 0xFC, 0x00, 0xFE, 0xFC, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x83, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xCF,
  0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF7, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x3F, 0xC1,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0x9F, 0x9F, 0xF8, 0xFC,
  0x7F, 0x87, 0xE0, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x20, 0x0F, 0xE3, 0xFC, 0x1F, 0xCF, 0xFC, 0x3F, 0xBF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xE7,
  0xF8, 0x1F, 0xEF, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F,
  0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00,
  0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xFC, 0x3F,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0x7F, 0xF0,
  0xFC, 0x7F, 0xE1, 0xF8, 0x7F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFE, 0x04, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x02, 0x7F, 0xC0, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x30, 0x7F, 0x07, 0xF1,
  0xFC, 0x3F, 0xF7, 0xF1, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xDF, 0xC0, 0xFF, 0x7F, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0,
  0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0xEF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xBF, 0x0F, 0xFC, 0xFC, 0x1F, 0xE1, 0xF0, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0x7E, 0x7F, 0x03, 0xFB,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x31, 0xFF, 0x8F, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0x18, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xE3, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF, 0x3F, 0xFE,
  0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0x7F, 0x03, 0xFD,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF7,
  0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFD, 0xFC, 0x3F, 0xF7, 0xF0, 0x7F, 0x1F,
  0xC0, 0x20, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x60, 0x03, 0xF9, 0xE0, 0x3F, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0x80, 0xFE, 0x3F, 0xC3,
  0xFB, 0xFF, 0x8F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xF8, 0x7F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF0, 0x3C, 0xFE, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0x01, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x8F, 0xF7, 0xFF, 0xBF,
  0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0x9F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x38, 0x1F, 0x87, 0xF8, 0x3F, 0xE3,
  0xF3, 0xFF, 0x8F, 0xFE, 0x7E, 0x7F, 0xFB, 0xFF, 0xEF, 0xDF, 0xFF, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xFC,
  0x0F, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0,
  0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC,
  0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x07,
  0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x0E, 0x03, 0xF0, 0xFF,
  0x0F, 0xCF, 0xFE, 0x3F, 0x3F, 0xFC, 0xFD, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x70, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFB, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xFC, 0xFE,
  0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x83, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x06, 0x01, 0xF8, 0x7F, 0x83, 0xF1,
  0xFF, 0x87, 0xF7, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFB,
  0xFE, 0x7F, 0xC1, 0xFC, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07,
  0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F,
  0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFF, 0x7F,
  0x81, 0xFE, 0xFF, 0x87, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x8F, 0xEF, 0xFF, 0x1F, 0xCF, 0xFC, 0x3F, 0x8F, 0xE0, 0x7F, 0x02,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xE3, 0xF0, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF, 0x3F,
  0xFE, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0x7F, 0x03,
  0xFD, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x87, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFD, 0xFC, 0x3F, 0xF7, 0xF0, 0x7F,
  0x1F, 0xC0, 0x30, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x0E, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0xFE, 0xFC, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xF7,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFC, 0x79, 0xFC, 0x04, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x02, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC1, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00,
  0x40, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0x7E,
  0x7F, 0xFB, 0xF1, 0xFF, 0x9F, 0x87, 0xF8, 0x7C, 0x04, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07,
  0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xF7, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x1F,
  0xF0, 0x1F, 0xDF, 0xC0, 0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0xF0, 0x7F, 0x1F, 0x81, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xFC,
  0x1F, 0xC7, 0xF0, 0xFB, 0xE0, 0xFC, 0x3F, 0x87, 0xDF, 0x0F, 0xE1, 0xFC,
  0x3E, 0xF8, 0x7F, 0x07, 0xF1, 0xF3, 0xE3, 0xF8, 0x3F, 0x8F, 0x9F, 0x1F,
  0x81, 0xFC, 0xF8, 0xF9, 0xFC, 0x0F, 0xE7, 0xC7, 0xCF, 0xE0, 0x7F, 0x3E,
  0x3E, 0x7F, 0x01, 0xF9, 0xF0, 0xF3, 0xF8, 0x0F, 0xEF, 0x87, 0x9F, 0x80,
  0x7F, 0x78, 0x3E, 0xFC, 0x03, 0xFB, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF9, 0xFC, 0x07, 0xF7, 0xF0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8,
  0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF0, 0x1F, 0xDF,
  0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF,
  0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF0,
  0x07, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xF7, 0xE0, 0x03, 0xF7, 0xE0,
  0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x27, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x02, 0x7F,
  0xE0, 0x05, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 40, 14, 3, -39 },
  { 41, 19, 14, 24, 3, -39 },
  { 75, 26, 39, 28, 1, -39 },
  { 202, 21, 45, 26, 2, -42 },
  { 321, 39, 40, 42, 2, -40 },
  { 516, 30, 41, 31, 1, -40 },
  { 670, 7, 14, 13, 3, -39 },
  { 683, 14, 48, 17, 3, -39 },
  { 767, 14, 48, 17, 1, -39 },
  { 851, 22, 22, 24, 1, -42 },
  { 912, 22, 27, 26, 2, -33 },
  { 987, 9, 13, 14, 2, -6 },
  { 1002, 13, 7, 17, 2, -18 },
  { 1014, 8, 9, 14, 3, -8 },
  { 1023, 22, 40, 22, 0, -40 },
  { 1133, 21, 41, 25, 2, -40 },
  { 1241, 16, 39, 25, 3, -39 },
  { 1319, 21, 40, 25, 2, -40 },
  { 1424, 21, 41, 25, 2, -40 },
  { 1532, 24, 39, 25, 1, -39 },
  { 1649, 20, 40, 25, 3, -39 },
  { 1749, 22, 41, 25, 2, -40 },
  { 1862, 23, 39, 25, 1, -39 },
  { 1975, 23, 41, 25, 1, -40 },
  { 2093, 23, 41, 25, 1, -40 },
  { 2211, 8, 31, 14, 3, -30 },
  { 2242, 9, 37, 14, 2, -30 },
  { 2284, 23, 26, 26, 1, -33 },
  { 2359, 23, 17, 26, 1, -28 },
  { 2408, 22, 26, 26, 2, -33 },
  { 2480, 19, 41, 20, 0, -40 },
  { 2578, 36, 44, 40, 2, -40 },
  { 2776, 29, 39, 29, 0, -39 },
  { 2918, 23, 39, 29, 4, -39 },
  { 3031, 23, 41, 27, 2, -40 },
  { 3149, 24, 39, 31, 4, -39 },
  { 3266, 17, 39, 24, 4, -39 },
  { 3349, 17, 39, 24, 4, -39 },
  { 3432, 25, 41, 31, 3, -40 },
  { 3561, 25, 39, 32, 4, -39 },
  { 3683, 15, 39, 17, 1, -39 },
  { 3757, 14, 51, 15, -3, -39 },
  { 3847, 25, 39, 28, 4, -39 },
  { 3969, 18, 39, 22, 4, -39 },
  { 4057, 35, 39, 42, 4, -39 },
  { 4228, 27, 39, 35, 4, -39 },
  { 4360, 28, 41, 33, 2, -40 },
  { 4504, 21, 39, 27, 4, -39 },
  { 4607, 28, 49, 33, 2, -40 },
  { 4779, 24, 39, 28, 4, -39 },
  { 4896, 20, 41, 23, 2, -40 },
  { 4999, 22, 39, 24, 1, -39 },
  { 5107, 24, 40, 31, 4, -39 },
  { 5227, 28, 39, 28, 0, -39 },
  { 5364, 43, 39, 41, -1, -39 },
  { 5574, 26, 39, 26, 0, -39 },
  { 5701, 26, 39, 26, 0, -39 },
  { 5828, 21, 39, 23, 1, -39 },
  { 5931, 13, 48, 17, 3, -39 },
  { 6009, 22, 40, 22, 0, -40 },
  { 6119, 13, 48, 17, 1, -39 },
  { 6197, 27, 24, 29, 1, -39 },
  { 6278, 23, 4, 22, 0, 5 },
  { 6290, 13, 9, 17, 2, -42 },
  { 6305, 21, 32, 26, 2, -31 },
  { 6389, 23, 43, 28, 3, -42 },
  { 6513, 19, 32, 22, 2, -31 },
  { 6589, 22, 43, 28, 2, -42 },
  { 6708, 21, 32, 25, 2, -31 },
  { 6792, 18, 42, 16, 0, -42 },
  { 6887, 22, 44, 28, 2, -31 },
  { 7008, 22, 42, 28, 3, -42 },
  { 7124, 8, 42, 13, 3, -42 },
  { 7166, 13, 55, 13, -2, -42 },
  { 7256, 24, 42, 27, 3, -42 },
  { 7382, 7, 42, 13, 3, -42 },
  { 7419, 35, 31, 41, 3, -31 },
  { 7555, 22, 31, 28, 3, -31 },
  { 7641, 23, 32, 27, 2, -31 },
  { 7733, 23, 44, 28, 3, -31 },
  { 7860, 22, 44, 28, 2, -31 },
  { 7981, 16, 31, 19, 3, -31 },
  { 8043, 17, 32, 21, 2, -31 },
  { 8111, 16, 37, 18, 1, -36 },
  { 8185, 21, 31, 28, 3, -30 },
  { 8267, 24, 30, 24, 0, -30 },
  { 8357, 37, 30, 37, 0, -30 },
  { 8496, 23, 30, 23, 0, -30 },
  { 8583, 24, 43, 24, 0, -30 },
  { 8712, 18, 30, 20, 1, -30 },
  { 8780, 16, 48, 19, 1, -39 },
  { 8876, 6, 55, 24, 9, -42 },
  { 8918, 17, 48, 19, 2, -39 },
  { 9020, 23, 9, 26, 1, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Bold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD55PT7B_H_
