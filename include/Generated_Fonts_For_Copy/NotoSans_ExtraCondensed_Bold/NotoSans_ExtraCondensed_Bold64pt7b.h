#ifndef _NOTOSANS_EXTRACONDENSED_BOLD64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x8F, 0xE0, 0xC0,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0x83,
  0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xFD,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xDC, 0xFC, 0xFF, 0x9C, 0x1C, 0xFF, 0x1C,
  0x00, 0xFF, 0x1C, 0x00, 0xFF, 0x1C, 0x00, 0xFF, 0x1C, 0x00, 0xFF, 0x9C,
  0x00, 0xFF, 0x9C, 0x00, 0x7F, 0xDC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1D, 0xFF, 0x00, 0x1D, 0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x1C,
  0xFF, 0x80, 0x1C, 0xFF, 0x80, 0x1C, 0xFF, 0xE0, 0x1C, 0xFF, 0xF8, 0x1D,
  0xFE, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x81,
  0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0xFE,
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0x80, 0x00,
  0x3F, 0x87, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x8F, 0xC3, 0xFF, 0x07,
  0xE1, 0xF8, 0xFE, 0x3F, 0xFC, 0x3F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x1F, 0x8F, 0xE3, 0xF0, 0xFF, 0xF0, 0xFC, 0x7E, 0x1F, 0xC3, 0xFF, 0x0F,
  0xC3, 0xF0, 0xFE, 0x0F, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF1,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F,
  0x07, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x00,
  0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xF0, 0x7F, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xF0, 0xFF, 0xBF, 0xE3, 0xFE, 0x3F, 0xF7, 0xFC, 0x7F, 0x87, 0xFC,
  0x7F, 0xDF, 0xF0, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x83,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x8F,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x0B, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x02, 0x03, 0xF0,
  0x08, 0xE0, 0xFC, 0x1E, 0x3F, 0x3F, 0x3F, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0x7F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0x03, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x0F, 0xE7,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xE0, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xE7, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07,
  0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF,
  0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0x1F,
  0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xDF, 0xFF, 0xF9, 0xFF, 0x7F, 0x1F, 0xF3, 0xE1, 0xFF,
  0x1C, 0x1F, 0xF0, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0x0F, 0xFC, 0x3E, 0x01, 0xFF, 0x0E, 0x00, 0xFF, 0x86, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7E, 0x0F, 0xFE, 0x1C, 0x01, 0xFF, 0x08, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFD, 0xFE, 0x00, 0x1F,
  0x9F, 0xE0, 0x01, 0xF9, 0xFE, 0x00, 0x3F, 0x1F, 0xE0, 0x03, 0xF1, 0xFE,
  0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0x81, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3C,
  0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0xC0, 0x07, 0xFE, 0xF8, 0x0F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x08, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xC0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF3, 0xFF, 0xC3, 0xFD, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xF8, 0x07, 0xFB,
  0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0x7F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x3F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE3, 0xFE,
  0x07, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC,
  0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF9,
  0xFF, 0x8F, 0xFE, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xC7, 0xFC, 0x7F, 0xC1, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF,
  0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xDF, 0xE3, 0xFF, 0xEF, 0xF0, 0xFF, 0xE7, 0xF8, 0x1F, 0xC3, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFD, 0xFF, 0x7F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x83, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xF3,
  0xF8, 0x38, 0x1F, 0xC7, 0xF8, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9,
  0xFF, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xF8, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x87, 0xFE, 0x3C, 0x03, 0xFC, 0x20, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0xFF,
  0x8F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE3, 0xF8, 0xFC, 0x0F, 0xFF, 0xF8, 0x7E,
  0x3F, 0x03, 0xFF, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0x3F, 0x07, 0xE7, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF9, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xDF, 0x83, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFD, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F, 0xDF,
  0x87, 0xF0, 0x3F, 0x03, 0xFF, 0xE1, 0xFC, 0x0F, 0xC1, 0xFB, 0xF8, 0x7F,
  0x07, 0xF0, 0x7E, 0x7E, 0x1F, 0xC1, 0xFC, 0x1F, 0x9F, 0x87, 0xF0, 0x7F,
  0x07, 0xE7, 0xE0, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F, 0x07, 0xF0, 0xFC,
  0x7E, 0x0F, 0xE3, 0xFC, 0x3F, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0,
  0x7F, 0xFB, 0xFF, 0xE1, 0xFC, 0x1F, 0xFE, 0x7F, 0xF0, 0x3F, 0x03, 0xFF,
  0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x03, 0x80, 0x3C,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x02, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0xFE, 0xFF,
  0x80, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F,
  0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x0F, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3,
  0xFE, 0x07, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x7E, 0x1F, 0xF8,
  0x03, 0x0F, 0xFC, 0x00, 0x43, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x61,
  0xFF, 0xE0, 0x78, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0x83,
  0xFF, 0xC7, 0xFC, 0x07, 0xFF, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0x7F,
  0xCF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF,
  0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x7E, 0x1F,
  0xFC, 0x00, 0x60, 0xFF, 0xC0, 0x01, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x07, 0xFC,
  0x7F, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF8, 0x7F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFE, 0x87, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x08, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F,
  0xEF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC7, 0xFE,
  0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x07,
  0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x80, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFD, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFB, 0xF8, 0x01, 0xFB, 0xFF, 0xFD, 0xFC,
  0x01, 0xFD, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0x7F, 0x00, 0x7F,
  0x7F, 0xFF, 0x9F, 0xC0, 0x7F, 0x3F, 0xFF, 0xCF, 0xE0, 0x3F, 0x9F, 0xFF,
  0xE7, 0xF0, 0x1F, 0xCF, 0xFF, 0xF3, 0xF8, 0x0F, 0xE7, 0xFF, 0xF8, 0xFE,
  0x0F, 0xE3, 0xFF, 0xFE, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0x3F, 0x83, 0xF8,
  0xFF, 0xFF, 0x9F, 0xC1, 0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF,
  0xE3, 0xF8, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0xFE,
  0x7F, 0x07, 0xFF, 0xFC, 0x3F, 0xBF, 0x83, 0xFF, 0xFE, 0x1F, 0xDF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xEF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0x07,
  0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x7F,
  0x80, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x1F,
  0xE0, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0x87,
  0xF8, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0x83,
  0xFE, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x05, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0xBF,
  0xE0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x80,
  0x7F, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF,
  0x81, 0xFF, 0xBF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x05, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0x87, 0xFC, 0x0F, 0xFC,
  0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F,
  0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC7, 0xFC,
  0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9,
  0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xE0,
  0x78, 0xFF, 0x80, 0x33, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0xE7, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xF0,
  0x7F, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0x80,
  0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xDF,
  0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF3, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFC,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x3F, 0x07, 0xFC, 0x03, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF3, 0xF8, 0x7F, 0x80, 0x1F, 0xE3,
  0xF8, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x3F, 0x8F, 0xF8, 0x01, 0xFE,
  0x3F, 0x87, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xE1, 0xFC, 0xFF, 0x00, 0x0F,
  0xE3, 0xF8, 0x7F, 0x3F, 0xC0, 0x03, 0xFD, 0xFE, 0x1F, 0xCF, 0xF0, 0x00,
  0xFF, 0x7F, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0xFD, 0xFF, 0x00,
  0x0F, 0xF7, 0xF0, 0x3F, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x0F, 0xDF, 0xE0,
  0x00, 0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFE,
  0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3,
  0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0,
  0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x83, 0xFF, 0x0E, 0x01, 0xFF, 0x08,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0x7F, 0xFF, 0x7F, 0x3F,
  0xFE, 0x7F, 0x1F, 0xFC, 0x3F, 0x0F, 0xF8, 0x3F, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xC0, 0x0F, 0xF1, 0xFF, 0x03,
  0xFC, 0xFF, 0xE0, 0xFF, 0x7F, 0xFC, 0x3F, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xCF, 0xF8,
  0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF,
  0xC0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF,
  0xBF, 0xF0, 0x7F, 0xCF, 0xFF, 0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xBF, 0xFF, 0x8F, 0xE7, 0xFF, 0xC3, 0xF8, 0xFF, 0xE0, 0xFC,
  0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xF0, 0x30, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x02, 0x3F,
  0xF0, 0x18, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1C, 0x0F, 0xF0, 0x3F, 0xE3,
  0xFC, 0x1F, 0xFC, 0xFF, 0x0F, 0xFF, 0xBF, 0xC7, 0xFF, 0xEF, 0xF1, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xF7,
  0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0,
  0x7F, 0xCF, 0xF8, 0x3F, 0xF3, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xF7, 0xF0, 0xFF, 0xF9, 0xFC, 0x1F, 0xFC, 0x7F,
  0x03, 0xFE, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F,
  0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x23, 0xFE,
  0x00, 0x71, 0xFF, 0xC1, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xDC, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x87,
  0xF0, 0x7F, 0xF1, 0xFC, 0x3F, 0xFE, 0x7F, 0x1F, 0xFF, 0xDF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0xFF, 0xDF,
  0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xEF, 0xF0, 0x7F, 0xF3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x00, 0x60, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF3, 0x00,
  0x0F, 0xF8, 0xF0, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x18, 0x03,
  0xFC, 0x7F, 0xC1, 0xFE, 0x7F, 0xF0, 0xFF, 0x7F, 0xFC, 0x7F, 0x7F, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFE, 0x0F,
  0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0x80, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x80, 0x00, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x03, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x9F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x1F, 0xF0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xE0,
  0x0F, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE7, 0xF8, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF9, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x03, 0x80, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF8, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0x80, 0x7E, 0x0F, 0xF8, 0x3F, 0x0F, 0xFE, 0x1F, 0xCF,
  0xFF, 0x8F, 0xEF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F, 0xDF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFF, 0x01,
  0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xF7, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x3F, 0x07, 0xFC, 0x0F, 0xE3, 0xFF, 0x83, 0xF9, 0xFF, 0xF0,
  0xFE, 0x7F, 0xFE, 0x3F, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF,
  0xFC, 0xFF, 0xC1, 0xFF, 0x3F, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xDF,
  0xFF, 0x0F, 0xF3, 0xFF, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0x03, 0x80, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0x87, 0xF0, 0x7F, 0xF1, 0xFC, 0x3F, 0xFE, 0x7F, 0x1F, 0xFF,
  0xDF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xE0, 0xFF, 0xDF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFE, 0x01, 0xFF,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07,
  0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xEF, 0xF0,
  0x7F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0x00, 0x60, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x3F, 0x07, 0xFF,
  0xC3, 0xFF, 0xF9, 0xFE, 0xFE, 0x7F, 0xBF, 0xBF, 0xEF, 0xEF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFC, 0x2F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF8, 0x7C,
  0xFF, 0x00, 0xCF, 0xF0, 0x04, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xBF, 0xC0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F,
  0x1F, 0xFF, 0x3F, 0x87, 0xFF, 0x0F, 0xC1, 0xFF, 0x07, 0xE0, 0x0E, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7,
  0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F,
  0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xE7, 0xF8, 0x0F, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0xC0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFF, 0x83, 0xFC, 0x3F,
  0xC0, 0xFB, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0x7E, 0x0F, 0xF0, 0x7F, 0x87,
  0xEF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFC, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0x9F,
  0x8F, 0xF0, 0x3F, 0xC3, 0xE3, 0xF1, 0xFE, 0x03, 0xFC, 0xFC, 0x7E, 0x3F,
  0xC0, 0x7F, 0x9F, 0x8F, 0xC7, 0xF8, 0x0F, 0xF3, 0xF0, 0xF8, 0xFE, 0x01,
  0xFE, 0x7E, 0x1F, 0x3F, 0xC0, 0x3F, 0xCF, 0xC3, 0xF7, 0xF8, 0x03, 0xF9,
  0xF0, 0x7E, 0xFF, 0x00, 0x7F, 0x3E, 0x0F, 0xDF, 0xE0, 0x0F, 0xEF, 0xC1,
  0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x1F, 0x7F, 0x00, 0x1F, 0xFF, 0x03, 0xEF,
  0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x03,
  0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC,
  0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x21, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x4F, 0xFC, 0x00, 0x17, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xA0, 0x00, 0xFF,
  0xC8, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 47, 16, 3, -46 },
  { 60, 22, 17, 28, 3, -46 },
  { 107, 30, 46, 32, 1, -46 },
  { 280, 24, 53, 30, 3, -49 },
  { 439, 45, 47, 49, 2, -46 },
  { 704, 35, 47, 36, 1, -46 },
  { 910, 9, 17, 15, 3, -46 },
  { 930, 16, 56, 20, 3, -46 },
  { 1042, 16, 56, 20, 1, -46 },
  { 1154, 26, 26, 28, 1, -49 },
  { 1239, 26, 31, 30, 2, -38 },
  { 1340, 11, 15, 16, 2, -7 },
  { 1361, 16, 8, 20, 2, -21 },
  { 1377, 10, 11, 16, 3, -10 },
  { 1391, 24, 46, 26, 1, -46 },
  { 1529, 25, 47, 30, 2, -46 },
  { 1676, 20, 46, 30, 3, -46 },
  { 1791, 25, 46, 30, 2, -46 },
  { 1935, 25, 47, 30, 2, -46 },
  { 2082, 28, 46, 30, 1, -46 },
  { 2243, 24, 47, 30, 3, -46 },
  { 2384, 26, 47, 30, 2, -46 },
  { 2537, 27, 46, 30, 1, -46 },
  { 2693, 26, 47, 30, 2, -46 },
  { 2846, 25, 47, 30, 2, -46 },
  { 2993, 10, 36, 17, 3, -35 },
  { 3038, 11, 43, 17, 2, -35 },
  { 3098, 26, 30, 30, 2, -38 },
  { 3196, 26, 19, 30, 2, -32 },
  { 3258, 26, 30, 30, 2, -38 },
  { 3356, 23, 47, 24, 0, -46 },
  { 3492, 42, 51, 46, 2, -46 },
  { 3760, 34, 46, 34, 0, -46 },
  { 3956, 27, 46, 34, 4, -46 },
  { 4112, 26, 47, 31, 3, -46 },
  { 4265, 29, 46, 36, 4, -46 },
  { 4432, 21, 46, 28, 4, -46 },
  { 4553, 21, 46, 28, 4, -46 },
  { 4674, 29, 47, 36, 3, -46 },
  { 4845, 29, 46, 38, 4, -46 },
  { 5012, 17, 46, 20, 2, -46 },
  { 5110, 16, 60, 18, -3, -46 },
  { 5230, 29, 46, 33, 4, -46 },
  { 5397, 21, 46, 26, 4, -46 },
  { 5518, 41, 46, 49, 4, -46 },
  { 5754, 32, 46, 40, 4, -46 },
  { 5938, 32, 47, 38, 3, -46 },
  { 6126, 26, 46, 31, 4, -46 },
  { 6276, 32, 57, 38, 3, -46 },
  { 6504, 29, 46, 33, 4, -46 },
  { 6671, 23, 47, 27, 2, -46 },
  { 6807, 26, 46, 27, 1, -46 },
  { 6957, 28, 47, 37, 4, -46 },
  { 7122, 32, 46, 32, 0, -46 },
  { 7306, 50, 46, 48, -1, -46 },
  { 7594, 30, 46, 30, 0, -46 },
  { 7767, 30, 46, 30, 0, -46 },
  { 7940, 24, 46, 26, 1, -46 },
  { 8078, 14, 56, 20, 4, -46 },
  { 8176, 24, 46, 26, 1, -46 },
  { 8314, 14, 56, 20, 2, -46 },
  { 8412, 31, 28, 34, 1, -46 },
  { 8521, 26, 4, 26, 0, 6 },
  { 8534, 14, 10, 20, 3, -49 },
  { 8552, 24, 37, 30, 2, -36 },
  { 8663, 26, 50, 32, 4, -49 },
  { 8826, 22, 37, 26, 2, -36 },
  { 8928, 26, 50, 32, 2, -49 },
  { 9091, 25, 37, 29, 2, -36 },
  { 9207, 20, 49, 19, 1, -49 },
  { 9330, 26, 51, 32, 2, -36 },
  { 9496, 25, 49, 32, 4, -49 },
  { 9650, 9, 49, 16, 3, -49 },
  { 9706, 14, 64, 16, -2, -49 },
  { 9818, 27, 49, 31, 4, -49 },
  { 9984, 8, 49, 15, 4, -49 },
  { 10033, 40, 36, 48, 4, -36 },
  { 10213, 25, 36, 32, 4, -36 },
  { 10326, 27, 37, 31, 2, -36 },
  { 10451, 26, 51, 32, 4, -36 },
  { 10617, 26, 51, 32, 2, -36 },
  { 10783, 18, 36, 22, 4, -36 },
  { 10864, 20, 37, 24, 2, -36 },
  { 10957, 19, 43, 21, 1, -42 },
  { 11060, 25, 36, 32, 3, -35 },
  { 11173, 28, 35, 28, 0, -35 },
  { 11296, 43, 35, 43, 0, -35 },
  { 11485, 27, 35, 27, 0, -35 },
  { 11604, 28, 50, 28, 0, -35 },
  { 11779, 21, 35, 23, 1, -35 },
  { 11871, 19, 56, 22, 1, -46 },
  { 12004, 8, 64, 28, 10, -49 },
  { 12068, 20, 56, 22, 2, -46 },
  { 12208, 26, 11, 30, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Bold64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD64PT7B_H_
