#ifndef _NOTOSANS_EXTRACONDENSED_BOLD31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0xFF, 0xFF,
  0xF9, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0xE3, 0xDC, 0x7B, 0x8F, 0x0E,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE3, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1,
  0xCE, 0x00, 0x02, 0x00, 0x20, 0x02, 0x01, 0xFE, 0x3F, 0xF7, 0xFE, 0x7A,
  0x6F, 0x20, 0xF2, 0x07, 0xA0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xE0, 0x2F, 0x02, 0xF8, 0x2F, 0xC2, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x3E, 0x07, 0x81, 0xFC, 0x1C, 0x0F, 0x70,
  0x70, 0x39, 0xC3, 0x80, 0xE7, 0x8E, 0x03, 0x8E, 0x78, 0x0E, 0x39, 0xC0,
  0x38, 0xE7, 0x00, 0xE7, 0xB8, 0xC3, 0x9C, 0xE7, 0xC7, 0x73, 0xBF, 0x9F,
  0xDC, 0xEE, 0x3E, 0x77, 0x9C, 0x03, 0x9C, 0x70, 0x0E, 0x71, 0xC0, 0x39,
  0xC7, 0x01, 0xC7, 0x1C, 0x07, 0x1C, 0x70, 0x3C, 0x3B, 0xC0, 0xE0, 0xFE,
  0x03, 0x83, 0xF8, 0x1C, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x79, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x79, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x1F, 0x80, 0x3F, 0x1F, 0x7F, 0x9F, 0xFF, 0x9E, 0xF3, 0xDE, 0xF3, 0xFE,
  0xF1, 0xFC, 0xF0, 0xFC, 0xF0, 0xF8, 0xFD, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0x9F, 0xFB, 0xDE, 0xF7, 0xB9, 0xCE, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0x70, 0x70,
  0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0xF0, 0x78,
  0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xE1, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x1F, 0x83, 0xFC, 0x79, 0xE3, 0x9C, 0x10, 0x80, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7B, 0xDE, 0xF7, 0x7B, 0xDC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E, 0x79, 0xEF, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x9F, 0x7D, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8,
  0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xBC, 0xCF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0x87, 0xFC, 0xFF, 0xE7, 0x1E, 0x61, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x8F, 0xFE, 0x7F, 0xE6, 0x1F, 0x41, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xE1, 0xFC, 0x1F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x1F, 0xE3, 0xFF, 0xFE, 0xFF, 0xC7, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF, 0x03, 0xBC,
  0x1C, 0xF0, 0x73, 0xC3, 0x8F, 0x0E, 0x3C, 0x78, 0xF1, 0xC3, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x7F, 0x87, 0xFC, 0x7F, 0xE7, 0x7F, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x1F, 0xF7, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0x07, 0xE1,
  0xFE, 0x3F, 0xE3, 0xE0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF7, 0xCF,
  0xFE, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7,
  0x8F, 0x7D, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0xC3, 0xFE, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF,
  0x0F, 0x78, 0xF7, 0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x83, 0xFC, 0x7F, 0xEF,
  0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0xFF, 0x7F, 0xE1,
  0xF8, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x87, 0xE7, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0xFF,
  0x60, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0xF0, 0x7B, 0xDE, 0xF3, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDD, 0xEF, 0x00, 0x00, 0x18, 0x07,
  0xC0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x03, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC1, 0xF0, 0x0E, 0x00, 0x40, 0x00,
  0x3F, 0x9F, 0xF9, 0xFF, 0xB9, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0x07, 0x81, 0xE0, 0x1C, 0x3C, 0x00, 0xE3, 0x83, 0x0E, 0x70, 0xFE,
  0x77, 0x1F, 0xE7, 0x73, 0xCE, 0x7E, 0x38, 0xE7, 0xE3, 0x8E, 0x7E, 0x79,
  0xE7, 0xE7, 0x9E, 0x7E, 0x79, 0xC7, 0xE3, 0x9C, 0x7E, 0x39, 0xEE, 0x73,
  0xF7, 0xE7, 0x1F, 0x7C, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x70, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1E, 0xF1, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0xEF, 0x1F,
  0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFF, 0xFD, 0xFF, 0xEF,
  0xFE, 0x7F, 0xC0, 0x07, 0xF0, 0xFF, 0xC7, 0xFE, 0x7C, 0x67, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x4F, 0xDE, 0x7F, 0xF1,
  0xFF, 0x83, 0xF8, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xF0, 0xFB,
  0xC1, 0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0xFB, 0xC3, 0xEF, 0xFF,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0x63, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xEF, 0x07, 0xDE, 0x0F, 0xBC, 0x1F, 0x7C, 0x3E, 0xF8, 0x7C,
  0xFC, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0x00, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF,
  0xFF, 0xFE, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x9F, 0xFF, 0xFE,
  0xFC, 0x20, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBC, 0x7C, 0xF1, 0xF3, 0xCF,
  0x8F, 0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC3, 0xEF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC,
  0x3E, 0xF0, 0x7F, 0xC1, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xEF, 0xF7, 0x0E, 0xFF, 0x71, 0xEF, 0xF7, 0x9C,
  0xFF, 0x79, 0xCF, 0xF3, 0x9C, 0xFF, 0x3B, 0xCF, 0xF3, 0xF8, 0xFF, 0x3F,
  0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF0, 0xFF, 0x1F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0E, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xF7, 0x9F, 0xEF, 0x3F, 0xCF,
  0x7F, 0x9E, 0x7F, 0x3C, 0xFE, 0x3D, 0xFC, 0x7B, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xC0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1F,
  0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x3F, 0x7E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0x8F, 0xFE, 0xFF, 0xEF, 0xFF,
  0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF7, 0xFF, 0xFE,
  0xFF, 0xCF, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7E, 0x7C,
  0x3E, 0x78, 0x1E, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C,
  0x1E, 0x7C, 0x3E, 0x3F, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x83, 0xFF,
  0x8F, 0xFE, 0x3D, 0xFC, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC7, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF8, 0xF1, 0xE3, 0xC7, 0xCF, 0x0F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1, 0xF0,
  0x1F, 0xCF, 0xFD, 0xFF, 0xFF, 0xEF, 0x85, 0xE0, 0x3C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF8,
  0x3F, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE1, 0xE7, 0xDF, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xF0, 0x0F,
  0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x38, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0xF0, 0x38, 0x1F, 0xF0, 0x7C, 0x1E,
  0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0x78, 0x7C, 0x3E, 0x78, 0x7C, 0x3C,
  0x78, 0xFE, 0x3C, 0x78, 0xEE, 0x3C, 0x78, 0xEE, 0x3C, 0x38, 0xEE, 0x3C,
  0x3C, 0xEE, 0x78, 0x3D, 0xEF, 0x78, 0x3D, 0xE7, 0x78, 0x3D, 0xC7, 0x78,
  0x1D, 0xC7, 0x78, 0x1D, 0xC7, 0x70, 0x1F, 0xC7, 0xF0, 0x1F, 0xC7, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0,
  0xF8, 0x7C, 0xF0, 0xF0, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x03, 0xDE, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0x78, 0x3E, 0xF0, 0x79, 0xF0, 0xF1, 0xE3,
  0xC3, 0xE7, 0x83, 0xDF, 0x07, 0xC0, 0xF8, 0x3E, 0xF0, 0x79, 0xE1, 0xF3,
  0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xB8, 0x1E, 0x78, 0x3C, 0x70, 0x70,
  0xF1, 0xE0, 0xE3, 0x81, 0xEF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0xF0, 0xF0, 0xF0, 0xE0, 0x1F, 0xC7, 0xFE, 0x3F, 0xE3, 0x1E, 0x00, 0xF0,
  0x0F, 0x03, 0xF3, 0xFF, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF,
  0x1F, 0xFF, 0xF7, 0xEF, 0x7E, 0x70, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFE, 0xF9, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF9, 0xFF, 0xFE, 0xEF, 0xEE, 0x7C, 0x1F, 0xC7, 0xFD, 0xFF, 0x3E, 0x67,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x9F, 0xF1, 0xFE, 0x1F, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xCF, 0x3F, 0x7B, 0xFF, 0xDF, 0x7F,
  0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x1F, 0xF1, 0xF7, 0x8F, 0xBF, 0xFC, 0xFF, 0xE3, 0xEF, 0x1F, 0x83, 0xFC,
  0x7F, 0xE7, 0x8F, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x82, 0x7F, 0xE3, 0xFE, 0x1F, 0xE0, 0x07,
  0x87, 0xF1, 0xFC, 0xFF, 0x3C, 0x0F, 0x03, 0xC1, 0xFE, 0xFF, 0xBF, 0xE3,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x79, 0xFB, 0xDF, 0xFE, 0xFB, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x8F, 0xBC, 0xFD, 0xFF, 0xE7, 0xEF, 0x1E, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE6, 0x1F, 0x3F, 0xF9, 0xFF, 0x8F, 0xF8, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x7C, 0xFF, 0xEF, 0xFE, 0xF9,
  0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x6F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x3C, 0x78, 0xF1,
  0xC0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xFF, 0xDF, 0xBE, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x1F, 0xF0, 0xF7, 0x8F, 0x3C, 0xF9, 0xE7, 0x8F, 0x78, 0x7F, 0x83, 0xFC,
  0x1F, 0xF0, 0xFF, 0x87, 0xDE, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0x7B,
  0xC3, 0xDE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xC7, 0xDD, 0xFD, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD,
  0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1,
  0xFE, 0x1E, 0x3F, 0xC3, 0xC7, 0xF8, 0x78, 0xFF, 0x0F, 0x1F, 0xE1, 0xE3,
  0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xE0, 0xE7, 0xCE, 0xFE, 0xFF,
  0xEF, 0x9F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x1F, 0xC1,
  0xFF, 0x1F, 0xFC, 0xF9, 0xE7, 0x8F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7, 0x8F, 0x3E, 0x79, 0xFF, 0xC7, 0xFC,
  0x1F, 0xC0, 0xE7, 0xCE, 0xFE, 0xFF, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFE, 0xF7, 0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x79, 0xFB, 0xDF, 0xFE, 0xFB, 0xF7, 0x8F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x8F, 0xBC,
  0xFD, 0xFF, 0xE7, 0xEF, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xE7, 0xF7, 0xBB, 0xDF, 0xEF, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x00, 0x3F, 0x9F, 0xFF, 0xFB, 0xC6, 0xF0, 0x3C, 0x0F, 0xC1, 0xF8, 0x7F,
  0x07, 0xE0, 0x7C, 0x0F, 0x83, 0xF1, 0xFF, 0xFB, 0xFE, 0xFF, 0x00, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x3F, 0xBF, 0xEF, 0xF8, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x93, 0xFC, 0x7F,
  0x0F, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0x3E, 0xF0, 0xF0, 0x7F, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78,
  0xF0, 0xE3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0x77, 0x81, 0xDE, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0xF8,
  0x7F, 0x87, 0xC3, 0xDE, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7, 0x9D, 0xCF, 0x3C,
  0xEE, 0x78, 0xE7, 0x73, 0x87, 0xBB, 0xBC, 0x3D, 0xCD, 0xE1, 0xEC, 0x6F,
  0x0F, 0x63, 0x78, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0xFB, 0xC7, 0x9F, 0x3C,
  0x7B, 0xC3, 0xDE, 0x0F, 0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x07,
  0xF0, 0x3F, 0xC3, 0xDE, 0x1E, 0xF1, 0xE3, 0xCF, 0x1E, 0xF8, 0x78, 0xF0,
  0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x1C, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0xBF, 0xEF, 0xF8, 0x1E, 0x0F, 0x83,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xC3, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0xF8, 0xFC, 0x3E, 0x0F, 0xE0, 0x78, 0x1E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0xC3, 0xF0,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7E, 0x3F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xF8, 0x3C, 0x7E, 0x3C, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0xFC, 0x7E, 0x3C, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0x40, 0x20,
};

const GFXglyph NotoSans_ExtraCondensed_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 11, 8, 14, 1, -22 },
  { 23, 14, 22, 16, 1, -22 },
  { 62, 12, 26, 14, 1, -24 },
  { 101, 22, 22, 24, 1, -22 },
  { 162, 16, 22, 17, 1, -22 },
  { 206, 5, 8, 7, 1, -22 },
  { 211, 8, 27, 10, 1, -22 },
  { 238, 8, 27, 10, 0, -22 },
  { 265, 12, 13, 14, 1, -24 },
  { 285, 12, 14, 14, 1, -18 },
  { 306, 5, 8, 8, 1, -4 },
  { 311, 8, 4, 9, 1, -10 },
  { 315, 4, 5, 8, 2, -5 },
  { 318, 12, 22, 13, 0, -22 },
  { 351, 12, 22, 14, 1, -22 },
  { 384, 10, 22, 14, 1, -22 },
  { 412, 12, 22, 14, 1, -22 },
  { 445, 12, 22, 14, 1, -22 },
  { 478, 14, 22, 14, 0, -22 },
  { 517, 12, 22, 14, 1, -22 },
  { 550, 12, 22, 14, 1, -22 },
  { 583, 12, 22, 14, 1, -22 },
  { 616, 12, 22, 14, 1, -22 },
  { 649, 12, 22, 14, 1, -22 },
  { 682, 4, 17, 8, 2, -17 },
  { 691, 5, 21, 8, 1, -17 },
  { 705, 13, 14, 14, 1, -18 },
  { 728, 13, 10, 14, 1, -16 },
  { 745, 13, 14, 14, 1, -18 },
  { 768, 11, 22, 11, 0, -22 },
  { 799, 20, 24, 22, 1, -22 },
  { 859, 16, 22, 16, 0, -22 },
  { 903, 13, 22, 16, 2, -22 },
  { 939, 13, 22, 15, 1, -22 },
  { 975, 14, 22, 17, 2, -22 },
  { 1014, 10, 22, 13, 2, -22 },
  { 1042, 10, 22, 13, 2, -22 },
  { 1070, 15, 22, 17, 1, -22 },
  { 1112, 14, 22, 18, 2, -22 },
  { 1151, 8, 22, 10, 1, -22 },
  { 1173, 8, 29, 9, -2, -22 },
  { 1202, 14, 22, 16, 2, -22 },
  { 1241, 10, 22, 13, 2, -22 },
  { 1269, 20, 22, 24, 2, -22 },
  { 1324, 15, 22, 20, 2, -22 },
  { 1366, 16, 22, 18, 1, -22 },
  { 1410, 12, 22, 15, 2, -22 },
  { 1443, 16, 27, 18, 1, -22 },
  { 1497, 14, 22, 16, 2, -22 },
  { 1536, 11, 22, 13, 1, -22 },
  { 1567, 13, 22, 13, 0, -22 },
  { 1603, 14, 22, 18, 2, -22 },
  { 1642, 16, 22, 16, 0, -22 },
  { 1686, 24, 22, 23, 0, -22 },
  { 1752, 15, 22, 15, 0, -22 },
  { 1794, 15, 22, 15, 0, -22 },
  { 1836, 12, 22, 13, 0, -22 },
  { 1869, 7, 27, 10, 2, -22 },
  { 1893, 12, 22, 13, 0, -22 },
  { 1926, 7, 27, 10, 1, -22 },
  { 1950, 15, 13, 16, 1, -22 },
  { 1975, 13, 2, 13, 0, 3 },
  { 1979, 7, 5, 10, 1, -24 },
  { 1984, 12, 17, 14, 1, -17 },
  { 2010, 12, 24, 16, 2, -24 },
  { 2046, 11, 17, 12, 1, -17 },
  { 2070, 13, 24, 16, 1, -24 },
  { 2109, 12, 17, 14, 1, -17 },
  { 2135, 10, 24, 9, 0, -24 },
  { 2165, 13, 24, 16, 1, -17 },
  { 2204, 12, 24, 16, 2, -24 },
  { 2240, 4, 24, 8, 2, -24 },
  { 2252, 7, 31, 8, -1, -24 },
  { 2280, 13, 24, 15, 2, -24 },
  { 2319, 4, 24, 8, 2, -24 },
  { 2331, 19, 17, 23, 2, -17 },
  { 2372, 12, 17, 16, 2, -17 },
  { 2398, 13, 17, 15, 1, -17 },
  { 2426, 12, 24, 16, 2, -17 },
  { 2462, 13, 24, 16, 1, -17 },
  { 2501, 9, 17, 11, 2, -17 },
  { 2521, 10, 17, 12, 1, -17 },
  { 2543, 10, 21, 10, 0, -21 },
  { 2570, 12, 17, 16, 2, -17 },
  { 2596, 14, 17, 14, 0, -17 },
  { 2626, 21, 17, 21, 0, -17 },
  { 2671, 13, 17, 13, 0, -17 },
  { 2699, 14, 24, 14, 0, -17 },
  { 2741, 10, 17, 11, 1, -17 },
  { 2763, 10, 27, 11, 0, -22 },
  { 2797, 4, 31, 14, 5, -24 },
  { 2813, 9, 27, 11, 1, -22 },
  { 2844, 13, 6, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Bold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD31PT7B_H_
