#ifndef _NOTOSANS_EXTRACONDENSED_BOLD53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7E, 0x10, 0xFF, 0x1F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF,
  0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C,
  0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x03, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0x70, 0xCF, 0xE7, 0x00, 0xFE, 0x70, 0x0F, 0xE7, 0x00,
  0x7E, 0x70, 0x07, 0xF7, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0x7F, 0x00, 0x77, 0xF0, 0x07, 0x3F, 0x00,
  0x73, 0xF8, 0x07, 0x3F, 0xE0, 0x77, 0xFF, 0xC7, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC,
  0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x7E, 0x00,
  0x7E, 0x7E, 0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x1F, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x87, 0xC0, 0x01, 0xF0, 0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xE3, 0xF0,
  0x00, 0x7C, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF1, 0xF8, 0x00, 0x1F, 0x0F,
  0x8F, 0x87, 0xF0, 0xF8, 0x7C, 0x7C, 0x7F, 0xC7, 0xE7, 0xE7, 0xE7, 0xFF,
  0x1F, 0xFF, 0x3E, 0x3F, 0xFC, 0xFF, 0xF1, 0xF3, 0xFF, 0xE3, 0xFF, 0x9F,
  0x1F, 0x1F, 0x0F, 0xF8, 0xF8, 0xF8, 0xFC, 0x3F, 0x0F, 0xCF, 0xC3, 0xE0,
  0x00, 0x7C, 0x7E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0xF8, 0x00, 0x3F, 0x1F,
  0x87, 0xC0, 0x01, 0xF0, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xE1, 0xF0, 0x00,
  0xF8, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x7C, 0x00, 0x7E, 0x07, 0xC3,
  0xE0, 0x03, 0xE0, 0x3E, 0x3F, 0x00, 0x1F, 0x01, 0xF1, 0xF8, 0x01, 0xF0,
  0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x3F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x83, 0xFC, 0x3F, 0xFC, 0x1F, 0xC3, 0xFF, 0xF0,
  0xFE, 0x1F, 0xFF, 0xC7, 0xF1, 0xFE, 0xFE, 0x7F, 0x8F, 0xE7, 0xFB, 0xF8,
  0x7F, 0x1F, 0xFF, 0xC7, 0xF8, 0x7F, 0xFE, 0x3F, 0x81, 0xFF, 0xE1, 0xFC,
  0x0F, 0xFF, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0xFE, 0x03,
  0xFF, 0x87, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x38, 0x7C, 0x19, 0xFB, 0xE7, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFB, 0xF8, 0x1F, 0xCF, 0xE1,
  0xFC, 0x3F, 0x83, 0xC1, 0xF0, 0x0E, 0x07, 0x00, 0x20, 0x20, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x9F, 0xDF, 0xCF,
  0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x07,
  0xE3, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F,
  0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD,
  0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0x8F, 0xF1,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x9F, 0xDF, 0xFF, 0xEF, 0xEF, 0xE7, 0xF3, 0xE3, 0xF8,
  0xE1, 0xFC, 0x20, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7C, 0x1F, 0xE3, 0x80,
  0xFE, 0x30, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x38, 0x1F, 0xE3, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3E, 0xFE, 0x00, 0x7D, 0xFC, 0x01, 0xF3,
  0xF8, 0x03, 0xE7, 0xF0, 0x0F, 0x8F, 0xE0, 0x1F, 0x1F, 0xC0, 0x7C, 0x3F,
  0x80, 0xF8, 0x7F, 0x03, 0xE0, 0xFE, 0x07, 0xC1, 0xFC, 0x1F, 0x03, 0xF8,
  0x3E, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x10, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x0E, 0x03, 0xF1,
  0xFE, 0x1F, 0x9F, 0xF8, 0xFD, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD,
  0xFF, 0x3F, 0xEF, 0xF0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0xCF, 0xF1, 0xFE, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F,
  0x87, 0xF0, 0xFF, 0x3F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x83, 0xFC, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x03, 0xF9, 0xFC,
  0x0F, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xC1, 0xFC,
  0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x03,
  0xFD, 0xFC, 0x1F, 0xF7, 0xF8, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xF7, 0xE1, 0xFF, 0xDF, 0x83, 0xFE, 0x7E, 0x03, 0xE1, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x3D, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x3F, 0x3F, 0x9F, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0x9F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0x07, 0xF1, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0xE3, 0xF0, 0x3F, 0xF0, 0xF8, 0xF8, 0x1F, 0xFE, 0x3E, 0x3E, 0x0F, 0xFF,
  0x8F, 0x9F, 0x07, 0xFF, 0xE1, 0xF7, 0xC3, 0xF0, 0xF8, 0x7D, 0xF0, 0xFC,
  0x3E, 0x1F, 0x7C, 0x3E, 0x0F, 0x87, 0xFE, 0x1F, 0x87, 0xE1, 0xFF, 0x87,
  0xE1, 0xF8, 0x7F, 0xE1, 0xF0, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0x87, 0xFE,
  0x1F, 0x07, 0xE1, 0xFF, 0x87, 0xC1, 0xF8, 0x7F, 0xE1, 0xF0, 0x7C, 0x1F,
  0xF8, 0x7C, 0x1F, 0x07, 0xFE, 0x1F, 0x87, 0xC3, 0xEF, 0x83, 0xE3, 0xF8,
  0xFB, 0xF0, 0xFD, 0xFE, 0x7C, 0x7C, 0x3F, 0xFF, 0xFF, 0x1F, 0x07, 0xFC,
  0xFF, 0x87, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x60, 0x01, 0xFF, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xC3, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xFC,
  0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0x3F, 0xC1,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xE1, 0xFF, 0x3F, 0xC0, 0xFF,
  0x7F, 0x80, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F,
  0x83, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0x07, 0x8F, 0xF8, 0x04, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x87, 0xFC, 0x0E,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0x3F, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE0,
  0x38, 0x3F, 0xE0, 0x04, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD,
  0xFC, 0x1F, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF9, 0xFE, 0x03,
  0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x18, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE8, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE,
  0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE,
  0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0xFE,
  0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xF7, 0xFF, 0xBE, 0x01, 0xFB, 0xFF, 0xDF, 0x80, 0xFD, 0xFF, 0xEF, 0xC0,
  0x7E, 0xFF, 0xF7, 0xE0, 0x3E, 0x7F, 0xF9, 0xF0, 0x3F, 0x7F, 0xFC, 0xFC,
  0x1F, 0xBF, 0xFE, 0x7E, 0x0F, 0x9F, 0xFF, 0x3F, 0x0F, 0xCF, 0xFF, 0x8F,
  0x87, 0xE7, 0xFF, 0xC7, 0xE3, 0xF3, 0xFF, 0xE3, 0xF1, 0xF1, 0xFF, 0xF1,
  0xF9, 0xF8, 0xFF, 0xF8, 0x7C, 0xFC, 0x7F, 0xFC, 0x3F, 0x7C, 0x3F, 0xFE,
  0x1F, 0xBE, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x87, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF,
  0xF8, 0x1F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF8, 0x1F,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x03,
  0xFF, 0xE0, 0x3F, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xF8, 0x1F, 0xFF,
  0x7F, 0x07, 0xFF, 0xDF, 0xC1, 0xFF, 0xF3, 0xF8, 0x7F, 0xFC, 0xFE, 0x1F,
  0xFF, 0x1F, 0xC7, 0xFF, 0xC7, 0xF1, 0xFF, 0xF0, 0xFC, 0x7F, 0xFC, 0x3F,
  0x9F, 0xFF, 0x0F, 0xE7, 0xFF, 0xC1, 0xFD, 0xFF, 0xF0, 0x7F, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03,
  0xFD, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x3F,
  0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0x03,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0x3F, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0xFF, 0x01,
  0xFC, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xF7, 0xE7, 0xF8, 0x0C, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xF7,
  0xC1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF7, 0xF0, 0x07, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x3F, 0x80,
  0xFF, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xF0,
  0x3F, 0x83, 0xF0, 0x3F, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xBE, 0x07, 0xF0, 0x7F, 0x07, 0xDF, 0x87, 0xF0, 0x3F, 0x83,
  0xEF, 0xC3, 0xF8, 0x0F, 0xC3, 0xF7, 0xE1, 0xFC, 0x07, 0xF1, 0xF9, 0xF0,
  0xFE, 0x03, 0xF8, 0xFC, 0xF8, 0x7F, 0x01, 0xFC, 0x7E, 0x7E, 0x7F, 0x00,
  0xFE, 0x3E, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x1F, 0x9F, 0xC0, 0x1F, 0x9F,
  0x87, 0xCF, 0xE0, 0x0F, 0xCF, 0xC3, 0xE7, 0xF0, 0x07, 0xF7, 0xE1, 0xF3,
  0xF0, 0x03, 0xFB, 0xE0, 0xFD, 0xF8, 0x00, 0xFD, 0xF0, 0x7F, 0xFC, 0x00,
  0x7E, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x3F,
  0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0x83, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xE7, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1E, 0x1F, 0xE1, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xF7, 0xFF, 0x3F, 0x3F, 0xF3, 0xF1, 0xFC, 0x3F, 0x02, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0xFE, 0xFF, 0xC3, 0xFB,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F,
  0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xFC, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0x8F, 0xCF, 0xFC, 0x3F, 0x1F,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFE, 0xF9, 0xFE, 0x04, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x05, 0xFE, 0x02, 0x7F, 0xE7,
  0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x08, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F,
  0xF9, 0xFC, 0x7F, 0xF7, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xDF,
  0xFD, 0xFE, 0x1F, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x03, 0xFD, 0xFC, 0x1F, 0xF7,
  0xFC, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xF0, 0xFF,
  0x8F, 0xC1, 0xFC, 0x3F, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD,
  0xFC, 0x07, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x8F, 0xF8, 0x3C, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0xFF, 0x9F, 0xC7, 0xFF, 0x7F, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0xDF, 0xE1, 0xFF, 0x7F, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF7,
  0xF0, 0x3F, 0xDF, 0xC1, 0xFF, 0x7F, 0xDF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xDF, 0xC7, 0xFF, 0x7F, 0x1F, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0x18, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x98,
  0x01, 0xFE, 0x7C, 0x1F, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0x01, 0xFC, 0xFF, 0x0F, 0xEF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF7,
  0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xBF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0x87, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x3F,
  0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFB, 0xF8, 0x1F, 0xE3, 0xF0, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xC7,
  0xF0, 0x3F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xBF, 0x80, 0x7F, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x04, 0x00, 0x20, 0x3F, 0x1F, 0xE0, 0xFF, 0x0F, 0xCF, 0xFC,
  0x7F, 0xE3, 0xF7, 0xFF, 0xBF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0xF0, 0xFE, 0xFF,
  0x07, 0xF8, 0x3F, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x81, 0xFF,
  0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0,
  0x1F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF8, 0x1F,
  0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF,
  0x81, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F,
  0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x00, 0x04, 0x07,
  0xC3, 0xFC, 0x3F, 0x3F, 0xF1, 0xFB, 0xFF, 0xCF, 0xDF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xF0, 0xFE, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x1F,
  0xE1, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x3F, 0xCF,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x03, 0xF1, 0xFE, 0x0F,
  0xCF, 0xFC, 0x3F, 0x3F, 0xF8, 0xFD, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFC,
  0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x80,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC1, 0xFE,
  0xFF, 0xDF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xBF, 0xF8, 0xFE,
  0xFF, 0xC3, 0xF8, 0xFE, 0x0F, 0xE0, 0x40, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0xFF,
  0x9F, 0xC7, 0xFF, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF,
  0xDF, 0xE1, 0xFF, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC1, 0xFF, 0x7F,
  0xDF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xDF, 0xC7, 0xFF, 0x7F, 0x1F, 0xF9,
  0xFC, 0x1F, 0xC7, 0xF0, 0x18, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x09, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xC1, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x40, 0x03, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFC, 0x3C, 0xFC, 0x04, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0xC0, 0x7F, 0x7E, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xE1, 0xFF, 0xC0, 0x02, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xFD, 0xC7, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x03, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFE, 0x7E, 0x7F, 0xF3, 0xF0, 0xFE, 0x1F, 0x80, 0x80, 0x00, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0xFC, 0x7F, 0x01,
  0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFC, 0x0F, 0xE7,
  0xF0, 0x7F, 0xC0, 0xFE, 0x7F, 0x07, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0xE0,
  0xFE, 0x3F, 0x07, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F, 0x87,
  0xBE, 0x1F, 0xC3, 0xF8, 0xF9, 0xF1, 0xFC, 0x1F, 0x8F, 0x9F, 0x1F, 0x81,
  0xF8, 0xF9, 0xF1, 0xF8, 0x1F, 0xCF, 0x9F, 0x3F, 0x81, 0xFC, 0xF0, 0xF3,
  0xF8, 0x1F, 0xCF, 0x0F, 0x3F, 0x00, 0xFD, 0xF0, 0xF3, 0xF0, 0x0F, 0xDF,
  0x0F, 0xBF, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xFF, 0x00,
  0x7D, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFD,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F,
  0x3F, 0xC1, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x3F, 0x81, 0xFC, 0xFE,
  0x07, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x3F, 0x9F,
  0xC0, 0xFF, 0xFF, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0x7F, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0x1F,
  0x80, 0x04, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x03, 0xFC, 0x80, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Bold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 39, 14, 3, -38 },
  { 40, 19, 14, 23, 2, -38 },
  { 74, 25, 38, 27, 1, -38 },
  { 193, 20, 43, 25, 2, -40 },
  { 301, 37, 38, 41, 2, -38 },
  { 477, 29, 39, 29, 1, -38 },
  { 619, 8, 14, 12, 2, -38 },
  { 633, 13, 46, 17, 3, -38 },
  { 708, 13, 46, 17, 1, -38 },
  { 783, 21, 21, 24, 1, -40 },
  { 839, 22, 25, 25, 1, -31 },
  { 908, 9, 13, 13, 2, -6 },
  { 923, 14, 7, 16, 1, -18 },
  { 936, 8, 9, 14, 3, -8 },
  { 945, 21, 38, 21, 0, -38 },
  { 1045, 21, 39, 24, 2, -38 },
  { 1148, 17, 38, 24, 2, -38 },
  { 1229, 20, 38, 24, 2, -38 },
  { 1324, 20, 39, 24, 2, -38 },
  { 1422, 23, 38, 24, 1, -38 },
  { 1532, 20, 39, 24, 2, -38 },
  { 1630, 21, 39, 24, 2, -38 },
  { 1733, 22, 38, 24, 1, -38 },
  { 1838, 22, 39, 24, 1, -38 },
  { 1946, 22, 39, 24, 1, -38 },
  { 2054, 8, 30, 14, 3, -29 },
  { 2084, 9, 36, 14, 2, -29 },
  { 2125, 22, 26, 25, 1, -32 },
  { 2197, 22, 16, 25, 1, -27 },
  { 2241, 22, 26, 25, 1, -32 },
  { 2313, 19, 39, 20, 0, -38 },
  { 2406, 34, 42, 38, 2, -38 },
  { 2585, 28, 38, 28, 0, -38 },
  { 2718, 23, 38, 28, 3, -38 },
  { 2828, 22, 39, 26, 2, -38 },
  { 2936, 24, 38, 30, 3, -38 },
  { 3050, 17, 38, 23, 4, -38 },
  { 3131, 16, 38, 23, 4, -38 },
  { 3207, 25, 39, 30, 2, -38 },
  { 3329, 24, 38, 31, 4, -38 },
  { 3443, 14, 38, 17, 1, -38 },
  { 3510, 14, 49, 15, -3, -38 },
  { 3596, 24, 38, 27, 4, -38 },
  { 3710, 18, 38, 22, 3, -38 },
  { 3796, 33, 38, 41, 4, -38 },
  { 3953, 26, 38, 33, 4, -38 },
  { 4077, 27, 39, 31, 2, -38 },
  { 4209, 21, 38, 26, 3, -38 },
  { 4309, 27, 47, 31, 2, -38 },
  { 4468, 24, 38, 27, 3, -38 },
  { 4582, 19, 39, 22, 2, -38 },
  { 4675, 21, 38, 23, 1, -38 },
  { 4775, 24, 39, 30, 3, -38 },
  { 4892, 27, 38, 27, 0, -38 },
  { 5021, 41, 38, 39, -1, -38 },
  { 5216, 25, 38, 25, 0, -38 },
  { 5335, 25, 38, 25, 0, -38 },
  { 5454, 20, 38, 22, 1, -38 },
  { 5549, 12, 46, 17, 3, -38 },
  { 5618, 21, 38, 21, 0, -38 },
  { 5718, 12, 46, 17, 1, -38 },
  { 5787, 26, 23, 28, 1, -38 },
  { 5862, 22, 3, 22, 0, 5 },
  { 5871, 12, 9, 16, 2, -41 },
  { 5885, 20, 31, 25, 2, -30 },
  { 5963, 22, 41, 27, 3, -40 },
  { 6076, 18, 31, 21, 2, -30 },
  { 6146, 22, 41, 27, 2, -40 },
  { 6259, 21, 30, 24, 2, -29 },
  { 6338, 18, 41, 16, 0, -41 },
  { 6431, 22, 43, 27, 2, -30 },
  { 6550, 21, 40, 27, 3, -40 },
  { 6655, 7, 40, 13, 3, -40 },
  { 6690, 11, 53, 13, -1, -40 },
  { 6763, 23, 40, 26, 3, -40 },
  { 6878, 7, 40, 13, 3, -40 },
  { 6913, 34, 30, 40, 3, -30 },
  { 7041, 21, 30, 27, 3, -30 },
  { 7120, 22, 31, 26, 2, -30 },
  { 7206, 22, 43, 27, 3, -30 },
  { 7325, 22, 43, 27, 2, -30 },
  { 7444, 15, 30, 18, 3, -30 },
  { 7501, 17, 31, 20, 1, -30 },
  { 7567, 15, 36, 17, 1, -35 },
  { 7635, 21, 30, 27, 3, -29 },
  { 7714, 23, 29, 24, 0, -29 },
  { 7798, 36, 29, 36, 0, -29 },
  { 7929, 22, 29, 22, 0, -29 },
  { 8009, 23, 42, 24, 0, -29 },
  { 8130, 17, 29, 19, 1, -29 },
  { 8192, 15, 46, 18, 1, -38 },
  { 8279, 6, 53, 23, 9, -41 },
  { 8319, 16, 46, 18, 2, -38 },
  { 8411, 22, 9, 25, 1, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Bold53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD53PT7B_H_
