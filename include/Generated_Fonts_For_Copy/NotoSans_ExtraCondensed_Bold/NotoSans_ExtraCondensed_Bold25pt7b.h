#ifndef _NOTOSANS_EXTRACONDENSED_BOLD25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x00, 0x6F, 0xF7, 0xF7, 0xFB,
  0xFC, 0xFE, 0x7E, 0x3B, 0x1D, 0x8C, 0x1D, 0xC3, 0xB8, 0x66, 0x0C, 0xC1,
  0x99, 0xFF, 0xFF, 0xF9, 0xDC, 0x3B, 0x86, 0x60, 0xCC, 0x7F, 0xFF, 0xFE,
  0x66, 0x1D, 0xC3, 0xB8, 0x67, 0x0C, 0xC0, 0x0C, 0x03, 0x03, 0xF9, 0xFE,
  0xFF, 0xBB, 0x0E, 0xC3, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x83,
  0x78, 0xFB, 0xFE, 0xFF, 0x0F, 0x00, 0xC0, 0x30, 0x78, 0x18, 0x1F, 0x0E,
  0x0E, 0xC3, 0x03, 0x38, 0xC0, 0xCE, 0x70, 0x33, 0x98, 0x0C, 0xEE, 0x03,
  0x3B, 0x3C, 0xEC, 0xDF, 0x9F, 0x77, 0xE3, 0x99, 0x98, 0x0E, 0xE6, 0x03,
  0xB9, 0xC0, 0xCE, 0x70, 0x71, 0x98, 0x18, 0x66, 0x0E, 0x1F, 0x83, 0x83,
  0xC0, 0x1E, 0x01, 0xF8, 0x1F, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xFC,
  0x07, 0xC0, 0x3C, 0x0B, 0xF3, 0xBF, 0x9D, 0xCF, 0xEE, 0x7E, 0x71, 0xF3,
  0x87, 0x1F, 0xFC, 0xFF, 0xF1, 0xF3, 0xC0, 0xFF, 0xFF, 0xE6, 0x60, 0x1E,
  0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x38, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0xC0, 0xE0, 0xE0, 0xE1, 0xC1, 0x83,
  0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0xE1,
  0xC7, 0x1C, 0x00, 0x1C, 0x07, 0x09, 0xCB, 0xFE, 0xFF, 0x8F, 0x93, 0xE1,
  0xDC, 0xF7, 0x88, 0x80, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x77, 0xFE, 0xEE, 0xFF, 0xFF,
  0xC0, 0x6F, 0xF7, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x38, 0x00, 0x3E, 0x1F, 0xC7, 0xFB, 0xCE, 0xE3, 0xB8, 0xEE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xB8, 0xEF, 0x39, 0xFE, 0x7F, 0x0F,
  0x80, 0x07, 0x0F, 0x1F, 0x3F, 0x77, 0xF7, 0x2F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x3E, 0x3F, 0xCF, 0xF9, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1E,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x3F, 0xCF, 0xF9, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0xFC, 0x3C, 0x0F, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF8,
  0x3B, 0xFE, 0xFF, 0x3F, 0x80, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x06, 0xE0, 0xDC, 0x3B, 0x86, 0x71, 0xCE, 0x31, 0xCF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70,
  0x1C, 0x0F, 0x03, 0xFC, 0xFF, 0x9F, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xE8,
  0x3B, 0xFE, 0xFF, 0x3F, 0x80, 0x0F, 0x8F, 0xE7, 0xF9, 0xE0, 0xF0, 0x38,
  0x0E, 0x63, 0xFC, 0xFF, 0xBC, 0xEE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0x39,
  0xFE, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x1E, 0x00, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E, 0xE3, 0xBC, 0xE7, 0x79,
  0xFC, 0x3E, 0x1F, 0xC7, 0x7B, 0x8E, 0xE3, 0xF8, 0x7E, 0x3F, 0xDE, 0x7F,
  0x8F, 0xC0, 0x3E, 0x1F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xFF, 0xF7, 0xDC, 0xEE, 0x03, 0x80, 0xE0, 0x79, 0xFC, 0x7E, 0x1F,
  0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x6F, 0xF7, 0x6F, 0xF7, 0x00, 0x00,
  0x00, 0x07, 0x77, 0xEE, 0xE0, 0x00, 0x40, 0x70, 0x7C, 0x7E, 0x7E, 0x3E,
  0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xF0, 0x7C, 0x7E, 0x7E, 0x3E, 0x0E, 0x02, 0x00, 0x3E, 0x7F, 0x9F,
  0xE8, 0xF0, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x78, 0x3C, 0x1E, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1C, 0x1C,
  0x38, 0x0E, 0x70, 0x06, 0x63, 0xF7, 0xE7, 0xF7, 0xE6, 0x73, 0xEE, 0x73,
  0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x67, 0xEE, 0x76, 0xE7, 0xFE, 0xE3, 0x9C,
  0x70, 0x00, 0x70, 0x00, 0x3C, 0x18, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xBC, 0x3C,
  0xE1, 0xC7, 0x0E, 0x38, 0x7F, 0xE7, 0xFF, 0x3F, 0xF9, 0xC1, 0xCE, 0x0F,
  0xF0, 0x7F, 0x83, 0xC0, 0xFE, 0x3F, 0xEF, 0xFB, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3B, 0xFE, 0xFF, 0x3F, 0xEE, 0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x3F, 0xFF,
  0xFF, 0xBF, 0x80, 0x0F, 0xC7, 0xF3, 0xFD, 0xE1, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x85, 0xFF, 0x3F,
  0xC7, 0xF0, 0xFC, 0x1F, 0xE3, 0xFE, 0x73, 0xEE, 0x3D, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xC3, 0xB8, 0xF7, 0xFC,
  0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x0F, 0xC1, 0xFF, 0x3F, 0xE7, 0xC2, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF7, 0x0F,
  0x78, 0xF3, 0xFF, 0x3F, 0xF1, 0xFE, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0xFF, 0xF0, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF,
  0xFF, 0xEF, 0x00, 0xE1, 0xFC, 0x3B, 0x8F, 0x73, 0xCE, 0x79, 0xDE, 0x3B,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x73, 0x8E, 0x79, 0xCF, 0x38, 0xE7,
  0x1E, 0xE1, 0xDC, 0x3C, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xEC, 0x7F, 0xEC, 0x6F, 0xEE, 0xEF, 0xEE, 0xEF, 0xEE, 0xEF, 0xE6, 0xCF,
  0xE7, 0xCF, 0xE7, 0xCF, 0xE7, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xF0, 0x7F,
  0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE, 0x7E,
  0xF7, 0xE7, 0x7E, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x0F, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x3B, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x38, 0x39,
  0xE3, 0xCF, 0xFC, 0x3F, 0xE0, 0xFC, 0x00, 0xFE, 0x3F, 0xCF, 0xFB, 0x9E,
  0xE3, 0xB8, 0xFE, 0x3B, 0x8E, 0xE7, 0xBF, 0xEF, 0xF3, 0xE0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF1,
  0xE7, 0x07, 0x78, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0x38, 0x39, 0xE3, 0xC7, 0xFC, 0x3F, 0xE0, 0xFE, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x7C, 0xFC, 0x1F, 0xE3, 0xFE, 0x73, 0xCE,
  0x3D, 0xC7, 0xB8, 0xF7, 0x1C, 0xFF, 0x9F, 0xE3, 0xF8, 0x77, 0x8E, 0x71,
  0xCF, 0x38, 0xE7, 0x1E, 0xE3, 0xDC, 0x3C, 0x3F, 0x3F, 0xFF, 0xDE, 0x2E,
  0x07, 0x03, 0xC0, 0xF0, 0x7E, 0x1F, 0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x1F,
  0xFE, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x77,
  0xFE, 0x7F, 0x87, 0xE0, 0xE0, 0x7F, 0x03, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F,
  0x38, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xCE, 0x07, 0x70, 0x3B, 0x81,
  0xDC, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0xE0, 0xE1,
  0xFC, 0x1C, 0x3F, 0x87, 0x87, 0xF8, 0xF0, 0xE7, 0x1F, 0x1C, 0xE3, 0xE3,
  0x9C, 0x7C, 0xF3, 0x9D, 0x9E, 0x7B, 0xB3, 0x87, 0x77, 0x70, 0xEE, 0xEE,
  0x1D, 0x9D, 0xC3, 0xF1, 0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0xF0, 0xE7, 0x1E, 0x79, 0xC3, 0x9C, 0x3B,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x3F,
  0x83, 0xBC, 0x39, 0xC7, 0x9E, 0x70, 0xEF, 0x0F, 0xF0, 0xF7, 0x0E, 0x70,
  0xE7, 0x9E, 0x39, 0xC3, 0x9C, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x3F, 0xFF, 0xF0, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x70, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCF, 0xFF, 0xFC, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x83,
  0xB8, 0x39, 0x87, 0x1C, 0x71, 0xCE, 0x0E, 0xE0, 0xF0, 0xFF, 0xFF, 0xF0,
  0xF1, 0xE3, 0x87, 0x3E, 0x3F, 0x9F, 0xE8, 0x70, 0x38, 0x3D, 0xFF, 0xFF,
  0xE3, 0xF1, 0xF8, 0xFE, 0xFF, 0xFB, 0xCC, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xEE, 0x3F, 0xE7, 0xFE, 0xF1, 0xDE, 0x3B, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x77, 0x8E, 0xFF, 0xDF, 0xF3, 0xBE, 0x00, 0x1E, 0x3F,
  0x7F, 0xF1, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF1, 0x7F, 0x7F, 0x3F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCE, 0x77, 0xDD, 0xFF, 0xF3, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0x7F, 0xDF, 0xF3, 0xDC,
  0x1E, 0x1F, 0xC7, 0xFB, 0xCE, 0xE3, 0xB8, 0x7F, 0xFF, 0xFF, 0xE0, 0x38,
  0x0F, 0x01, 0xEE, 0x7F, 0x8F, 0xE0, 0x1F, 0x3F, 0x3F, 0x38, 0x38, 0x7E,
  0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x39, 0xDF, 0xF7, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7F, 0x3D, 0xFF, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x83, 0xDF, 0xE7,
  0xF9, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3D, 0xCF, 0xFB, 0xFF,
  0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1C, 0x6F, 0xF2, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x18, 0xF3, 0xC2, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xBE, 0xF0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE3, 0xFC, 0x77, 0x9E, 0xF7, 0x9E, 0xE3, 0xF8, 0x7F, 0x0F,
  0xF1, 0xFE, 0x3C, 0xE7, 0x9C, 0xF1, 0xDE, 0x3B, 0xC7, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x1E, 0xEF, 0xBF,
  0xFF, 0xFF, 0xF3, 0xE7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xE7, 0x3B, 0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x1E, 0x0F, 0xE7, 0xFB, 0xCF, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFE, 0x7F, 0x8F, 0xC0,
  0xE7, 0x1D, 0xF3, 0xFF, 0x78, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3B, 0xC7, 0x7F, 0xEF, 0xF9, 0xEF, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x00, 0x39, 0xDF, 0xF7, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFF, 0x7F, 0xCF, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0xE7, 0xDF, 0xBF, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0x3C, 0xFF, 0xFE, 0xE2, 0xE0, 0xF0,
  0xFC, 0x7E, 0x1E, 0x0F, 0x8F, 0xFE, 0xFE, 0xFC, 0x18, 0x38, 0x38, 0x3F,
  0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F,
  0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x3D, 0xFF, 0x7F, 0xCF, 0x70, 0xE0, 0xFE, 0x3D, 0xC7, 0x38,
  0xE7, 0x1C, 0xF7, 0x8E, 0xE1, 0xDC, 0x3B, 0x83, 0x70, 0x7C, 0x0F, 0x81,
  0xF0, 0x1C, 0x00, 0xE1, 0xC3, 0xF9, 0xF3, 0xDC, 0xF9, 0xCE, 0x6C, 0xE7,
  0x36, 0x73, 0x9B, 0x39, 0xED, 0xB8, 0x7E, 0xFC, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF1, 0xCE, 0x79,
  0xEE, 0x1D, 0xC3, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xEE,
  0x39, 0xC7, 0x3D, 0xE3, 0xC0, 0xF0, 0xFE, 0x3D, 0xC7, 0x38, 0xE7, 0x1C,
  0x77, 0x8E, 0xE1, 0xDC, 0x3B, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x0F, 0x81, 0xF0, 0x38, 0x00, 0x7F, 0x3F, 0x9F,
  0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8,
  0xF8, 0x7C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x1F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE1, 0xE3, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0x78, 0xF3, 0xC7, 0x0E, 0x1C, 0x38,
  0x70, 0xE7, 0xCF, 0x1C, 0x00, 0x70, 0x7F, 0xBF, 0xFE, 0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 18, 6, 1, -18 },
  { 10, 9, 7, 11, 1, -18 },
  { 18, 11, 18, 13, 1, -18 },
  { 43, 10, 20, 12, 1, -19 },
  { 68, 18, 18, 19, 1, -18 },
  { 109, 13, 18, 14, 1, -18 },
  { 139, 4, 7, 6, 1, -18 },
  { 143, 7, 22, 8, 1, -18 },
  { 163, 7, 22, 8, 0, -18 },
  { 183, 10, 10, 11, 1, -19 },
  { 196, 10, 12, 12, 1, -15 },
  { 211, 4, 6, 6, 1, -3 },
  { 214, 6, 3, 8, 1, -8 },
  { 217, 4, 4, 6, 1, -4 },
  { 219, 10, 18, 10, 0, -18 },
  { 242, 10, 18, 12, 1, -18 },
  { 265, 8, 18, 12, 1, -18 },
  { 283, 10, 18, 12, 1, -18 },
  { 306, 10, 18, 12, 1, -18 },
  { 329, 11, 18, 12, 0, -18 },
  { 354, 10, 18, 12, 1, -18 },
  { 377, 10, 18, 12, 1, -18 },
  { 400, 10, 18, 12, 1, -18 },
  { 423, 10, 18, 12, 1, -18 },
  { 446, 10, 18, 12, 1, -18 },
  { 469, 4, 14, 7, 1, -14 },
  { 476, 4, 17, 6, 1, -14 },
  { 485, 10, 12, 12, 1, -15 },
  { 500, 10, 8, 12, 1, -13 },
  { 510, 10, 12, 12, 1, -15 },
  { 525, 9, 18, 9, 0, -18 },
  { 546, 16, 20, 18, 1, -18 },
  { 586, 13, 18, 13, 0, -18 },
  { 616, 10, 18, 13, 2, -18 },
  { 639, 10, 18, 12, 1, -18 },
  { 662, 11, 18, 14, 2, -18 },
  { 687, 8, 18, 11, 2, -18 },
  { 705, 8, 18, 11, 2, -18 },
  { 723, 12, 18, 14, 1, -18 },
  { 750, 11, 18, 15, 2, -18 },
  { 775, 6, 18, 8, 1, -18 },
  { 789, 6, 23, 7, -1, -18 },
  { 807, 11, 18, 13, 2, -18 },
  { 832, 8, 18, 10, 2, -18 },
  { 850, 16, 18, 19, 2, -18 },
  { 886, 12, 18, 16, 2, -18 },
  { 913, 13, 18, 15, 1, -18 },
  { 943, 10, 18, 12, 2, -18 },
  { 966, 13, 22, 15, 1, -18 },
  { 1002, 11, 18, 13, 2, -18 },
  { 1027, 9, 18, 11, 1, -18 },
  { 1048, 10, 18, 11, 0, -18 },
  { 1071, 11, 18, 14, 2, -18 },
  { 1096, 13, 18, 13, 0, -18 },
  { 1126, 19, 18, 19, 0, -18 },
  { 1169, 12, 18, 12, 0, -18 },
  { 1196, 12, 18, 12, 0, -18 },
  { 1223, 10, 18, 10, 0, -18 },
  { 1246, 6, 22, 8, 1, -18 },
  { 1263, 10, 18, 10, 0, -18 },
  { 1286, 5, 22, 8, 1, -18 },
  { 1300, 12, 11, 13, 1, -18 },
  { 1317, 10, 2, 10, 0, 2 },
  { 1320, 6, 4, 8, 1, -19 },
  { 1323, 9, 14, 12, 1, -14 },
  { 1339, 11, 19, 13, 1, -19 },
  { 1366, 8, 14, 10, 1, -14 },
  { 1380, 10, 19, 13, 1, -19 },
  { 1404, 10, 14, 11, 1, -14 },
  { 1422, 8, 19, 7, 0, -19 },
  { 1441, 10, 20, 13, 1, -14 },
  { 1466, 10, 19, 13, 1, -19 },
  { 1490, 4, 19, 6, 1, -19 },
  { 1500, 6, 25, 6, -1, -19 },
  { 1519, 11, 19, 12, 1, -19 },
  { 1546, 4, 19, 6, 1, -19 },
  { 1556, 16, 14, 19, 1, -14 },
  { 1584, 10, 14, 13, 1, -14 },
  { 1602, 10, 14, 12, 1, -14 },
  { 1620, 11, 20, 13, 1, -14 },
  { 1648, 10, 20, 13, 1, -14 },
  { 1673, 7, 14, 9, 1, -14 },
  { 1686, 8, 14, 9, 1, -14 },
  { 1700, 8, 17, 8, 0, -17 },
  { 1717, 10, 14, 13, 1, -14 },
  { 1735, 11, 14, 11, 0, -14 },
  { 1755, 17, 14, 17, 0, -14 },
  { 1785, 11, 14, 11, 0, -14 },
  { 1805, 11, 20, 11, 0, -14 },
  { 1833, 9, 14, 9, 0, -14 },
  { 1849, 8, 22, 9, 0, -18 },
  { 1871, 3, 25, 11, 4, -19 },
  { 1881, 7, 22, 9, 1, -18 },
  { 1901, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Bold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD25PT7B_H_
