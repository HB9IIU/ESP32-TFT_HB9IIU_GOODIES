#ifndef _NOTOSANS_EXTRACONDENSED_BOLD15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xF7, 0xB0, 0x14, 0x68, 0xD3, 0xF7, 0xE5,
  0x8B, 0x7F, 0x28, 0xD1, 0xA0, 0x27, 0xFB, 0xCE, 0x38, 0xE5, 0xBF, 0xC8,
  0x40, 0x71, 0x8E, 0x21, 0x6C, 0x6D, 0x05, 0xEC, 0xEF, 0xDD, 0x58, 0x69,
  0x09, 0x21, 0x3C, 0x63, 0x00, 0x38, 0x7C, 0x6C, 0x6C, 0x38, 0x73, 0x7B,
  0xCF, 0xCE, 0x7E, 0x7B, 0xFF, 0x36, 0x4C, 0xCC, 0xCC, 0xCC, 0xC6, 0x70,
  0xC6, 0x63, 0x33, 0x33, 0x33, 0x26, 0xC0, 0x31, 0x5F, 0xCE, 0x6C, 0xA0,
  0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C,
  0x21, 0x86, 0x10, 0xC3, 0x18, 0x61, 0x0C, 0x00, 0x39, 0xF6, 0xDB, 0x6F,
  0x34, 0xDB, 0x6D, 0xF3, 0x80, 0x37, 0xFF, 0x33, 0x33, 0x33, 0x30, 0x3B,
  0xF4, 0xC3, 0x0C, 0x61, 0x8C, 0x61, 0xFF, 0xC0, 0x7B, 0xF4, 0xC3, 0x1C,
  0xE1, 0xC3, 0x0F, 0xFF, 0x80, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0x93, 0x7F,
  0xFE, 0x18, 0x30, 0xFF, 0xF1, 0x8F, 0x7C, 0x63, 0x1F, 0xFC, 0x1C, 0xF6,
  0x18, 0x5B, 0xFE, 0xF3, 0x6D, 0xF3, 0x80, 0xFF, 0xF0, 0xC3, 0x0C, 0x61,
  0x86, 0x30, 0xC7, 0x00, 0x39, 0xF6, 0xDB, 0x7C, 0xE6, 0xD3, 0xC5, 0xB7,
  0x80, 0x39, 0xF6, 0xF3, 0xCD, 0xB7, 0x43, 0x0D, 0xE7, 0x80, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x02, 0x1C, 0xE7, 0x07, 0x83, 0xC1, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x81, 0xC0, 0xE0, 0x73, 0xDE, 0x30, 0x00, 0x77, 0xE6,
  0x31, 0x98, 0x84, 0x03, 0x98, 0x1C, 0x39, 0x90, 0x7B, 0xDB, 0x6D, 0xB6,
  0xDB, 0x69, 0x9B, 0x60, 0x18, 0x87, 0xC0, 0x18, 0x3C, 0x3C, 0x3C, 0x2C,
  0x66, 0x66, 0x7E, 0x66, 0xE7, 0xC3, 0xF3, 0xFC, 0xF3, 0xDF, 0xEC, 0xF3,
  0xCF, 0xFF, 0x80, 0x39, 0xFE, 0x70, 0xC3, 0x0C, 0x30, 0xC1, 0xF7, 0xC0,
  0xF1, 0xFB, 0x36, 0x7C, 0x78, 0xF1, 0xE7, 0xCD, 0xFB, 0xE0, 0xFF, 0xF1,
  0x8C, 0x7F, 0x18, 0xC7, 0xFE, 0xFF, 0xF1, 0x8C, 0x7F, 0xF8, 0xC6, 0x30,
  0x3E, 0xFB, 0x96, 0x0C, 0x1B, 0xF7, 0xE7, 0xCE, 0xFD, 0xF8, 0xC7, 0x8F,
  0x1E, 0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xF7, 0x66, 0x66, 0x66,
  0x67, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xCF, 0x9B, 0x76,
  0xCF, 0x1E, 0x3E, 0x6C, 0xCD, 0x9B, 0x38, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0xFE, 0xE1, 0xF8, 0xFE, 0x3F, 0xCF, 0xF2, 0xFD, 0xBD, 0x6F, 0x73,
  0xDC, 0xF7, 0x3C, 0xCC, 0xC3, 0xC7, 0x8F, 0x9F, 0x3B, 0x76, 0xE7, 0xCF,
  0x9F, 0x18, 0x38, 0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xF9, 0xF0,
  0xF3, 0xEC, 0xF3, 0xCF, 0xFF, 0xB0, 0xC3, 0x0C, 0x00, 0x38, 0xFB, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0xF9, 0xF0, 0x60, 0xC0, 0xC0, 0xF1, 0xF3,
  0x36, 0x6C, 0xDF, 0x3E, 0x6C, 0xD9, 0x9B, 0x38, 0x39, 0xF6, 0x58, 0x60,
  0xE1, 0xC3, 0x8F, 0xFF, 0x80, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x00, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0xF9, 0xF0,
  0xC3, 0xC6, 0x46, 0x66, 0x66, 0x6C, 0x2C, 0x3C, 0x3C, 0x38, 0x18, 0xC4,
  0x78, 0xCF, 0x39, 0xE7, 0x36, 0xA6, 0xD5, 0x9E, 0xF3, 0xDE, 0x7B, 0xC7,
  0x38, 0xC6, 0x00, 0xC6, 0xD9, 0xB1, 0x63, 0x87, 0x0E, 0x1E, 0x6C, 0xDB,
  0x18, 0xC7, 0xCD, 0xB3, 0x63, 0x87, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0xF0, 0xC6, 0x18, 0xC3, 0x18, 0x63, 0xFF, 0xC0, 0xFF, 0x6D, 0xB6, 0xDB,
  0x6E, 0xC1, 0x06, 0x18, 0x20, 0xC3, 0x06, 0x18, 0x20, 0xC0, 0xFF, 0x33,
  0x33, 0x33, 0x33, 0x33, 0xF0, 0x18, 0x18, 0x3C, 0x3C, 0x64, 0x66, 0xC3,
  0xFC, 0xCC, 0x7D, 0x30, 0xDF, 0x6F, 0x36, 0xDD, 0xC3, 0x0C, 0x3E, 0xDF,
  0x3C, 0xF3, 0xCF, 0xFF, 0x80, 0x7E, 0xB1, 0x8C, 0x63, 0xCE, 0x0C, 0x30,
  0xFB, 0xDF, 0x3C, 0xF3, 0xCF, 0x7E, 0xC0, 0x7E, 0xF3, 0xF8, 0x63, 0xAF,
  0x7B, 0x19, 0xE6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0x7C, 0xF3, 0xCF, 0x3F,
  0xFB, 0x0E, 0x6F, 0x98, 0xC3, 0x0C, 0x3E, 0xDF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xC0, 0xF3, 0xFF, 0xFC, 0x6C, 0x36, 0xDB, 0x6D, 0xB7, 0xE0, 0xC3, 0x0C,
  0x33, 0xDB, 0xCF, 0x3E, 0xDB, 0x3C, 0xC0, 0xFF, 0xFF, 0xFC, 0xFB, 0xEE,
  0xF3, 0x79, 0xBC, 0xDE, 0x6F, 0x37, 0x9B, 0xFB, 0x7C, 0xF3, 0xCF, 0x3C,
  0xF3, 0x7B, 0x6C, 0xF3, 0xCF, 0x3F, 0x9E, 0xFB, 0x7C, 0xF3, 0xCF, 0x3F,
  0xFE, 0xC3, 0x0C, 0x30, 0xFF, 0x7C, 0xF3, 0xCF, 0x3F, 0xFB, 0x0C, 0x30,
  0xC3, 0xBF, 0xCC, 0xCC, 0xCC, 0x7E, 0x78, 0xE3, 0x8F, 0xFF, 0x63, 0x3E,
  0xC6, 0x31, 0x8C, 0x7B, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFB, 0xCE,
  0x99, 0xB3, 0x66, 0x87, 0x0E, 0x1C, 0xCC, 0xF3, 0x36, 0xED, 0xEE, 0x7B,
  0x9C, 0xE3, 0x38, 0xCC, 0xCD, 0xE7, 0x8E, 0x39, 0xE6, 0xF3, 0xCE, 0x99,
  0xB3, 0x66, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0x82, 0x00, 0xF8, 0xCC, 0x66,
  0x33, 0xFF, 0x19, 0xCC, 0x63, 0x1B, 0x9C, 0x31, 0x8C, 0x63, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x8C, 0x44, 0x46, 0x77, 0x64, 0x44, 0xC0, 0x23, 0xFE,
  0x70,
};

const GFXglyph NotoSans_ExtraCondensed_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 7, 11, 8, 0, -11 },
  { 17, 5, 12, 7, 1, -11 },
  { 25, 11, 11, 12, 0, -11 },
  { 41, 8, 11, 8, 0, -11 },
  { 52, 2, 4, 4, 1, -11 },
  { 53, 4, 13, 5, 1, -11 },
  { 60, 4, 13, 5, 0, -11 },
  { 67, 6, 6, 7, 0, -11 },
  { 72, 7, 7, 7, 0, -9 },
  { 79, 3, 4, 4, 0, -2 },
  { 81, 4, 2, 5, 0, -5 },
  { 82, 2, 2, 4, 1, -2 },
  { 83, 6, 11, 6, 0, -11 },
  { 92, 6, 11, 7, 0, -11 },
  { 101, 4, 11, 7, 1, -11 },
  { 107, 6, 11, 7, 0, -11 },
  { 116, 6, 11, 7, 0, -11 },
  { 125, 7, 11, 7, 0, -11 },
  { 135, 5, 11, 7, 1, -11 },
  { 142, 6, 11, 7, 0, -11 },
  { 151, 6, 11, 7, 0, -11 },
  { 160, 6, 11, 7, 0, -11 },
  { 169, 6, 11, 7, 0, -11 },
  { 178, 2, 8, 4, 1, -8 },
  { 180, 2, 10, 4, 1, -8 },
  { 183, 7, 7, 7, 0, -9 },
  { 190, 7, 5, 7, 0, -8 },
  { 195, 7, 7, 7, 0, -9 },
  { 202, 5, 11, 6, 0, -11 },
  { 209, 9, 12, 11, 1, -11 },
  { 223, 8, 11, 8, 0, -11 },
  { 234, 6, 11, 8, 1, -11 },
  { 243, 6, 11, 7, 1, -11 },
  { 252, 7, 11, 8, 1, -11 },
  { 262, 5, 11, 7, 1, -11 },
  { 269, 5, 11, 6, 1, -11 },
  { 276, 7, 11, 8, 1, -11 },
  { 286, 7, 11, 9, 1, -11 },
  { 296, 4, 11, 5, 0, -11 },
  { 302, 4, 14, 4, -1, -11 },
  { 309, 7, 11, 8, 1, -11 },
  { 319, 5, 11, 6, 1, -11 },
  { 326, 10, 11, 12, 1, -11 },
  { 340, 7, 11, 9, 1, -11 },
  { 350, 7, 11, 9, 1, -11 },
  { 360, 6, 11, 7, 1, -11 },
  { 369, 7, 14, 9, 1, -11 },
  { 382, 7, 11, 8, 1, -11 },
  { 392, 6, 11, 6, 0, -11 },
  { 401, 6, 11, 6, 0, -11 },
  { 410, 7, 11, 9, 1, -11 },
  { 420, 8, 11, 8, 0, -11 },
  { 431, 11, 11, 11, 0, -11 },
  { 447, 7, 11, 7, 0, -11 },
  { 457, 7, 11, 7, 0, -11 },
  { 467, 6, 11, 6, 0, -11 },
  { 476, 3, 13, 5, 1, -11 },
  { 481, 6, 11, 6, 0, -11 },
  { 490, 4, 13, 5, 0, -11 },
  { 497, 8, 7, 8, 0, -11 },
  { 504, 6, 1, 6, 0, 1 },
  { 505, 3, 2, 5, 1, -11 },
  { 506, 6, 8, 7, 0, -8 },
  { 512, 6, 11, 8, 1, -11 },
  { 521, 5, 8, 6, 1, -8 },
  { 526, 6, 11, 8, 1, -11 },
  { 535, 5, 8, 7, 1, -8 },
  { 540, 5, 11, 4, 0, -11 },
  { 547, 6, 12, 8, 1, -8 },
  { 556, 6, 11, 8, 1, -11 },
  { 565, 2, 11, 4, 1, -11 },
  { 568, 3, 15, 4, 0, -11 },
  { 574, 6, 11, 7, 1, -11 },
  { 583, 2, 11, 4, 1, -11 },
  { 586, 9, 8, 11, 1, -8 },
  { 595, 6, 8, 8, 1, -8 },
  { 601, 6, 8, 7, 1, -8 },
  { 607, 6, 12, 8, 1, -8 },
  { 616, 6, 12, 8, 1, -8 },
  { 625, 4, 8, 5, 1, -8 },
  { 629, 5, 8, 6, 0, -8 },
  { 634, 5, 10, 5, 0, -10 },
  { 641, 6, 8, 8, 1, -8 },
  { 647, 7, 8, 7, 0, -8 },
  { 654, 10, 8, 10, 0, -8 },
  { 664, 6, 8, 6, 0, -8 },
  { 670, 7, 12, 7, 0, -8 },
  { 681, 5, 8, 5, 0, -8 },
  { 686, 5, 13, 5, 0, -11 },
  { 695, 2, 14, 7, 2, -11 },
  { 699, 4, 13, 5, 1, -11 },
  { 706, 7, 3, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Bold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD15PT7B_H_
