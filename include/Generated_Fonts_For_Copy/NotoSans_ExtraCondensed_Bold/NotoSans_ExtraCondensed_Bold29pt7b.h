#ifndef _NOTOSANS_EXTRACONDENSED_BOLD29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0xE7, 0x38, 0x00, 0x03,
  0xFE, 0xF7, 0x00, 0xF3, 0xFE, 0x7B, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x9C,
  0x73, 0x8E, 0x0E, 0x60, 0x73, 0x03, 0x38, 0x19, 0xC1, 0xCE, 0x0E, 0x73,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEE, 0x06, 0x70, 0x33, 0x8F, 0xFF, 0x7F,
  0xFB, 0xFF, 0xC7, 0x30, 0x3B, 0x81, 0x9C, 0x0C, 0xE0, 0xE7, 0x07, 0x38,
  0x00, 0x06, 0x00, 0xC0, 0x3E, 0x1F, 0xF7, 0xFE, 0xFD, 0xBD, 0x87, 0xB0,
  0xF6, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x37, 0x86,
  0xFE, 0xFF, 0xFF, 0x7F, 0xC0, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x3C, 0x07,
  0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x0E, 0x71, 0xC0, 0xE7, 0x1C, 0x0E, 0x71,
  0xC0, 0xE7, 0x38, 0x0E, 0x73, 0x80, 0xE7, 0x31, 0x8E, 0x77, 0x3E, 0x7E,
  0x77, 0xF7, 0xEE, 0x77, 0x3C, 0xEE, 0x70, 0x0C, 0xE7, 0x01, 0xCE, 0x70,
  0x1C, 0xE7, 0x03, 0x8E, 0x70, 0x38, 0x67, 0x03, 0x87, 0x70, 0x70, 0x7E,
  0x07, 0x03, 0xE0, 0x0F, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xCE, 0x07, 0x9E,
  0x0F, 0x38, 0x1E, 0x70, 0x1D, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0xFC, 0x7B,
  0xF9, 0xEF, 0x7B, 0xDE, 0x7F, 0xBC, 0xFE, 0x78, 0xFC, 0xF0, 0xF1, 0xF3,
  0xF3, 0xFF, 0xE3, 0xFF, 0xE3, 0xFB, 0xE0, 0xFF, 0xF7, 0x77, 0x77, 0x0F,
  0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E,
  0x0F, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x38, 0x70, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x77, 0x7F, 0xFF, 0xFF, 0xC7,
  0xC1, 0xF8, 0x3B, 0x8F, 0x78, 0xC6, 0x08, 0x80, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7B, 0xDD, 0xEF, 0x73, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0xE0, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x3D, 0xE7, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0x71,
  0xEF, 0x79, 0xFF, 0x1F, 0xC1, 0xF0, 0x03, 0x83, 0xC3, 0xE3, 0xF3, 0xFB,
  0xFF, 0xDE, 0x4F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1F, 0x0F, 0xF3, 0xFF, 0x7D, 0xF6,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0x1F, 0xFB, 0xFF, 0x39, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x07, 0xC7,
  0xF0, 0xFC, 0x1F, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF8, 0x7F,
  0xFF, 0x7F, 0xEF, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xBC, 0x1D, 0xE0, 0xCF, 0x0E, 0x78, 0x73, 0xC7,
  0x1E, 0x38, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x7F, 0x8F, 0xF9, 0xFF, 0x11, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF8, 0x7F, 0xFF, 0x7F, 0xC7, 0xF0, 0x07, 0xC3, 0xF8, 0xFF,
  0x1F, 0x97, 0x80, 0xE0, 0x3C, 0x07, 0x90, 0xFF, 0xDD, 0xFB, 0xFF, 0xF8,
  0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xEF, 0x3D, 0xFF, 0x9F, 0xE1,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xFC,
  0x7F, 0xCF, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE7, 0xBE, 0x7F, 0xC3, 0xF8,
  0x1F, 0x87, 0xFC, 0x7B, 0xEF, 0x1E, 0xF0, 0xEE, 0x0F, 0xF0, 0xEF, 0x1E,
  0xFF, 0xE7, 0xFC, 0x3F, 0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x7D, 0xEF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xEF, 0xBF, 0xF7, 0xEE, 0x39,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF9, 0xFE, 0x3F, 0x87, 0xE0, 0xEF, 0xFF,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x73, 0xDE, 0xF3, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3D, 0xEF, 0x77, 0xBD, 0xC0, 0x00, 0x30, 0x0F, 0x03, 0xF0,
  0xFE, 0x3F, 0x8F, 0xE0, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x00,
  0xC0, 0x08, 0x00, 0x3F, 0x3F, 0xEF, 0xFD, 0xDF, 0x43, 0xC0, 0x70, 0x3C,
  0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x03, 0xE0, 0xF8, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3E,
  0x7C, 0x0E, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x43, 0x9C, 0x7F, 0x73, 0x9F,
  0xE7, 0x63, 0x9C, 0xFC, 0xE3, 0x9F, 0x9C, 0x73, 0xF3, 0x8E, 0x7E, 0x71,
  0xCF, 0xCE, 0x71, 0xB9, 0xCF, 0x77, 0x1F, 0xFE, 0x73, 0xEF, 0x8E, 0x18,
  0xE1, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3C, 0xE0, 0x71, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0x78, 0x3C, 0xF0, 0x79, 0xE0,
  0xFF, 0xC0, 0xFF, 0x01, 0xE0, 0xFE, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF3, 0xEF, 0xFC, 0xFF, 0xCF, 0xFE, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC, 0xFF,
  0x80, 0x07, 0xE1, 0xFF, 0x1F, 0xF3, 0xFF, 0x7C, 0x17, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x7C, 0x03, 0xE3, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xFC,
  0x3F, 0xF9, 0xFF, 0xCF, 0x1F, 0x78, 0x7B, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0xF1,
  0xF7, 0xBF, 0x3F, 0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x03, 0xF0, 0x3F, 0xF1,
  0xFF, 0x8F, 0xCE, 0x3C, 0x09, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE0, 0xF7, 0x83, 0xDE, 0x0F,
  0x78, 0x3C, 0xF0, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0x80, 0xFF, 0xFF, 0xFB, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7B,
  0xFF, 0xFF, 0xE0, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0xBF, 0xFE, 0xFE, 0xF8, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xE3,
  0xCF, 0x3E, 0x79, 0xE3, 0xDF, 0x1E, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x79, 0xE3, 0xCF, 0x1E, 0x7C, 0xF1, 0xE7, 0x8F, 0xBC,
  0x3D, 0xE1, 0xEF, 0x07, 0x80, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xDF, 0xF8, 0x77, 0xFE,
  0x1D, 0xFD, 0xCF, 0x7F, 0x73, 0x9F, 0xDC, 0xE7, 0xF7, 0x39, 0xFC, 0xFE,
  0x7F, 0x3F, 0x1F, 0xCF, 0xC7, 0xF3, 0xF1, 0xFC, 0x78, 0x7F, 0x1E, 0x1F,
  0xC7, 0x87, 0xF1, 0xE1, 0xC0, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1F, 0xDE, 0x7F, 0x79,
  0xFC, 0xE7, 0xF3, 0xDF, 0xC7, 0x7F, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xF7, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xDE, 0x0F, 0xBC, 0x1E,
  0x78, 0x3C, 0x7C, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x1F,
  0xF3, 0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xFF, 0xFF, 0xEF, 0xF9, 0xF8, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xF7, 0xE7, 0xC3,
  0xCF, 0x07, 0x9E, 0x0F, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0x03, 0xDE, 0x0F, 0xBC, 0x1E, 0x78, 0x3C, 0x7C,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0xFE, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0x1E,
  0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x3F, 0xF1, 0xFF, 0x0F,
  0xF8, 0x7B, 0xC3, 0xCF, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x3C, 0x7D, 0xE1,
  0xEF, 0x0F, 0x80, 0x1F, 0x0F, 0xF7, 0xFF, 0xFF, 0xF0, 0xBC, 0x0F, 0x03,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xC7, 0x9F, 0xFC, 0xFF, 0xC1, 0xFC,
  0x00, 0xF0, 0x1F, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xE7, 0x83, 0xCF, 0x07,
  0x0E, 0x0E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0xE0, 0x71, 0xC0, 0xE7, 0x81,
  0xCF, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07,
  0x83, 0xFC, 0x1E, 0x1E, 0xF0, 0xF8, 0x79, 0xC3, 0xE1, 0xE7, 0x8F, 0xC7,
  0x9E, 0x3F, 0x1E, 0x79, 0xFC, 0x71, 0xE7, 0x73, 0xC3, 0x9D, 0xCF, 0x0E,
  0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0xFF, 0x3B, 0x83, 0xF8, 0xEE, 0x07, 0xE3,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xF0,
  0x0F, 0x07, 0xC0, 0xF8, 0x79, 0xE1, 0xE7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0,
  0x77, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x0F, 0x78, 0x3C, 0xF0, 0xF3, 0xC7, 0x87,
  0x9E, 0x1E, 0xF0, 0x7C, 0xF0, 0x3F, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01,
  0xDE, 0x0F, 0x38, 0x38, 0xF1, 0xE1, 0xC7, 0x07, 0xBC, 0x0E, 0xE0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0x1F, 0x8F, 0xF8, 0xFF, 0x10,
  0xF0, 0x1E, 0x03, 0xC7, 0xFB, 0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x3F, 0xFF, 0xDF, 0xBB, 0xE7, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x39, 0xE7, 0x7E, 0xFF, 0xDF, 0x3F, 0xC7, 0xF8, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xF1, 0xFE, 0x3F, 0xC7, 0xFF, 0xFE, 0xFD, 0xDF, 0x00,
  0x1F, 0x8F, 0xF7, 0xF9, 0xE2, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x78, 0x5F, 0xF3, 0xFC, 0x7E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF3, 0xFF, 0x7F, 0xF7, 0x9F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79,
  0xF7, 0xFF, 0x7F, 0xF3, 0xE7, 0x1F, 0x07, 0xF9, 0xFF, 0x3C, 0xFF, 0x0F,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x78, 0x07, 0x82, 0xFF,
  0xCF, 0xF8, 0xFE, 0x0F, 0xC7, 0xE3, 0xF8, 0xF2, 0x3C, 0x0F, 0x07, 0xFB,
  0xFE, 0xFF, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1E, 0x73, 0xFF, 0x7F, 0xF7,
  0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0x79, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xE6,
  0x3E, 0x7F, 0xE7, 0xFC, 0x3F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x39, 0xE7, 0x7E, 0xFF, 0xDF, 0x7F, 0xC7, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xC0, 0x73, 0xFE, 0xE0, 0x01, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x1C, 0x3C, 0xF8, 0xE0, 0x00, 0x07, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1D, 0x7B, 0xF7, 0xCF, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0xFE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF3, 0x8E, 0x3C, 0xE3, 0xCE, 0x1E, 0xE1,
  0xEE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7,
  0x8F, 0x3B, 0xF7, 0xEF, 0xFF, 0xFF, 0xEF, 0xDF, 0xF1, 0xE3, 0xFC, 0x78,
  0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F,
  0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xE7,
  0x9D, 0xFB, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0x1F, 0x83, 0xFC,
  0x7F, 0xE7, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xE7, 0x9D, 0xFB,
  0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xFF, 0xFB, 0xF7, 0x3C, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x73, 0xFF, 0x7F, 0xF7, 0x9F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79,
  0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0xE7, 0xEF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x3F, 0xFF, 0xDE,
  0x2E, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0xF8, 0x7F, 0xFF,
  0xFD, 0xFC, 0x1C, 0x0E, 0x0F, 0x07, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0x9F, 0xC7, 0xE0,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x3F, 0xFF, 0xFF, 0xBB, 0xE7, 0xF0, 0x7F,
  0x83, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x1C, 0x70, 0xE7, 0x87, 0xBC, 0x3D,
  0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0xF0, 0xF0, 0xFF, 0x1F, 0x0E, 0x71, 0xF1, 0xE7, 0x9F, 0x9E, 0x79, 0xF9,
  0xE7, 0x9B, 0x9C, 0x39, 0xB9, 0xC3, 0xB9, 0xBC, 0x3B, 0x9B, 0xC3, 0xF9,
  0xB8, 0x3F, 0x9F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F,
  0x0F, 0x00, 0xF0, 0xF0, 0xF0, 0xF7, 0x9E, 0x79, 0xE3, 0xDE, 0x3F, 0xC1,
  0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0xC3, 0xFC, 0x39, 0xE7,
  0x9E, 0x78, 0xEF, 0x0F, 0xF0, 0x7F, 0x83, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F,
  0x1C, 0x70, 0xF7, 0x87, 0xBC, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xBC,
  0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0x87, 0xC3, 0xE3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x9F, 0x8F, 0x87, 0xE1, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xF0, 0xF8, 0xFC, 0xFC, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF1, 0xF0, 0xF8, 0x40, 0x00, 0x30,
  0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 21, 7, 1, -21 },
  { 15, 11, 8, 13, 1, -21 },
  { 26, 13, 21, 15, 1, -21 },
  { 61, 11, 24, 14, 1, -22 },
  { 94, 20, 21, 22, 1, -21 },
  { 147, 15, 21, 16, 1, -21 },
  { 187, 4, 8, 7, 1, -21 },
  { 191, 8, 26, 9, 1, -21 },
  { 217, 8, 26, 9, 0, -21 },
  { 243, 11, 12, 13, 1, -22 },
  { 260, 12, 14, 13, 1, -17 },
  { 281, 5, 7, 7, 1, -3 },
  { 286, 7, 4, 9, 1, -10 },
  { 290, 5, 4, 7, 1, -4 },
  { 293, 12, 21, 12, 0, -21 },
  { 325, 11, 21, 13, 1, -21 },
  { 354, 9, 21, 13, 1, -21 },
  { 378, 11, 21, 13, 1, -21 },
  { 407, 11, 21, 13, 1, -21 },
  { 436, 13, 21, 13, 0, -21 },
  { 471, 11, 21, 13, 1, -21 },
  { 500, 11, 21, 13, 1, -21 },
  { 529, 12, 21, 13, 1, -21 },
  { 561, 12, 21, 13, 1, -21 },
  { 593, 11, 21, 13, 1, -21 },
  { 622, 4, 16, 8, 2, -16 },
  { 630, 5, 20, 8, 1, -16 },
  { 643, 12, 14, 13, 1, -17 },
  { 664, 12, 9, 13, 1, -15 },
  { 678, 12, 14, 13, 1, -17 },
  { 699, 10, 21, 11, 0, -21 },
  { 726, 19, 23, 21, 1, -21 },
  { 781, 15, 21, 15, 0, -21 },
  { 821, 12, 21, 15, 2, -21 },
  { 853, 12, 21, 14, 1, -21 },
  { 885, 13, 21, 16, 2, -21 },
  { 920, 9, 21, 13, 2, -21 },
  { 944, 9, 21, 13, 2, -21 },
  { 968, 14, 21, 16, 1, -21 },
  { 1005, 13, 21, 17, 2, -21 },
  { 1040, 7, 21, 9, 1, -21 },
  { 1059, 8, 27, 8, -2, -21 },
  { 1086, 13, 21, 15, 2, -21 },
  { 1121, 9, 21, 12, 2, -21 },
  { 1145, 18, 21, 22, 2, -21 },
  { 1193, 14, 21, 18, 2, -21 },
  { 1230, 15, 21, 17, 1, -21 },
  { 1270, 11, 21, 14, 2, -21 },
  { 1299, 15, 26, 17, 1, -21 },
  { 1348, 13, 21, 15, 2, -21 },
  { 1383, 10, 21, 12, 1, -21 },
  { 1410, 12, 21, 12, 0, -21 },
  { 1442, 13, 21, 17, 2, -21 },
  { 1477, 15, 21, 15, 0, -21 },
  { 1517, 22, 21, 22, 0, -21 },
  { 1575, 14, 21, 14, 0, -21 },
  { 1612, 14, 21, 14, 0, -21 },
  { 1649, 12, 21, 12, 0, -21 },
  { 1681, 6, 26, 9, 2, -21 },
  { 1701, 12, 21, 12, 0, -21 },
  { 1733, 6, 26, 9, 1, -21 },
  { 1753, 14, 13, 15, 1, -21 },
  { 1776, 12, 2, 12, 0, 3 },
  { 1779, 7, 4, 9, 1, -22 },
  { 1783, 11, 16, 13, 1, -16 },
  { 1805, 11, 22, 15, 2, -22 },
  { 1836, 10, 16, 12, 1, -16 },
  { 1856, 12, 22, 15, 1, -22 },
  { 1889, 11, 16, 13, 1, -16 },
  { 1911, 10, 22, 9, 0, -22 },
  { 1939, 12, 23, 15, 1, -16 },
  { 1974, 11, 22, 15, 2, -22 },
  { 2005, 5, 22, 7, 1, -22 },
  { 2019, 7, 29, 7, -1, -22 },
  { 2045, 12, 22, 14, 2, -22 },
  { 2078, 3, 22, 7, 2, -22 },
  { 2087, 18, 16, 22, 2, -16 },
  { 2123, 11, 16, 15, 2, -16 },
  { 2145, 12, 16, 14, 1, -16 },
  { 2169, 11, 23, 15, 2, -16 },
  { 2201, 12, 23, 15, 1, -16 },
  { 2236, 8, 16, 10, 2, -16 },
  { 2252, 9, 16, 11, 1, -16 },
  { 2270, 9, 19, 10, 0, -19 },
  { 2292, 11, 16, 15, 2, -16 },
  { 2314, 13, 16, 13, 0, -16 },
  { 2340, 20, 16, 20, 0, -16 },
  { 2380, 12, 16, 12, 0, -16 },
  { 2404, 13, 23, 13, 0, -16 },
  { 2442, 9, 16, 10, 1, -16 },
  { 2460, 9, 26, 10, 0, -21 },
  { 2490, 3, 29, 13, 5, -22 },
  { 2501, 9, 26, 10, 1, -21 },
  { 2531, 12, 5, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Bold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD29PT7B_H_
