#ifndef _NOTOSANS_EXTRACONDENSED_BOLD14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xA5, 0x20, 0x34, 0x68, 0xB3, 0xF2, 0x85,
  0x3F, 0x34, 0x68, 0xB0, 0x21, 0xBF, 0x4E, 0x70, 0xC7, 0xBF, 0x88, 0x40,
  0x73, 0x14, 0x8D, 0x23, 0x58, 0x55, 0xDD, 0x50, 0xB4, 0x2D, 0x19, 0x44,
  0x70, 0x38, 0x6C, 0x6C, 0x78, 0x31, 0x7A, 0xDE, 0xCE, 0x7E, 0x7F, 0xFA,
  0x6B, 0x69, 0x24, 0xD9, 0x30, 0xC6, 0x62, 0x33, 0x33, 0x22, 0x6C, 0x30,
  0xCF, 0xCC, 0x79, 0x20, 0x30, 0xCF, 0xFF, 0x30, 0xC0, 0x6D, 0x60, 0xFF,
  0xF0, 0x0C, 0x61, 0x84, 0x30, 0x86, 0x18, 0x43, 0x00, 0x39, 0xE4, 0xD3,
  0xCF, 0x34, 0xD3, 0x78, 0xE0, 0x37, 0xFB, 0x33, 0x33, 0x33, 0x7B, 0xF0,
  0xC3, 0x18, 0x63, 0x18, 0x7F, 0xF0, 0xF9, 0x70, 0xC2, 0x38, 0xE0, 0xC3,
  0xDF, 0xE0, 0x18, 0x62, 0x8E, 0x79, 0x6F, 0xFF, 0x18, 0x60, 0xF7, 0xB1,
  0x8F, 0x0C, 0x63, 0xFF, 0x80, 0x3D, 0xD6, 0x14, 0xFF, 0xBC, 0xD3, 0x7C,
  0xE0, 0xFF, 0xF0, 0xC6, 0x18, 0x63, 0x0C, 0x31, 0x80, 0x79, 0xB4, 0xDB,
  0x39, 0xE4, 0xF3, 0x6D, 0xE0, 0x79, 0xEC, 0xF3, 0xCD, 0xF2, 0xC3, 0x59,
  0xC0, 0xF8, 0x0F, 0x6D, 0x00, 0x1B, 0x58, 0x0C, 0xFF, 0x3C, 0x3C, 0x30,
  0xFC, 0x00, 0x3F, 0xC1, 0xC1, 0xC7, 0x73, 0x00, 0xF7, 0xC6, 0x33, 0x11,
  0x80, 0x63, 0x00, 0x3C, 0x31, 0xB2, 0x57, 0xAA, 0x5D, 0x2E, 0x95, 0x7E,
  0x80, 0x21, 0x0F, 0x80, 0x38, 0x70, 0xF1, 0x66, 0xCD, 0x9F, 0xBF, 0xC7,
  0x8C, 0xFB, 0xEC, 0xF2, 0xFB, 0xEC, 0xF3, 0xFF, 0xE0, 0x7F, 0xF1, 0x8C,
  0x63, 0x18, 0xFB, 0xC0, 0xF3, 0xEC, 0xF3, 0xCF, 0x3C, 0xF3, 0xFB, 0xC0,
  0xFF, 0xCC, 0xFF, 0xCC, 0xFF, 0xFF, 0xCC, 0xFF, 0xCC, 0xCC, 0x3D, 0xFC,
  0x30, 0xDF, 0x7C, 0xF3, 0xFD, 0xF0, 0xCF, 0x3C, 0xF3, 0xFF, 0xFC, 0xF3,
  0xCF, 0x30, 0xF6, 0x66, 0x66, 0x66, 0x6F, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xE0, 0xCF, 0x6D, 0xBC, 0xF3, 0xCD, 0xB6, 0xCF, 0x30, 0xCC, 0xCC,
  0xCC, 0xCC, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0xFF, 0x7F, 0xAF, 0x77, 0xBB,
  0xD9, 0xEC, 0xC0, 0xC7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCF, 0x9C,
  0x79, 0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE6, 0xFC, 0xF0, 0xF7, 0xF7, 0x9D,
  0xFF, 0x18, 0xC6, 0x00, 0x79, 0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE6, 0xFC,
  0xF0, 0x60, 0x70, 0xF3, 0xED, 0xF2, 0xDB, 0xCD, 0xB6, 0xDB, 0x30, 0x7D,
  0xE4, 0x18, 0x70, 0xE1, 0x82, 0xFB, 0xE0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC0, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0, 0xC7,
  0x8D, 0x13, 0x26, 0xCD, 0x8A, 0x14, 0x38, 0x70, 0xCC, 0x79, 0x9B, 0x3B,
  0x27, 0x66, 0xEC, 0xF5, 0x9E, 0xA3, 0x9C, 0x33, 0x86, 0x70, 0xCC, 0xD9,
  0xA1, 0xC3, 0x87, 0x0E, 0x36, 0x6D, 0x9C, 0xCE, 0x99, 0xB3, 0x43, 0x87,
  0x0C, 0x18, 0x30, 0x60, 0xFB, 0xE1, 0x84, 0x30, 0xC6, 0x18, 0xFF, 0xF0,
  0xF2, 0x49, 0x24, 0x92, 0x70, 0xC1, 0x06, 0x18, 0x20, 0xC1, 0x06, 0x18,
  0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10, 0x30, 0xE1, 0x66, 0x58,
  0xC0, 0xFC, 0xD9, 0x80, 0x39, 0xE0, 0xCF, 0x6F, 0x3D, 0xDF, 0xC3, 0x0C,
  0x3C, 0xFB, 0x6C, 0xB3, 0xCB, 0x6B, 0x80, 0x3B, 0xD8, 0x8C, 0x21, 0xA7,
  0x0C, 0x30, 0xCF, 0x7D, 0xB4, 0xF3, 0x4D, 0xB7, 0x40, 0x39, 0xE4, 0xDF,
  0xFD, 0x06, 0x4F, 0x3B, 0x98, 0xEF, 0x31, 0x8C, 0x63, 0x18, 0x35, 0xF6,
  0xD3, 0xCD, 0x36, 0xDF, 0x0D, 0x37, 0x80, 0xC6, 0x31, 0xEF, 0xEF, 0x7B,
  0xDE, 0xF6, 0xB3, 0xFF, 0xFC, 0x4C, 0x36, 0xDB, 0x6D, 0xB7, 0x80, 0xC3,
  0x0C, 0x33, 0xDB, 0xCF, 0x3C, 0xDB, 0x6C, 0xC0, 0xFF, 0xFF, 0xFC, 0xB3,
  0x7F, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xB7, 0xF7, 0xBD, 0xEF,
  0x7B, 0x39, 0xF6, 0xD3, 0xCD, 0x36, 0xCE, 0xB3, 0xED, 0xB2, 0xCF, 0x2D,
  0xBE, 0xC3, 0x0C, 0x00, 0x35, 0xF6, 0xD3, 0xCD, 0x36, 0xDF, 0x0C, 0x30,
  0xC0, 0xBB, 0xCC, 0xCC, 0xCC, 0x73, 0xF0, 0xC3, 0x8F, 0x7E, 0x67, 0xF6,
  0x66, 0x67, 0x70, 0xDE, 0xF7, 0xBD, 0xEF, 0x7D, 0xCF, 0x34, 0xDA, 0x79,
  0xE3, 0x8C, 0xCC, 0xE6, 0xD7, 0x6E, 0xB7, 0x5B, 0xB9, 0xCC, 0x66, 0xCD,
  0xE7, 0x8C, 0x31, 0xE7, 0xB3, 0xCF, 0x34, 0xDA, 0x78, 0xE3, 0x0C, 0x30,
  0xC6, 0x00, 0xFF, 0xCC, 0x66, 0x33, 0xFF, 0x33, 0x22, 0x2E, 0xE2, 0x22,
  0x23, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0x08, 0x42, 0x1C, 0xE4, 0x21, 0x19,
  0xC0, 0xF6, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 6, 1, -10 },
  { 7, 7, 10, 7, 0, -10 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 10, 10, 11, 0, -10 },
  { 37, 8, 10, 8, 0, -10 },
  { 47, 2, 4, 3, 1, -10 },
  { 48, 3, 12, 4, 1, -10 },
  { 53, 4, 12, 4, 0, -10 },
  { 59, 6, 6, 6, 0, -11 },
  { 64, 6, 6, 7, 0, -8 },
  { 69, 3, 4, 3, 0, -2 },
  { 71, 4, 2, 4, 0, -5 },
  { 72, 2, 2, 4, 1, -2 },
  { 73, 6, 10, 6, 0, -10 },
  { 81, 6, 10, 6, 0, -10 },
  { 89, 4, 10, 6, 1, -10 },
  { 94, 6, 10, 6, 0, -10 },
  { 102, 6, 10, 6, 0, -10 },
  { 110, 6, 10, 6, 0, -10 },
  { 118, 5, 10, 6, 1, -10 },
  { 125, 6, 10, 6, 0, -10 },
  { 133, 6, 10, 6, 0, -10 },
  { 141, 6, 10, 6, 0, -10 },
  { 149, 6, 10, 6, 0, -10 },
  { 157, 2, 8, 4, 1, -8 },
  { 159, 3, 10, 4, 0, -8 },
  { 163, 6, 6, 7, 0, -8 },
  { 168, 6, 4, 7, 0, -7 },
  { 171, 6, 6, 7, 0, -8 },
  { 176, 5, 10, 5, 0, -10 },
  { 183, 9, 11, 10, 1, -10 },
  { 196, 7, 10, 7, 0, -10 },
  { 205, 6, 10, 7, 1, -10 },
  { 213, 5, 10, 7, 1, -10 },
  { 220, 6, 10, 8, 1, -10 },
  { 228, 4, 10, 6, 1, -10 },
  { 233, 4, 10, 6, 1, -10 },
  { 238, 6, 10, 8, 1, -10 },
  { 246, 6, 10, 8, 1, -10 },
  { 254, 4, 10, 4, 0, -10 },
  { 259, 4, 13, 4, -1, -10 },
  { 266, 6, 10, 7, 1, -10 },
  { 274, 4, 10, 6, 1, -10 },
  { 279, 9, 10, 11, 1, -10 },
  { 291, 7, 10, 9, 1, -10 },
  { 300, 7, 10, 8, 1, -10 },
  { 309, 5, 10, 7, 1, -10 },
  { 316, 7, 12, 8, 1, -10 },
  { 327, 6, 10, 7, 1, -10 },
  { 335, 6, 10, 6, 0, -10 },
  { 343, 6, 10, 6, 0, -10 },
  { 351, 6, 10, 8, 1, -10 },
  { 359, 7, 10, 7, 0, -10 },
  { 368, 11, 10, 10, 0, -10 },
  { 382, 7, 10, 7, 0, -10 },
  { 391, 7, 10, 7, 0, -10 },
  { 400, 6, 10, 6, 0, -10 },
  { 408, 3, 12, 4, 1, -10 },
  { 413, 6, 10, 6, 0, -10 },
  { 421, 4, 12, 4, 0, -10 },
  { 427, 7, 6, 7, 0, -10 },
  { 433, 6, 1, 6, 0, 1 },
  { 434, 3, 3, 4, 1, -11 },
  { 436, 6, 8, 7, 0, -8 },
  { 442, 6, 11, 7, 1, -11 },
  { 451, 5, 8, 6, 0, -8 },
  { 456, 6, 11, 7, 0, -11 },
  { 465, 6, 8, 6, 0, -8 },
  { 471, 5, 11, 4, 0, -11 },
  { 478, 6, 11, 7, 0, -8 },
  { 487, 5, 11, 7, 1, -11 },
  { 494, 2, 11, 3, 1, -11 },
  { 497, 3, 14, 3, 0, -11 },
  { 503, 6, 11, 7, 1, -11 },
  { 512, 2, 11, 3, 1, -11 },
  { 515, 9, 8, 10, 1, -8 },
  { 524, 5, 8, 7, 1, -8 },
  { 529, 6, 8, 7, 0, -8 },
  { 535, 6, 11, 7, 1, -8 },
  { 544, 6, 11, 7, 0, -8 },
  { 553, 4, 8, 5, 1, -8 },
  { 557, 5, 8, 5, 0, -8 },
  { 562, 4, 9, 5, 0, -9 },
  { 567, 5, 8, 7, 1, -8 },
  { 572, 6, 8, 6, 0, -8 },
  { 578, 9, 8, 10, 0, -8 },
  { 587, 6, 8, 6, 0, -8 },
  { 593, 6, 11, 6, 0, -8 },
  { 602, 5, 8, 5, 0, -8 },
  { 607, 4, 12, 5, 0, -10 },
  { 613, 2, 14, 6, 2, -11 },
  { 617, 5, 12, 5, 0, -10 },
  { 625, 6, 2, 7, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Bold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD14PT7B_H_
