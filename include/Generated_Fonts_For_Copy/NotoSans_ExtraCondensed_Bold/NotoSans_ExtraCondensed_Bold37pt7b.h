#ifndef _NOTOSANS_EXTRACONDENSED_BOLD37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7,
  0x9E, 0x78, 0x00, 0x00, 0x33, 0xEF, 0xFF, 0xF9, 0xE0, 0xF9, 0xFF, 0xC7,
  0xFE, 0x3D, 0xF1, 0xEF, 0x8F, 0x7C, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xF0,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x3C, 0xF0, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0xCE, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x79, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBE, 0xC4, 0xF3, 0x03,
  0xCC, 0x0F, 0xB0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x37, 0x80, 0xDF, 0x83, 0x7F, 0x0D, 0xEF, 0xBF,
  0xBF, 0xFC, 0xFF, 0xE0, 0xFF, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x3C, 0x07, 0xF8, 0x0E, 0x01, 0xFF,
  0x07, 0x80, 0x73, 0xC1, 0xE0, 0x3C, 0x70, 0x70, 0x0F, 0x1E, 0x3C, 0x03,
  0xC7, 0x8E, 0x00, 0xF1, 0xE7, 0x80, 0x3C, 0x79, 0xE0, 0x0F, 0x1E, 0x70,
  0x03, 0xC7, 0x3C, 0x7C, 0x73, 0xCF, 0x3F, 0x9F, 0xF7, 0x9F, 0xE7, 0xF9,
  0xEF, 0x3C, 0xFE, 0x73, 0xCF, 0x0E, 0x3C, 0xF3, 0xC0, 0x0F, 0x3C, 0x70,
  0x03, 0x8F, 0x1C, 0x01, 0xE3, 0xC7, 0x00, 0x70, 0xF1, 0xC0, 0x3C, 0x3C,
  0xF0, 0x0F, 0x0F, 0x3C, 0x03, 0x81, 0xCF, 0x01, 0xE0, 0x7F, 0x80, 0x78,
  0x0F, 0xE0, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7,
  0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x3E, 0x3F, 0xE3, 0xE7, 0xFE, 0x7C, 0xFD, 0xF7, 0xCF,
  0x9F, 0xFC, 0xF8, 0xFF, 0x8F, 0x87, 0xF8, 0xF8, 0x3F, 0x8F, 0x83, 0xF0,
  0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x0F, 0x87, 0x87, 0x83, 0xC3,
  0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E,
  0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F,
  0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x02, 0x3C, 0x27, 0x3B, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC1, 0xE7, 0xC7, 0xC7, 0x83, 0x0E, 0x02, 0x10, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3E, 0xF9,
  0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x33,
  0xEF, 0xBF, 0xF9, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x7F,
  0xC1, 0xFF, 0xC3, 0xFF, 0x8F, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x78, 0x3D,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9F, 0x1F, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x03, 0xE0,
  0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0x73, 0xE4, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80,
  0x3F, 0xC1, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xCE, 0x0F, 0x88, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xC4, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xB0, 0x3F, 0x7F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xE1, 0xFF, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0E, 0xF8, 0x1E, 0xF8,
  0x1C, 0xF8, 0x3C, 0xF8, 0x38, 0xF8, 0x78, 0xF8, 0x70, 0xF8, 0xF0, 0xF8,
  0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xFC, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xFE, 0x0F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xDF, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x80, 0xFB, 0x07, 0xEF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xC7, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE7, 0xC7, 0xDF, 0xCF, 0xFF, 0xDF, 0xFF, 0xBF, 0x1F, 0x7E, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0x87, 0xDF,
  0x1F, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x0F, 0x3C,
  0x1E, 0x7C, 0x7C, 0xF8, 0xF8, 0xFB, 0xE1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC,
  0x0F, 0xFC, 0x1F, 0xFC, 0x7C, 0xFD, 0xF0, 0xFB, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xBF, 0xFE, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F,
  0x80, 0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9F, 0x8F,
  0xBE, 0x1F, 0x7C, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x87, 0xEF, 0x9F, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xBE, 0x1E, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xC1, 0xFE, 0x00, 0x7B, 0xEF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x3E, 0xFF, 0xFF, 0x9E, 0x3C, 0xFD, 0xFB, 0xF3, 0xC3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x79, 0xF3,
  0xE7, 0xCF, 0x1E, 0x3C, 0xF0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00,
  0x06, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x0F, 0x01, 0xFF, 0x3F, 0xFC, 0xFF, 0xE7, 0xFF, 0xB0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xE1, 0xF8, 0x0F, 0x80, 0x7C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3C, 0x1F, 0x0E, 0x38, 0x7F, 0xCF, 0x78,
  0xFF, 0xCF, 0x78, 0xF3, 0xCF, 0x71, 0xE3, 0xC7, 0x71, 0xE3, 0xC7, 0x71,
  0xE3, 0xC7, 0xF1, 0xE3, 0xC7, 0xF1, 0xC3, 0xC7, 0xF1, 0xC3, 0xC7, 0xF1,
  0xC3, 0x8F, 0x71, 0xE7, 0xCF, 0x71, 0xE7, 0xDE, 0x78, 0xFF, 0xFE, 0x78,
  0xFC, 0xFC, 0x78, 0x38, 0x70, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x20, 0x0F, 0xC0, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x9E, 0x01,
  0xF3, 0xC0, 0x3E, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x1E, 0x07,
  0xC3, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xFB, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7C, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xE0, 0x0F, 0xF8,
  0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0xCF, 0xC0, 0x9F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC3, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87, 0xF7, 0xC1, 0xFB,
  0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xCF, 0xF3, 0xFF, 0xF1,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0x11, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF8, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x87, 0xF3, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0xBF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3E,
  0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0xF9,
  0xF8, 0xF9, 0xF0, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xF9, 0xF0, 0xF9,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7E, 0xF8,
  0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0x83, 0xFF, 0xEF, 0x0F,
  0x7F, 0xDE, 0x1E, 0xFF, 0xBC, 0x3D, 0xFF, 0x3C, 0x7B, 0xFE, 0x79, 0xE7,
  0xFC, 0xF3, 0xCF, 0xF9, 0xE7, 0x9F, 0xF1, 0xEF, 0x3F, 0xE3, 0xFC, 0x7F,
  0xC7, 0xF8, 0xFF, 0x8F, 0xF1, 0xFF, 0x0F, 0xC3, 0xFE, 0x1F, 0x87, 0xFC,
  0x3F, 0x0F, 0xF8, 0x7E, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0xF0, 0x7C, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xF7, 0x87, 0xFD, 0xF1, 0xFF, 0x7C, 0x7F,
  0xCF, 0x9F, 0xF3, 0xE7, 0xFC, 0x79, 0xFF, 0x1F, 0x7F, 0xC7, 0xDF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xF0, 0x01, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x87, 0xE7,
  0xC0, 0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0x9F, 0x03, 0xE7,
  0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0xFF, 0x81, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0x87, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF,
  0x03, 0xE7, 0xF3, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x1F, 0x9F, 0x3F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF9, 0xF0, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xC0, 0x07,
  0x80, 0x7F, 0xE3, 0xFF, 0xDF, 0xFE, 0x7F, 0xF9, 0xF0, 0xCF, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFB,
  0x03, 0xEF, 0x1F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x83, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xF1, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x81, 0xF1, 0xE0,
  0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0xBC, 0x01, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x0F, 0x01, 0xFF, 0x81,
  0xF0, 0x1F, 0xF8, 0x1F, 0x03, 0xEF, 0x81, 0xF8, 0x3E, 0x78, 0x1F, 0x83,
  0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x3F, 0x83, 0xE7, 0xC3, 0xF8, 0x3E, 0x7C,
  0x3F, 0xC7, 0xC3, 0xC3, 0xBC, 0x7C, 0x3C, 0x7B, 0xC7, 0xC3, 0xE7, 0xBC,
  0x7C, 0x3E, 0x79, 0xC7, 0xC3, 0xE7, 0x9E, 0xF8, 0x1E, 0x79, 0xEF, 0x81,
  0xEF, 0x9E, 0xF8, 0x1E, 0xF1, 0xEF, 0x81, 0xFF, 0x1E, 0xF8, 0x1F, 0xF0,
  0xEF, 0x01, 0xFF, 0x0E, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x7C, 0x1F, 0xBE, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC1, 0xE3,
  0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xDF, 0x03, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1,
  0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0xFE, 0x07, 0xC0, 0xFC, 0x0F,
  0xDF, 0x03, 0xE7, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x81,
  0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3C, 0xF0,
  0x1F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xE0, 0xF0, 0x7C, 0x7C, 0x0F, 0x1E,
  0x03, 0xEF, 0x80, 0x7B, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x03, 0x80, 0x7F, 0xC3, 0xFF,
  0x8F, 0xFE, 0x3C, 0xFC, 0x41, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFC, 0x7F,
  0xF3, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xFF, 0xF7, 0xFF, 0xDF, 0xEF, 0x3F, 0x3C, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x60, 0xFB,
  0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFE, 0x3E, 0xFF, 0xFD, 0xFF, 0xFB, 0xDF, 0xE7, 0x9F,
  0x80, 0x01, 0x80, 0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xFF, 0x3F, 0x09, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x1B, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x83, 0x0F, 0x1F, 0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3,
  0xEF, 0x87, 0xDE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7F, 0xFE, 0x7F,
  0xFC, 0xFF, 0x78, 0x7C, 0xF0, 0x03, 0x00, 0x1F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xC7, 0xE7, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x04, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xF0, 0xFF,
  0x1F, 0xF1, 0xFE, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x02, 0x00, 0x3F, 0x3C, 0xFF, 0x79, 0xFF, 0xF7, 0xFF,
  0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x1F, 0x7C, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF9, 0xFE, 0xF1, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x40, 0x3E, 0xF1, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x01, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x20, 0xFB, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7,
  0xDF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xBF, 0xFE, 0xFE, 0xFC, 0xF8,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x20, 0xF3, 0xF9, 0xFC, 0xF7, 0xFB, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x7E, 0x3E, 0xF8, 0x7E, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0x00, 0x41, 0xE7, 0xE3, 0xDF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x1E, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x01, 0x80, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x78,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF0, 0x00, 0x41, 0xE7, 0xE3, 0xDF, 0xE7, 0xFF, 0xEF, 0xFF,
  0xDF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x7D, 0xFF,
  0xFB, 0xFF, 0xF7, 0xDF, 0xCF, 0x9F, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x02, 0x00, 0x3F, 0x3C, 0xFF, 0x79, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xDF,
  0x0F, 0xBC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xDE, 0x0F, 0xBE, 0x1F, 0x7C, 0x7E, 0xFF, 0xFC, 0xFF, 0xF9,
  0xFE, 0xF1, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xFE, 0x7B,
  0xCF, 0x7B, 0xEF, 0xFD, 0xFF, 0xBF, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x02, 0x03, 0xFE, 0x7F, 0xF7, 0xFE, 0xFD, 0xEF, 0x82, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFF,
  0x3F, 0xFF, 0xFD, 0xFF, 0xF7, 0xFB, 0xCF, 0xC7, 0xF8, 0x1F, 0x78, 0x1F,
  0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C,
  0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0xF8, 0x3E, 0x0F, 0xBC, 0x1F, 0x87, 0xDF, 0x1F, 0xC3, 0xCF, 0x8F, 0xE3,
  0xE7, 0xC7, 0x71, 0xF3, 0xE3, 0xB8, 0xF8, 0xF1, 0xDC, 0x78, 0x7D, 0xEF,
  0x3C, 0x3E, 0xF3, 0xBE, 0x1F, 0x71, 0xDF, 0x07, 0xB8, 0xEF, 0x83, 0xDC,
  0x77, 0x81, 0xEE, 0x3B, 0xC0, 0xF7, 0x1D, 0xE0, 0x7B, 0x8E, 0xF0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00,
  0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0x7C, 0x3E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x1E,
  0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x5F, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x3F, 0xC7, 0xE0, 0xFE, 0x1F, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xFE, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0x07, 0xE1, 0xFC, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0x07, 0x80, 0x3E, 0x03,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 13, 9, 16, 2, -26 },
  { 36, 17, 26, 19, 1, -26 },
  { 92, 14, 30, 17, 2, -28 },
  { 145, 26, 27, 29, 1, -27 },
  { 233, 20, 27, 21, 1, -27 },
  { 301, 5, 9, 9, 2, -26 },
  { 307, 9, 32, 12, 2, -26 },
  { 343, 9, 32, 12, 1, -26 },
  { 379, 15, 15, 16, 1, -28 },
  { 408, 15, 18, 17, 1, -22 },
  { 442, 7, 9, 9, 1, -4 },
  { 450, 9, 4, 11, 1, -12 },
  { 455, 6, 6, 9, 2, -6 },
  { 460, 15, 27, 15, 0, -27 },
  { 511, 15, 27, 17, 1, -27 },
  { 562, 11, 26, 17, 2, -26 },
  { 598, 15, 27, 17, 1, -27 },
  { 649, 15, 27, 17, 1, -27 },
  { 700, 16, 26, 17, 1, -26 },
  { 752, 14, 26, 17, 2, -26 },
  { 798, 15, 27, 17, 1, -27 },
  { 849, 15, 26, 17, 1, -26 },
  { 898, 15, 27, 17, 1, -27 },
  { 949, 15, 27, 17, 1, -27 },
  { 1000, 6, 20, 10, 2, -20 },
  { 1015, 7, 25, 10, 1, -20 },
  { 1037, 15, 18, 17, 1, -22 },
  { 1071, 15, 12, 17, 1, -19 },
  { 1094, 15, 18, 17, 1, -22 },
  { 1128, 13, 27, 14, 0, -27 },
  { 1172, 24, 30, 27, 1, -27 },
  { 1262, 19, 26, 19, 0, -26 },
  { 1324, 16, 26, 19, 2, -26 },
  { 1376, 15, 27, 18, 2, -27 },
  { 1427, 17, 26, 21, 2, -26 },
  { 1483, 11, 26, 16, 3, -26 },
  { 1519, 11, 26, 16, 3, -26 },
  { 1555, 17, 27, 21, 2, -27 },
  { 1613, 16, 26, 22, 3, -26 },
  { 1665, 10, 26, 12, 1, -26 },
  { 1698, 10, 34, 10, -2, -26 },
  { 1741, 16, 26, 19, 3, -26 },
  { 1793, 12, 26, 15, 2, -26 },
  { 1832, 23, 26, 29, 3, -26 },
  { 1907, 18, 26, 23, 3, -26 },
  { 1966, 18, 27, 22, 2, -27 },
  { 2027, 15, 26, 18, 2, -26 },
  { 2076, 18, 33, 22, 2, -27 },
  { 2151, 17, 26, 19, 2, -26 },
  { 2207, 14, 27, 16, 1, -27 },
  { 2255, 14, 26, 16, 1, -26 },
  { 2301, 17, 26, 21, 2, -26 },
  { 2357, 19, 26, 19, 0, -26 },
  { 2419, 28, 26, 28, 0, -26 },
  { 2510, 17, 26, 18, 0, -26 },
  { 2566, 18, 26, 18, 0, -26 },
  { 2625, 14, 26, 15, 1, -26 },
  { 2671, 9, 32, 12, 2, -26 },
  { 2707, 15, 27, 15, 0, -27 },
  { 2758, 8, 32, 12, 1, -26 },
  { 2790, 18, 16, 20, 1, -26 },
  { 2826, 15, 3, 15, 0, 3 },
  { 2832, 9, 6, 12, 1, -28 },
  { 2839, 14, 21, 17, 1, -21 },
  { 2876, 15, 28, 19, 2, -28 },
  { 2929, 13, 21, 15, 1, -21 },
  { 2964, 15, 28, 19, 1, -28 },
  { 3017, 15, 21, 17, 1, -21 },
  { 3057, 12, 28, 11, 0, -28 },
  { 3099, 15, 30, 19, 1, -21 },
  { 3156, 15, 28, 19, 2, -28 },
  { 3209, 5, 28, 9, 2, -28 },
  { 3227, 8, 37, 9, -1, -28 },
  { 3264, 16, 28, 18, 2, -28 },
  { 3320, 5, 28, 9, 2, -28 },
  { 3338, 24, 21, 28, 2, -21 },
  { 3401, 15, 21, 19, 2, -21 },
  { 3441, 16, 21, 18, 1, -21 },
  { 3483, 15, 30, 19, 2, -21 },
  { 3540, 15, 30, 19, 1, -21 },
  { 3597, 11, 21, 13, 2, -21 },
  { 3626, 12, 21, 14, 1, -21 },
  { 3658, 11, 25, 12, 0, -25 },
  { 3693, 14, 20, 19, 2, -20 },
  { 3728, 16, 20, 16, 0, -20 },
  { 3768, 25, 20, 25, 0, -20 },
  { 3831, 16, 20, 16, 0, -20 },
  { 3871, 16, 29, 16, 0, -20 },
  { 3929, 12, 20, 13, 1, -20 },
  { 3959, 11, 32, 13, 0, -26 },
  { 4003, 4, 37, 16, 6, -28 },
  { 4022, 11, 32, 13, 1, -26 },
  { 4066, 15, 6, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Bold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD37PT7B_H_
