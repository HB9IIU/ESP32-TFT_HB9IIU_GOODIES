#ifndef _NOTOSANS_EXTRACONDENSED_BOLD38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0xCF, 0xBF, 0xFF, 0xF7, 0x80, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0x80, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xC7, 0x80, 0x71, 0xC1, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x00, 0xE3,
  0x80, 0x78, 0xE0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x79, 0xE0,
  0x1C, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xF8, 0x3F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBE, 0xCE, 0xFB, 0x03, 0xCC, 0x0F, 0xB0, 0x3E,
  0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0xDF, 0x03, 0x7E, 0x0D, 0xFC, 0x37, 0xFF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xC3, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0xFE, 0x03, 0xC0, 0x3F, 0xE0, 0x78,
  0x07, 0xBC, 0x0E, 0x01, 0xE3, 0xC3, 0xC0, 0x3C, 0x78, 0x78, 0x07, 0x8F,
  0x1E, 0x00, 0xF1, 0xE3, 0xC0, 0x1E, 0x3C, 0x70, 0x03, 0xC7, 0x9E, 0x00,
  0x78, 0xF3, 0xC7, 0x0F, 0x1E, 0xF1, 0xF8, 0xF7, 0x9E, 0x7F, 0x9F, 0xF3,
  0x9F, 0xF1, 0xFC, 0xF3, 0xCF, 0x1F, 0x1E, 0x71, 0xE0, 0x83, 0x9E, 0x3C,
  0x00, 0xF3, 0xC7, 0x80, 0x1E, 0x78, 0xF0, 0x07, 0x8F, 0x1E, 0x00, 0xF1,
  0xE3, 0xC0, 0x1C, 0x1C, 0x78, 0x07, 0x83, 0xCF, 0x00, 0xF0, 0x7B, 0xC0,
  0x3C, 0x0F, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE7,
  0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0x3F, 0xC3, 0xE7,
  0xFE, 0x3E, 0x7F, 0xF3, 0xEF, 0xDF, 0xBE, 0xF8, 0xFF, 0xCF, 0x87, 0xFC,
  0xF8, 0x7F, 0x8F, 0x83, 0xF8, 0xFC, 0x1F, 0x0F, 0xE3, 0xF8, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8,
  0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x78, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x87,
  0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x1C, 0x06, 0x38, 0xDF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0xC1, 0xF7, 0xC7, 0xCF, 0xC7, 0x8F, 0x02, 0x08, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x73, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0x01, 0x80, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0xC3, 0xFF, 0xCF, 0xCF,
  0x9F, 0x1F, 0x3E, 0x1F, 0x7C, 0x3E, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x1F, 0x3F, 0x3E, 0x3F, 0xFC,
  0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1,
  0xFE, 0x7F, 0xDF, 0xFF, 0xDF, 0x73, 0xE4, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0x00, 0x3F, 0xC0,
  0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xCF, 0x0F, 0x8C, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x00, 0x7F, 0xC1, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xC6, 0x0F,
  0x88, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFD,
  0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x78, 0x0F, 0xF8,
  0x0E, 0xF8, 0x1E, 0xF8, 0x1C, 0xF8, 0x3C, 0xF8, 0x38, 0xF8, 0x78, 0xF8,
  0x70, 0xF8, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xE4, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x03, 0xFE, 0x1F, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x87, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF1, 0xC3, 0xEF, 0xE7, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x9F, 0x9F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xC7, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x7C, 0xFC,
  0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0x7E,
  0x7C, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFF,
  0x0F, 0xBF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x8F, 0xBE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC7, 0xEF, 0xFF, 0xDF,
  0xFF, 0x9F, 0xFF, 0x1F, 0xBE, 0x1C, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x00,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0xFB, 0xFF, 0xFF, 0x78, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F,
  0x3C, 0x79, 0xE0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x02, 0x01, 0xFF, 0x1F, 0xFD, 0xFF, 0xF7, 0xFF, 0xB8, 0x7D, 0x03,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0x80,
  0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x7F, 0x9E,
  0x38, 0x7F, 0xC7, 0x3C, 0x7F, 0xE3, 0xDE, 0x3C, 0xF1, 0xEF, 0x3C, 0x78,
  0xF7, 0x1E, 0x3C, 0x7B, 0x8F, 0x1E, 0x3F, 0xC7, 0x8F, 0x1F, 0xE3, 0xC7,
  0x8F, 0xF1, 0xE3, 0xC7, 0xB8, 0xF1, 0xE3, 0x9C, 0x78, 0xF1, 0xCE, 0x3E,
  0xFD, 0xE7, 0x8F, 0xEF, 0xE3, 0xC3, 0xE3, 0xE0, 0xF0, 0xE0, 0xE0, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x08, 0x03, 0xF0, 0x3C, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7B, 0xE0, 0x0F, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x9F,
  0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E,
  0x07, 0xC7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3E, 0xFC, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC,
  0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x00,
  0x40, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xE1, 0x9F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0xBF, 0x87, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFC, 0xFF, 0x3F, 0x0F, 0xCF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F,
  0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0,
  0x7E, 0xFC, 0x1F, 0x3F, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x30, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFC, 0x19, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF8, 0x3E, 0xFE, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3,
  0xEF, 0xFB, 0xFE, 0xFF, 0x3F, 0x8F, 0xC0, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE,
  0x0F, 0x9F, 0x0F, 0xCF, 0x8F, 0xC7, 0xC7, 0xE3, 0xE7, 0xE1, 0xF3, 0xF0,
  0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFD, 0xF0, 0x7C, 0xFC, 0x3E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3F,
  0x7C, 0x0F, 0xBE, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xF7, 0x83, 0xDF, 0xF7, 0x83, 0xDF, 0xF7, 0x83, 0xDF, 0xF7, 0xC7,
  0xDF, 0xF3, 0xC7, 0x9F, 0xF3, 0xC7, 0x9F, 0xF3, 0xC7, 0x9F, 0xF3, 0xEF,
  0x1F, 0xF1, 0xEF, 0x1F, 0xF1, 0xEF, 0x1F, 0xF1, 0xEF, 0x1F, 0xF1, 0xFE,
  0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0xFC,
  0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x78, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFD, 0xF1, 0xFF, 0x7C, 0x7F, 0xCF,
  0x9F, 0xF3, 0xE3, 0xFC, 0x7C, 0xFF, 0x1F, 0x3F, 0xC7, 0xCF, 0xF0, 0xFB,
  0xFC, 0x3E, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x00,
  0x40, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFE,
  0x3F, 0x1F, 0x83, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0xC0,
  0x7C, 0xF8, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFC, 0xFE, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F,
  0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0xFE, 0x3F, 0x1F, 0x83, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF,
  0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0xFF, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xCF, 0xE7, 0xE1, 0xF3, 0xF0, 0xFD,
  0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x8F, 0xCF, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFD, 0xF0, 0x7E, 0x7C, 0x3F,
  0x3E, 0x1F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE3, 0xF3, 0xF0, 0xF9, 0xF8, 0x7E,
  0xFC, 0x1F, 0x7E, 0x0F, 0xFF, 0x07, 0xE0, 0x01, 0x00, 0x3F, 0xC3, 0xFF,
  0xCF, 0xFF, 0x7F, 0xF9, 0xF9, 0xE7, 0xC0, 0xBF, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xFE,
  0x7E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7D, 0xE0, 0x0F,
  0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x3C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x9E, 0x01, 0xF7, 0xC0,
  0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x0F,
  0x00, 0xFF, 0xC0, 0x7C, 0x0F, 0xBE, 0x03, 0xE0, 0x7D, 0xF0, 0x3F, 0x03,
  0xEF, 0x81, 0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0xF9, 0xF0, 0x7F, 0x0F, 0xCF,
  0x87, 0xF8, 0x7C, 0x7C, 0x3F, 0xC3, 0xE3, 0xE1, 0xFE, 0x1F, 0x0F, 0x0F,
  0x70, 0xF8, 0x7C, 0x7B, 0xCF, 0xC3, 0xE7, 0xDE, 0x7C, 0x1F, 0x3C, 0xF3,
  0xE0, 0xF9, 0xE7, 0x9F, 0x03, 0xCF, 0x3C, 0xF8, 0x1E, 0x78, 0xF7, 0xC0,
  0xFF, 0xC7, 0xBC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0,
  0x7C, 0x0F, 0x9F, 0x07, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F,
  0xCF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF8, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x81, 0xE1, 0xE0, 0xF8, 0x7C,
  0x3C, 0x0F, 0x1F, 0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x0F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE1, 0x87, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x07, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xF9, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xFD, 0xF3, 0xF1,
  0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC,
  0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF1, 0xF0, 0x07,
  0xF0, 0xFF, 0xC7, 0xFE, 0x7F, 0xF7, 0xE1, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x19, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x7F,
  0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x8F, 0x07, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE7, 0xC3, 0xCF, 0x87, 0xDE, 0x0F, 0xBC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x04, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xF1, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0xE3, 0xFF, 0x3F, 0xF9, 0xFF, 0xC1, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0x8F, 0x1F, 0xDF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x7F, 0x7C, 0x3F,
  0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x40, 0x3E, 0x70, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xE7,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x77, 0xFF, 0xFF, 0xB8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xBF,
  0xFF, 0xFE, 0xFE, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xC1,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xE7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x03, 0xEF, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF1, 0xF0, 0xFC, 0xF3, 0xF9, 0xFE, 0xFF, 0xFD, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x3F, 0xFC, 0x7E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x1F, 0xF8, 0x3E, 0x1F, 0xF1, 0xF1, 0xE7, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF,
  0xE7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xF0, 0xF1, 0xF0, 0xF3, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xFE, 0x7E,
  0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x0F, 0x8F, 0x1F, 0xDF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7E, 0x7F,
  0x7C, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7E, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x1F, 0xC3, 0xFF, 0x7F, 0xFF,
  0xFE, 0xF8, 0x6F, 0x80, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0x7F, 0x80, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xE7, 0xFE,
  0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x11, 0xFF,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xFC,
  0x7E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFC, 0xF1, 0xF1, 0xE0, 0xF8, 0x0F, 0xFE,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF1, 0xE1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xEF, 0x81, 0xF7,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1,
  0xE7, 0xC3, 0xF0, 0xF9, 0xF0, 0xFC, 0x3E, 0x7C, 0x7F, 0x0F, 0x9F, 0x1F,
  0xE3, 0xC3, 0xC7, 0x79, 0xF0, 0xF9, 0xCE, 0x7C, 0x3E, 0x73, 0x9F, 0x0F,
  0xBC, 0xE7, 0xC3, 0xEF, 0x39, 0xE0, 0x7B, 0xCF, 0x78, 0x1E, 0xE3, 0xFE,
  0x07, 0xB8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x07,
  0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x1E, 0x3E, 0x0F, 0x9E, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0xF7,
  0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x27, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x7F, 0x8F, 0xF0, 0xFC, 0x0F, 0xF0,
  0x7F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xF0, 0xFF, 0x01,
  0xF0, 0xFF, 0x0F, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xF8,
  0x00, 0x00, 0x01, 0x7F, 0x01, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFE, 0x80, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 13, 10, 17, 2, -27 },
  { 39, 18, 27, 19, 1, -27 },
  { 100, 14, 31, 18, 2, -29 },
  { 155, 27, 28, 29, 1, -28 },
  { 250, 20, 28, 21, 1, -28 },
  { 320, 5, 10, 9, 2, -27 },
  { 327, 9, 33, 12, 2, -27 },
  { 365, 9, 33, 12, 1, -27 },
  { 403, 15, 15, 17, 1, -29 },
  { 432, 16, 19, 18, 1, -23 },
  { 470, 7, 9, 9, 1, -4 },
  { 478, 10, 5, 12, 1, -13 },
  { 485, 6, 6, 10, 2, -6 },
  { 490, 15, 27, 15, 0, -27 },
  { 541, 15, 28, 18, 1, -28 },
  { 594, 11, 27, 18, 2, -27 },
  { 632, 15, 28, 18, 1, -28 },
  { 685, 15, 28, 18, 1, -28 },
  { 738, 16, 27, 18, 1, -27 },
  { 792, 14, 27, 18, 2, -27 },
  { 840, 15, 27, 18, 1, -27 },
  { 891, 15, 27, 18, 1, -27 },
  { 942, 15, 27, 18, 1, -27 },
  { 993, 15, 27, 18, 1, -27 },
  { 1044, 6, 21, 10, 2, -21 },
  { 1060, 7, 26, 10, 1, -21 },
  { 1083, 16, 18, 18, 1, -23 },
  { 1119, 16, 11, 18, 1, -19 },
  { 1141, 16, 18, 18, 1, -23 },
  { 1177, 13, 28, 14, 0, -28 },
  { 1223, 25, 30, 27, 1, -27 },
  { 1317, 20, 27, 20, 0, -27 },
  { 1385, 16, 27, 20, 2, -27 },
  { 1439, 15, 28, 18, 2, -28 },
  { 1492, 18, 27, 21, 2, -27 },
  { 1553, 12, 27, 17, 3, -27 },
  { 1594, 12, 27, 16, 3, -27 },
  { 1635, 17, 28, 21, 2, -28 },
  { 1695, 17, 27, 22, 3, -27 },
  { 1753, 10, 27, 12, 1, -27 },
  { 1787, 10, 35, 10, -2, -27 },
  { 1831, 17, 27, 20, 3, -27 },
  { 1889, 13, 27, 15, 2, -27 },
  { 1933, 24, 27, 29, 3, -27 },
  { 2014, 18, 27, 24, 3, -27 },
  { 2075, 19, 28, 23, 2, -28 },
  { 2142, 16, 27, 19, 2, -27 },
  { 2196, 19, 34, 23, 2, -28 },
  { 2277, 17, 27, 19, 2, -27 },
  { 2335, 14, 28, 16, 1, -28 },
  { 2384, 15, 27, 16, 1, -27 },
  { 2435, 16, 27, 22, 3, -27 },
  { 2489, 19, 27, 19, 0, -27 },
  { 2554, 29, 27, 28, 0, -27 },
  { 2652, 18, 27, 18, 0, -27 },
  { 2713, 18, 27, 18, 0, -27 },
  { 2774, 14, 27, 16, 1, -27 },
  { 2822, 9, 33, 12, 2, -27 },
  { 2860, 15, 27, 15, 0, -27 },
  { 2911, 9, 33, 12, 1, -27 },
  { 2949, 18, 16, 20, 1, -27 },
  { 2985, 16, 3, 16, 0, 3 },
  { 2991, 8, 6, 12, 2, -29 },
  { 2997, 15, 21, 18, 1, -21 },
  { 3037, 16, 29, 19, 2, -29 },
  { 3095, 13, 21, 15, 1, -21 },
  { 3130, 16, 29, 19, 1, -29 },
  { 3188, 15, 21, 17, 1, -21 },
  { 3228, 13, 29, 11, 0, -29 },
  { 3276, 16, 30, 19, 1, -21 },
  { 3336, 15, 29, 19, 2, -29 },
  { 3391, 5, 29, 9, 2, -29 },
  { 3410, 8, 38, 9, -1, -29 },
  { 3448, 17, 29, 18, 2, -29 },
  { 3510, 5, 29, 9, 2, -29 },
  { 3529, 24, 21, 28, 2, -21 },
  { 3592, 15, 21, 19, 2, -21 },
  { 3632, 16, 21, 19, 1, -21 },
  { 3674, 16, 30, 19, 2, -21 },
  { 3734, 16, 30, 19, 1, -21 },
  { 3794, 11, 21, 13, 2, -21 },
  { 3823, 12, 21, 14, 1, -21 },
  { 3855, 12, 25, 13, 0, -25 },
  { 3893, 15, 21, 19, 2, -21 },
  { 3933, 17, 21, 17, 0, -21 },
  { 3978, 26, 21, 26, 0, -21 },
  { 4047, 16, 21, 16, 0, -21 },
  { 4089, 17, 30, 17, 0, -21 },
  { 4153, 12, 21, 14, 1, -21 },
  { 4185, 12, 33, 13, 0, -27 },
  { 4235, 5, 38, 17, 6, -29 },
  { 4259, 12, 33, 13, 1, -27 },
  { 4309, 16, 7, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Bold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD38PT7B_H_
