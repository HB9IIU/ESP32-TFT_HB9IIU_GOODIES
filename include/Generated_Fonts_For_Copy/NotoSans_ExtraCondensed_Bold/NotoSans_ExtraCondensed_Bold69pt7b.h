#ifndef _NOTOSANS_EXTRACONDENSED_BOLD69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x81, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0x87, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x80,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0x7F, 0xEE, 0x7F, 0x3F, 0xF3, 0x81, 0xCF, 0xF8, 0xE0, 0x13, 0xFE, 0x38,
  0x00, 0xFF, 0x8E, 0x00, 0x3F, 0xE3, 0x80, 0x0F, 0xF8, 0xE0, 0x01, 0xFF,
  0x38, 0x00, 0x7F, 0xEE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0E, 0xFF, 0x80, 0x03, 0xBF, 0xF0,
  0x00, 0xE7, 0xFC, 0x00, 0x38, 0xFF, 0x00, 0x0E, 0x3F, 0xE0, 0x03, 0x8F,
  0xFC, 0x00, 0xE3, 0xFF, 0x80, 0x39, 0xFF, 0xFC, 0x0E, 0xFF, 0xBF, 0xE3,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x83, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x0F, 0xC1,
  0xFF, 0xC1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7, 0xF1,
  0xFF, 0xF8, 0x3F, 0x9F, 0xC7, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0xC3, 0xFF, 0xF1, 0xFC,
  0x7F, 0x8F, 0xE0, 0xFF, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0x3F, 0xF0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F,
  0x87, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x00, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0xE3, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFE,
  0xFF, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xCF, 0xFC, 0x7F, 0xEF, 0xF8,
  0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF, 0xF8, 0xFF, 0x81, 0xFF,
  0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xF8,
  0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFD, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xEF, 0xFE,
  0x07, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0x01, 0xFC, 0x04, 0x3E, 0x1F, 0xC3, 0xE3, 0xF9, 0xF9, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF0, 0x7F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x07, 0xF1, 0xFF,
  0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xEF, 0xF8, 0xFF, 0x07,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF9, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xFB, 0xFE,
  0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF,
  0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF,
  0xE7, 0xFD, 0xFE, 0x3F, 0xE7, 0xE1, 0xFF, 0x1E, 0x0F, 0xF8, 0x60, 0x7F,
  0xC1, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC1, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x78, 0x03, 0xFF, 0x06,
  0x00, 0x3F, 0xE0, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xC3, 0xC0, 0x1F, 0xF8, 0x20, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFC, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xEF, 0xF8,
  0x00, 0x3F, 0xBF, 0xE0, 0x00, 0xFC, 0xFF, 0x80, 0x07, 0xF3, 0xFE, 0x00,
  0x1F, 0x8F, 0xF8, 0x00, 0xFE, 0x3F, 0xE0, 0x03, 0xF0, 0xFF, 0x80, 0x1F,
  0xC3, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F,
  0xE0, 0x3F, 0x80, 0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFB, 0x00, 0x07, 0xFE, 0xF0, 0x03, 0xFF, 0xBF, 0xE7, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x81, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0xFF,
  0xC0, 0xFF, 0x9F, 0xFF, 0x0F, 0xFB, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0,
  0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F,
  0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFC, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xC0,
  0x7F, 0xCF, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F,
  0xE0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xDF, 0xE1, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0x9F, 0xE0,
  0x7F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x30, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x1F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE3, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7F, 0x9F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE1, 0xE0, 0x0F,
  0xC1, 0xFE, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF1, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F,
  0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0x87, 0xFF, 0x1C, 0x01, 0xFF, 0x10, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0x0F, 0xE3,
  0xF8, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0,
  0x3F, 0xFF, 0xF0, 0x7E, 0x7F, 0x03, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x7F,
  0x87, 0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0x07,
  0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0x3F,
  0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xFF, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xEF, 0xE0, 0xFE, 0x1F, 0xF0, 0xFC, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF,
  0xCF, 0xE0, 0x7F, 0xFE, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xCF, 0xFF, 0x87,
  0xF0, 0x3F, 0xF8, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x06,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF1, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC,
  0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF,
  0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0xFF, 0xF0,
  0x06, 0x07, 0xFF, 0x00, 0x10, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0xFF, 0xF0, 0x07, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x00, 0x1C, 0x1F, 0xFE, 0x00, 0x08,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF,
  0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF,
  0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0xBF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE8, 0x1F, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFE, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xF0,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x07,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFF, 0x80, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0x9F, 0xFC, 0x01, 0xFF,
  0x7F, 0xF0, 0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF,
  0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x9F,
  0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF7, 0xF0, 0x01, 0xFD, 0xFF, 0xFF, 0x7F, 0x00, 0x1F, 0xDF, 0xFF, 0xF7,
  0xF8, 0x03, 0xFD, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xFF, 0xF3, 0xF8,
  0x03, 0xF9, 0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0x9F, 0xFF, 0xF3, 0xFC, 0x07,
  0xF9, 0xFF, 0xFF, 0x3F, 0xC0, 0x7F, 0x1F, 0xFF, 0xF1, 0xFC, 0x07, 0xF1,
  0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xFF, 0xF1, 0xFE, 0x0F, 0xF1, 0xFF,
  0xFF, 0x9F, 0xE0, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF,
  0x8F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF, 0x8F,
  0xF1, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x87, 0xF3,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xBF, 0x81, 0xFF, 0xFF, 0x87, 0xFB, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xBF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0xF3,
  0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF,
  0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xC7,
  0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F,
  0xDF, 0xFF, 0xF8, 0x1F, 0xF7, 0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC1, 0xFF, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE,
  0xFF, 0xC1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0B, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x00,
  0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF,
  0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80,
  0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xF8, 0x1F,
  0x1F, 0xF8, 0x03, 0x8F, 0xF8, 0x00, 0x47, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFE, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF7, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xBF, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFC,
  0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x3F, 0x83, 0xFE, 0x00, 0xFF, 0x87, 0xF1, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0x8F, 0xF1, 0xFF, 0x00, 0x3F, 0xE1, 0xFC, 0x7F, 0x8F, 0xF8,
  0x01, 0xFF, 0x1F, 0xE1, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x0F, 0xE3,
  0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0x83,
  0xFC, 0xFF, 0x00, 0x0F, 0xF9, 0xFC, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF,
  0xE0, 0x7F, 0x7F, 0xC0, 0x01, 0xFE, 0xFF, 0x03, 0xFB, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x1F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0xFE, 0xFF, 0x00,
  0x03, 0xFD, 0xFC, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x1F, 0xBF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1E, 0x07, 0xFF, 0x06, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xF8,
  0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFD, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0xFF, 0xFC, 0x7F, 0x1F,
  0xFE, 0x1F, 0xC3, 0xFF, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87,
  0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0x0F, 0xFB, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFC, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F,
  0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0x3F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF,
  0x0F, 0xF3, 0xFF, 0xF0, 0xFF, 0x1F, 0xFE, 0x0F, 0xE0, 0xFF, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFE, 0xFC, 0x3F, 0xF8, 0x0C, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0x3F, 0xF0, 0x06, 0x3F, 0xFC, 0x1E,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0x07, 0xFF,
  0xCF, 0xF8, 0x7F, 0xFF, 0x7F, 0xC3, 0xFF, 0xFB, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xE7,
  0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF0,
  0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x07,
  0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC,
  0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x03,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x0F, 0xFE,
  0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFE,
  0x3F, 0xC0, 0xFF, 0xE1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x07, 0xF9, 0xFF,
  0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x8F, 0xFE, 0x00, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFC, 0x30, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF,
  0xF1, 0xFE, 0x1F, 0xFF, 0xDF, 0xF0, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xBF, 0xFF, 0x3F, 0xF0, 0x7F, 0xF9,
  0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC,
  0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFE, 0x00,
  0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF,
  0x9F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF,
  0x9F, 0xF0, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x01, 0xE0, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE2, 0x00, 0x03, 0xFF, 0x1C, 0x00,
  0x3F, 0xF0, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE1,
  0xFE, 0x07, 0xFC, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x1F, 0xEF, 0xFF, 0xF3,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x86, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x03, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFC, 0x01, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80,
  0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF7,
  0xFC, 0x03, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xF3, 0xFE,
  0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xF7, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xEF, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0xFF, 0xFC,
  0x7F, 0xBF, 0xFF, 0xCF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x9F,
  0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0,
  0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x07,
  0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0x0F, 0xF3, 0xFF, 0xF0, 0xFF,
  0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x0F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF,
  0xC0, 0x3F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0x0F,
  0xFB, 0xFF, 0xF0, 0xFF, 0x9F, 0xFE, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x81,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xDF,
  0xF0, 0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xBF, 0xFF, 0x3F, 0xF0, 0x7F, 0xF9, 0xFF, 0x01, 0xFF, 0xDF, 0xF8,
  0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F,
  0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x7F, 0xC3, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0x9F, 0xF0, 0x3F, 0xF8, 0xFF,
  0x80, 0xFF, 0x87, 0xFC, 0x01, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7C, 0xFF,
  0x80, 0x63, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x30, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1C, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0xCF,
  0xF0, 0xFF, 0xF1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00,
  0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFF,
  0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF9, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7E,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFD, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFB,
  0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xF7, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xCF,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0x8F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0x1F,
  0x87, 0xF8, 0x07, 0xF8, 0x7E, 0x3F, 0x0F, 0xF0, 0x0F, 0xF9, 0xFC, 0x7E,
  0x3F, 0xE0, 0x1F, 0xF3, 0xF8, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xE0, 0xFC,
  0xFF, 0x00, 0x3F, 0xCF, 0xC1, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0x83, 0xF3,
  0xFC, 0x00, 0xFF, 0x3F, 0x07, 0xEF, 0xF8, 0x01, 0xFE, 0x7E, 0x0F, 0xDF,
  0xF0, 0x03, 0xFC, 0xF8, 0x1F, 0xBF, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0x7F,
  0x80, 0x07, 0xFF, 0xE0, 0x3E, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7D, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xFB, 0xFF, 0x00,
  0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x07, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00,
  0x7F, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0xFF, 0xC0, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF,
  0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xBF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x13, 0xFF, 0xC0, 0x01, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0xFF,
  0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Bold69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 50, 18, 4, -49 },
  { 64, 24, 18, 31, 3, -49 },
  { 118, 33, 49, 35, 1, -49 },
  { 321, 26, 56, 32, 3, -52 },
  { 503, 49, 51, 53, 2, -50 },
  { 816, 36, 51, 38, 2, -50 },
  { 1046, 10, 18, 16, 3, -49 },
  { 1069, 18, 60, 22, 3, -49 },
  { 1204, 17, 60, 22, 1, -49 },
  { 1332, 28, 28, 31, 1, -53 },
  { 1430, 28, 33, 32, 2, -41 },
  { 1546, 12, 17, 17, 2, -8 },
  { 1572, 17, 9, 21, 2, -23 },
  { 1592, 11, 12, 18, 3, -11 },
  { 1609, 26, 50, 28, 1, -50 },
  { 1772, 27, 51, 32, 2, -50 },
  { 1945, 21, 49, 32, 3, -49 },
  { 2074, 27, 50, 32, 2, -50 },
  { 2243, 27, 51, 32, 2, -50 },
  { 2416, 30, 49, 32, 1, -49 },
  { 2600, 26, 50, 32, 3, -49 },
  { 2763, 28, 51, 32, 2, -50 },
  { 2942, 29, 49, 32, 1, -49 },
  { 3120, 28, 51, 32, 2, -50 },
  { 3299, 28, 51, 32, 2, -50 },
  { 3478, 10, 39, 18, 4, -38 },
  { 3527, 12, 47, 18, 2, -38 },
  { 3598, 28, 33, 32, 2, -41 },
  { 3714, 28, 21, 32, 2, -35 },
  { 3788, 28, 33, 32, 2, -41 },
  { 3904, 24, 51, 25, 0, -50 },
  { 4057, 44, 55, 50, 3, -50 },
  { 4360, 36, 49, 36, 0, -49 },
  { 4581, 30, 49, 36, 4, -49 },
  { 4765, 29, 51, 33, 3, -50 },
  { 4950, 32, 49, 39, 4, -49 },
  { 5146, 22, 49, 30, 5, -49 },
  { 5281, 22, 49, 30, 5, -49 },
  { 5416, 32, 51, 39, 3, -50 },
  { 5620, 31, 49, 41, 5, -49 },
  { 5810, 18, 49, 22, 2, -49 },
  { 5921, 18, 64, 19, -4, -49 },
  { 6065, 31, 49, 36, 5, -49 },
  { 6255, 23, 49, 28, 4, -49 },
  { 6396, 44, 49, 53, 5, -49 },
  { 6666, 34, 49, 43, 5, -49 },
  { 6875, 35, 51, 41, 3, -50 },
  { 7099, 28, 49, 34, 4, -49 },
  { 7271, 35, 62, 41, 3, -50 },
  { 7543, 31, 49, 35, 4, -49 },
  { 7733, 25, 51, 29, 2, -50 },
  { 7893, 28, 49, 30, 1, -49 },
  { 8065, 30, 50, 39, 5, -49 },
  { 8253, 35, 49, 35, 0, -49 },
  { 8468, 53, 49, 51, -1, -49 },
  { 8793, 33, 49, 33, 0, -49 },
  { 8996, 33, 49, 33, 0, -49 },
  { 9199, 26, 49, 28, 1, -49 },
  { 9359, 16, 60, 22, 4, -49 },
  { 9479, 26, 50, 28, 1, -50 },
  { 9642, 16, 60, 22, 2, -49 },
  { 9762, 33, 30, 37, 2, -49 },
  { 9886, 28, 5, 28, 0, 6 },
  { 9904, 16, 11, 21, 3, -53 },
  { 9926, 26, 39, 32, 2, -38 },
  { 10053, 28, 53, 35, 4, -52 },
  { 10239, 24, 39, 28, 2, -38 },
  { 10356, 29, 53, 35, 2, -52 },
  { 10549, 27, 39, 32, 2, -38 },
  { 10681, 22, 53, 21, 1, -53 },
  { 10827, 29, 55, 35, 2, -38 },
  { 11027, 27, 52, 35, 4, -52 },
  { 11203, 9, 53, 17, 4, -53 },
  { 11263, 15, 70, 17, -2, -53 },
  { 11395, 30, 52, 33, 4, -52 },
  { 11590, 9, 52, 17, 4, -52 },
  { 11649, 44, 38, 52, 4, -38 },
  { 11858, 27, 38, 35, 4, -38 },
  { 11987, 29, 39, 34, 2, -38 },
  { 12129, 28, 55, 35, 4, -38 },
  { 12322, 29, 55, 35, 2, -38 },
  { 12522, 19, 38, 24, 4, -38 },
  { 12613, 22, 39, 26, 2, -38 },
  { 12721, 20, 47, 23, 1, -46 },
  { 12839, 27, 39, 35, 4, -38 },
  { 12971, 30, 38, 31, 0, -38 },
  { 13114, 47, 38, 47, 0, -38 },
  { 13338, 29, 38, 29, 0, -38 },
  { 13476, 30, 55, 31, 0, -38 },
  { 13683, 23, 38, 25, 1, -38 },
  { 13793, 20, 60, 24, 1, -49 },
  { 13943, 8, 69, 30, 11, -53 },
  { 14012, 21, 60, 24, 2, -49 },
  { 14170, 28, 11, 32, 2, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Bold69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD69PT7B_H_
