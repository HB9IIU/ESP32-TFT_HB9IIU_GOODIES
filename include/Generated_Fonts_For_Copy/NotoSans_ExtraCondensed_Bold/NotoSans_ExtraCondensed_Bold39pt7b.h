#ifndef _NOTOSANS_EXTRACONDENSED_BOLD39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDE, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0x7F, 0xC3, 0xC0, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x38,
  0x07, 0x8E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x38, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x3C, 0x70, 0x0F,
  0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xF0, 0x1F, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFB, 0x0B, 0xEC, 0x0F,
  0xB0, 0x3E, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0xDF, 0x03, 0x3C, 0x0C, 0xF8, 0x33, 0xF8, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x0F, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x70,
  0x07, 0xBC, 0x0F, 0x00, 0x79, 0xE0, 0xF0, 0x0F, 0x1E, 0x1E, 0x00, 0xF1,
  0xE1, 0xE0, 0x0F, 0x1E, 0x1C, 0x00, 0xF1, 0xE3, 0xC0, 0x0F, 0x1E, 0x3C,
  0x00, 0xF1, 0xE7, 0x80, 0x0F, 0x1E, 0x78, 0xF8, 0x79, 0xE7, 0x9F, 0xC7,
  0xBC, 0xF3, 0xFE, 0x7F, 0xCF, 0x3D, 0xE3, 0xF9, 0xE7, 0x9E, 0x1F, 0x1E,
  0x78, 0xF0, 0x01, 0xE7, 0x8F, 0x00, 0x3C, 0x78, 0xF0, 0x03, 0xC7, 0x8F,
  0x00, 0x38, 0x78, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0x78, 0x78, 0xF0, 0x0F,
  0x07, 0x8E, 0x00, 0xF0, 0x3D, 0xE0, 0x0F, 0x03, 0xFE, 0x01, 0xE0, 0x1F,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xC7,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0xF8, 0xFF, 0x87, 0xCF, 0xFE, 0x7E, 0x7D, 0xF3,
  0xE7, 0xE7, 0xDF, 0x3E, 0x3F, 0xF9, 0xF0, 0xFF, 0x8F, 0x83, 0xFC, 0x7C,
  0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xFE, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x43, 0xC6, 0x7B, 0xBE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E,
  0xF8, 0x7C, 0x7C, 0x1C, 0x78, 0x08, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x7D, 0xF3,
  0xE7, 0xCF, 0x9E, 0x3C, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C,
  0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC,
  0x3E, 0xFC, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E,
  0x7C, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x3F,
  0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0xDF, 0xF9, 0xF7, 0x1F,
  0x21, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xE7, 0xCF,
  0xE6, 0x0F, 0xC8, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFC, 0x78, 0xFE, 0x20, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x80, 0x7E, 0xE0, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0x7C, 0x0F, 0x7C,
  0x0E, 0x7C, 0x1E, 0x7C, 0x1C, 0x7C, 0x3C, 0x7C, 0x38, 0x7C, 0x78, 0x7C,
  0x70, 0x7C, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xE7, 0xFF, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x1F,
  0xF0, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xC2, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x79, 0xF0, 0xFB,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E,
  0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7C, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E,
  0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7E, 0x7E, 0x7C, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7E, 0xFC, 0x7C,
  0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3F, 0x7C, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDE, 0x1F,
  0x9E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x01,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x31, 0xEF, 0xFF,
  0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x18, 0x7D, 0xFB, 0xF7, 0xE7, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF7, 0xEF, 0x9F, 0x3E, 0x78,
  0xF3, 0xE0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x79, 0xFC, 0x83,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x78, 0xF0, 0x3E, 0x1E, 0x78, 0x7F, 0xCF, 0x38, 0x7F, 0xE7, 0xBC, 0x7C,
  0xF1, 0xDE, 0x3C, 0x78, 0xFF, 0x3C, 0x3C, 0x7F, 0x1E, 0x1E, 0x3F, 0x8F,
  0x0F, 0x1F, 0xC7, 0x87, 0x8F, 0xE3, 0xC3, 0xC7, 0x71, 0xE3, 0xC3, 0xB8,
  0xF1, 0xE3, 0xDC, 0x7C, 0xF9, 0xEF, 0x1F, 0xFF, 0xE7, 0x8F, 0xEF, 0xF3,
  0xC3, 0xF3, 0xF0, 0xF0, 0x20, 0x40, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x08, 0x03, 0xF0, 0x3C, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x78, 0x00, 0xFB,
  0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0x03, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xF3, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x03, 0xF0, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC,
  0x1F, 0x7E, 0x0F, 0xBF, 0x0F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0xF9, 0xFF, 0xFE, 0xFC, 0x3F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF9, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFE, 0x3F, 0x9E, 0x7E, 0x02, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x02, 0x3F, 0x8E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF,
  0xFF, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0xFC,
  0x0F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xCF, 0x8F, 0xC0, 0x47, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xFC, 0xFC, 0x3F, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFF, 0xFE, 0xFF,
  0xBF, 0xEF, 0xF3, 0xF0, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0x07,
  0xCF, 0x87, 0xE7, 0xC7, 0xE3, 0xE3, 0xF1, 0xF3, 0xF0, 0xF9, 0xF8, 0x7D,
  0xF8, 0x3E, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xFC, 0x3E, 0x3E, 0x1F, 0x1F, 0x8F, 0x8F,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE,
  0x07, 0xFF, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xF7,
  0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB,
  0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB, 0xC3, 0xDF, 0xFB, 0xE7, 0x9F, 0xF9,
  0xE7, 0x9F, 0xF9, 0xE7, 0x9F, 0xF9, 0xEF, 0x9F, 0xF9, 0xFF, 0x1F, 0xF8,
  0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8,
  0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFE,
  0xF8, 0x7F, 0xDF, 0x0F, 0xF9, 0xF1, 0xFF, 0xBE, 0x3F, 0xF3, 0xE7, 0xFE,
  0x7C, 0xFF, 0xCF, 0x9F, 0xF8, 0xFB, 0xFF, 0x1F, 0x7F, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFB, 0xFC, 0xFC, 0x1F, 0x9F,
  0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xF8,
  0x0F, 0x9F, 0x83, 0xF1, 0xFD, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFB, 0xFC,
  0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7E, 0xF8, 0x0F, 0x9F, 0x83, 0xF1, 0xFD, 0xFE, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0xC3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xF0, 0xFC, 0x7C, 0x3F,
  0x1F, 0x8F, 0xC3, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xEF, 0xC1,
  0xFB, 0xF0, 0x3F, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7F, 0xF9,
  0xF0, 0x6F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xFC, 0xFE,
  0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C,
  0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x1E, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1,
  0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xE0, 0x07,
  0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xE0,
  0x3E, 0x03, 0xEF, 0x80, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x3E, 0xF8, 0x1F,
  0xC1, 0xF9, 0xF0, 0x7F, 0x07, 0xE7, 0xC1, 0xFC, 0x1F, 0x1F, 0x07, 0xF0,
  0x7C, 0x7C, 0x1D, 0xC1, 0xF1, 0xF0, 0xF7, 0x87, 0xC3, 0xE3, 0xDE, 0x3F,
  0x0F, 0x8F, 0x78, 0xF8, 0x3E, 0x3D, 0xE3, 0xE0, 0xF8, 0xF7, 0x8F, 0x83,
  0xE7, 0xDF, 0x3E, 0x07, 0x9E, 0x3D, 0xF8, 0x1F, 0x78, 0xF7, 0xC0, 0x7D,
  0xE3, 0xDF, 0x01, 0xF7, 0x8F, 0x7C, 0x07, 0xDE, 0x3D, 0xF0, 0x0F, 0xF8,
  0x77, 0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xDF, 0x83, 0xE3, 0xE1, 0xF8, 0xF8,
  0x7C, 0x3F, 0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3E,
  0xF8, 0x1F, 0xBE, 0x07, 0xCF, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x9F, 0x83, 0xE7, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0xFD, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0xBE, 0x01, 0xE3, 0xC0, 0x7C, 0x7C,
  0x0F, 0x0F, 0x83, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x01, 0xE3, 0xC0, 0x3E,
  0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x01, 0xC0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE1,
  0xEF, 0xE2, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x1F, 0xFC, 0xFF,
  0xFB, 0xFF, 0xF7, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xF9, 0xE7, 0xE3, 0xC0, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x60, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF1, 0xF8, 0x01, 0xC0,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3F, 0xF9, 0xF8, 0x27, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x05, 0xF8, 0x63, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0x1F, 0x1F, 0xDF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F,
  0xCF, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x7E, 0x7C,
  0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x06, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x7F,
  0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x03,
  0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x00,
  0x1F, 0xCF, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF,
  0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x40, 0x1F, 0x70, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xF0,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x61, 0xF7, 0xF3, 0xEF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x73, 0xEF, 0xBF,
  0xF9, 0xE0, 0x00, 0x03, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x0E, 0x0F, 0x87, 0xC3,
  0xF1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xDF,
  0xEF, 0xF7, 0xF3, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1,
  0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xF7, 0xC3, 0xF3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3F, 0x3E,
  0x0F, 0x9F, 0x07, 0xEF, 0x81, 0xF7, 0xC0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x38, 0x79, 0xFC, 0x7F, 0x3E, 0xFF, 0x7F,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFF, 0xF0, 0xFC,
  0x3F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F,
  0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0,
  0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE,
  0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7C,
  0x00, 0x61, 0xE7, 0xF3, 0xEF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xFD,
  0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xE0, 0xF1, 0xF8, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9,
  0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x1F, 0xCF, 0x1F,
  0xEF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFE, 0x3F,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0x01, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xFE,
  0x7C, 0x13, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0x81, 0xFF, 0x0F, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFE, 0x3F, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF1, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7E, 0xFF, 0xFD, 0xFF, 0x79, 0xFE, 0xF1, 0xF9, 0xE0, 0xFC,
  0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x1F, 0x07, 0xCF, 0x03, 0xEF,
  0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xF8, 0x3F, 0x07, 0xDF,
  0x0F, 0xC1, 0xF7, 0xC3, 0xF8, 0x7D, 0xF0, 0xFE, 0x1E, 0x7C, 0x3F, 0x8F,
  0x9F, 0x1E, 0xE3, 0xE3, 0xE7, 0xB8, 0xF8, 0xF9, 0xEE, 0x3E, 0x3E, 0x73,
  0xDF, 0x0F, 0x9C, 0xF7, 0xC1, 0xEF, 0x1D, 0xF0, 0x7B, 0xC7, 0x7C, 0x1F,
  0xF1, 0xDE, 0x07, 0xFC, 0x77, 0x81, 0xFE, 0x1D, 0xE0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E,
  0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xDF, 0x01, 0xEF,
  0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x8F, 0xF8, 0xFE,
  0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0x0F, 0xF0, 0xFC, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x3E, 0x01, 0x7F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 13, 10, 17, 2, -28 },
  { 39, 18, 28, 20, 1, -28 },
  { 102, 14, 32, 18, 2, -30 },
  { 158, 28, 28, 30, 1, -28 },
  { 256, 21, 28, 22, 1, -28 },
  { 330, 5, 10, 9, 2, -28 },
  { 337, 10, 34, 12, 2, -28 },
  { 380, 9, 34, 12, 1, -28 },
  { 419, 16, 16, 17, 1, -30 },
  { 451, 16, 19, 18, 1, -23 },
  { 489, 7, 9, 10, 1, -4 },
  { 497, 10, 5, 12, 1, -13 },
  { 504, 6, 6, 10, 2, -6 },
  { 509, 16, 28, 16, 0, -28 },
  { 565, 16, 28, 18, 1, -28 },
  { 621, 12, 28, 18, 2, -28 },
  { 663, 15, 28, 18, 1, -28 },
  { 716, 16, 28, 18, 1, -28 },
  { 772, 16, 28, 18, 1, -28 },
  { 828, 14, 28, 18, 2, -28 },
  { 877, 16, 28, 18, 1, -28 },
  { 933, 16, 28, 18, 1, -28 },
  { 989, 16, 28, 18, 1, -28 },
  { 1045, 16, 28, 18, 1, -28 },
  { 1101, 6, 22, 10, 2, -22 },
  { 1118, 7, 27, 10, 1, -22 },
  { 1142, 16, 18, 18, 1, -23 },
  { 1178, 16, 12, 18, 1, -20 },
  { 1202, 16, 18, 18, 1, -23 },
  { 1238, 14, 28, 14, 0, -28 },
  { 1287, 25, 31, 28, 2, -28 },
  { 1384, 21, 28, 21, 0, -28 },
  { 1458, 17, 28, 21, 2, -28 },
  { 1518, 16, 28, 19, 2, -28 },
  { 1574, 18, 28, 22, 2, -28 },
  { 1637, 12, 28, 17, 3, -28 },
  { 1679, 12, 28, 17, 3, -28 },
  { 1721, 18, 28, 22, 2, -28 },
  { 1784, 17, 28, 23, 3, -28 },
  { 1844, 10, 28, 12, 1, -28 },
  { 1879, 10, 36, 11, -2, -28 },
  { 1924, 17, 28, 20, 3, -28 },
  { 1984, 13, 28, 16, 2, -28 },
  { 2030, 24, 28, 30, 3, -28 },
  { 2114, 19, 28, 25, 3, -28 },
  { 2181, 19, 28, 23, 2, -28 },
  { 2248, 16, 28, 19, 2, -28 },
  { 2304, 19, 35, 23, 2, -28 },
  { 2388, 18, 28, 20, 2, -28 },
  { 2451, 14, 28, 17, 1, -28 },
  { 2500, 15, 28, 17, 1, -28 },
  { 2553, 17, 28, 22, 3, -28 },
  { 2613, 20, 28, 20, 0, -28 },
  { 2683, 30, 28, 29, 0, -28 },
  { 2788, 18, 28, 18, 0, -28 },
  { 2851, 18, 28, 18, 0, -28 },
  { 2914, 14, 28, 16, 1, -28 },
  { 2963, 9, 34, 12, 2, -28 },
  { 3002, 15, 28, 16, 0, -28 },
  { 3055, 9, 34, 12, 1, -28 },
  { 3094, 19, 17, 21, 1, -28 },
  { 3135, 16, 3, 16, 0, 3 },
  { 3141, 9, 6, 12, 2, -30 },
  { 3148, 15, 22, 18, 1, -22 },
  { 3190, 16, 30, 20, 2, -30 },
  { 3250, 14, 22, 16, 1, -22 },
  { 3289, 16, 30, 20, 1, -30 },
  { 3349, 16, 22, 18, 1, -22 },
  { 3393, 13, 30, 12, 0, -30 },
  { 3442, 16, 31, 20, 1, -22 },
  { 3504, 15, 30, 20, 2, -30 },
  { 3561, 6, 30, 10, 2, -30 },
  { 3584, 9, 39, 10, -1, -30 },
  { 3628, 17, 30, 19, 2, -30 },
  { 3692, 5, 30, 9, 2, -30 },
  { 3711, 25, 22, 29, 2, -22 },
  { 3780, 15, 22, 20, 2, -22 },
  { 3822, 17, 22, 19, 1, -22 },
  { 3869, 16, 31, 20, 2, -22 },
  { 3931, 16, 31, 20, 1, -22 },
  { 3993, 11, 22, 14, 2, -22 },
  { 4024, 13, 22, 15, 1, -22 },
  { 4060, 12, 26, 13, 0, -26 },
  { 4099, 15, 21, 20, 2, -21 },
  { 4139, 17, 21, 17, 0, -21 },
  { 4184, 26, 21, 26, 0, -21 },
  { 4253, 16, 21, 17, 0, -21 },
  { 4295, 17, 30, 17, 0, -21 },
  { 4359, 12, 21, 14, 1, -21 },
  { 4391, 12, 34, 14, 0, -28 },
  { 4442, 5, 39, 17, 6, -30 },
  { 4467, 12, 34, 14, 1, -28 },
  { 4518, 16, 7, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Bold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD39PT7B_H_
