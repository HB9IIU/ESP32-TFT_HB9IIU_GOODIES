#ifndef _NOTOSANS_EXTRACONDENSED_BOLD54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFF, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F,
  0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F,
  0x7F, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x0F, 0x81, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x7C, 0x7C, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xDC, 0x78, 0xFE, 0xE0,
  0x4F, 0xE7, 0x00, 0x7F, 0x38, 0x01, 0xF9, 0xC0, 0x0F, 0xEE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1D, 0xFC, 0x00, 0xE7, 0xF0, 0x07, 0x3F, 0x80, 0x39, 0xFF,
  0x01, 0xCF, 0xFE, 0x0E, 0x7E, 0xFC, 0x77, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xE0,
  0x03, 0xF3, 0xF0, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x7E, 0x00, 0x3F, 0x1F,
  0x81, 0xF0, 0x00, 0xF8, 0x7E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x3E, 0x00,
  0x0F, 0x87, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x7E,
  0x1F, 0x00, 0x03, 0xE1, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xE3, 0xE0, 0x00,
  0x3E, 0x1F, 0x8F, 0x83, 0xC0, 0xF8, 0x7E, 0x7E, 0x3F, 0xC3, 0xF1, 0xF1,
  0xF1, 0xFF, 0x87, 0xCF, 0xC7, 0xC7, 0xFF, 0x1F, 0xFF, 0x3F, 0x3F, 0xFE,
  0x7F, 0xF8, 0xF8, 0xFD, 0xF8, 0xFF, 0xE7, 0xE7, 0xE3, 0xE1, 0xFF, 0x1F,
  0x1F, 0x8F, 0xC3, 0xF0, 0x7C, 0x7C, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0xFC,
  0x00, 0x0F, 0x87, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0x7C, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xC3, 0xF0,
  0x00, 0xF8, 0x1F, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0xFC, 0x00, 0x7C, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0x0F, 0xFF, 0x80,
  0x0F, 0x80, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x0F, 0xE1, 0xFF, 0xF0, 0xFF, 0x1F,
  0xFF, 0x87, 0xF8, 0xFF, 0xFE, 0x3F, 0x8F, 0xF7, 0xF9, 0xFC, 0x7F, 0x1F,
  0xEF, 0xE7, 0xF8, 0x7F, 0xFE, 0x3F, 0xC3, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF,
  0x8F, 0xF0, 0x3F, 0xF8, 0x7F, 0x81, 0xFF, 0xC3, 0xFC, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE7,
  0xF8, 0x0F, 0xFC, 0x1F, 0xE0, 0x04, 0x00, 0x00, 0xFF, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01,
  0x83, 0xF0, 0x67, 0xCF, 0xCF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xC1,
  0xF8, 0x7E, 0x03, 0xC0, 0xF0, 0x03, 0x03, 0x00, 0x04, 0x08, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x9F, 0xDF, 0xEF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x7F, 0x3F, 0x1F, 0x8F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0x7F, 0x8F, 0xF1, 0xFC,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x8F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F,
  0x7C, 0x7F, 0x38, 0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xF8, 0x7F,
  0x8F, 0x01, 0xFE, 0x30, 0x07, 0xF0, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF0, 0x7F, 0xC6, 0x01, 0xFE, 0x20, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0xE0, 0x1F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0x7D, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F,
  0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xC1,
  0xFC, 0x1F, 0x83, 0xF8, 0x3E, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFD, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x08, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xD8, 0x01, 0xFE, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x58, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x47, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0xFC, 0x1F, 0x9F, 0xF8, 0xFC, 0xFF, 0xE7, 0xEF, 0xFF, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0x7F, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF,
  0x7F, 0x8F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x01, 0xF9, 0xFC, 0x07,
  0xE7, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0xFF, 0x1F, 0xE1,
  0xFE, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0xFF,
  0x0F, 0xF1, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0,
  0x7F, 0x7F, 0x03, 0xFD, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x03, 0xF9,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x0F,
  0xF7, 0xF8, 0x7F, 0xDF, 0xFB, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0x07, 0xF9, 0xFC, 0x07, 0x87, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x1E, 0x1F, 0x9F, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x3F, 0x1F,
  0x8F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x8F, 0xF9, 0x80, 0x7F, 0x20, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x03,
  0xF8, 0x3E, 0x1F, 0x81, 0xFF, 0xC7, 0xE3, 0xE0, 0x7F, 0xF8, 0x7C, 0xFC,
  0x1F, 0xFF, 0x0F, 0x9F, 0x07, 0xF3, 0xE1, 0xF3, 0xE1, 0xF8, 0x7C, 0x3F,
  0x7C, 0x3F, 0x0F, 0x83, 0xEF, 0x87, 0xC1, 0xF0, 0x7F, 0xF0, 0xF8, 0x3E,
  0x0F, 0xFC, 0x3F, 0x07, 0xC1, 0xFF, 0x87, 0xE0, 0xF8, 0x3F, 0xF0, 0xFC,
  0x1F, 0x07, 0xFE, 0x1F, 0x83, 0xE0, 0xFF, 0xC3, 0xF0, 0xFC, 0x1F, 0xF8,
  0x7E, 0x1F, 0x87, 0xDF, 0x8F, 0xC3, 0xF0, 0xFB, 0xF0, 0xF8, 0x7E, 0x1F,
  0x7E, 0x1F, 0x1F, 0xC7, 0xC7, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x3F, 0xF7,
  0xFE, 0x1F, 0x07, 0xFC, 0xFF, 0xC3, 0xF0, 0x7F, 0x8F, 0xF0, 0x3E, 0x03,
  0xC0, 0x78, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xC0,
  0x01, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFD,
  0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3,
  0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF,
  0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFF, 0x7F,
  0x83, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0x7F, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFE, 0x1E, 0x0F, 0xF8, 0x0C, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x02, 0x1F, 0xF8, 0x3C, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x06, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFB,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x80,
  0x3F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8,
  0x0F, 0xF3, 0xFC, 0x0F, 0xF9, 0xFE, 0x0F, 0xF8, 0xFF, 0x3F, 0xFC, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F,
  0xF8, 0x7C, 0x3F, 0xF0, 0x04, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFD, 0xFC, 0x1F, 0xFE, 0xFE, 0x0F, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xF9, 0xFC,
  0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0xC0, 0x7F, 0x1F, 0xF0, 0x3F, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0,
  0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xE0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0x80,
  0xFF, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF7, 0xE0, 0x1F, 0xFF, 0xFD, 0xF8, 0x07, 0xDF, 0xFF, 0x7E, 0x03, 0xF7,
  0xFF, 0xDF, 0x80, 0xFD, 0xFF, 0xF3, 0xF0, 0x3F, 0x7F, 0xFC, 0xFC, 0x0F,
  0x9F, 0xFF, 0xBF, 0x07, 0xE7, 0xFF, 0xEF, 0xC1, 0xF9, 0xFF, 0xF9, 0xF8,
  0x7E, 0x7F, 0xFE, 0x7E, 0x3F, 0x1F, 0xFF, 0x9F, 0x8F, 0xC7, 0xFF, 0xE7,
  0xE3, 0xF1, 0xFF, 0xF8, 0xFC, 0xF8, 0x7F, 0xFE, 0x3F, 0x7E, 0x1F, 0xFF,
  0x8F, 0xDF, 0x87, 0xFF, 0xE3, 0xF7, 0xE1, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0x83, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0x07,
  0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x01, 0xFC, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFD, 0xF8, 0x1F, 0xFF, 0x7F, 0x07, 0xFF, 0xDF, 0xC1, 0xFF,
  0xF3, 0xF8, 0x7F, 0xFC, 0xFE, 0x1F, 0xFF, 0x1F, 0xC7, 0xFF, 0xC7, 0xF1,
  0xFF, 0xF8, 0xFC, 0x3F, 0xFE, 0x3F, 0x8F, 0xFF, 0x8F, 0xE3, 0xFF, 0xE1,
  0xFC, 0xFF, 0xF8, 0x7F, 0x3F, 0xFE, 0x0F, 0xEF, 0xFF, 0x83, 0xFB, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xC1, 0xFE,
  0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF9, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x07,
  0xFB, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xF8, 0x1E, 0xFF,
  0x00, 0x9F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xDF, 0xC0,
  0x0F, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x3F,
  0x80, 0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0xE0,
  0xFF, 0x07, 0xF0, 0x7F, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xBE, 0x0F, 0xE0,
  0x7F, 0x07, 0xEF, 0x83, 0xF8, 0x0F, 0xC1, 0xF3, 0xE0, 0xFE, 0x03, 0xF8,
  0x7C, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xCF,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF3, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x7C, 0x7F,
  0x00, 0x7E, 0x3F, 0x1F, 0x9F, 0xC0, 0x1F, 0xDF, 0x87, 0xEF, 0xE0, 0x07,
  0xF7, 0xE1, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x7E, 0xFE, 0x00, 0x7F, 0x7E,
  0x0F, 0xBF, 0x80, 0x0F, 0xDF, 0x83, 0xEF, 0xE0, 0x03, 0xF7, 0xC0, 0xFB,
  0xF0, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x7F,
  0x8F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE3, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0x8F, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1,
  0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE7, 0xF8,
  0x07, 0xF3, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE7,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1C, 0x0F, 0xF1, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xF7,
  0xFF, 0xBF, 0x3F, 0xF3, 0xF1, 0xFE, 0x1F, 0x03, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xC0, 0xFE, 0x7F, 0xC3, 0xFB, 0xFF,
  0x8F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xEF,
  0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xF8, 0x7F, 0xBF, 0xFB,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xEF, 0xFE, 0x3F, 0x3F, 0xF0,
  0xFC, 0x3F, 0x80, 0x00, 0x10, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFC, 0x39, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x05, 0xFE, 0x03,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xF8,
  0x7F, 0x0F, 0xF9, 0xFC, 0x7F, 0xF7, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFE, 0x1F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFD, 0xFC,
  0x0F, 0xF7, 0xF8, 0x7F, 0xDF, 0xF3, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xCF, 0xC3, 0xFF, 0x3F, 0x07, 0xF0, 0xFC, 0x02, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xF7,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x06, 0x3F, 0xE1, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0x08, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0xE3,
  0xF1, 0xFF, 0xCF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xF8, 0x7F, 0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xE1,
  0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F,
  0x0F, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0x18, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x98, 0x01, 0xFE, 0x7C, 0x0F,
  0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x7E, 0x0F, 0xE7, 0xFC, 0x7F, 0x7F, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x87, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0xBF, 0x80, 0xFE, 0x7F, 0x03,
  0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xF1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x1F, 0xF7, 0xF0, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0xFE, 0x00,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x1F, 0xF0, 0xFF, 0xCF, 0xCF, 0xFE,
  0x7F, 0xFB, 0xF7, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE7, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF,
  0x07, 0xF8, 0x1F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF,
  0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8,
  0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF8, 0x0F,
  0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF,
  0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F,
  0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x80, 0xFE, 0x07, 0xF0, 0xFC, 0x3F, 0x07,
  0xE3, 0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F,
  0xC0, 0xFE, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xE0, 0xFE, 0x3F, 0xEF,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xF1, 0xFF, 0x0F,
  0xCF, 0xFE, 0x3F, 0x3F, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8,
  0x7F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xBF, 0xE1, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xBF, 0xF8, 0xFE,
  0x7F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE0, 0x60, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0xE3, 0xF1, 0xFF,
  0xCF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F,
  0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xE1, 0xFF, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F, 0x0F, 0xF9,
  0xFC, 0x1F, 0xC7, 0xF0, 0x18, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0xF8, 0x1F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF3, 0xF8, 0x39, 0xF8, 0x04, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xC3, 0xFF, 0x80, 0x06, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x40, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0x7E, 0x7F, 0xFB, 0xF1, 0xFF,
  0x9F, 0x87, 0xF8, 0xFC, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xE0, 0x7F, 0x7F, 0x03,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xE0, 0x7F, 0x7F, 0x07, 0xFE, 0x07, 0xE3,
  0xF0, 0x7F, 0xE0, 0xFE, 0x3F, 0x87, 0xDF, 0x0F, 0xE3, 0xF8, 0x7D, 0xF0,
  0xFE, 0x3F, 0x87, 0xDF, 0x0F, 0xC3, 0xF8, 0x7D, 0xF1, 0xFC, 0x1F, 0xCF,
  0x9F, 0x1F, 0xC1, 0xFC, 0xF8, 0xF1, 0xFC, 0x1F, 0xCF, 0x8F, 0x9F, 0x81,
  0xFC, 0xF8, 0xF9, 0xF8, 0x0F, 0xCF, 0x8F, 0xBF, 0x80, 0xFC, 0xF0, 0xFB,
  0xF8, 0x0F, 0xCF, 0x0F, 0xBF, 0x80, 0xFF, 0xF0, 0x7B, 0xF0, 0x0F, 0xFF,
  0x07, 0xBF, 0x00, 0x7F, 0xF0, 0x7B, 0xF0, 0x07, 0xFF, 0x07, 0xBF, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF8,
  0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xF3, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x27, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x3F, 0xC0, 0x05,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 40, 14, 3, -39 },
  { 41, 19, 14, 24, 2, -39 },
  { 75, 25, 39, 27, 1, -39 },
  { 197, 21, 44, 25, 2, -41 },
  { 313, 38, 39, 42, 2, -39 },
  { 499, 29, 40, 30, 1, -39 },
  { 644, 8, 14, 13, 2, -39 },
  { 658, 13, 48, 17, 3, -39 },
  { 736, 13, 48, 17, 1, -39 },
  { 814, 22, 22, 24, 1, -41 },
  { 875, 21, 26, 25, 2, -32 },
  { 944, 9, 13, 13, 2, -6 },
  { 959, 13, 7, 16, 2, -18 },
  { 971, 8, 9, 14, 3, -8 },
  { 980, 21, 39, 22, 0, -39 },
  { 1083, 21, 40, 25, 2, -39 },
  { 1188, 16, 39, 25, 3, -39 },
  { 1266, 21, 39, 25, 2, -39 },
  { 1369, 21, 40, 25, 2, -39 },
  { 1474, 23, 39, 25, 1, -39 },
  { 1587, 21, 40, 25, 2, -39 },
  { 1692, 21, 40, 25, 2, -39 },
  { 1797, 22, 39, 25, 1, -39 },
  { 1905, 22, 40, 25, 1, -39 },
  { 2015, 22, 40, 25, 1, -39 },
  { 2125, 8, 31, 14, 3, -30 },
  { 2156, 9, 37, 14, 2, -30 },
  { 2198, 23, 26, 25, 1, -32 },
  { 2273, 23, 16, 25, 1, -27 },
  { 2319, 22, 26, 25, 2, -32 },
  { 2391, 19, 40, 20, 0, -39 },
  { 2486, 35, 43, 39, 2, -39 },
  { 2675, 28, 39, 28, 0, -39 },
  { 2812, 23, 39, 28, 3, -39 },
  { 2925, 23, 40, 26, 2, -39 },
  { 3040, 25, 39, 30, 3, -39 },
  { 3162, 17, 39, 23, 4, -39 },
  { 3245, 17, 39, 23, 4, -39 },
  { 3328, 25, 40, 30, 2, -39 },
  { 3453, 24, 39, 32, 4, -39 },
  { 3570, 15, 39, 17, 1, -39 },
  { 3644, 14, 50, 15, -3, -39 },
  { 3732, 24, 39, 28, 4, -39 },
  { 3849, 18, 39, 22, 3, -39 },
  { 3937, 34, 39, 42, 4, -39 },
  { 4103, 26, 39, 34, 4, -39 },
  { 4230, 28, 40, 32, 2, -39 },
  { 4370, 22, 39, 26, 3, -39 },
  { 4478, 28, 48, 32, 2, -39 },
  { 4646, 25, 39, 28, 3, -39 },
  { 4768, 19, 40, 23, 2, -39 },
  { 4863, 21, 39, 23, 1, -39 },
  { 4966, 23, 40, 31, 4, -39 },
  { 5081, 27, 39, 27, 0, -39 },
  { 5213, 42, 39, 40, -1, -39 },
  { 5418, 25, 39, 26, 0, -39 },
  { 5540, 26, 39, 26, 0, -39 },
  { 5667, 20, 39, 22, 1, -39 },
  { 5765, 13, 48, 17, 3, -39 },
  { 5843, 21, 39, 22, 0, -39 },
  { 5946, 13, 48, 17, 1, -39 },
  { 6024, 26, 24, 29, 1, -39 },
  { 6102, 22, 3, 22, 0, 5 },
  { 6111, 13, 8, 17, 2, -41 },
  { 6124, 20, 31, 25, 2, -30 },
  { 6202, 22, 42, 27, 3, -41 },
  { 6318, 18, 31, 22, 2, -30 },
  { 6388, 22, 42, 27, 2, -41 },
  { 6504, 21, 31, 25, 2, -30 },
  { 6586, 18, 41, 16, 0, -41 },
  { 6679, 22, 43, 27, 2, -30 },
  { 6798, 21, 41, 27, 3, -41 },
  { 6906, 7, 41, 13, 3, -41 },
  { 6942, 12, 54, 13, -2, -41 },
  { 7023, 23, 41, 26, 3, -41 },
  { 7141, 7, 41, 13, 3, -41 },
  { 7177, 34, 30, 40, 3, -30 },
  { 7305, 21, 30, 27, 3, -30 },
  { 7384, 22, 31, 26, 2, -30 },
  { 7470, 22, 43, 27, 3, -30 },
  { 7589, 22, 43, 27, 2, -30 },
  { 7708, 15, 30, 19, 3, -30 },
  { 7765, 17, 31, 20, 2, -30 },
  { 7831, 16, 37, 18, 1, -36 },
  { 7905, 21, 31, 27, 3, -30 },
  { 7987, 24, 30, 24, 0, -30 },
  { 8077, 36, 29, 37, 0, -29 },
  { 8208, 23, 29, 23, 0, -29 },
  { 8292, 24, 43, 24, 0, -30 },
  { 8421, 17, 30, 19, 1, -30 },
  { 8485, 16, 48, 19, 1, -39 },
  { 8581, 6, 54, 24, 9, -41 },
  { 8622, 16, 48, 19, 2, -39 },
  { 8718, 23, 9, 25, 1, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Bold54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD54PT7B_H_
