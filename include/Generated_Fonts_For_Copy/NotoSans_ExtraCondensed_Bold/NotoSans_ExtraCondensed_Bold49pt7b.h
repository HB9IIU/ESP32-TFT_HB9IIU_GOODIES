#ifndef _NOTOSANS_EXTRACONDENSED_BOLD49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E,
  0x3E, 0x00, 0x00, 0x00, 0x08, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E,
  0x08, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB,
  0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87,
  0xEF, 0x83, 0xF7, 0xC1, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC1, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3C, 0x00, 0x78, 0x78, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xDC, 0x73, 0xFB, 0x80,
  0x7E, 0x70, 0x0F, 0xCE, 0x01, 0xFD, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xEF, 0xE0, 0x1C, 0xFC,
  0x03, 0x9F, 0xC0, 0x73, 0xEE, 0x0E, 0xFD, 0xF9, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x03,
  0xE0, 0x03, 0xFE, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x1F, 0xFC,
  0x03, 0xE0, 0x07, 0xEF, 0x80, 0xF8, 0x00, 0xF8, 0xF8, 0x1F, 0x00, 0x1F,
  0x1F, 0x03, 0xE0, 0x03, 0xE3, 0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x1F, 0x00,
  0x1F, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x1F,
  0x00, 0x07, 0xC7, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0xF8, 0x10, 0x1F, 0x1F,
  0x1E, 0x1F, 0xC3, 0xE3, 0xE7, 0xC7, 0xFC, 0x7C, 0xFC, 0xF9, 0xFF, 0xC7,
  0xFF, 0x3E, 0x3F, 0xF8, 0xFF, 0xE7, 0xCF, 0x9F, 0x0F, 0xF8, 0xF9, 0xF1,
  0xF0, 0xFE, 0x3E, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x0F, 0x80, 0x07, 0x81, 0xF1, 0xF0,
  0x01, 0xF0, 0x3E, 0x3E, 0x00, 0x3E, 0x07, 0xC7, 0xC0, 0x0F, 0x80, 0xF9,
  0xF0, 0x01, 0xF0, 0x0F, 0xFE, 0x00, 0x3C, 0x01, 0xFF, 0xC0, 0x0F, 0x80,
  0x1F, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0x07, 0xE3, 0xFF, 0xC3, 0xF8, 0xFF, 0xF8, 0xFE,
  0x7F, 0x7F, 0x3F, 0x9F, 0xCF, 0xCF, 0xCF, 0xE3, 0xFF, 0xF3, 0xF8, 0x7F,
  0xFC, 0xFE, 0x0F, 0xFE, 0x3F, 0x83, 0xFF, 0x8F, 0xE0, 0x7F, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xF3, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xE0, 0x7F, 0xC1,
  0xFC, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x41, 0xF0, 0x27, 0x8F, 0x1E, 0x7E, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0x9F, 0x83, 0xF9, 0xFC, 0x3F, 0x0F, 0x80, 0xF0,
  0xF0, 0x06, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC,
  0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x08, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x08, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFF, 0x1F, 0xEF, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0xDF, 0xC1,
  0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F,
  0x9F, 0xEF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFF, 0xFE, 0xFD, 0xF9, 0xF9,
  0xE3, 0xF1, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xF1, 0xFE,
  0x3C, 0x0F, 0xE1, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xF8, 0x7F, 0x8C, 0x07, 0xF1, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFD, 0xE0, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xBF, 0x80, 0x7D, 0xFC, 0x03,
  0xCF, 0xE0, 0x3E, 0x7F, 0x01, 0xE3, 0xF8, 0x1F, 0x1F, 0xC0, 0xF0, 0xFE,
  0x0F, 0x87, 0xF0, 0x78, 0x3F, 0x87, 0xC1, 0xFC, 0x3C, 0x0F, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF0, 0xF3, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xEC, 0x03, 0xFD, 0xF0, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0x02,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x1E, 0x07, 0xE7, 0xF8, 0x7E, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF8, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0x7F, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F,
  0x9F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xF0, 0xFE,
  0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF9, 0xFC,
  0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0,
  0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F,
  0xFB, 0xF0, 0xFF, 0x3F, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC2, 0x07, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xF0, 0x80, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9, 0xE3,
  0xFC, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x0F, 0xF8, 0xF8, 0xF0, 0x3F, 0xF8, 0xFB,
  0xE0, 0xFF, 0xF1, 0xF7, 0xC3, 0xFF, 0xE3, 0xEF, 0x0F, 0xC7, 0xC3, 0xFE,
  0x1F, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0x0F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF1,
  0xF0, 0x7C, 0x3F, 0xE3, 0xE0, 0xF8, 0x7F, 0xC7, 0xC1, 0xF0, 0xFF, 0x8F,
  0x83, 0xE1, 0xFF, 0x1F, 0x0F, 0x83, 0xFE, 0x3E, 0x1F, 0x0F, 0xFC, 0x7C,
  0x3E, 0x1F, 0xF8, 0x7C, 0x7E, 0x3D, 0xF0, 0xFF, 0xFF, 0xFB, 0xE0, 0xFF,
  0xBF, 0xE3, 0xE1, 0xFE, 0x7F, 0x87, 0xC1, 0xF8, 0x7E, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF8,
  0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD,
  0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF,
  0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x1E, 0x3F, 0xC0, 0x63, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x21, 0xFF, 0x9E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xE0, 0xFF, 0x3F, 0x81, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC,
  0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0x07, 0xF8, 0x02,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x80,
  0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xFC, 0x0F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xFE,
  0xFF, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xFE, 0x01, 0xFD,
  0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC,
  0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF,
  0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFB,
  0xE0, 0x1F, 0xFF, 0xF7, 0xC0, 0x7F, 0xFF, 0xEF, 0x80, 0xFF, 0xFF, 0xDF,
  0x81, 0xF7, 0xFF, 0x9F, 0x03, 0xEF, 0xFF, 0x3E, 0x0F, 0xDF, 0xFF, 0x7C,
  0x1F, 0x3F, 0xFE, 0xFC, 0x3E, 0x7F, 0xFC, 0xF8, 0x7C, 0xFF, 0xF9, 0xF1,
  0xF9, 0xFF, 0xF3, 0xE3, 0xE3, 0xFF, 0xE7, 0xE7, 0xC7, 0xFF, 0xC7, 0xDF,
  0x8F, 0xFF, 0x8F, 0xBE, 0x1F, 0xFF, 0x1F, 0x7C, 0x3F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xFC, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0xF0, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x1F,
  0xFF, 0x07, 0xF0, 0x3F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0xFF,
  0xF8, 0x1F, 0x01, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFD, 0xF8, 0x3F, 0xFD, 0xFC, 0x3F, 0xFC, 0xFC, 0x3F, 0xFC, 0xFC,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFE, 0x7E, 0x3F, 0xFE, 0x7F, 0x3F, 0xFE, 0x3F,
  0x3F, 0xFE, 0x3F, 0xBF, 0xFE, 0x1F, 0xBF, 0xFE, 0x1F, 0xBF, 0xFE, 0x1F,
  0xDF, 0xFE, 0x0F, 0xDF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F,
  0xDF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x1F, 0xEF,
  0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x3F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0x80, 0xFF, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xE1, 0xFE, 0x3F,
  0x83, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0x1D, 0xFC, 0x02, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0x7F, 0x03, 0xF9, 0xFF, 0x3F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xE0,
  0x1F, 0xDF, 0xC0, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0xFE, 0x01, 0xF9, 0xFC,
  0x07, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0xC0,
  0xFE, 0x3F, 0x01, 0xFF, 0x03, 0xF0, 0xFE, 0x07, 0xFC, 0x0F, 0xC3, 0xF8,
  0x3F, 0xF0, 0x3F, 0x07, 0xE0, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xEF, 0x87,
  0xF0, 0x7E, 0x0F, 0xBE, 0x1F, 0xC1, 0xFC, 0x3E, 0xF8, 0x7E, 0x07, 0xF1,
  0xFB, 0xE1, 0xF8, 0x0F, 0xC7, 0xCF, 0x8F, 0xE0, 0x3F, 0x1F, 0x3F, 0x3F,
  0x80, 0xFC, 0x7C, 0xFC, 0xFE, 0x03, 0xF3, 0xF1, 0xF3, 0xF0, 0x0F, 0xEF,
  0xC7, 0xCF, 0xC0, 0x1F, 0xBF, 0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x7D, 0xFC,
  0x01, 0xFB, 0xE1, 0xFF, 0xF0, 0x07, 0xEF, 0x83, 0xFF, 0x80, 0x1F, 0xBE,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xEF, 0xE0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFE, 0x1F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFB,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xF3,
  0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7F,
  0x3F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x1C, 0x1F, 0xC2, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0xFC, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0x7F, 0x8F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x0F,
  0xCF, 0xF0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF9, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0xFE,
  0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0x9F, 0xF0, 0xF8, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFE, 0x7F, 0x8E, 0x7F, 0x02, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0x7F,
  0x87, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xE7, 0xF1, 0xFF, 0x7F, 0x3F, 0xFB, 0xF3, 0xFF, 0xBF, 0x7F, 0xFF,
  0xF7, 0xF9, 0xFF, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x7E, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFB, 0xF1, 0xFF, 0x3F, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x83,
  0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x04, 0xFE, 0x03,
  0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xE2, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF,
  0xBF, 0x7F, 0xFF, 0xF7, 0xF9, 0xFF, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF7, 0xF1, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xBF, 0x3F, 0xFB, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE4, 0x00, 0xFE, 0x70,
  0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x7E, 0xFF, 0x8F, 0xDF, 0xF9,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFE, 0x7E, 0xFD, 0xFF,
  0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFF,
  0xFF, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFE, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x1F,
  0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x3F, 0x81, 0xF9, 0xF8,
  0x0F, 0xDF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0x81, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xE7, 0xE0,
  0x7F, 0x3F, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x7E, 0x07, 0xF1, 0xF3, 0xFF, 0x1F, 0xF3, 0xEF, 0xFE,
  0x7F, 0xF7, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0,
  0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x1F,
  0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFF,
  0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0xFE, 0x07, 0xFF,
  0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0xF8,
  0x7E, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7D, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0x7F, 0xBF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0xF8, 0x7E, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xF1, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF,
  0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFD, 0xFF, 0x8F, 0xDF, 0xF0, 0xFC, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xBF,
  0x7F, 0xFF, 0xF7, 0xFB, 0xFF, 0x7F, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF7, 0xF1, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFF, 0xBF, 0x3F, 0xFB, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0xF8, 0x7F, 0xE3, 0xEF, 0x9F, 0xBE, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7E, 0x0C, 0xFE, 0x04, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x47, 0xFF, 0x1F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xF7, 0xE7, 0xFC, 0xFC, 0x7F, 0x0F, 0x80, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0x80, 0xFE, 0x7F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7E,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xBF, 0x03, 0xF8, 0x0F, 0xDF, 0x81,
  0xFE, 0x0F, 0xEF, 0xC1, 0xFF, 0x07, 0xE7, 0xE0, 0xFF, 0x83, 0xF3, 0xF8,
  0x7F, 0xC1, 0xF8, 0xFC, 0x3D, 0xE1, 0xFC, 0x7E, 0x1E, 0xF8, 0xFC, 0x3F,
  0x0F, 0x7C, 0x7E, 0x1F, 0x8F, 0xBE, 0x3F, 0x07, 0xE7, 0xCF, 0x1F, 0x83,
  0xF3, 0xC7, 0x9F, 0xC1, 0xF9, 0xE3, 0xCF, 0xC0, 0xFC, 0xF1, 0xF7, 0xE0,
  0x7E, 0x78, 0xFB, 0xF0, 0x1F, 0x7C, 0x3D, 0xF8, 0x0F, 0xFE, 0x1E, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x9F,
  0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xF9,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0x07, 0xE3,
  0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07,
  0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF3,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x87, 0xFF,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0xFF,
  0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xC1, 0xFF, 0x87, 0xFF, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFC, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x0B, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFB, 0x00, 0xFF, 0x90,
  0x00, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_Bold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 36, 13, 2, -35 },
  { 37, 17, 13, 22, 2, -35 },
  { 65, 23, 35, 25, 1, -35 },
  { 166, 19, 40, 23, 2, -37 },
  { 261, 35, 35, 38, 1, -35 },
  { 415, 26, 35, 27, 1, -35 },
  { 529, 7, 13, 12, 2, -35 },
  { 541, 13, 43, 15, 2, -35 },
  { 611, 12, 43, 15, 1, -35 },
  { 676, 20, 19, 22, 1, -37 },
  { 724, 20, 23, 23, 1, -29 },
  { 782, 8, 12, 12, 2, -6 },
  { 794, 13, 6, 15, 1, -16 },
  { 804, 8, 9, 13, 2, -8 },
  { 813, 20, 35, 20, 0, -35 },
  { 901, 19, 36, 23, 2, -36 },
  { 987, 15, 35, 23, 2, -35 },
  { 1053, 20, 35, 23, 1, -35 },
  { 1141, 19, 35, 23, 2, -35 },
  { 1225, 21, 35, 23, 1, -35 },
  { 1317, 19, 35, 23, 2, -35 },
  { 1401, 20, 35, 23, 1, -35 },
  { 1489, 20, 35, 23, 1, -35 },
  { 1577, 20, 35, 23, 1, -35 },
  { 1665, 20, 35, 23, 1, -35 },
  { 1753, 7, 28, 13, 3, -27 },
  { 1778, 8, 33, 13, 2, -27 },
  { 1811, 20, 23, 23, 1, -29 },
  { 1869, 20, 15, 23, 1, -25 },
  { 1907, 21, 23, 23, 1, -29 },
  { 1968, 17, 36, 18, 0, -35 },
  { 2045, 31, 39, 35, 2, -35 },
  { 2197, 26, 35, 26, 0, -35 },
  { 2311, 21, 35, 26, 3, -35 },
  { 2403, 20, 35, 24, 2, -35 },
  { 2491, 22, 35, 27, 3, -35 },
  { 2588, 16, 35, 21, 3, -35 },
  { 2658, 16, 35, 21, 3, -35 },
  { 2728, 23, 35, 28, 2, -35 },
  { 2829, 22, 35, 29, 3, -35 },
  { 2926, 13, 35, 15, 1, -35 },
  { 2983, 13, 45, 13, -3, -35 },
  { 3057, 23, 35, 25, 3, -35 },
  { 3158, 16, 35, 20, 3, -35 },
  { 3228, 31, 35, 38, 3, -35 },
  { 3364, 24, 35, 31, 3, -35 },
  { 3469, 25, 36, 29, 2, -36 },
  { 3582, 20, 35, 24, 3, -35 },
  { 3670, 25, 44, 29, 2, -36 },
  { 3808, 22, 35, 25, 3, -35 },
  { 3905, 17, 35, 21, 2, -35 },
  { 3980, 19, 35, 21, 1, -35 },
  { 4064, 22, 35, 28, 3, -35 },
  { 4161, 25, 35, 25, 0, -35 },
  { 4271, 38, 35, 37, -1, -35 },
  { 4438, 23, 35, 23, 0, -35 },
  { 4539, 23, 35, 23, 0, -35 },
  { 4640, 18, 35, 20, 1, -35 },
  { 4719, 11, 43, 15, 3, -35 },
  { 4779, 19, 35, 20, 0, -35 },
  { 4863, 11, 43, 15, 1, -35 },
  { 4923, 24, 21, 26, 1, -35 },
  { 4986, 20, 4, 20, 0, 4 },
  { 4996, 11, 8, 15, 2, -38 },
  { 5007, 19, 27, 23, 1, -27 },
  { 5072, 20, 37, 25, 3, -37 },
  { 5165, 16, 27, 20, 2, -27 },
  { 5219, 20, 37, 25, 2, -37 },
  { 5312, 19, 27, 22, 2, -27 },
  { 5377, 16, 37, 15, 0, -37 },
  { 5451, 20, 39, 25, 2, -27 },
  { 5549, 19, 37, 25, 3, -37 },
  { 5637, 7, 37, 12, 2, -37 },
  { 5670, 10, 49, 12, -1, -37 },
  { 5732, 21, 37, 24, 3, -37 },
  { 5830, 6, 37, 12, 3, -37 },
  { 5858, 31, 27, 37, 3, -27 },
  { 5963, 19, 27, 25, 3, -27 },
  { 6028, 20, 27, 24, 2, -27 },
  { 6096, 20, 39, 25, 3, -27 },
  { 6194, 20, 39, 25, 2, -27 },
  { 6292, 14, 27, 17, 3, -27 },
  { 6340, 16, 27, 18, 1, -27 },
  { 6394, 14, 32, 16, 1, -32 },
  { 6450, 19, 27, 25, 3, -27 },
  { 6515, 22, 27, 22, 0, -27 },
  { 6590, 33, 27, 33, 0, -27 },
  { 6702, 21, 27, 21, 0, -27 },
  { 6773, 22, 39, 22, 0, -27 },
  { 6881, 16, 27, 18, 1, -27 },
  { 6935, 15, 43, 17, 0, -35 },
  { 7016, 6, 48, 22, 8, -37 },
  { 7052, 15, 43, 17, 2, -35 },
  { 7133, 21, 8, 23, 1, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Bold49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD49PT7B_H_
