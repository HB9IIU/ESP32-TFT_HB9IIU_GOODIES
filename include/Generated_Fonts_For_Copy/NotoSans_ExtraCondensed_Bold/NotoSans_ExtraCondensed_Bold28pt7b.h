#ifndef _NOTOSANS_EXTRACONDENSED_BOLD28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x77,
  0xFE, 0xE0, 0xF3, 0xFC, 0xFF, 0x3D, 0xCF, 0x73, 0xDC, 0x77, 0x1C, 0x0E,
  0xE0, 0x67, 0x03, 0x38, 0x39, 0xC1, 0xCC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x19, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x0F, 0xFF, 0x7F, 0xF8, 0xEE, 0x06,
  0x70, 0x33, 0x81, 0x9C, 0x1C, 0xE0, 0xE6, 0x00, 0x04, 0x00, 0x80, 0x7F,
  0x3F, 0xF7, 0xFD, 0xE8, 0xBD, 0x07, 0xA0, 0x7C, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7C, 0x0B, 0xC1, 0x7C, 0x2F, 0xE5, 0xDF, 0xFB, 0xFE, 0x07, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x3C, 0x0E, 0x07, 0xE0, 0xC0, 0xEE, 0x1C, 0x0E,
  0x71, 0xC0, 0xE7, 0x38, 0x0E, 0x73, 0x80, 0xE7, 0x38, 0x0E, 0x77, 0x00,
  0xE7, 0x73, 0xCE, 0xE6, 0x7E, 0x7E, 0xEE, 0xE3, 0xCE, 0xE7, 0x01, 0xCE,
  0x70, 0x1C, 0xE7, 0x01, 0x8E, 0x70, 0x38, 0xE7, 0x03, 0x8E, 0x70, 0x70,
  0xEE, 0x07, 0x07, 0xE0, 0x60, 0x3C, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x1E, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C,
  0x79, 0xFC, 0xF7, 0xF9, 0xEF, 0x7B, 0x9C, 0x7F, 0x38, 0x7E, 0x78, 0xF8,
  0xF1, 0xF1, 0xFF, 0xF1, 0xFF, 0xF1, 0xF9, 0xF0, 0xFF, 0xF7, 0x77, 0x70,
  0x0E, 0x38, 0x71, 0xC3, 0x8F, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x38, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0x0E, 0x01, 0xC2,
  0x39, 0x7E, 0xEF, 0xFF, 0xFF, 0xC7, 0xC1, 0xFC, 0x7B, 0xCE, 0x70, 0x44,
  0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7B, 0x9D, 0xEF,
  0x73, 0x80, 0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xE0, 0x00, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x00,
  0x1F, 0x07, 0xF1, 0xFF, 0x3D, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x7B, 0xCF,
  0xF8, 0xFE, 0x0F, 0x80, 0x07, 0x87, 0xC7, 0xE7, 0xF7, 0xFF, 0xFD, 0xDE,
  0x4F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x3F, 0x0F, 0xF3, 0xFF, 0x31, 0xE4, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x1F, 0xF3, 0xFF, 0x31,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x3F, 0x87, 0xC0, 0xFE, 0x03, 0xE0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xFF, 0xFB, 0xFE, 0x7F, 0x80, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x37, 0x83, 0xBC,
  0x19, 0xE1, 0xCF, 0x0E, 0x78, 0xE3, 0xC7, 0x1E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x7F, 0xCF, 0xF9, 0xFF,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xF8, 0x7F, 0x8F, 0xF9, 0xFF, 0x01,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xC3, 0xDF, 0xFB, 0xFE, 0x3F, 0x80,
  0x0F, 0xC3, 0xF8, 0xFF, 0x3E, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x3C, 0xEF,
  0xDF, 0xFB, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0x79, 0xEF,
  0xF8, 0xFF, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x3F, 0x0F, 0xF9, 0xFF,
  0x78, 0xFF, 0x1F, 0xE3, 0xDC, 0x73, 0xDE, 0x3F, 0x83, 0xE0, 0xFE, 0x3D,
  0xEF, 0x1F, 0xE3, 0xF8, 0x3F, 0x0F, 0xF1, 0xFF, 0xF9, 0xFF, 0x1F, 0xC0,
  0x3F, 0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1,
  0xFE, 0x7F, 0xFF, 0xBF, 0xF3, 0xDE, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0xCF,
  0xF1, 0xFC, 0x3F, 0x00, 0x77, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0xFD, 0xC0, 0x7B, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xCE,
  0xF7, 0x38, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xF1, 0xF8, 0xFC, 0x3E, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF0, 0x06, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x03,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x0F, 0xC7, 0xE3, 0xF0,
  0x78, 0x0C, 0x01, 0x00, 0x00, 0x3F, 0x3F, 0xE7, 0xFD, 0x8F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x70, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0x83, 0xE0, 0x70, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0,
  0xF0, 0xF0, 0x1C, 0x38, 0x03, 0x9C, 0x3E, 0x67, 0x3F, 0x9D, 0x8E, 0xE7,
  0xE7, 0x39, 0xF9, 0xCE, 0x7E, 0x73, 0x9F, 0x9C, 0xE7, 0xE7, 0x39, 0xF9,
  0xCE, 0x7E, 0x7F, 0xFB, 0x8F, 0xBE, 0x71, 0xC6, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x30, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0xB8, 0x0F, 0x78, 0x1C,
  0xF0, 0x38, 0xE0, 0xF1, 0xC1, 0xE3, 0xC3, 0xFF, 0x87, 0xFF, 0x1F, 0xFE,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xF0, 0xFF, 0x0F,
  0xFC, 0xFF, 0xEF, 0x3E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xFF, 0xCF,
  0xF8, 0xFF, 0xCF, 0x1E, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xEF,
  0xFE, 0xFF, 0xCF, 0xF0, 0x0F, 0xE1, 0xFF, 0x3F, 0xE3, 0xC2, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x23, 0xFE, 0x1F, 0xE0, 0xFE, 0xFF, 0x0F,
  0xF8, 0xFF, 0xCF, 0x3E, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xF7, 0xEF,
  0xFC, 0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xFF, 0x7F, 0xBF, 0xDE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7F, 0xBF, 0xDF, 0xEF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0x7C, 0x27, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xBC,
  0x3D, 0xE1, 0xEF, 0x0F, 0x7C, 0x79, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0xFF, 0xFF, 0xF1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xFB,
  0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0x7E, 0xF9,
  0xE0, 0xF0, 0xFF, 0x87, 0xBC, 0x79, 0xE7, 0xCF, 0x3C, 0x7B, 0xE3, 0xDE,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0x78, 0x79, 0xE3,
  0xCF, 0x1E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x3D, 0xE1, 0xF0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xFE, 0xE1,
  0xFF, 0xB8, 0xEF, 0xEE, 0x3B, 0xFB, 0xCE, 0xFE, 0x73, 0xBF, 0x9D, 0xCF,
  0xE7, 0x73, 0xF9, 0xFC, 0xFE, 0x3F, 0x3F, 0x8F, 0x8F, 0xE3, 0xE3, 0xF8,
  0xF8, 0xFE, 0x1C, 0x3F, 0x87, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF8, 0xFE, 0xE3, 0xFB, 0xCF, 0xEF, 0x3F, 0x9C, 0xFE,
  0x7B, 0xF8, 0xEF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x83, 0xFE, 0x07, 0xF8, 0x1F, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E,
  0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x1F, 0x7C, 0x78, 0xFF,
  0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0x1F, 0xF3, 0xFF, 0x79, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0xFB, 0xFF, 0x7F, 0xCF, 0xE1, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x9F, 0x1E, 0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE, 0x1F,
  0x7C, 0x78, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0xFF, 0x0F, 0xF8, 0xFF, 0xCF, 0x3E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0xF7, 0x8F,
  0x78, 0xF3, 0xCF, 0x3C, 0xF1, 0xEF, 0x1E, 0xF1, 0xFF, 0x0F, 0x3F, 0x9F,
  0xF7, 0xFF, 0xE6, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0xE7, 0xFF, 0xEF, 0xF9, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFE, 0x7F, 0xE3, 0xF8, 0xF0,
  0x3F, 0xC0, 0xF7, 0x03, 0xDC, 0x0E, 0x78, 0x39, 0xE1, 0xE3, 0x87, 0x8E,
  0x1C, 0x3C, 0x70, 0xF3, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x7B, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0xE0, 0x70,
  0x7F, 0x83, 0x83, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xF7, 0x0F, 0x87, 0x38,
  0x7C, 0x79, 0xE3, 0x63, 0xCF, 0x3B, 0x9E, 0x79, 0xDC, 0xF1, 0xCE, 0xE7,
  0x0E, 0x77, 0x78, 0x77, 0xBB, 0xC3, 0xF8, 0xDE, 0x1F, 0xC7, 0xF0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC1, 0xF0,
  0x1E, 0x0F, 0x00, 0xF8, 0x7B, 0xC7, 0x9E, 0x3C, 0x79, 0xC3, 0xDE, 0x0E,
  0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0xF7, 0x87, 0xBC, 0x38, 0xF3, 0xC7, 0x9E, 0x1F, 0xE0, 0xF0,
  0xF0, 0x7B, 0x83, 0xDE, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0x70, 0xF7, 0x83,
  0xB8, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0xFF,
  0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01,
  0xFC, 0x0E, 0xE0, 0xF7, 0x07, 0x1C, 0x78, 0xE3, 0x83, 0xBC, 0x1D, 0xC0,
  0x70, 0xFF, 0xFF, 0xFC, 0xF8, 0xF0, 0xF0, 0xF0, 0x04, 0x1F, 0xE7, 0xFC,
  0xCF, 0x01, 0xC0, 0x70, 0x7C, 0xFF, 0x7F, 0xFC, 0x7F, 0x1F, 0x87, 0xF3,
  0xFF, 0xFF, 0xFD, 0xF3, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC4,
  0x3B, 0xE7, 0xFE, 0xFF, 0xDE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFE, 0x3B, 0xFF, 0x7F, 0xEE, 0xF8, 0x06, 0x0F, 0xF7,
  0xF9, 0xFE, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0x78, 0x9F, 0xE3, 0xF8, 0x7E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x11, 0xCF, 0xBB, 0xFF, 0x7F, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3D, 0xFF, 0xBF, 0xF3, 0xEE, 0x04, 0x07,
  0xF1, 0xFF, 0x3D, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xC0, 0x78, 0x07, 0x04, 0xFF, 0x8F, 0xF0, 0xFE, 0x1F, 0x9F, 0xCF, 0xE7,
  0x83, 0xC1, 0xE1, 0xFD, 0xFE, 0xFF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x08, 0x07, 0xDD, 0xFF,
  0xBF, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFF, 0x1E, 0xFF, 0xDF, 0xF9, 0xF7, 0x00, 0xE0, 0x1E, 0x07, 0xBB, 0xF7,
  0xFC, 0xFF, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x8E,
  0xFB, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x7F, 0x77, 0x00, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x1C, 0xF1, 0xC7, 0x00, 0x01, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF,
  0xFF, 0xFF, 0x9C, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE1, 0xEE, 0x3C, 0xE3, 0xCE, 0x78, 0xEF, 0x0E, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x0F, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x02, 0x04, 0x77, 0xCF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0x0F, 0x1F, 0x87, 0x0F, 0xC3, 0x87,
  0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E,
  0x1F, 0x87, 0x0F, 0xC3, 0x87, 0x02, 0x3B, 0xEF, 0xFF, 0xFF, 0xF1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0x06, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0xF1, 0xEF, 0x0E, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0x79, 0xE7, 0xFE, 0x3F, 0xC1,
  0xF8, 0x02, 0x1D, 0xF3, 0xFF, 0x7F, 0xEF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x3D, 0xFF, 0xBF, 0xF7, 0x7C, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x08, 0x07, 0xDD,
  0xFF, 0xBF, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFF, 0x1E, 0xFF, 0xDF, 0xF9, 0xF7, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xDF, 0xFF, 0xFF, 0x9E, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x08, 0x3F, 0xFF, 0xDE, 0xEE,
  0x07, 0x83, 0xE0, 0xFC, 0x7F, 0x0F, 0x83, 0xE0, 0xF8, 0x7F, 0xFB, 0xFD,
  0xFC, 0x18, 0x0C, 0x0E, 0x07, 0x07, 0xF7, 0xFB, 0xFC, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3F, 0x9F, 0xC7, 0xE0, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x3F, 0xCF, 0xFF, 0xFF, 0xF7, 0xDC, 0xF0, 0xF7, 0x0F, 0x70, 0xF7, 0x8E,
  0x79, 0xE3, 0x9E, 0x39, 0xE3, 0xDC, 0x3D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF1, 0xF1, 0xEE, 0x3E, 0x39, 0xC7, 0xC7,
  0x3C, 0xD8, 0xE7, 0x9B, 0x3C, 0xF7, 0x77, 0x8E, 0xEE, 0xE1, 0xDD, 0xDC,
  0x3B, 0x1B, 0x87, 0x63, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF1, 0xF7, 0x9E, 0x39, 0xC3, 0xFC, 0x3F,
  0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0xC3, 0xBC, 0x79,
  0xE7, 0x9E, 0xF0, 0xF0, 0xF0, 0xF7, 0x0F, 0x78, 0xF7, 0x8E, 0x79, 0xE3,
  0x9E, 0x3D, 0xE3, 0xDC, 0x1D, 0xC1, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0x00, 0xFF, 0x7F, 0xBF, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0x87, 0xC7, 0xE3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x1F, 0x8F, 0x87, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF8, 0xF8, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3E, 0x1F, 0x0F, 0x1F, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xF8, 0x78, 0x3F, 0xFF, 0xFF,
  0xC3, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 20, 7, 1, -20 },
  { 14, 10, 7, 12, 1, -20 },
  { 23, 13, 20, 14, 1, -20 },
  { 56, 11, 23, 13, 1, -21 },
  { 88, 20, 20, 22, 1, -20 },
  { 138, 15, 20, 16, 1, -20 },
  { 176, 4, 7, 7, 1, -20 },
  { 180, 7, 24, 9, 1, -20 },
  { 201, 8, 24, 9, 0, -20 },
  { 225, 11, 11, 12, 1, -21 },
  { 241, 11, 14, 13, 1, -17 },
  { 261, 5, 7, 7, 1, -3 },
  { 266, 7, 3, 9, 1, -9 },
  { 269, 5, 4, 7, 1, -4 },
  { 272, 11, 20, 11, 0, -20 },
  { 300, 11, 20, 13, 1, -20 },
  { 328, 9, 20, 13, 1, -20 },
  { 351, 11, 20, 13, 1, -20 },
  { 379, 11, 20, 13, 1, -20 },
  { 407, 13, 20, 13, 0, -20 },
  { 440, 11, 20, 13, 1, -20 },
  { 468, 11, 20, 13, 1, -20 },
  { 496, 11, 20, 13, 1, -20 },
  { 524, 11, 20, 13, 1, -20 },
  { 552, 11, 20, 13, 1, -20 },
  { 580, 5, 15, 7, 1, -15 },
  { 590, 5, 19, 7, 1, -15 },
  { 602, 11, 14, 13, 1, -17 },
  { 622, 11, 8, 13, 1, -14 },
  { 633, 11, 14, 13, 1, -17 },
  { 653, 10, 20, 10, 0, -20 },
  { 678, 18, 22, 20, 1, -20 },
  { 728, 15, 20, 15, 0, -20 },
  { 766, 12, 20, 15, 2, -20 },
  { 796, 12, 20, 14, 1, -20 },
  { 826, 12, 20, 16, 2, -20 },
  { 856, 9, 20, 12, 2, -20 },
  { 879, 9, 20, 12, 2, -20 },
  { 902, 13, 20, 16, 1, -20 },
  { 935, 13, 20, 16, 2, -20 },
  { 968, 7, 20, 9, 1, -20 },
  { 986, 7, 26, 8, -1, -20 },
  { 1009, 13, 20, 14, 2, -20 },
  { 1042, 9, 20, 11, 2, -20 },
  { 1065, 18, 20, 22, 2, -20 },
  { 1110, 14, 20, 18, 2, -20 },
  { 1145, 14, 20, 17, 1, -20 },
  { 1180, 11, 20, 14, 2, -20 },
  { 1208, 14, 25, 17, 1, -20 },
  { 1252, 12, 20, 14, 2, -20 },
  { 1282, 10, 20, 12, 1, -20 },
  { 1307, 12, 20, 12, 0, -20 },
  { 1337, 12, 20, 16, 2, -20 },
  { 1367, 14, 20, 14, 0, -20 },
  { 1402, 21, 20, 21, 0, -20 },
  { 1455, 13, 20, 13, 0, -20 },
  { 1488, 13, 20, 13, 0, -20 },
  { 1521, 11, 20, 12, 0, -20 },
  { 1549, 6, 24, 9, 2, -20 },
  { 1567, 11, 20, 11, 0, -20 },
  { 1595, 6, 24, 9, 1, -20 },
  { 1613, 13, 12, 15, 1, -20 },
  { 1633, 11, 2, 11, 0, 2 },
  { 1636, 7, 4, 9, 1, -21 },
  { 1640, 10, 16, 13, 1, -16 },
  { 1660, 11, 21, 14, 2, -21 },
  { 1689, 10, 16, 11, 1, -16 },
  { 1709, 11, 21, 14, 1, -21 },
  { 1738, 11, 16, 13, 1, -16 },
  { 1760, 9, 21, 8, 0, -21 },
  { 1784, 11, 23, 14, 1, -16 },
  { 1816, 10, 21, 14, 2, -21 },
  { 1843, 4, 21, 7, 1, -21 },
  { 1854, 6, 28, 7, -1, -21 },
  { 1875, 12, 21, 14, 2, -21 },
  { 1907, 3, 21, 7, 2, -21 },
  { 1915, 17, 16, 21, 2, -16 },
  { 1949, 10, 16, 14, 2, -16 },
  { 1969, 12, 16, 14, 1, -16 },
  { 1993, 11, 23, 14, 2, -16 },
  { 2025, 11, 23, 14, 1, -16 },
  { 2057, 7, 16, 10, 2, -16 },
  { 2071, 9, 16, 10, 1, -16 },
  { 2089, 9, 19, 9, 0, -19 },
  { 2111, 10, 15, 14, 2, -15 },
  { 2130, 12, 15, 12, 0, -15 },
  { 2153, 19, 15, 19, 0, -15 },
  { 2189, 12, 15, 12, 0, -15 },
  { 2212, 12, 22, 12, 0, -15 },
  { 2245, 9, 15, 10, 1, -15 },
  { 2262, 9, 24, 10, 0, -20 },
  { 2289, 3, 28, 12, 5, -21 },
  { 2300, 8, 24, 10, 1, -20 },
  { 2324, 11, 4, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Bold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD28PT7B_H_
