#ifndef _NOTOSANS_EXTRACONDENSED_BOLD11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xD5, 0x50, 0x29, 0x7E, 0xE5, 0x7D, 0x4A, 0x23, 0xF8, 0xC3,
  0x1F, 0xC4, 0x20, 0x64, 0xE4, 0xA8, 0xEA, 0x6D, 0x15, 0x15, 0x27, 0x71,
  0x45, 0x1C, 0x7F, 0x6D, 0x9F, 0xD4, 0x7A, 0xAA, 0xD0, 0xC9, 0x92, 0x5B,
  0x58, 0x27, 0xDC, 0xA0, 0x21, 0x09, 0xF2, 0x10, 0x70, 0xFC, 0xC0, 0x11,
  0x22, 0x64, 0x4C, 0x72, 0xB7, 0xBD, 0xED, 0x4E, 0x7F, 0xB6, 0xDB, 0x76,
  0x86, 0x23, 0x31, 0x1F, 0xF2, 0x86, 0xE7, 0x0E, 0x7E, 0x11, 0x8C, 0xA5,
  0x7C, 0x42, 0x72, 0x10, 0xE1, 0x8E, 0x5E, 0x33, 0x11, 0xED, 0xED, 0x6E,
  0xF8, 0xC4, 0x23, 0x11, 0x8C, 0x76, 0xD6, 0xE7, 0x6F, 0x6E, 0x76, 0xB7,
  0xB7, 0x8C, 0x4C, 0xCC, 0x50, 0x1C, 0x08, 0xD9, 0xC3, 0x84, 0xFF, 0xC1,
  0xF0, 0x86, 0x0C, 0x7E, 0x40, 0xEB, 0x32, 0x60, 0x46, 0x3C, 0x62, 0x5E,
  0x7E, 0xAF, 0xEE, 0x56, 0x64, 0x3C, 0x30, 0xC7, 0x1E, 0x59, 0xEC, 0xB3,
  0xEB, 0x9F, 0xF9, 0x9F, 0x3B, 0x51, 0x8C, 0x21, 0xA7, 0xE5, 0xA7, 0x39,
  0xCE, 0xDC, 0xF2, 0x7F, 0x27, 0xF2, 0x4F, 0x24, 0x3D, 0xA4, 0x10, 0xDD,
  0x36, 0xCF, 0x9C, 0xE7, 0xFF, 0xCE, 0x73, 0xE9, 0x24, 0x97, 0x24, 0x92,
  0x49, 0x3C, 0x9D, 0xA9, 0xCE, 0x5A, 0xD3, 0x92, 0x49, 0x27, 0xC7, 0x9F,
  0x3F, 0x7A, 0xF6, 0xED, 0xDB, 0xCE, 0x7B, 0x5A, 0xDE, 0x73, 0x39, 0xB4,
  0xF3, 0xCD, 0x36, 0xCE, 0xEB, 0x9B, 0xE8, 0x88, 0x39, 0xB4, 0xF3, 0xCD,
  0x36, 0xCE, 0x18, 0x30, 0xE5, 0xA5, 0x6E, 0x52, 0xD3, 0x75, 0xC6, 0x31,
  0x9F, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x9C, 0xE7, 0x39, 0xCE, 0x5E, 0x8F,
  0x24, 0x96, 0x51, 0xC3, 0x0C, 0x99, 0xD9, 0xDB, 0x5B, 0x5E, 0x76, 0x66,
  0x66, 0xDA, 0x9C, 0x63, 0x39, 0x7B, 0xCA, 0xD4, 0xE3, 0x10, 0x84, 0xF1,
  0x32, 0x64, 0xCF, 0xEA, 0xAA, 0xB0, 0xC4, 0x46, 0x22, 0x11, 0xED, 0xB6,
  0xDB, 0x7C, 0x20, 0xC7, 0x12, 0xCC, 0xF8, 0xE0, 0x70, 0x9F, 0xBD, 0xBC,
  0x88, 0xFB, 0x99, 0xBF, 0x74, 0xCC, 0x57, 0x18, 0xDE, 0xBD, 0xED, 0x6D,
  0x72, 0xFF, 0x84, 0xB8, 0x74, 0xE4, 0x44, 0x44, 0x6A, 0xF7, 0xB5, 0xBC,
  0x6F, 0x60, 0x88, 0xFB, 0xBB, 0xBB, 0xBF, 0x45, 0x55, 0x78, 0x88, 0xBA,
  0xEE, 0xB9, 0xFF, 0xFD, 0x6E, 0xDD, 0xBB, 0x76, 0xC0, 0xFB, 0xBB, 0xBB,
  0x72, 0xF3, 0xB5, 0xB8, 0xFB, 0x99, 0xBF, 0x88, 0x80, 0x6A, 0xF7, 0xB5,
  0xBC, 0x63, 0x18, 0xFA, 0x49, 0x00, 0x7C, 0x63, 0xBE, 0x5D, 0x24, 0x98,
  0xBB, 0xBB, 0xBD, 0xDE, 0x94, 0xA7, 0x10, 0xDB, 0xB5, 0xBB, 0x76, 0xCD,
  0x80, 0xDB, 0x98, 0xC7, 0x6C, 0xDE, 0x94, 0xA7, 0x10, 0x9C, 0xC0, 0xF2,
  0x64, 0x4F, 0x2D, 0xBD, 0x9B, 0x64, 0xFF, 0xE0, 0xC6, 0x66, 0x77, 0x66,
  0x6C, 0x6D, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 4, 3, 5, 0, -8 },
  { 4, 5, 8, 6, 0, -8 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 8, 8, 8, 0, -8 },
  { 23, 6, 8, 6, 0, -8 },
  { 29, 2, 3, 3, 0, -8 },
  { 30, 2, 10, 3, 1, -8 },
  { 33, 3, 10, 3, 0, -8 },
  { 37, 5, 4, 5, 0, -8 },
  { 40, 5, 6, 5, 0, -7 },
  { 44, 2, 2, 3, 0, -1 },
  { 45, 3, 2, 3, 0, -4 },
  { 46, 1, 2, 3, 1, -2 },
  { 47, 4, 8, 4, 0, -8 },
  { 51, 5, 8, 5, 0, -8 },
  { 56, 3, 8, 5, 1, -8 },
  { 59, 5, 8, 5, 0, -8 },
  { 64, 5, 8, 5, 0, -8 },
  { 69, 5, 8, 5, 0, -8 },
  { 74, 5, 8, 5, 0, -8 },
  { 79, 5, 8, 5, 0, -8 },
  { 84, 5, 8, 5, 0, -8 },
  { 89, 5, 8, 5, 0, -8 },
  { 94, 5, 8, 5, 0, -8 },
  { 99, 1, 6, 3, 1, -6 },
  { 100, 2, 7, 3, 0, -6 },
  { 102, 5, 6, 5, 0, -7 },
  { 106, 5, 4, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -7 },
  { 113, 4, 8, 4, 0, -8 },
  { 117, 8, 9, 8, 0, -8 },
  { 126, 6, 8, 6, 0, -8 },
  { 132, 4, 8, 6, 1, -8 },
  { 136, 5, 8, 5, 0, -8 },
  { 141, 5, 8, 6, 1, -8 },
  { 146, 3, 8, 5, 1, -8 },
  { 149, 3, 8, 5, 1, -8 },
  { 152, 6, 8, 6, 0, -8 },
  { 158, 5, 8, 6, 1, -8 },
  { 163, 3, 8, 3, 0, -8 },
  { 166, 3, 10, 3, -1, -8 },
  { 170, 5, 8, 6, 1, -8 },
  { 175, 3, 8, 4, 1, -8 },
  { 178, 7, 8, 8, 1, -8 },
  { 185, 5, 8, 7, 1, -8 },
  { 190, 6, 8, 7, 0, -8 },
  { 196, 4, 8, 5, 1, -8 },
  { 200, 6, 10, 7, 0, -8 },
  { 208, 5, 8, 6, 1, -8 },
  { 213, 4, 8, 5, 0, -8 },
  { 217, 5, 8, 5, 0, -8 },
  { 222, 5, 8, 6, 1, -8 },
  { 227, 6, 8, 6, 0, -8 },
  { 233, 8, 8, 8, 0, -8 },
  { 241, 5, 8, 5, 0, -8 },
  { 246, 5, 8, 5, 0, -8 },
  { 251, 4, 8, 5, 0, -8 },
  { 255, 2, 10, 3, 1, -8 },
  { 258, 4, 8, 4, 0, -8 },
  { 262, 3, 10, 3, 0, -8 },
  { 266, 6, 5, 6, 0, -8 },
  { 270, 5, 1, 4, 0, 1 },
  { 271, 3, 1, 3, 0, -8 },
  { 272, 5, 6, 5, 0, -6 },
  { 276, 4, 8, 6, 1, -8 },
  { 280, 4, 6, 4, 0, -6 },
  { 283, 5, 8, 6, 0, -8 },
  { 288, 5, 6, 5, 0, -6 },
  { 292, 4, 8, 3, 0, -8 },
  { 296, 5, 9, 6, 0, -6 },
  { 302, 4, 8, 6, 1, -8 },
  { 306, 1, 8, 3, 1, -8 },
  { 307, 2, 11, 3, 0, -8 },
  { 310, 4, 8, 5, 1, -8 },
  { 314, 1, 8, 3, 1, -8 },
  { 315, 7, 6, 8, 1, -6 },
  { 321, 4, 6, 6, 1, -6 },
  { 324, 5, 6, 5, 0, -6 },
  { 328, 4, 9, 6, 1, -6 },
  { 333, 5, 9, 6, 0, -6 },
  { 339, 3, 6, 4, 1, -6 },
  { 342, 4, 6, 4, 0, -6 },
  { 345, 3, 7, 4, 0, -7 },
  { 348, 4, 6, 6, 1, -6 },
  { 351, 5, 6, 5, 0, -6 },
  { 355, 7, 6, 7, 0, -6 },
  { 361, 5, 6, 5, 0, -6 },
  { 365, 5, 9, 5, 0, -6 },
  { 371, 4, 6, 4, 0, -6 },
  { 374, 3, 10, 4, 0, -8 },
  { 378, 1, 11, 5, 2, -8 },
  { 380, 4, 10, 4, 0, -8 },
  { 385, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Bold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD11PT7B_H_
