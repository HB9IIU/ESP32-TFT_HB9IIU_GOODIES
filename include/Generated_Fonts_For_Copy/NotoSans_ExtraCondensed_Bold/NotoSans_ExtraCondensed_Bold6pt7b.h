#ifndef _NOTOSANS_EXTRACONDENSED_BOLD6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xE0, 0x5F, 0x3C, 0xEF, 0x35, 0xEB, 0xF0, 0x80,
  0x6A, 0x40, 0x95, 0x80, 0x5F, 0x00, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A,
  0xD6, 0xE0, 0xD5, 0xC9, 0x70, 0xE8, 0xE0, 0x4B, 0xA0, 0xD8, 0xE0, 0xDA,
  0xE0, 0xE9, 0x60, 0xEA, 0xE0, 0xD5, 0x60, 0xA0, 0xB0, 0x39, 0x80, 0xFC,
  0x8F, 0x00, 0xDA, 0x7F, 0xFE, 0x57, 0xD0, 0xFE, 0xF0, 0x72, 0x30, 0xF6,
  0xF0, 0xFB, 0xFA, 0x72, 0xB0, 0xBE, 0xD0, 0xEB, 0xF8, 0xBA, 0xD0, 0xAB,
  0xDD, 0xBB, 0xFE, 0xD0, 0xF6, 0xB0, 0xF7, 0x40, 0xF6, 0xB2, 0xF7, 0x50,
  0xE7, 0xD5, 0xB6, 0xB0, 0xB5, 0x20, 0xBD, 0xBC, 0xA0, 0xE9, 0x50, 0xA9,
  0x20, 0xDB, 0xEA, 0xC0, 0x95, 0xD5, 0xC0, 0x54, 0xC0, 0xC0, 0xFC, 0x93,
  0xDE, 0xEC, 0x27, 0xDE, 0xFF, 0x00, 0x6E, 0x80, 0xF7, 0xF0, 0x93, 0xDA,
  0xB8, 0xBC, 0x93, 0xEA, 0xF8, 0xFB, 0xB0, 0xF6, 0x80, 0xF7, 0x00, 0xF7,
  0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0xBB, 0xB7, 0x80, 0xB9, 0x00, 0xFF, 0x60,
  0xCB, 0x80, 0xA9, 0x60, 0xDC, 0x59, 0x40, 0xFC, 0x95, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 5, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 3, 3, 3, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 2, 0, -3 },
  { 44, 1, 4, 2, 0, -3 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 2, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 4, 4, 4, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 2, 4, 3, 0, -4 },
  { 62, 2, 4, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 1, 5, 2, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 2, 4, 2, 0, -4 },
  { 72, 4, 4, 5, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 3, 5, 4, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 2, 4, 3, 0, -4 },
  { 85, 2, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 5, 4, 4, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 2, 4, 2, 0, -4 },
  { 98, 2, 5, 2, 0, -4 },
  { 100, 2, 4, 2, 0, -4 },
  { 101, 2, 5, 2, 0, -4 },
  { 103, 3, 2, 3, 0, -4 },
  { 104, 2, 1, 2, 0, 0 },
  { 105, 2, 1, 2, 0, -5 },
  { 106, 2, 3, 3, 0, -3 },
  { 107, 3, 5, 3, 0, -5 },
  { 109, 2, 3, 2, 0, -3 },
  { 110, 3, 5, 3, 0, -5 },
  { 112, 3, 3, 3, 0, -3 },
  { 114, 2, 5, 2, 0, -5 },
  { 116, 3, 4, 3, 0, -3 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 1, 5, 1, 0, -5 },
  { 121, 1, 6, 1, 0, -5 },
  { 122, 3, 5, 3, 0, -5 },
  { 124, 1, 5, 1, 0, -5 },
  { 125, 4, 3, 4, 0, -3 },
  { 127, 3, 3, 3, 0, -3 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 3, 4, 3, 0, -3 },
  { 133, 3, 4, 3, 0, -3 },
  { 135, 2, 3, 2, 0, -3 },
  { 136, 2, 3, 2, 0, -3 },
  { 137, 2, 4, 2, 0, -4 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 4, 3, 4, 0, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 4, 3, 0, -3 },
  { 148, 2, 3, 2, 0, -3 },
  { 149, 2, 5, 2, 0, -4 },
  { 151, 1, 6, 3, 1, -5 },
  { 152, 2, 5, 2, 0, -4 },
  { 154, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Bold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD6PT7B_H_
