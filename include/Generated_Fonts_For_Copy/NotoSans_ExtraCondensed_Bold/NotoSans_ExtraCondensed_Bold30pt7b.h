#ifndef _NOTOSANS_EXTRACONDENSED_BOLD30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x4F, 0xFF, 0xF0,
  0xF9, 0xEF, 0x3D, 0xC7, 0xB8, 0xF7, 0x1E, 0xE3, 0xDC, 0x70, 0x0E, 0x70,
  0x39, 0xC0, 0xE7, 0x03, 0x98, 0x0C, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x06, 0x70, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x8E, 0x70, 0x39, 0xC0, 0xE6, 0x03, 0x38, 0x0C, 0xE0, 0x73, 0x80, 0x06,
  0x00, 0x60, 0x07, 0x01, 0xFF, 0x7F, 0xE7, 0xFE, 0xF6, 0x2F, 0x60, 0xF6,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x6F, 0x06,
  0xFC, 0x6E, 0xFF, 0xEF, 0xFE, 0x7F, 0x80, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x00, 0x03, 0xF0, 0x38, 0x1F, 0xC3, 0x81, 0xCE, 0x1C, 0x0E,
  0x70, 0xE0, 0x73, 0x8E, 0x03, 0x9C, 0x70, 0x1C, 0xE7, 0x00, 0xE7, 0x38,
  0x07, 0x39, 0xCF, 0x3D, 0xDC, 0xFC, 0xFE, 0xEF, 0xF7, 0xE7, 0x73, 0x8E,
  0x73, 0x9C, 0x03, 0x9C, 0xE0, 0x38, 0xE7, 0x01, 0xC7, 0x38, 0x0E, 0x39,
  0xC0, 0xE1, 0xCE, 0x07, 0x0F, 0xF0, 0x70, 0x3F, 0x03, 0x80, 0xF0, 0x07,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x79,
  0xE0, 0x79, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x7F, 0x1E, 0x7F,
  0x9E, 0xF7, 0xDE, 0xF3, 0xFC, 0xF1, 0xFC, 0xF1, 0xF8, 0xF0, 0xF8, 0xF9,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x9F, 0xFB, 0xDC, 0xE7, 0x39, 0xC0,
  0x0F, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E,
  0x0E, 0x07, 0xF0, 0x38, 0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C,
  0x3C, 0x38, 0x78, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x0C, 0xE6, 0xFF, 0xEF,
  0xFE, 0xFF, 0xF1, 0xF0, 0x3F, 0x87, 0xBC, 0x79, 0xE1, 0x18, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7B, 0xDE, 0xEF,
  0x7B, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0xFE, 0xF7, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0x01, 0xF8, 0x3F, 0xC7,
  0xFE, 0x79, 0xE7, 0x1E, 0xF0, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xE7, 0x9E, 0x79, 0xE7,
  0xFC, 0x3F, 0xC1, 0xF8, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x3F, 0xFE, 0xF7,
  0x3C, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x0E, 0x03, 0xF8, 0xFF, 0xCF,
  0xFE, 0x61, 0xE4, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0xFC, 0xFF, 0xC7, 0xFE, 0x61, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE3, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0xC3, 0xEF, 0xFE, 0xFF, 0xCF,
  0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0x70, 0x3F,
  0x81, 0xBC, 0x1D, 0xE0, 0xCF, 0x0E, 0x78, 0x73, 0xC7, 0x1E, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x70,
  0x7F, 0xC7, 0xFC, 0x7F, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x81, 0xEE, 0x3E, 0xFF, 0xEF, 0xFC, 0x7F, 0x00, 0x03, 0xE0, 0xFE, 0x1F,
  0xE3, 0xFE, 0x7C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF7, 0x8F, 0xFC, 0xFF,
  0xEF, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x79,
  0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0xF1, 0xEF, 0x0E, 0xF0, 0xE7,
  0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0xC7, 0x9E, 0xF1, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x7F, 0xE3, 0xF8, 0x0E, 0x03,
  0xF8, 0x7F, 0xC7, 0xFE, 0xF1, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xFF, 0xFF, 0x7F, 0xF3, 0xEF, 0x08, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x07, 0xC7, 0xFC, 0x7F, 0x87, 0xE0, 0x6F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x6F, 0xFF, 0xF0, 0x33, 0xDE, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0x7B, 0x9D, 0xEE, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F,
  0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x07, 0xF1, 0xFC, 0x7F, 0x0F, 0xC0, 0xF0,
  0x0C, 0x00, 0x1E, 0x0F, 0xF3, 0xFF, 0x3F, 0xE6, 0x3E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0x03, 0xC3, 0xC0, 0x1C, 0x70, 0x03, 0x9C,
  0x3F, 0x3B, 0x8F, 0xE7, 0x73, 0xDC, 0xFC, 0x73, 0x8F, 0x9C, 0x71, 0xF3,
  0x8E, 0x3E, 0x71, 0xC7, 0xCE, 0x39, 0xF9, 0xC7, 0x3F, 0x1D, 0xE7, 0xE3,
  0xFF, 0xCE, 0x3C, 0xF9, 0xC1, 0x04, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x0C, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1E, 0x78,
  0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFC, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE,
  0x3E, 0xFF, 0xE7, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0x0F, 0x78, 0x7B, 0xC3,
  0xFE, 0x1F, 0xF0, 0xF7, 0x9F, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8, 0x00, 0x03,
  0xC0, 0x7F, 0xC7, 0xFC, 0x7F, 0xE3, 0xE1, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x8C, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xE3, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0xF0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xEF, 0xFB, 0xFE, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E,
  0x09, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x9F, 0xFE,
  0x7F, 0xF9, 0xFF, 0xE7, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xF0, 0xF3,
  0xE3, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0x7E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0xFE, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x9F, 0xFE, 0xFE, 0xFC, 0xF0, 0x7F, 0xC3, 0xEF,
  0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x7C, 0x3D, 0xE0, 0xFF, 0x83,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFB, 0xC3, 0xCF, 0x0F, 0x3E, 0x3C, 0x78,
  0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1E, 0xF0, 0x7C, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xF7, 0x1D, 0xFE, 0xE3, 0xBF,
  0xDC, 0x77, 0xFB, 0xDE, 0xFF, 0x3B, 0x9F, 0xE7, 0x73, 0xFC, 0xFE, 0x7F,
  0x9F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF0, 0xFF,
  0x0E, 0x1E, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xF7, 0x9F, 0xEF, 0x3F, 0xCF, 0x7F, 0x9E,
  0xFF, 0x3D, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0x3E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x3E, 0x78, 0x1E,
  0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1E,
  0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x3E, 0x7C,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xE3, 0xEF, 0x1F,
  0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F,
  0xF8, 0x79, 0xE3, 0xCF, 0x1E, 0x7C, 0xF1, 0xE7, 0x8F, 0xBC, 0x3D, 0xE1,
  0xFF, 0x07, 0x80, 0x0E, 0x07, 0xF9, 0xFF, 0xBF, 0xEF, 0x8D, 0xE0, 0x3C,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x01, 0xF0, 0x7F, 0xDF, 0x7F, 0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xDF,
  0xFC, 0x7F, 0xE1, 0xFC, 0x00, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x73, 0xC1,
  0xE7, 0x83, 0xCF, 0x07, 0x8E, 0x0E, 0x1E, 0x1C, 0x3C, 0x78, 0x78, 0xF0,
  0x71, 0xC0, 0xF3, 0x81, 0xEF, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x78, 0x3F,
  0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF7, 0x83, 0xE1, 0xE7, 0x8F, 0xC3, 0xCF,
  0x1F, 0x87, 0x9E, 0x3F, 0x1E, 0x3C, 0x7E, 0x3C, 0x78, 0xEE, 0x78, 0x73,
  0xDC, 0xF0, 0xF7, 0xB9, 0xE1, 0xEE, 0x77, 0x83, 0xDC, 0xEF, 0x07, 0xB9,
  0xFE, 0x07, 0x71, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7D,
  0xE1, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE,
  0x0F, 0xBC, 0x3C, 0xF0, 0xF3, 0xE7, 0x87, 0x9E, 0x1F, 0xF8, 0x3C, 0xF8,
  0x3D, 0xE1, 0xE7, 0x87, 0x9F, 0x1E, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xF0, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x81, 0xCE, 0x0F, 0x3C, 0x38, 0x71, 0xE1, 0xE7, 0x03, 0xBC, 0x0F,
  0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0x07, 0x0F,
  0xF9, 0xFF, 0x9D, 0xF2, 0x1E, 0x03, 0xC0, 0x79, 0xFF, 0x7F, 0xFF, 0xBF,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xFB, 0xF7, 0x7C, 0xE0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0x0F, 0xFC, 0xEF, 0xEF,
  0xFE, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xFF, 0x9E, 0xFF, 0xEE, 0xFC, 0xE7, 0x80, 0x07, 0x07, 0xF3,
  0xFD, 0xFF, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x1E, 0x17, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x0C, 0xF3, 0xFF, 0x7F, 0x77, 0xFF, 0x78, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7,
  0x9F, 0x7F, 0xF3, 0xF7, 0x1E, 0x70, 0x0E, 0x01, 0xF8, 0x3F, 0xC7, 0xFE,
  0x70, 0xEF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x82, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x0F, 0x87, 0xF3, 0xF8,
  0xFE, 0x3C, 0x0F, 0x03, 0xC1, 0xFE, 0xFF, 0xBF, 0xE3, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0x0C, 0x03, 0xF7, 0x7F, 0x77, 0xFF, 0x78, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xF3,
  0xFF, 0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x61, 0xF7, 0xFE, 0x7F, 0xC3,
  0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0xC7, 0x7E,
  0xEF, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x78, 0xEF, 0xFF, 0x40,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3C, 0x78,
  0xF0, 0x80, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF7, 0xEF, 0xDF, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x1E, 0xF1, 0xE7, 0x9E, 0x3C, 0xF1, 0xEF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xF0, 0xFF, 0x87, 0x9E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x78, 0x7B,
  0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x87, 0x1D, 0xF9, 0xFB, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x1F, 0x3F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xFE,
  0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC,
  0x78, 0x7F, 0x8F, 0x0F, 0xF1, 0xE1, 0xE0, 0x03, 0x1D, 0xFB, 0xBF, 0xFF,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x07, 0x00, 0xFE, 0x0F, 0xF8,
  0xFF, 0xC7, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x3D, 0xE1, 0xE7, 0x8F, 0x3C, 0x79, 0xFF, 0x87, 0xFC, 0x1F, 0x80, 0x03,
  0x0E, 0xFC, 0xEF, 0xEF, 0xFE, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x9E, 0xFF, 0xEE, 0xFC, 0xF7,
  0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0C,
  0x03, 0xF7, 0x7F, 0x77, 0xFF, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xF3, 0xF7, 0x3E,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03,
  0xEF, 0xEF, 0xFF, 0xFD, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE1,
  0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0xF0, 0x7E, 0x3F, 0xFF, 0xFE, 0xFE, 0x00,
  0x1C, 0x0E, 0x07, 0x07, 0x87, 0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x9F, 0xC7, 0xE3, 0xF0, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0xFF, 0xDF, 0xBB, 0xE7, 0xF0, 0x7B, 0xC3,
  0xDE, 0x1C, 0xF1, 0xE7, 0x8F, 0x1C, 0x78, 0xF3, 0x87, 0xBC, 0x3D, 0xE0,
  0xEF, 0x07, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0xF0,
  0xF8, 0xF7, 0x0F, 0x8F, 0x79, 0xF8, 0xF7, 0x9F, 0x8E, 0x79, 0xF9, 0xE7,
  0x9D, 0x9E, 0x39, 0x9D, 0xE3, 0xD9, 0xDC, 0x3F, 0x9D, 0xC3, 0xF9, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x80, 0xF0, 0xF8, 0xF8, 0xF3, 0xC7, 0x8F, 0x78, 0x7B, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x7B, 0xC3, 0xDE,
  0x3C, 0xF1, 0xE3, 0xDE, 0x1F, 0xF0, 0x7B, 0xC3, 0xDE, 0x1C, 0xF1, 0xE3,
  0x8F, 0x1E, 0x78, 0xF3, 0x87, 0xBC, 0x1D, 0xE0, 0xEF, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0,
  0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0x87, 0xC3, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x9F, 0xCF, 0x87, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x3F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xF0, 0x78, 0xFC, 0x78,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF1, 0xF8, 0xF8, 0x70,
  0x00, 0x7C, 0x1F, 0xF3, 0xFF, 0xFC, 0xFF, 0x81, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 11, 7, 13, 1, -21 },
  { 22, 14, 21, 15, 1, -21 },
  { 59, 12, 25, 14, 1, -23 },
  { 97, 21, 22, 23, 1, -22 },
  { 155, 16, 22, 17, 1, -22 },
  { 199, 5, 7, 7, 1, -21 },
  { 204, 8, 26, 9, 1, -21 },
  { 230, 8, 26, 9, 0, -21 },
  { 256, 12, 12, 13, 1, -23 },
  { 274, 12, 15, 14, 1, -18 },
  { 297, 5, 7, 7, 1, -3 },
  { 302, 7, 4, 9, 1, -10 },
  { 306, 5, 5, 8, 1, -5 },
  { 310, 12, 22, 12, 0, -22 },
  { 343, 12, 22, 14, 1, -22 },
  { 376, 10, 21, 14, 1, -21 },
  { 403, 12, 22, 14, 1, -22 },
  { 436, 12, 22, 14, 1, -22 },
  { 469, 13, 21, 14, 0, -21 },
  { 504, 12, 21, 14, 1, -21 },
  { 536, 12, 22, 14, 1, -22 },
  { 569, 12, 21, 14, 1, -21 },
  { 601, 12, 22, 14, 1, -22 },
  { 634, 12, 22, 14, 1, -22 },
  { 667, 4, 17, 8, 2, -17 },
  { 676, 5, 21, 8, 1, -17 },
  { 690, 12, 14, 14, 1, -18 },
  { 711, 12, 9, 14, 1, -15 },
  { 725, 12, 14, 14, 1, -18 },
  { 746, 11, 22, 11, 0, -22 },
  { 777, 19, 24, 22, 1, -22 },
  { 834, 16, 21, 16, 0, -21 },
  { 876, 13, 21, 16, 2, -21 },
  { 911, 13, 22, 14, 1, -22 },
  { 947, 13, 21, 17, 2, -21 },
  { 982, 10, 21, 13, 2, -21 },
  { 1009, 10, 21, 13, 2, -21 },
  { 1036, 14, 22, 17, 1, -22 },
  { 1075, 14, 21, 18, 2, -21 },
  { 1112, 8, 21, 9, 1, -21 },
  { 1133, 8, 27, 8, -2, -21 },
  { 1160, 14, 21, 15, 2, -21 },
  { 1197, 10, 21, 12, 2, -21 },
  { 1224, 19, 21, 23, 2, -21 },
  { 1274, 15, 21, 19, 2, -21 },
  { 1314, 16, 22, 18, 1, -22 },
  { 1358, 12, 21, 15, 2, -21 },
  { 1390, 16, 27, 18, 1, -22 },
  { 1444, 13, 21, 15, 2, -21 },
  { 1479, 11, 22, 13, 1, -22 },
  { 1510, 12, 21, 13, 0, -21 },
  { 1542, 13, 21, 17, 2, -21 },
  { 1577, 15, 21, 15, 0, -21 },
  { 1617, 23, 21, 22, 0, -21 },
  { 1678, 14, 21, 14, 0, -21 },
  { 1715, 14, 21, 14, 0, -21 },
  { 1752, 12, 21, 12, 0, -21 },
  { 1784, 7, 26, 9, 2, -21 },
  { 1807, 12, 22, 12, 0, -22 },
  { 1840, 7, 26, 9, 1, -21 },
  { 1863, 14, 13, 16, 1, -21 },
  { 1886, 12, 2, 12, 0, 3 },
  { 1889, 7, 5, 9, 1, -23 },
  { 1894, 11, 17, 14, 1, -17 },
  { 1918, 12, 23, 15, 2, -23 },
  { 1953, 10, 17, 12, 1, -17 },
  { 1975, 12, 23, 15, 1, -23 },
  { 2010, 12, 17, 14, 1, -17 },
  { 2036, 10, 23, 9, 0, -23 },
  { 2065, 12, 24, 15, 1, -17 },
  { 2101, 11, 23, 15, 2, -23 },
  { 2133, 4, 23, 7, 2, -23 },
  { 2145, 7, 30, 7, -1, -23 },
  { 2172, 13, 23, 14, 2, -23 },
  { 2210, 4, 23, 7, 2, -23 },
  { 2222, 19, 17, 22, 2, -17 },
  { 2263, 11, 17, 15, 2, -17 },
  { 2287, 13, 17, 15, 1, -17 },
  { 2315, 12, 24, 15, 2, -17 },
  { 2351, 12, 24, 15, 1, -17 },
  { 2387, 8, 17, 10, 2, -17 },
  { 2404, 9, 17, 11, 1, -17 },
  { 2424, 9, 20, 10, 0, -20 },
  { 2447, 11, 16, 15, 2, -16 },
  { 2469, 13, 16, 13, 0, -16 },
  { 2495, 20, 16, 20, 0, -16 },
  { 2535, 13, 16, 13, 0, -16 },
  { 2561, 13, 23, 13, 0, -16 },
  { 2599, 9, 16, 11, 1, -16 },
  { 2617, 9, 26, 10, 0, -21 },
  { 2647, 3, 30, 13, 5, -23 },
  { 2659, 9, 26, 10, 1, -21 },
  { 2689, 12, 5, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Bold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD30PT7B_H_
