#ifndef _UBUNTUSANSMONO_REGULAR27PT7B_H_
#define _UBUNTUSANSMONO_REGULAR27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE9, 0x24, 0x00, 0xFF, 0x80, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xD1, 0xA2, 0x0E, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC6,
  0x7F, 0xFF, 0xFF, 0xE3, 0x0C, 0x18, 0x60, 0xC6, 0x06, 0x30, 0x61, 0x8F,
  0xFF, 0xFF, 0xFC, 0xC6, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60, 0x06,
  0x00, 0xC0, 0x18, 0x0F, 0xC7, 0xFC, 0xC0, 0xB8, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0F,
  0xCF, 0xFF, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x78, 0x1B, 0x30, 0xCC,
  0xC3, 0x23, 0x18, 0x8C, 0x62, 0x33, 0x0C, 0xD8, 0x33, 0x60, 0x7B, 0x00,
  0x0C, 0x00, 0x67, 0x03, 0x36, 0x0D, 0x98, 0x66, 0x21, 0x98, 0xCC, 0x62,
  0x61, 0x89, 0x86, 0x6C, 0x0F, 0x00, 0x1F, 0x01, 0xFC, 0x0C, 0x70, 0xE1,
  0x86, 0x0C, 0x38, 0xC0, 0xC6, 0x07, 0x60, 0x1E, 0x01, 0xE1, 0x9F, 0x8C,
  0xCE, 0x6E, 0x3A, 0x60, 0xF3, 0x03, 0x9C, 0x1C, 0xE1, 0xF3, 0xFD, 0x8F,
  0xC6, 0xFF, 0xF6, 0x92, 0x06, 0x1C, 0x70, 0xC3, 0x8E, 0x18, 0x30, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x03, 0x07, 0x07,
  0x07, 0x0E, 0x04, 0xC1, 0xC1, 0xC1, 0x83, 0x83, 0x83, 0x06, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x61, 0xC7, 0x0C, 0x38,
  0xE0, 0x80, 0x0E, 0x01, 0xC0, 0x18, 0x43, 0x1F, 0x5F, 0xFF, 0xC3, 0x80,
  0xD8, 0x3B, 0x8E, 0x38, 0xC6, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x03, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x38, 0xE7, 0xCF, 0x18, 0xEF, 0x38, 0xFF,
  0xFC, 0x73, 0xFE, 0xE0, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x00, 0x1F, 0x03, 0xF8, 0x71, 0xC6, 0x0E, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x47, 0xCE, 0x7C, 0xE7, 0xCE, 0x7C, 0x07, 0xC0, 0x6C,
  0x06, 0xC0, 0x6E, 0x0E, 0x60, 0xC3, 0xFC, 0x1F, 0x80, 0x06, 0x03, 0x81,
  0xE1, 0xF8, 0xEE, 0x23, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFC, 0x3F, 0x1F, 0xFB,
  0x07, 0x40, 0x60, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0x1F, 0xF1, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x1F,
  0x03, 0xF0, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xFF,
  0xFB, 0xFE, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x06, 0xC0, 0x66, 0x06,
  0x30, 0x31, 0x83, 0x0C, 0x30, 0x61, 0x83, 0x18, 0x18, 0xC0, 0xCF, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x3F, 0xE7,
  0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0x03, 0xF8,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xFF, 0xFB, 0xFE,
  0x00, 0x01, 0xC0, 0x7C, 0x1E, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xFF, 0x8F, 0xBC, 0xC0, 0xEC, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x6E,
  0x06, 0x60, 0xE7, 0x9C, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0E,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x1F,
  0x0F, 0xF9, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xF8, 0x1B, 0x06, 0x79, 0x83,
  0xF1, 0xCF, 0x30, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x6E, 0x78,
  0xFE, 0x00, 0x1F, 0x0F, 0xF3, 0x83, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x6E, 0x1C, 0xFF, 0x82, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x07, 0x0F, 0xC1, 0xE0, 0x00, 0x73, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0xFF, 0xB8, 0x38, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x3C,
  0xF1, 0x8E, 0xF3, 0x80, 0x00, 0x10, 0x07, 0x03, 0xE0, 0xF8, 0x3C, 0x0F,
  0x00, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x02, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x70, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x0C, 0x00, 0x7E, 0x7F, 0xA0, 0xE0, 0x30, 0x18, 0x0C,
  0x0C, 0x0E, 0x06, 0x06, 0x06, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x1E, 0x0E, 0x00, 0x07, 0xC0, 0xFF, 0x06, 0x0C, 0x60, 0x73, 0x01, 0xB0,
  0x0D, 0x83, 0xEC, 0x7F, 0x67, 0x1F, 0x30, 0xF9, 0x87, 0xCC, 0x3E, 0x61,
  0xB3, 0x0D, 0x98, 0x6C, 0x63, 0x73, 0xFB, 0x87, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x36,
  0x00, 0x6E, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x38, 0x18, 0x30, 0x30, 0x60,
  0x60, 0xC1, 0x80, 0xC3, 0xFF, 0x87, 0xFF, 0x18, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0xC0, 0x1B, 0x80, 0x38, 0xFE, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0F,
  0x81, 0xF0, 0x36, 0x0E, 0xFF, 0x9F, 0xF3, 0x07, 0x60, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xFF, 0xFB, 0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0x38,
  0x27, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x13, 0xFF, 0x0F,
  0xE0, 0xFC, 0x0F, 0xF0, 0xC3, 0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x7C,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0x6C,
  0x0E, 0xC1, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xDF, 0xFB, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0x9F, 0xF3, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xBF, 0xEC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0xE1, 0xFF,
  0x38, 0x27, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x33, 0xEF,
  0x0F, 0xF0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xFF, 0xFF, 0xC7,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x7F, 0xFF, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x81, 0xDE, 0xF1, 0xFC, 0x00, 0xC0, 0x36,
  0x03, 0x30, 0x39, 0x83, 0x8C, 0x38, 0x63, 0x83, 0x38, 0x1B, 0x80, 0xD8,
  0x07, 0xC0, 0x37, 0x01, 0x9C, 0x0C, 0x30, 0x61, 0xC3, 0x07, 0x18, 0x1C,
  0xC0, 0x76, 0x01, 0xB0, 0x0E, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x70, 0x73, 0x83, 0x9C,
  0x1C, 0xF0, 0xE7, 0x8D, 0x3C, 0x69, 0xB2, 0x4D, 0xB2, 0x6D, 0x9A, 0x28,
  0xF1, 0xC7, 0x86, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x06, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xB0, 0xF6,
  0x1E, 0x63, 0xCC, 0x78, 0xCF, 0x19, 0xE1, 0xBC, 0x37, 0x83, 0xF0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0x80, 0x0F, 0x81, 0xFF, 0x0C, 0x1C, 0xC0,
  0x66, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xEC, 0x06, 0x70, 0x71, 0xEF, 0x07,
  0xF0, 0x7F, 0x0F, 0xFC, 0xE0, 0xEE, 0x06, 0xE0, 0x6E, 0x07, 0xE0, 0x7E,
  0x06, 0xE0, 0x6E, 0x0E, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x0C, 0x1C, 0xC0,
  0x66, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xEC, 0x06, 0x70, 0x71, 0xEF, 0x07,
  0xF0, 0x0E, 0x00, 0x30, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xFE, 0x0F, 0xF8,
  0xC1, 0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCC, 0x38,
  0xFF, 0x0F, 0x70, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0xEC, 0x06,
  0xC0, 0x70, 0x1F, 0xC7, 0xFD, 0x81, 0x70, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x6C, 0x06,
  0xE0, 0xE7, 0xBC, 0x3F, 0x80, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00,
  0x67, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x1C, 0x0C, 0x18, 0x30, 0x30, 0x60,
  0x60, 0xC0, 0x61, 0x80, 0xC6, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x60, 0x06,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC7, 0x1A, 0x28, 0xD1, 0x64, 0xDB,
  0x26, 0xD9, 0x34, 0x69, 0xE3, 0xCF, 0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C,
  0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0x60, 0xC1, 0x8E, 0x0C, 0x60, 0x36, 0x01,
  0xB0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1B, 0x01, 0x8C, 0x0C, 0x70, 0xC1,
  0x86, 0x0E, 0x60, 0x33, 0x01, 0xF0, 0x06, 0xE0, 0x0E, 0xC0, 0x19, 0xC0,
  0x71, 0x80, 0xC3, 0x81, 0x83, 0x06, 0x07, 0x0C, 0x06, 0x30, 0x0E, 0x60,
  0x0D, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xE0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0xFF, 0xFC, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFC, 0x07, 0x00, 0x38, 0x03, 0x60,
  0x1B, 0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x8E, 0x0E, 0x60, 0x36, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x47, 0x18, 0x61, 0x80, 0x7F, 0x87, 0xF8, 0x03,
  0x80, 0x30, 0x06, 0x00, 0xCF, 0xFB, 0xCF, 0xE0, 0x78, 0x0F, 0x01, 0xF0,
  0x37, 0xFE, 0x7F, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0D, 0xF8, 0xFF, 0xCE, 0x0E, 0xC0, 0x6C, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0xEF, 0xFC, 0xFF, 0x80,
  0x1F, 0xE3, 0xFE, 0x70, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x31, 0xFF, 0x3F, 0xF7, 0x07,
  0x60, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x03,
  0x30, 0x33, 0xFF, 0x0F, 0xF0, 0x0F, 0xC1, 0xFF, 0x0C, 0x1C, 0xC0, 0x66,
  0x03, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0xFE, 0x07, 0xF8, 0x03, 0xE8, 0x7F, 0x83, 0x04, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x1F, 0xFC, 0xFF, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x1F, 0xF3, 0xFF, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x33, 0xDF, 0x1F, 0xF0, 0x63,
  0x00, 0x30, 0x07, 0x00, 0xE7, 0xFC, 0x3F, 0x80, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFC, 0xFF, 0xD8, 0x1B, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x06, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0x83, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0x06, 0xFE, 0xFE, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x07, 0xC0, 0xCC,
  0x18, 0xC7, 0x0C, 0xE0, 0xDC, 0x0F, 0x80, 0xDC, 0x0C, 0xE0, 0xC7, 0x8C,
  0x1C, 0xC0, 0xCC, 0x06, 0xC0, 0x70, 0xFC, 0x1F, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0xF0, 0x7E, 0xFD,
  0xF7, 0x7F, 0xB1, 0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63,
  0xC3, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0xFF, 0x9F,
  0xFB, 0x03, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x1F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0,
  0x66, 0x03, 0x70, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x3B, 0x01, 0x98, 0x0C,
  0xE0, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x6E, 0x0E, 0xFF,
  0xCF, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xF3,
  0xFF, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36,
  0x03, 0x60, 0x37, 0x07, 0x3F, 0xF1, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x7F, 0xFF, 0x3E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3F, 0xCF, 0xFB,
  0x80, 0x60, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3F, 0xFD, 0xFF, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0xFF,
  0xFF, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x0F, 0xE0, 0xFC, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xB0, 0x37, 0xFE,
  0x7F, 0xC0, 0xE0, 0x1F, 0x01, 0xD8, 0x0C, 0xC0, 0x67, 0x07, 0x18, 0x30,
  0xC1, 0x83, 0x18, 0x18, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0x70, 0x03,
  0x80, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x84, 0x3C, 0x71, 0xE3, 0x8D, 0x94,
  0x6D, 0xB6, 0x6D, 0xB3, 0x47, 0x9E, 0x3C, 0xF1, 0xE3, 0x07, 0x18, 0x30,
  0xE0, 0x3B, 0x83, 0x8E, 0x18, 0x31, 0x80, 0xD8, 0x07, 0xC0, 0x1C, 0x00,
  0xF0, 0x0D, 0xC0, 0xC6, 0x0E, 0x18, 0x60, 0xE6, 0x03, 0x60, 0x1C, 0x60,
  0x3B, 0x01, 0x9C, 0x0C, 0x60, 0x63, 0x07, 0x1C, 0x30, 0x61, 0x83, 0x0C,
  0x0C, 0xC0, 0x66, 0x03, 0xB0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x07, 0xE0, 0x3E, 0x00, 0x7F, 0xEF, 0xFC, 0x07, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0xF0, 0x3C, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0F, 0xC1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x1E,
  0x07, 0xC0, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0xFE, 0x1F, 0x00, 0x3C, 0x13, 0xF0, 0xD0, 0xFD, 0x83,
  0xC0,
};

const GFXglyph UbuntuSansMono_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 19, 15, 6, -19 },
  { 9, 7, 8, 15, 4, -21 },
  { 16, 13, 19, 15, 1, -19 },
  { 47, 11, 24, 15, 2, -21 },
  { 80, 14, 19, 15, 1, -19 },
  { 114, 13, 19, 15, 1, -19 },
  { 145, 3, 8, 15, 6, -21 },
  { 148, 7, 26, 15, 4, -21 },
  { 171, 7, 26, 15, 4, -21 },
  { 194, 11, 11, 15, 2, -19 },
  { 210, 13, 14, 15, 1, -15 },
  { 233, 6, 8, 15, 5, -4 },
  { 239, 7, 2, 15, 4, -9 },
  { 241, 5, 4, 15, 5, -4 },
  { 244, 11, 26, 15, 2, -21 },
  { 280, 12, 19, 15, 2, -19 },
  { 309, 10, 19, 15, 3, -19 },
  { 333, 11, 19, 15, 2, -19 },
  { 360, 11, 19, 15, 2, -19 },
  { 387, 13, 19, 15, 1, -19 },
  { 418, 11, 19, 15, 2, -19 },
  { 445, 12, 19, 15, 2, -19 },
  { 474, 12, 19, 15, 2, -19 },
  { 503, 11, 19, 15, 2, -19 },
  { 530, 11, 19, 15, 2, -19 },
  { 557, 5, 14, 15, 5, -14 },
  { 566, 6, 18, 15, 4, -14 },
  { 580, 12, 12, 15, 2, -14 },
  { 598, 13, 8, 15, 1, -12 },
  { 611, 12, 12, 15, 2, -14 },
  { 629, 9, 19, 15, 3, -19 },
  { 651, 13, 23, 15, 1, -19 },
  { 689, 15, 19, 15, 0, -19 },
  { 725, 11, 19, 15, 2, -19 },
  { 752, 12, 19, 15, 2, -19 },
  { 781, 12, 19, 15, 2, -19 },
  { 810, 11, 19, 15, 3, -19 },
  { 837, 10, 19, 15, 3, -19 },
  { 861, 12, 19, 15, 2, -19 },
  { 890, 13, 19, 15, 1, -19 },
  { 921, 9, 19, 15, 3, -19 },
  { 943, 11, 19, 15, 2, -19 },
  { 970, 13, 19, 15, 2, -19 },
  { 1001, 11, 19, 15, 3, -19 },
  { 1028, 13, 19, 15, 1, -19 },
  { 1059, 11, 19, 15, 2, -19 },
  { 1086, 13, 19, 15, 1, -19 },
  { 1117, 12, 19, 15, 2, -19 },
  { 1146, 13, 24, 15, 1, -19 },
  { 1185, 12, 19, 15, 2, -19 },
  { 1214, 11, 19, 15, 2, -19 },
  { 1241, 13, 19, 15, 1, -19 },
  { 1272, 12, 19, 15, 2, -19 },
  { 1301, 15, 19, 15, 0, -19 },
  { 1337, 13, 19, 15, 1, -19 },
  { 1368, 13, 19, 15, 1, -19 },
  { 1399, 15, 19, 15, 0, -19 },
  { 1435, 12, 19, 15, 2, -19 },
  { 1464, 6, 26, 15, 5, -21 },
  { 1484, 11, 26, 15, 2, -21 },
  { 1520, 7, 26, 15, 4, -21 },
  { 1543, 13, 10, 15, 1, -19 },
  { 1560, 15, 2, 15, 0, 3 },
  { 1564, 5, 5, 15, 5, -21 },
  { 1568, 11, 14, 15, 2, -14 },
  { 1588, 12, 21, 15, 2, -21 },
  { 1620, 12, 14, 15, 2, -14 },
  { 1641, 12, 21, 15, 1, -21 },
  { 1673, 13, 14, 15, 1, -14 },
  { 1696, 13, 21, 15, 2, -21 },
  { 1731, 12, 19, 15, 1, -14 },
  { 1760, 11, 21, 15, 2, -21 },
  { 1789, 11, 20, 15, 2, -20 },
  { 1817, 9, 25, 15, 2, -20 },
  { 1846, 12, 21, 15, 2, -21 },
  { 1878, 11, 21, 15, 2, -21 },
  { 1907, 13, 14, 15, 1, -14 },
  { 1930, 11, 14, 15, 2, -14 },
  { 1950, 13, 14, 15, 1, -14 },
  { 1973, 12, 19, 15, 2, -14 },
  { 2002, 12, 19, 15, 1, -14 },
  { 2031, 10, 14, 15, 3, -14 },
  { 2049, 11, 14, 15, 2, -14 },
  { 2069, 11, 18, 15, 2, -18 },
  { 2094, 11, 14, 15, 2, -14 },
  { 2114, 13, 14, 15, 1, -14 },
  { 2137, 13, 14, 15, 1, -14 },
  { 2160, 13, 14, 15, 1, -14 },
  { 2183, 13, 19, 15, 1, -14 },
  { 2214, 11, 14, 15, 2, -14 },
  { 2234, 10, 26, 15, 3, -21 },
  { 2267, 2, 26, 15, 7, -21 },
  { 2274, 11, 26, 15, 2, -21 },
  { 2310, 13, 4, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_Regular27pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular27pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUSANSMONO_REGULAR27PT7B_H_
