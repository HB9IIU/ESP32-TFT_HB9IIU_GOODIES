#ifndef _UBUNTUSANSMONO_REGULAR48PT7B_H_
#define _UBUNTUSANSMONO_REGULAR48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0xDF, 0xFF, 0xFE, 0x7C, 0x20, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x30,
  0x00, 0xE0, 0x38, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x78, 0x03,
  0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x0F, 0x01,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x3C,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x80,
  0x38, 0x0F, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0xF0, 0x07,
  0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xEF, 0xC1, 0xF0,
  0x02, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC8, 0x00, 0x3E, 0x7C,
  0x07, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0x9F, 0xF0, 0x03, 0x8E,
  0x1C, 0x03, 0x87, 0x0E, 0x03, 0xC7, 0x07, 0x01, 0xC3, 0x81, 0xC1, 0xE1,
  0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0xF0, 0x38, 0x1C, 0x70,
  0x1C, 0x1C, 0x78, 0x07, 0x0E, 0x38, 0x03, 0x8F, 0x38, 0x00, 0xFF, 0x3C,
  0x00, 0x7F, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x0F, 0x3F, 0xC0, 0x07, 0x1F, 0xE0, 0x07, 0x9C, 0x38, 0x03,
  0x8E, 0x1C, 0x03, 0x8F, 0x07, 0x03, 0xC7, 0x03, 0x81, 0xC3, 0x81, 0xC1,
  0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0xF0, 0x1C, 0x38,
  0x70, 0x0E, 0x1C, 0x78, 0x07, 0x8E, 0x38, 0x01, 0xFE, 0x38, 0x00, 0x7E,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0xF8, 0x7C, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x70, 0x1C, 0x00,
  0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x30, 0x1F, 0xC0, 0x70, 0x7F, 0xC0, 0xE1, 0xE7,
  0xC1, 0xC7, 0x87, 0xC7, 0x0F, 0x07, 0xCE, 0x3E, 0x07, 0xDC, 0x78, 0x07,
  0xB8, 0xF0, 0x07, 0xF1, 0xE0, 0x0F, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x0F,
  0x0F, 0x80, 0x3F, 0x0F, 0x00, 0xFF, 0x1F, 0x87, 0xFE, 0x1F, 0xFF, 0x9E,
  0x1F, 0xFE, 0x3E, 0x1F, 0xF0, 0x3C, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x77,
  0x70, 0x00, 0x08, 0x00, 0x60, 0x03, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0x00,
  0x40, 0x03, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x30, 0x38, 0x19, 0xF1, 0xC7, 0xCF,
  0xEE, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x01, 0xF0,
  0x00, 0x1D, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x3C, 0x01, 0xF1, 0xF0, 0x1F,
  0x07, 0xC0, 0x70, 0x3C, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x81,
  0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x1E, 0x03, 0xC0, 0xF0,
  0x7E, 0x7F, 0x87, 0xE0, 0xF0, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xE0, 0x3C,
  0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0xC0,
  0x07, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x38, 0x3F,
  0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF1, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x3E,
  0x1F, 0xE0, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01,
  0xE3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0x9E, 0x03,
  0xE3, 0xC0, 0x70, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFE, 0x7F,
  0x87, 0x80, 0x7C, 0x30, 0x01, 0xF0, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7C, 0x7F, 0x83, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF9, 0x80, 0x1F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80,
  0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x00, 0x1E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE6, 0x00, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x39, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x03,
  0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE3, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x3E, 0x0F, 0x83,
  0xC0, 0x1E, 0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00,
  0xF3, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0xC0, 0x1E, 0x1F,
  0x00, 0xF0, 0xFC, 0x0F, 0x03, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x07, 0xCF, 0xF0, 0x7C, 0x0F, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x7B, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x79, 0xF0, 0x07, 0xC7, 0xFB,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xC0, 0x3E, 0x3C, 0x00,
  0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x7C, 0x00, 0xF9, 0xFC, 0x7F, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFE, 0xE0, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x20, 0x0F, 0x87, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0x78,
  0x1E, 0x1F, 0x3F, 0x8F, 0xC3, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x8E,
  0x07, 0xE4, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF8, 0xFC, 0x0F, 0x00, 0xF0, 0x78, 0x01,
  0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xE3, 0xFC, 0x3E, 0x0F, 0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x1E, 0x03,
  0xFC, 0x78, 0x0F, 0xF1, 0xE0, 0x3F, 0xC7, 0x80, 0xFF, 0x1E, 0x03, 0xFC,
  0x78, 0x0F, 0xF0, 0xE0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFE, 0x1E,
  0x0F, 0xF8, 0x7E, 0x7D, 0xE0, 0xFF, 0xF7, 0xC1, 0xFF, 0xDF, 0x00, 0x60,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x38,
  0x07, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00,
  0x70, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1C, 0x00, 0x0F, 0x07, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F,
  0x00, 0xFC, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01,
  0xE7, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x01, 0xE3, 0xC0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3C, 0x03, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x1F, 0x9F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xFE, 0xFE, 0x0F, 0x80, 0x30, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x20, 0xFC, 0x03, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xF0, 0x1F, 0x83, 0xC0, 0x1F,
  0x0F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x03, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xE1, 0xF0, 0xF8,
  0x03, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDF, 0x00, 0x0E, 0x78,
  0x00, 0x73, 0xE0, 0x03, 0x8F, 0x80, 0x1C, 0x3F, 0x00, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF4, 0x00, 0x3C, 0xE0,
  0x0F, 0xBF, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0xC3, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03,
  0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xDF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xDF, 0x80,
  0x0F, 0x3F, 0x00, 0x3C, 0x7E, 0x00, 0xF0, 0xFC, 0x03, 0xC1, 0xF8, 0x0F,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00,
  0x3E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x86, 0xE0, 0x3F, 0x0D, 0xC0,
  0x7E, 0x1B, 0xC1, 0xDE, 0x73, 0x83, 0x9C, 0xE7, 0x07, 0x39, 0xCF, 0x1C,
  0x73, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xCE, 0x1C, 0xC3, 0x9C, 0x3B, 0x87,
  0x38, 0x77, 0x0E, 0x70, 0x6E, 0x1C, 0xE0, 0xF8, 0x39, 0xC1, 0xF0, 0x73,
  0x81, 0xE0, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFE, 0xF0,
  0x0F, 0xF7, 0x80, 0x7F, 0x9E, 0x03, 0xFC, 0xF0, 0x1F, 0xE3, 0xC0, 0xFF,
  0x1E, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x0F, 0x0F, 0xF0, 0x78,
  0x7F, 0x81, 0xC3, 0xFC, 0x0F, 0x1F, 0xE0, 0x38, 0xFF, 0x01, 0xE7, 0xF8,
  0x07, 0x3F, 0xC0, 0x3D, 0xFE, 0x01, 0xEF, 0xF0, 0x07, 0x7F, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x3F, 0x01, 0xE0, 0x1F, 0x07, 0x80, 0x1F,
  0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x7C,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xF0, 0x07,
  0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x3F,
  0x01, 0xE0, 0x1F, 0x07, 0x80, 0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3, 0xC0, 0x07,
  0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x60, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0,
  0x07, 0xC7, 0x87, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x80,
  0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x01,
  0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0x07, 0xC3, 0xE0, 0x06,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x20, 0x00, 0x79, 0xC0, 0x0F, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x1F, 0x01,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0x83, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xCE, 0x0F, 0x03,
  0x9C, 0x1F, 0x07, 0x38, 0x3E, 0x0E, 0x70, 0xEC, 0x1C, 0xE1, 0xDC, 0x39,
  0xC3, 0xB8, 0x73, 0x8E, 0x78, 0xE7, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x9C,
  0xE1, 0xE7, 0x39, 0xC1, 0xCC, 0x73, 0x83, 0xB8, 0xEE, 0x07, 0xF0, 0xDC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x70, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x3E,
  0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x0F, 0x00,
  0x0F, 0x1E, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xBC, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x03,
  0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3D, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x3C, 0x01,
  0xE0, 0xE0, 0x0E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x00, 0xF0, 0x78, 0x03,
  0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x7B, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0x60,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x20, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x06, 0x1F, 0xFF, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x3F, 0x7C, 0x00, 0xF7, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0xC0, 0x0F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x03, 0x40, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x7F, 0xC0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC1, 0xF8, 0xF8, 0x03, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xDE,
  0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0x80, 0x63, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x0C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1F,
  0xF7, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x7F, 0x3E, 0x00, 0xF9,
  0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xF0, 0x01,
  0xE7, 0x80, 0x0F, 0x3E, 0x00, 0x78, 0xFC, 0x03, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xE0, 0x7C, 0x1E, 0x00, 0xF8, 0xF0, 0x01, 0xE7,
  0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x40, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x0E, 0x03, 0xC0, 0x04, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x01, 0xF3,
  0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03,
  0xDF, 0x00, 0x1E, 0x7C, 0x01, 0xF1, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xEF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x10, 0x00, 0xF8, 0xF8, 0x3F, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xC0, 0x7E, 0xF0, 0x07, 0xDE,
  0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x10, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x40, 0x1F, 0x78,
  0x7E, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0x8F, 0x00, 0x3C,
  0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0xF8, 0x0F, 0x07, 0xC0, 0x3C,
  0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xC0, 0x03, 0xDF, 0x80, 0x0F, 0x3F, 0x00, 0x3C, 0x7E, 0x00,
  0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF0,
  0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00,
  0x7C, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x7F, 0xC7, 0xF1, 0xFF, 0xDF, 0xF3, 0xFF,
  0xFF, 0xF7, 0x83, 0xE1, 0xEF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E,
  0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0,
  0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x7F, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x78, 0x07, 0xEF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x1F, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0x38, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x03, 0xF0, 0x7E, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE1, 0xE0, 0x3F, 0x8F, 0x00, 0x7C, 0x78, 0x01, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xCF, 0x00, 0x3E, 0x7E, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF7,
  0xFC, 0x07, 0x86, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x00,
  0xF3, 0xF0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0,
  0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0xC0, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0x78, 0x00, 0x83, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3E, 0x00, 0x4F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x02, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x60, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xFC, 0x03, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x0A, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x07,
  0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x39, 0xE0, 0x70, 0x3C, 0xF0, 0x38, 0x1E, 0x78, 0x3E, 0x0F, 0x3C,
  0x1F, 0x07, 0x9E, 0x0F, 0x83, 0x87, 0x0E, 0xE1, 0xC3, 0x87, 0x70, 0xE1,
  0xE3, 0xB8, 0xF0, 0xF3, 0x8E, 0x78, 0x79, 0xC7, 0x3C, 0x1C, 0xE3, 0x9C,
  0x0E, 0xE0, 0xEE, 0x07, 0x70, 0x77, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0E, 0x00,
  0x38, 0x00, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0xF0,
  0x07, 0x80, 0xF0, 0x1E, 0x01, 0xF0, 0x78, 0x01, 0xF1, 0xF0, 0x01, 0xE3,
  0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF3, 0xC0,
  0x07, 0xC7, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x81,
  0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xE0,
  0x01, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x10, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xFE, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xC0, 0x1C, 0xFF, 0xC0, 0x73, 0xCF, 0xE0, 0xE7,
  0x07, 0xFF, 0x9C, 0x03, 0xFF, 0x38, 0x01, 0xFC, 0x00, 0x00, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 34, 27, 10, -33 },
  { 31, 11, 12, 27, 8, -36 },
  { 48, 23, 33, 27, 2, -33 },
  { 143, 21, 42, 27, 3, -37 },
  { 254, 25, 35, 27, 1, -34 },
  { 364, 23, 34, 27, 2, -34 },
  { 462, 4, 13, 27, 11, -36 },
  { 469, 14, 47, 27, 6, -38 },
  { 552, 13, 47, 27, 7, -38 },
  { 629, 21, 19, 27, 3, -33 },
  { 679, 21, 24, 27, 3, -26 },
  { 742, 11, 15, 27, 8, -7 },
  { 763, 11, 3, 27, 8, -15 },
  { 768, 7, 8, 27, 10, -7 },
  { 775, 19, 47, 27, 4, -38 },
  { 887, 21, 35, 27, 3, -34 },
  { 979, 19, 33, 27, 4, -33 },
  { 1058, 21, 34, 27, 3, -34 },
  { 1148, 21, 35, 27, 3, -34 },
  { 1240, 23, 33, 27, 2, -33 },
  { 1335, 20, 34, 27, 4, -33 },
  { 1420, 21, 34, 27, 3, -33 },
  { 1510, 21, 33, 27, 4, -33 },
  { 1597, 21, 35, 27, 3, -34 },
  { 1689, 21, 34, 27, 3, -34 },
  { 1779, 7, 26, 27, 10, -25 },
  { 1802, 10, 33, 27, 7, -25 },
  { 1844, 22, 21, 27, 3, -24 },
  { 1902, 21, 14, 27, 3, -21 },
  { 1939, 22, 21, 27, 3, -24 },
  { 1997, 17, 35, 27, 5, -34 },
  { 2072, 22, 41, 27, 3, -34 },
  { 2185, 26, 33, 27, 0, -33 },
  { 2293, 21, 34, 27, 3, -34 },
  { 2383, 22, 35, 27, 3, -34 },
  { 2480, 22, 34, 27, 3, -34 },
  { 2574, 20, 33, 27, 5, -33 },
  { 2657, 19, 33, 27, 5, -33 },
  { 2736, 21, 35, 27, 3, -34 },
  { 2828, 22, 33, 27, 2, -33 },
  { 2919, 17, 33, 27, 5, -33 },
  { 2990, 19, 34, 27, 3, -33 },
  { 3071, 22, 33, 27, 4, -33 },
  { 3162, 20, 33, 27, 5, -33 },
  { 3245, 23, 33, 27, 2, -33 },
  { 3340, 21, 33, 27, 3, -33 },
  { 3427, 23, 35, 27, 2, -34 },
  { 3528, 20, 34, 27, 4, -34 },
  { 3613, 23, 43, 27, 2, -34 },
  { 3737, 21, 34, 27, 3, -34 },
  { 3827, 21, 35, 27, 3, -34 },
  { 3919, 23, 33, 27, 2, -33 },
  { 4014, 21, 34, 27, 3, -33 },
  { 4104, 25, 33, 27, 1, -33 },
  { 4208, 23, 33, 27, 2, -33 },
  { 4303, 23, 33, 27, 2, -33 },
  { 4398, 25, 33, 27, 1, -33 },
  { 4502, 22, 33, 27, 3, -33 },
  { 4593, 12, 47, 27, 8, -38 },
  { 4664, 19, 47, 27, 4, -38 },
  { 4776, 13, 47, 27, 6, -38 },
  { 4853, 21, 17, 27, 3, -33 },
  { 4898, 26, 3, 27, 0, 6 },
  { 4908, 8, 9, 27, 9, -37 },
  { 4917, 20, 26, 27, 3, -25 },
  { 4982, 21, 38, 27, 4, -37 },
  { 5082, 21, 26, 27, 3, -25 },
  { 5151, 21, 38, 27, 2, -37 },
  { 5251, 22, 26, 27, 2, -25 },
  { 5323, 22, 37, 27, 4, -37 },
  { 5425, 21, 34, 27, 2, -25 },
  { 5515, 19, 37, 27, 4, -37 },
  { 5603, 21, 37, 27, 3, -36 },
  { 5701, 16, 45, 27, 4, -36 },
  { 5791, 22, 37, 27, 4, -37 },
  { 5893, 21, 38, 27, 3, -37 },
  { 5993, 23, 25, 27, 2, -25 },
  { 6065, 19, 25, 27, 4, -25 },
  { 6125, 23, 26, 27, 2, -25 },
  { 6200, 21, 34, 27, 4, -25 },
  { 6290, 21, 34, 27, 2, -25 },
  { 6380, 17, 25, 27, 6, -25 },
  { 6434, 19, 26, 27, 4, -25 },
  { 6496, 20, 34, 27, 4, -33 },
  { 6581, 19, 26, 27, 4, -25 },
  { 6643, 23, 25, 27, 2, -25 },
  { 6715, 25, 25, 27, 1, -25 },
  { 6794, 23, 25, 27, 2, -25 },
  { 6866, 23, 34, 27, 2, -25 },
  { 6964, 19, 25, 27, 4, -25 },
  { 7024, 19, 47, 27, 4, -38 },
  { 7136, 3, 47, 27, 12, -38 },
  { 7154, 18, 47, 27, 4, -38 },
  { 7260, 23, 8, 27, 2, -18 },
};

const GFXfont UbuntuSansMono_Regular48pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular48pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular48pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUSANSMONO_REGULAR48PT7B_H_
