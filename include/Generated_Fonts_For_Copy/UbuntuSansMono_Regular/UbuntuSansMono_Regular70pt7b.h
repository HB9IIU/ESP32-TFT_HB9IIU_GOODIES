#ifndef _UBUNTUSANSMONO_REGULAR70PT7B_H_
#define _UBUNTUSANSMONO_REGULAR70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0,
  0x38, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1E, 0x00, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7B, 0x80, 0x3D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F,
  0xC0, 0xFF, 0x00, 0x03, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF9, 0x00, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x00, 0xF8, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x3F,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0xF0,
  0x07, 0xC0, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x0F, 0x03, 0xE0,
  0x0F, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x0F, 0x80, 0xF0,
  0xF8, 0x00, 0xF8, 0x1F, 0x1F, 0x00, 0x07, 0x81, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x3E, 0x00, 0x03, 0xFF, 0xC3, 0xE0, 0x00, 0x3F, 0xFC, 0x7C, 0x00,
  0x00, 0xFF, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00,
  0x07, 0xC3, 0xFF, 0x00, 0x00, 0x7C, 0x7F, 0xF8, 0x00, 0x0F, 0x87, 0xCF,
  0xC0, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x03, 0xE0, 0x03, 0xE1,
  0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x01, 0xE0, 0x07, 0xC1, 0xE0, 0x1E, 0x00,
  0x7C, 0x1E, 0x01, 0xE0, 0x0F, 0x81, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x3E, 0x01,
  0xE0, 0x1E, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x1E, 0x0F,
  0x80, 0x1F, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC3, 0xE0, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x07, 0xFF, 0x87, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xF8,
  0x03, 0xC0, 0x3F, 0x7F, 0x00, 0xF0, 0x1F, 0x8F, 0xE0, 0x3C, 0x0F, 0xC3,
  0xF8, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0xC1, 0xF8, 0x0F, 0xE1, 0xF0, 0x7E,
  0x01, 0xFC, 0x78, 0x3F, 0x00, 0x3F, 0x9E, 0x0F, 0xC0, 0x07, 0xFF, 0x83,
  0xF0, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x07, 0xFC,
  0x0F, 0xC0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0xC1, 0xFC, 0x00,
  0x7F, 0xF0, 0x7F, 0x80, 0x7F, 0xFE, 0x0F, 0xF8, 0x7F, 0xDF, 0x81, 0xFF,
  0xFF, 0xE3, 0xF0, 0x3F, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x80,
  0x7F, 0xF0, 0x07, 0xF0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDC, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x60, 0x0F, 0x80, 0x33, 0xE0, 0x7C, 0x0F, 0x9F, 0xC1,
  0xE1, 0xFD, 0xFF, 0x8F, 0x3F, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xF0, 0x07, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x87, 0xF9, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xCF,
  0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x07, 0xFF,
  0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x1F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xF8, 0x3F, 0xE0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xE0,
  0x7F, 0x83, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x80, 0x70, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFD, 0xF8, 0x03, 0xFE, 0x3F, 0x00, 0x7F, 0x87, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0x80, 0x01, 0xFC, 0x30,
  0x00, 0x07, 0xE1, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0x03, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE6,
  0x00, 0x01, 0xFE, 0x3E, 0x00, 0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0xC0, 0x00, 0x3F, 0x87, 0xC0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF0, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0,
  0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0x8F, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x03, 0xF0, 0x01, 0xFF, 0x07, 0xC0,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x0F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x9F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x87,
  0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0x1F, 0xC0,
  0xF0, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0xE3, 0xFF, 0x87, 0xFE, 0x0F,
  0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7C, 0x07, 0xFC, 0x60, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0xDF, 0x80, 0x1F,
  0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xF8, 0x1F, 0xC0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0xFF, 0x07, 0xE0, 0x07, 0xFF, 0x83,
  0xF0, 0x03, 0xFF, 0xC1, 0xF8, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xF0,
  0x7E, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0x3F, 0xFC, 0x1F, 0x80, 0x1F, 0xFE,
  0x0F, 0xC0, 0x0F, 0xFF, 0x07, 0xE0, 0x07, 0xFF, 0x83, 0xF0, 0x03, 0xFF,
  0xC1, 0xF8, 0x01, 0xFF, 0xE0, 0x7C, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x7E,
  0xFC, 0x1F, 0x80, 0x3F, 0x7E, 0x07, 0xE0, 0x1F, 0xBF, 0x03, 0xFC, 0x0F,
  0xDF, 0xC0, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF,
  0xF9, 0xFC, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0x04, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE1, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x0F, 0xFC, 0x3F,
  0x00, 0x07, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x7F, 0x8F, 0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC3, 0xFE, 0x03, 0xFE,
  0x00, 0x3C, 0x07, 0xF8, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x07, 0xFC, 0x00, 0x0E, 0x03, 0xFF,
  0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0x0C,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F,
  0x03, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x30, 0x00, 0x0F, 0xE3, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x7C,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7F, 0x0F,
  0x80, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x80,
  0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x3F, 0x80,
  0x07, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x1F, 0xC0, 0x01, 0xF0, 0x1F, 0xC0,
  0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x3E, 0x1F, 0xC0,
  0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x07, 0xDF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3E, 0x7F, 0x80, 0x00, 0x1F, 0x1F,
  0xE0, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x03, 0xE0,
  0x3F, 0x80, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xE0, 0x0F,
  0x80, 0x03, 0xF8, 0x07, 0xC0, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0xFE, 0x1F, 0x00, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0xFE, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1D, 0xE0, 0x03, 0xDE, 0x1E,
  0xF8, 0x01, 0xEF, 0x0F, 0x7C, 0x01, 0xF7, 0x87, 0x9E, 0x00, 0xF3, 0xC3,
  0xCF, 0x80, 0x79, 0xE1, 0xE7, 0xC0, 0x7C, 0xF0, 0xF1, 0xE0, 0x3C, 0x7C,
  0x78, 0xF8, 0x1E, 0x3E, 0x3C, 0x7C, 0x1F, 0x1F, 0x1E, 0x1E, 0x0F, 0x0F,
  0x8F, 0x0F, 0x87, 0x87, 0xCF, 0x87, 0xC3, 0xC3, 0xE7, 0xC1, 0xE3, 0xE1,
  0xF3, 0xE0, 0xF9, 0xE0, 0xF9, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0x1E, 0xF8,
  0x3E, 0x7C, 0x0F, 0x78, 0x1F, 0x3E, 0x03, 0xFC, 0x0F, 0x9F, 0x01, 0xFE,
  0x07, 0xCF, 0x80, 0xFE, 0x03, 0xE7, 0xC0, 0x3F, 0x01, 0xF3, 0xE0, 0x1F,
  0x80, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xBE,
  0x00, 0x07, 0xFE, 0xFC, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x7F, 0xE7, 0xE0,
  0x01, 0xFF, 0x8F, 0x80, 0x07, 0xFE, 0x3F, 0x00, 0x1F, 0xF8, 0x7C, 0x00,
  0x7F, 0xE1, 0xF8, 0x01, 0xFF, 0x83, 0xE0, 0x07, 0xFE, 0x0F, 0xC0, 0x1F,
  0xF8, 0x1F, 0x00, 0x7F, 0xE0, 0x7E, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE,
  0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x81, 0xFF, 0x80,
  0x3E, 0x07, 0xFE, 0x00, 0xF8, 0x1F, 0xF8, 0x01, 0xF0, 0x7F, 0xE0, 0x07,
  0xC1, 0xFF, 0x80, 0x1F, 0x87, 0xFE, 0x00, 0x3E, 0x1F, 0xF8, 0x00, 0xFC,
  0x7F, 0xE0, 0x01, 0xF1, 0xFF, 0x80, 0x07, 0xC7, 0xFE, 0x00, 0x0F, 0x9F,
  0xF8, 0x00, 0x3E, 0x7F, 0xE0, 0x00, 0x7D, 0xFF, 0x80, 0x01, 0xF7, 0xFE,
  0x00, 0x07, 0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFD, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0x81, 0xFC, 0x00,
  0x1E, 0x0F, 0xE0, 0x00, 0x10, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x90, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x7C, 0x03, 0xE7, 0xC0, 0x7E,
  0x01, 0xF3, 0xE0, 0x3F, 0x80, 0xF9, 0xF0, 0x1F, 0xC0, 0x7C, 0xF8, 0x1F,
  0xF0, 0x3E, 0x7C, 0x0F, 0x78, 0x1F, 0x3E, 0x07, 0xBC, 0x0F, 0x9F, 0x07,
  0xDF, 0x07, 0xCF, 0x83, 0xC7, 0x83, 0xE7, 0xC1, 0xE3, 0xC1, 0xF3, 0xE1,
  0xF1, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x78, 0x3C, 0x3E, 0x3C,
  0x3C, 0x1F, 0x1E, 0x1E, 0x3E, 0x0F, 0x8F, 0x0F, 0x1E, 0x03, 0xC7, 0x87,
  0x8F, 0x01, 0xF3, 0xC3, 0xCF, 0x80, 0xF9, 0xE1, 0xE7, 0x80, 0x3C, 0xF0,
  0xF3, 0xC0, 0x1F, 0x78, 0x7B, 0xE0, 0x0F, 0xBC, 0x3D, 0xE0, 0x03, 0xDE,
  0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x18, 0x03, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1E, 0x00, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x3F, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x3F, 0xC0, 0x03, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0xFF, 0x80, 0x0F, 0x9F,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0x0F,
  0xE3, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x7E, 0x3E,
  0x00, 0x07, 0xF8, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x02, 0x07, 0xFF,
  0x80, 0x7C, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0xFC, 0x01, 0xFF, 0xFD, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFE, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x7E, 0x0F, 0xFC, 0x07, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x08, 0x07, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x7F, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0x02, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x1F, 0x3F, 0x80,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0xE0, 0x00,
  0x1F, 0x1F, 0xC0, 0x00, 0x7C, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xE7, 0xC0, 0x03, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x1E, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x8F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0x80, 0x01, 0xFC,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x02, 0x00, 0x0F, 0xF0,
  0x78, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x40, 0x00, 0xFE, 0x78, 0x01, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0B,
  0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x80, 0xF8,
  0x00, 0xFE, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xC0,
  0x7F, 0x80, 0x0F, 0x81, 0xFC, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x3E, 0x1F,
  0xC0, 0x00, 0x7C, 0xFF, 0x00, 0x00, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0x3F, 0xE0, 0x00, 0x3E, 0x3F, 0xE0, 0x00, 0x7C, 0x1F, 0xE0,
  0x00, 0xF8, 0x1F, 0xE0, 0x01, 0xF0, 0x1F, 0xE0, 0x03, 0xE0, 0x0F, 0xE0,
  0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0xE0, 0x1F, 0x00, 0x0F, 0xE0,
  0x3E, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x0F, 0xE1,
  0xF0, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x0F, 0xEF,
  0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x08,
  0x00, 0x3F, 0xC3, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x1F, 0xFC, 0x3F, 0xFF, 0xDF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFB, 0xFF, 0xCF, 0xF7, 0xE0, 0x3F, 0x81, 0xFB,
  0xF0, 0x0F, 0x80, 0x7F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x03, 0xE0, 0x0F,
  0xFE, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x01,
  0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x0F, 0xFE, 0x01, 0xF8,
  0x07, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3F,
  0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xE0, 0x07, 0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x83, 0xF0, 0x03, 0xFE, 0x0F, 0x80, 0x03, 0xFC, 0x3E, 0x00, 0x03,
  0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xF9, 0xFF,
  0xF0, 0x03, 0xE0, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0,
  0x03, 0xF0, 0xFF, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x7C, 0xFE, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x3F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x0F, 0xC3,
  0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x7C, 0x00, 0x1F,
  0xC1, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xF0, 0x00, 0x0B, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xC0, 0x00, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x04, 0x00, 0xFF, 0x81, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x3E, 0xFE, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0xF9, 0xFF, 0x80, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x80, 0x7C, 0x7E, 0x03, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x80, 0x7C,
  0x3E, 0x03, 0xFC, 0x0F, 0xC3, 0xE0, 0x7F, 0xC0, 0xF8, 0x3E, 0x07, 0xBC,
  0x0F, 0x83, 0xE0, 0x7B, 0xE0, 0xF8, 0x3E, 0x0F, 0xBE, 0x0F, 0x83, 0xF0,
  0xF1, 0xE0, 0xF8, 0x1F, 0x0F, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0xF1, 0xF0,
  0x1F, 0x1E, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0xF9, 0xF0, 0x1F, 0x3E, 0x07,
  0x9F, 0x01, 0xF3, 0xC0, 0x7D, 0xF0, 0x0F, 0xFC, 0x07, 0xDF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xBF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0x87, 0xFF, 0xC0, 0x03, 0xE3, 0xFF, 0xF8, 0x01,
  0xE3, 0xFF, 0xFF, 0x01, 0xF3, 0xE0, 0x7F, 0xC0, 0xF9, 0xE0, 0x0F, 0xFF,
  0xF8, 0xF0, 0x01, 0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0xF8, 0x18, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 9, 50, 39, 15, -49 },
  { 58, 17, 18, 39, 11, -53 },
  { 97, 35, 49, 39, 2, -49 },
  { 312, 30, 62, 39, 5, -54 },
  { 545, 36, 51, 39, 2, -50 },
  { 775, 34, 51, 39, 3, -50 },
  { 992, 5, 20, 39, 17, -53 },
  { 1005, 21, 68, 39, 9, -55 },
  { 1184, 20, 68, 39, 10, -55 },
  { 1354, 29, 29, 39, 5, -49 },
  { 1460, 32, 35, 39, 4, -38 },
  { 1600, 16, 21, 39, 12, -10 },
  { 1642, 16, 5, 39, 12, -22 },
  { 1652, 11, 11, 39, 14, -10 },
  { 1668, 27, 68, 39, 6, -55 },
  { 1898, 31, 51, 39, 4, -50 },
  { 2096, 27, 49, 39, 7, -49 },
  { 2262, 29, 50, 39, 5, -50 },
  { 2444, 29, 51, 39, 5, -50 },
  { 2629, 33, 49, 39, 3, -49 },
  { 2832, 29, 50, 39, 6, -49 },
  { 3014, 31, 50, 39, 4, -49 },
  { 3208, 31, 49, 39, 5, -49 },
  { 3398, 31, 51, 39, 4, -50 },
  { 3596, 31, 50, 39, 4, -50 },
  { 3790, 11, 37, 39, 14, -36 },
  { 3841, 15, 47, 39, 10, -36 },
  { 3930, 32, 30, 39, 4, -35 },
  { 4050, 32, 19, 39, 4, -30 },
  { 4126, 32, 30, 39, 4, -35 },
  { 4246, 24, 51, 39, 8, -50 },
  { 4399, 33, 61, 39, 4, -50 },
  { 4651, 38, 49, 39, 1, -49 },
  { 4884, 31, 49, 39, 4, -49 },
  { 5074, 32, 51, 39, 4, -50 },
  { 5278, 32, 49, 39, 4, -49 },
  { 5474, 28, 49, 39, 8, -49 },
  { 5646, 27, 49, 39, 8, -49 },
  { 5812, 32, 51, 39, 4, -50 },
  { 6016, 33, 49, 39, 3, -49 },
  { 6219, 23, 49, 39, 8, -49 },
  { 6360, 28, 50, 39, 4, -49 },
  { 6535, 33, 49, 39, 6, -49 },
  { 6738, 28, 49, 39, 8, -49 },
  { 6910, 33, 49, 39, 3, -49 },
  { 7113, 30, 49, 39, 5, -49 },
  { 7297, 35, 51, 39, 2, -50 },
  { 7521, 29, 49, 39, 6, -49 },
  { 7699, 35, 63, 39, 2, -50 },
  { 7975, 32, 49, 39, 4, -49 },
  { 8171, 30, 51, 39, 5, -50 },
  { 8363, 33, 49, 39, 3, -49 },
  { 8566, 31, 50, 39, 4, -49 },
  { 8760, 37, 49, 39, 1, -49 },
  { 8987, 33, 49, 39, 3, -49 },
  { 9190, 35, 49, 39, 2, -49 },
  { 9405, 37, 49, 39, 1, -49 },
  { 9632, 32, 49, 39, 4, -49 },
  { 9828, 18, 68, 39, 12, -55 },
  { 9981, 27, 68, 39, 6, -55 },
  { 10211, 18, 68, 39, 9, -55 },
  { 10364, 31, 26, 39, 4, -49 },
  { 10465, 38, 5, 39, 1, 8 },
  { 10489, 12, 13, 39, 13, -54 },
  { 10509, 29, 38, 39, 5, -37 },
  { 10647, 30, 55, 39, 6, -54 },
  { 10854, 31, 38, 39, 4, -37 },
  { 11002, 31, 55, 39, 3, -54 },
  { 11216, 32, 38, 39, 3, -37 },
  { 11368, 32, 54, 39, 6, -54 },
  { 11584, 30, 50, 39, 3, -37 },
  { 11772, 28, 54, 39, 6, -54 },
  { 11961, 30, 54, 39, 5, -53 },
  { 12164, 24, 66, 39, 6, -53 },
  { 12362, 31, 54, 39, 6, -54 },
  { 12572, 30, 55, 39, 5, -54 },
  { 12779, 33, 37, 39, 3, -37 },
  { 12932, 28, 37, 39, 6, -37 },
  { 13062, 33, 38, 39, 3, -37 },
  { 13219, 30, 50, 39, 6, -37 },
  { 13407, 30, 50, 39, 3, -37 },
  { 13595, 25, 37, 39, 9, -37 },
  { 13711, 29, 38, 39, 5, -37 },
  { 13849, 29, 49, 39, 6, -48 },
  { 14027, 27, 37, 39, 6, -36 },
  { 14152, 33, 36, 39, 3, -36 },
  { 14301, 36, 36, 39, 2, -36 },
  { 14463, 35, 36, 39, 2, -36 },
  { 14621, 33, 49, 39, 3, -36 },
  { 14824, 27, 36, 39, 6, -36 },
  { 14946, 26, 68, 39, 7, -55 },
  { 15167, 5, 68, 39, 17, -55 },
  { 15210, 27, 68, 39, 6, -55 },
  { 15440, 33, 11, 39, 3, -26 },
};

const GFXfont UbuntuSansMono_Regular70pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular70pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular70pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _UBUNTUSANSMONO_REGULAR70PT7B_H_
