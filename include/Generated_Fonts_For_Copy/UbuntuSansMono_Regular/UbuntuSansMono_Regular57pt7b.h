#ifndef _UBUNTUSANSMONO_REGULAR57PT7B_H_
#define _UBUNTUSANSMONO_REGULAR57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xB8, 0x0E, 0x60, 0x19, 0x80, 0x66, 0x01, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x01,
  0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0x80, 0x78, 0x7E, 0x00, 0x08, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x40, 0x00, 0x3E, 0xF8,
  0x00, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x00, 0x78, 0x7F, 0xC0, 0x03, 0xC3, 0xFF, 0x00, 0x1F, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0xF0, 0x0F, 0x07, 0x03, 0xC0,
  0x78, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x78,
  0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x7C, 0x01,
  0xC0, 0xF1, 0xE0, 0x07, 0x83, 0x8F, 0x00, 0x1E, 0x1E, 0x3C, 0x00, 0x3E,
  0xF9, 0xE0, 0x00, 0x7F, 0xCF, 0x80, 0x00, 0xFE, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF1,
  0xFE, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x3C, 0x78, 0xF0, 0x00, 0xF1, 0xE1,
  0xE0, 0x07, 0x8F, 0x07, 0x80, 0x1E, 0x3C, 0x0E, 0x00, 0xF0, 0xF0, 0x38,
  0x07, 0x83, 0xC0, 0xF0, 0x1E, 0x0E, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1E, 0x03, 0xC0, 0xE0, 0xF0, 0x0F, 0x03, 0x83, 0xC0,
  0x3C, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x78, 0x01, 0xE3, 0xC3, 0xC0, 0x03,
  0xFF, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x01,
  0xF0, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x38, 0x07, 0xFC, 0x03, 0x80, 0xFF,
  0xE0, 0x78, 0x1F, 0x3F, 0x07, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x87,
  0x87, 0xC0, 0x7C, 0x70, 0x7C, 0x07, 0xEF, 0x07, 0x80, 0x3F, 0xF0, 0xF8,
  0x01, 0xFF, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xF0, 0x7C, 0x00, 0xFF, 0x87,
  0xF0, 0x3F, 0xFC, 0x3F, 0xCF, 0xF7, 0xC1, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF,
  0x83, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x04, 0x20, 0x00, 0x30,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x00, 0x70, 0x3C,
  0x0E, 0x7C, 0x3C, 0x3E, 0xFF, 0x3C, 0xFE, 0xFF, 0xDB, 0xFF, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x01, 0xF0, 0x07, 0x00, 0xC0, 0x02, 0x00,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x3F, 0xCF, 0xF8, 0xFE, 0x0F, 0xC0, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7B, 0xE0, 0x10, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF,
  0x87, 0xF8, 0x7F, 0xE1, 0xFE, 0x1F, 0xF8, 0x7F, 0x87, 0xFE, 0x0F, 0xC1,
  0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x30, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x07, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xEF, 0x00, 0xFF, 0x9E, 0x00, 0xFC, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFC, 0x01,
  0xF8, 0x78, 0x00, 0xFC, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3C, 0x01,
  0xF8, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x60, 0x00, 0xFC, 0x7C, 0x07,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x1E,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF2, 0x00, 0x0F, 0xCF, 0xC0, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F,
  0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xFD, 0xE0, 0x00, 0x3E, 0xF0, 0x00,
  0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xF8, 0x07,
  0xE1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7E, 0x00, 0x7C, 0x1F,
  0x80, 0x7C, 0x07, 0xF0, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x3E, 0x7F, 0xE0, 0x3E, 0x07, 0xF8, 0x3E, 0x00, 0xFE,
  0x3E, 0x00, 0x3F, 0x1E, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xE7, 0xC0,
  0x07, 0xE3, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xF8, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0xE0, 0x03, 0xF1, 0xFF, 0x7F, 0xF8,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x08,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x80, 0x3F, 0x03, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xF1, 0xFF, 0x0F, 0xF0, 0x3E, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xE3, 0xFC, 0x60, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80,
  0x1F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3E, 0xF8, 0x01, 0xFF, 0xDF, 0x00, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0x78,
  0x0F, 0xE7, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0xFC, 0x0F, 0xFC, 0x1F, 0x01,
  0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0xF8, 0x07, 0xFE, 0x1F, 0x00, 0xFF, 0xC3,
  0xE0, 0x1F, 0xF8, 0x7C, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xE1, 0xF0, 0x0F,
  0xFC, 0x3E, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0x78, 0x07, 0xDF, 0x0F,
  0x80, 0xFB, 0xE1, 0xF0, 0x1F, 0x7C, 0x1F, 0x03, 0xEF, 0x81, 0xFC, 0xFD,
  0xF8, 0x3F, 0xFF, 0x9F, 0x01, 0xFF, 0xF3, 0xE0, 0x0F, 0xF8, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F,
  0xC7, 0xC0, 0x07, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x1E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x87, 0xC0, 0x1F, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x00,
  0x1F, 0xCF, 0xE1, 0xFF, 0xE7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0x81, 0xF8, 0x00, 0x60, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x06, 0x03,
  0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xF8, 0x3E, 0x00, 0x7F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x0F,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFE,
  0x07, 0xF0, 0x07, 0x81, 0xF8, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0xF3, 0xE0, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xE0,
  0x00, 0xF0, 0xFC, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x03, 0xFC, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF4, 0x00, 0x0F, 0x9C, 0x00, 0x7E, 0xFC, 0x07, 0xF3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC7,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x3E, 0x7F,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xFD, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x3B, 0xC3, 0xDC, 0x03, 0xBC, 0x3D, 0xE0, 0x7B, 0xC3, 0xDE, 0x07, 0x3C,
  0x3C, 0xE0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x79, 0xE1, 0xC3, 0x83, 0x9E, 0x1E, 0x78, 0x39, 0xC1,
  0xE7, 0x83, 0xFC, 0x1E, 0x78, 0x1F, 0xC1, 0xE7, 0x81, 0xF8, 0x1E, 0x78,
  0x1F, 0x81, 0xE7, 0x80, 0xF8, 0x1E, 0x78, 0x0F, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xF7, 0x80, 0x0F, 0xF7, 0xC0, 0x0F, 0xF3, 0xC0, 0x0F, 0xF3,
  0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0,
  0xF8, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0,
  0x0F, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x07, 0x8F, 0xF0, 0x07, 0xCF, 0xF0,
  0x03, 0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x01, 0xEF, 0xF0, 0x01, 0xEF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xF8, 0x03, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x00, 0x3F,
  0x87, 0x80, 0x07, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x3F, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x3D, 0xE0,
  0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0x80, 0x3C, 0x3E, 0x00, 0x04, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x3E, 0x70,
  0x00, 0x7E, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC,
  0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x1F, 0x01, 0xE7, 0x81,
  0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x83, 0xF8, 0x1E, 0x78, 0x3F, 0xC1,
  0xE7, 0x83, 0xBC, 0x1C, 0x78, 0x79, 0xC1, 0xC7, 0x87, 0x9E, 0x1C, 0x38,
  0x71, 0xE3, 0xC3, 0x87, 0x0E, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F,
  0x3C, 0x3C, 0xE0, 0x73, 0xC3, 0xDE, 0x07, 0xBC, 0x3D, 0xE0, 0x7B, 0xC3,
  0xDC, 0x03, 0xBC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x3C,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x1F,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0x70, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x38, 0x3E, 0x0F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x80, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0xF9, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0x80, 0x7E, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x3D, 0xFE,
  0x01, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0xF7,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xF8, 0xF8,
  0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xF0,
  0x01, 0xF8, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0x03, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x20, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xD0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0x8F, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x3E, 0x00, 0x0F, 0x3F, 0x00, 0x0F, 0x1F, 0xC0, 0x0F, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x80, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x01, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0x3F, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7E,
  0x00, 0x0F, 0x3F, 0x00, 0x1F, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x8F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x20, 0x00, 0x7E, 0x3E, 0x03, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x02, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x3F,
  0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xC0, 0x3F,
  0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x40, 0x07, 0xCF, 0x83, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x87, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0xFC, 0x07,
  0x80, 0xFC, 0x03, 0xC0, 0xFC, 0x01, 0xE0, 0xFC, 0x00, 0xF1, 0xF8, 0x00,
  0x79, 0xF8, 0x00, 0x3D, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xDF, 0xE0, 0x01, 0xE3, 0xF8, 0x00, 0xF0, 0xFE,
  0x00, 0x78, 0x1F, 0x80, 0x3C, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x0F, 0x00,
  0x7E, 0x07, 0x80, 0x1F, 0x83, 0xC0, 0x07, 0xE1, 0xE0, 0x01, 0xF8, 0xF0,
  0x00, 0x7E, 0x78, 0x00, 0x1F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF0,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01,
  0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xF0, 0x3F, 0xE0, 0xFC, 0x1F, 0xFE, 0x7F, 0xE3, 0xFF, 0xFF,
  0xFE, 0x7F, 0x7F, 0xEF, 0xCF, 0x03, 0xF0, 0x7D, 0xE0, 0x3C, 0x07, 0xBC,
  0x07, 0x80, 0xF7, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0,
  0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0,
  0x3C, 0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0x03,
  0xFE, 0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF0, 0x03, 0xFB, 0xC0,
  0x03, 0xEF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xF8, 0x07, 0xF8, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xF7, 0xFF, 0x80, 0xF0, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0x3F, 0x80, 0x0F, 0x3E, 0x00,
  0x0F, 0x7E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x7E, 0x00, 0x0F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x7F, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xCF, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xFF, 0xF9, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x3E, 0x00, 0x08, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0x7F, 0x01, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x08, 0x0F, 0xFB, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07,
  0xBE, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x7E, 0x00, 0x3C, 0x7F, 0xCF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x1E, 0x7C, 0x07, 0x80, 0xF9, 0xF0, 0x1E, 0x03, 0xC3, 0xC0,
  0xFC, 0x0F, 0x0F, 0x03, 0xF0, 0x3C, 0x3C, 0x0F, 0xC0, 0xF0, 0xF0, 0x3F,
  0x83, 0xC3, 0xE1, 0xFE, 0x0F, 0x0F, 0x87, 0x38, 0x7C, 0x1E, 0x3C, 0xF1,
  0xE0, 0x78, 0xF3, 0xC7, 0x81, 0xE3, 0x87, 0x1E, 0x07, 0x9E, 0x1E, 0x78,
  0x1E, 0x78, 0x79, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x07,
  0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x78, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x81, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0x07, 0xFC, 0x00, 0x73, 0xFF, 0xC0, 0x3D, 0xFF, 0xF8,
  0x0F, 0x70, 0x3F, 0x87, 0xBC, 0x07, 0xFF, 0xCE, 0x00, 0x7F, 0xF1, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0x60, 0x00,
};

const GFXglyph UbuntuSansMono_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 41, 32, 12, -40 },
  { 42, 14, 15, 32, 9, -43 },
  { 69, 28, 40, 32, 2, -40 },
  { 209, 24, 50, 32, 4, -44 },
  { 359, 30, 41, 32, 1, -40 },
  { 513, 28, 41, 32, 2, -40 },
  { 657, 4, 16, 32, 14, -43 },
  { 665, 16, 56, 32, 8, -45 },
  { 777, 16, 56, 32, 8, -45 },
  { 889, 24, 24, 32, 4, -40 },
  { 961, 26, 28, 32, 3, -31 },
  { 1052, 12, 17, 32, 10, -8 },
  { 1078, 13, 4, 32, 9, -18 },
  { 1085, 8, 10, 32, 12, -9 },
  { 1095, 22, 56, 32, 5, -45 },
  { 1249, 26, 41, 32, 3, -40 },
  { 1383, 23, 40, 32, 5, -40 },
  { 1498, 24, 40, 32, 4, -40 },
  { 1618, 24, 41, 32, 4, -40 },
  { 1741, 28, 40, 32, 2, -40 },
  { 1881, 23, 41, 32, 5, -40 },
  { 1999, 25, 41, 32, 4, -40 },
  { 2128, 25, 40, 32, 4, -40 },
  { 2253, 25, 41, 32, 3, -40 },
  { 2382, 25, 40, 32, 3, -40 },
  { 2507, 8, 31, 32, 12, -30 },
  { 2538, 13, 39, 32, 8, -30 },
  { 2602, 26, 25, 32, 3, -29 },
  { 2684, 26, 16, 32, 3, -25 },
  { 2736, 26, 25, 32, 3, -29 },
  { 2818, 20, 41, 32, 6, -40 },
  { 2921, 27, 49, 32, 3, -40 },
  { 3087, 30, 40, 32, 1, -40 },
  { 3237, 25, 40, 32, 3, -40 },
  { 3362, 26, 41, 32, 3, -40 },
  { 3496, 26, 40, 32, 3, -40 },
  { 3626, 23, 40, 32, 6, -40 },
  { 3741, 22, 40, 32, 6, -40 },
  { 3851, 26, 41, 32, 3, -40 },
  { 3985, 26, 40, 32, 3, -40 },
  { 4115, 20, 40, 32, 6, -40 },
  { 4215, 22, 41, 32, 4, -40 },
  { 4328, 27, 40, 32, 4, -40 },
  { 4463, 23, 40, 32, 6, -40 },
  { 4578, 28, 40, 32, 2, -40 },
  { 4718, 24, 40, 32, 4, -40 },
  { 4838, 28, 41, 32, 2, -40 },
  { 4982, 24, 40, 32, 5, -40 },
  { 5102, 28, 50, 32, 2, -40 },
  { 5277, 25, 40, 32, 4, -40 },
  { 5402, 24, 41, 32, 4, -40 },
  { 5525, 26, 40, 32, 3, -40 },
  { 5655, 26, 41, 32, 3, -40 },
  { 5789, 30, 40, 32, 1, -40 },
  { 5939, 28, 40, 32, 2, -40 },
  { 6079, 28, 40, 32, 2, -40 },
  { 6219, 30, 40, 32, 1, -40 },
  { 6369, 25, 40, 32, 4, -40 },
  { 6494, 14, 56, 32, 10, -45 },
  { 6592, 22, 56, 32, 5, -45 },
  { 6746, 14, 56, 32, 8, -45 },
  { 6844, 26, 22, 32, 3, -40 },
  { 6916, 30, 4, 32, 1, 7 },
  { 6931, 9, 11, 32, 11, -44 },
  { 6944, 23, 31, 32, 4, -30 },
  { 7034, 24, 45, 32, 5, -44 },
  { 7169, 26, 31, 32, 3, -30 },
  { 7270, 24, 45, 32, 3, -44 },
  { 7405, 26, 31, 32, 3, -30 },
  { 7506, 26, 44, 32, 5, -44 },
  { 7649, 24, 41, 32, 3, -30 },
  { 7772, 22, 44, 32, 5, -44 },
  { 7893, 24, 44, 32, 4, -43 },
  { 8025, 19, 54, 32, 5, -43 },
  { 8154, 25, 44, 32, 5, -44 },
  { 8292, 24, 45, 32, 4, -44 },
  { 8427, 27, 30, 32, 3, -30 },
  { 8529, 22, 30, 32, 5, -30 },
  { 8612, 26, 31, 32, 3, -30 },
  { 8713, 24, 41, 32, 5, -30 },
  { 8836, 24, 41, 32, 3, -30 },
  { 8959, 21, 30, 32, 7, -30 },
  { 9038, 24, 31, 32, 4, -30 },
  { 9131, 23, 40, 32, 5, -39 },
  { 9246, 23, 31, 32, 4, -30 },
  { 9336, 28, 30, 32, 2, -30 },
  { 9441, 30, 30, 32, 1, -30 },
  { 9554, 28, 30, 32, 2, -30 },
  { 9659, 26, 41, 32, 3, -30 },
  { 9793, 22, 30, 32, 5, -30 },
  { 9876, 22, 56, 32, 5, -45 },
  { 10030, 4, 56, 32, 14, -45 },
  { 10058, 22, 56, 32, 5, -45 },
  { 10212, 26, 9, 32, 3, -21 },
};

const GFXfont UbuntuSansMono_Regular57pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular57pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular57pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _UBUNTUSANSMONO_REGULAR57PT7B_H_
