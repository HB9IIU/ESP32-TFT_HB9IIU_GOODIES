#ifndef _UBUNTUSANSMONO_REGULAR54PT7B_H_
#define _UBUNTUSANSMONO_REGULAR54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0x7E, 0x7E, 0x18, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x03,
  0x70, 0x18, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x07, 0x80, 0x1F, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFC, 0x01, 0xC3, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF4, 0x00, 0x03, 0xEF, 0x00,
  0x1F, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x1E, 0x3F, 0xF0, 0x03, 0xC7, 0x87, 0x00, 0x3C, 0x70,
  0x78, 0x07, 0x87, 0x07, 0x80, 0xF0, 0xF0, 0x38, 0x0F, 0x0F, 0x03, 0x81,
  0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x83, 0xC0, 0xF0, 0x38, 0x78, 0x0F,
  0x03, 0x87, 0x80, 0xF0, 0x38, 0xF0, 0x07, 0x07, 0x8F, 0x00, 0x78, 0x71,
  0xE0, 0x03, 0xCF, 0x3C, 0x00, 0x3F, 0xE3, 0xC0, 0x01, 0xFC, 0x78, 0x00,
  0x02, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x01,
  0xE3, 0xF8, 0x00, 0x3C, 0x7F, 0xC0, 0x03, 0xCF, 0x1E, 0x00, 0x78, 0xE0,
  0xE0, 0x0F, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0xF0, 0x1E, 0x1C, 0x07, 0x01,
  0xE1, 0xC0, 0x70, 0x3C, 0x1C, 0x07, 0x07, 0x81, 0xC0, 0x70, 0x78, 0x1E,
  0x07, 0x0F, 0x01, 0xE0, 0xF0, 0xF0, 0x1E, 0x0F, 0x1E, 0x00, 0xE0, 0xE3,
  0xC0, 0x0F, 0x1E, 0x3C, 0x00, 0x7F, 0xC7, 0x80, 0x03, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0xF0, 0x3F, 0xE0, 0x3C, 0x1F, 0x7C, 0x0F, 0x07, 0x9F,
  0x83, 0xC3, 0xE3, 0xF0, 0xE1, 0xF0, 0x7E, 0x38, 0x7C, 0x0F, 0x9E, 0x1E,
  0x01, 0xF7, 0x8F, 0x80, 0x3F, 0xC3, 0xE0, 0x07, 0xF0, 0xF8, 0x01, 0xFC,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF8, 0x7C, 0x01,
  0xFE, 0x1F, 0x80, 0xFF, 0xC3, 0xF8, 0xFE, 0xF8, 0xFF, 0xFF, 0x3E, 0x0F,
  0xFF, 0x07, 0xC1, 0xFF, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x76, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x04, 0x30, 0x00,
  0x38, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x08, 0x0F, 0x01, 0x1C,
  0x1E, 0x0F, 0x7F, 0x1C, 0x7E, 0xFF, 0xBB, 0xFD, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xF3,
  0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x7C, 0x0F,
  0xC0, 0x78, 0x1F, 0x00, 0x60, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0xBF, 0x87, 0xF0, 0x7E, 0x07,
  0x80, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8,
  0x7E, 0x0F, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x0F, 0xF8,
  0x7E, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1E,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0xFE, 0xF0, 0x1F, 0xC7, 0x80, 0x7C, 0x3C, 0x03, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F,
  0x0E, 0x00, 0x3E, 0x18, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0x80, 0x3F, 0x04, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x80,
  0x03, 0xF3, 0xE0, 0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x80, 0x03,
  0xF3, 0xC0, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x7B, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0xFF, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3E,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0xFB, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xDF, 0xF8, 0x1F, 0x03, 0xFC, 0x3E, 0x00, 0xFC,
  0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC7, 0xF0,
  0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x1F, 0xE7, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x07,
  0x80, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFC, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFC, 0x0F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFC, 0x0F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF1,
  0xFE, 0x40, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x07,
  0xFB, 0xC0, 0x1F, 0xFD, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0x07, 0xFC, 0x1F, 0x03, 0xFE, 0x1F, 0x01, 0xFF, 0x0F, 0x80, 0xFF, 0x87,
  0x80, 0x7F, 0xC3, 0xC0, 0x3F, 0xE1, 0xE0, 0x1F, 0xF1, 0xF0, 0x0F, 0xF8,
  0x78, 0x07, 0xFC, 0x3C, 0x03, 0xFE, 0x1E, 0x01, 0xFF, 0x0F, 0x00, 0xFF,
  0x87, 0xC0, 0x7F, 0xC3, 0xE0, 0x3D, 0xE0, 0xF8, 0x1E, 0xF8, 0x3E, 0x0F,
  0x7C, 0x1F, 0xFF, 0xBE, 0x07, 0xFF, 0xCF, 0x80, 0xFF, 0xC7, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF0,
  0x03, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF0,
  0x07, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x7E, 0xF0, 0x00, 0xFC, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7E, 0x00, 0xF0, 0x7E, 0x00, 0x10,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x01, 0x81, 0xFE, 0x03, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0x00, 0xFF, 0x07, 0x80,
  0x0F, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0xF8, 0x78, 0x01, 0xF8, 0x3F, 0x1F, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03,
  0xFE, 0x7F, 0x07, 0xE0, 0x0E, 0x0F, 0xC0, 0x02, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x1F, 0x80, 0x0F, 0x0F, 0xC0, 0x0F, 0x07, 0xF0, 0x0F, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x88, 0x00, 0x3E, 0x30,
  0x01, 0xF9, 0xF0, 0x0F, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x8F, 0x00,
  0x07, 0xC3, 0xC0, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x0F,
  0x00, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x07, 0xE0,
  0x0F, 0x03, 0xF0, 0x03, 0xC1, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0x3C, 0x7E,
  0x00, 0x0F, 0x1F, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0xF1, 0xF8, 0x00,
  0x3C, 0x3F, 0x00, 0x0F, 0x07, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0xF0,
  0x01, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF8,
  0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xFB, 0xC0, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC,
  0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xB8, 0x07, 0x70, 0xEF, 0x01,
  0xDC, 0x3B, 0xC0, 0xF7, 0x0E, 0x70, 0x39, 0xE3, 0x9E, 0x0E, 0x78, 0xE7,
  0x87, 0x9E, 0x38, 0xE1, 0xE7, 0x8E, 0x3C, 0x71, 0xE7, 0x8F, 0x1C, 0x79,
  0xE1, 0xCF, 0x1E, 0x78, 0x7B, 0x87, 0x9E, 0x0E, 0xE1, 0xE7, 0x83, 0xF8,
  0x79, 0xE0, 0xFC, 0x1E, 0x78, 0x1F, 0x07, 0x9E, 0x07, 0xC1, 0xE7, 0x81,
  0xE0, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFB, 0xC0, 0x07, 0xF7, 0xC0, 0x0F, 0xE7,
  0x80, 0x1F, 0xCF, 0x80, 0x3F, 0x8F, 0x00, 0x7F, 0x1F, 0x00, 0xFE, 0x1E,
  0x01, 0xFC, 0x3E, 0x03, 0xF8, 0x3C, 0x07, 0xF0, 0x7C, 0x0F, 0xE0, 0x78,
  0x1F, 0xC0, 0xF8, 0x3F, 0x80, 0xF0, 0x7F, 0x01, 0xE0, 0xFE, 0x01, 0xE1,
  0xFC, 0x03, 0xC3, 0xF8, 0x03, 0xC7, 0xF0, 0x07, 0x8F, 0xE0, 0x07, 0x9F,
  0xC0, 0x0F, 0x3F, 0x80, 0x1E, 0x7F, 0x00, 0x1E, 0xFE, 0x00, 0x3D, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF9, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x78, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x07,
  0xF3, 0xC0, 0x07, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x03,
  0xEF, 0x00, 0x1F, 0x3C, 0x01, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF9, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x78, 0xF8, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x18, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0x80, 0x3F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x83,
  0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0x7C, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F,
  0xC3, 0xF0, 0x07, 0x0F, 0x80, 0x02, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0xC0, 0x01, 0xFB, 0xE0, 0x0F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x78, 0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0,
  0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x81, 0xE0, 0x79,
  0xE0, 0x7C, 0x1E, 0x78, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0xF8,
  0x79, 0xE1, 0xEE, 0x1E, 0x78, 0x73, 0x87, 0x9E, 0x1C, 0xF1, 0xE7, 0x8F,
  0x3C, 0x79, 0xE3, 0x87, 0x1E, 0x78, 0xE1, 0xE7, 0x8E, 0x78, 0x79, 0xC3,
  0x9C, 0x0E, 0x70, 0xE7, 0x03, 0xDC, 0x3B, 0xC0, 0xF7, 0x0E, 0xE0, 0x1D,
  0xC3, 0xB8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x00,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x1E,
  0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0xF8, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x78, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0xC0,
  0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x1F,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xE7,
  0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x06, 0x10, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x38,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0x80, 0x80, 0x00,
  0x70, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1C, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xFF, 0x3C, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3D, 0xFC, 0x01, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x30, 0x00, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0x87, 0xF0, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xFC, 0xF8, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x1E, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x0F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x0B,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x03, 0x83, 0xC0, 0x7F, 0xE7, 0x83, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0x87, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x01, 0xF7, 0xC0,
  0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xE7,
  0xE0, 0x03, 0xC7, 0xF8, 0x1F, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x7C, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xC0, 0x30, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE,
  0x1F, 0xE7, 0xE0, 0x03, 0xDF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF,
  0x80, 0x03, 0xDF, 0x80, 0x0F, 0x9F, 0x80, 0x7F, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x80, 0x07, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x80, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x20, 0x0F,
  0xC3, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE4, 0x00, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xFB,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xDF, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0xF8, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x40, 0x1F, 0x87,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0xE0, 0x7F, 0xF1, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xEF, 0x07, 0xE1, 0xF7, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78,
  0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x07,
  0x80, 0xFF, 0x03, 0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0,
  0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x20, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFE, 0x07, 0xF3, 0xE0, 0x07, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xF1, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xFC, 0x01, 0xF8, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFB, 0xFF, 0x80, 0xF8, 0x70, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x07,
  0xE7, 0xE0, 0x03, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x3F, 0xC7,
  0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xF9, 0xE0, 0x03, 0x83,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x05, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0x00, 0x71, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x60, 0x00, 0x7D, 0xF0, 0x07, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8,
  0x38, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xB8,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0,
  0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x3F, 0x80, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x3A, 0x00, 0xF8, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x03,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0xF0, 0x1E, 0x78, 0x0F, 0x01, 0xE7,
  0xC0, 0xF8, 0x1E, 0x3C, 0x1F, 0x81, 0xE3, 0xC1, 0xF8, 0x1C, 0x3C, 0x1F,
  0xC3, 0xC3, 0xC3, 0xFC, 0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9E, 0x3C,
  0x1E, 0x78, 0xE3, 0xC1, 0xE7, 0x0E, 0x38, 0x1E, 0x70, 0xF7, 0x81, 0xEF,
  0x07, 0x78, 0x1E, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0x80, 0x1F, 0x00, 0x70, 0x00, 0xE0, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF0,
  0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x03,
  0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C,
  0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x02, 0x07, 0xFC, 0x00, 0xF3, 0xFF, 0xC0, 0x38, 0xFF, 0xFC,
  0x1E, 0x78, 0x3F, 0xCF, 0x9C, 0x03, 0xFF, 0xCF, 0x00, 0x3F, 0xE0, 0x80,
  0x07, 0xF0,
};

const GFXglyph UbuntuSansMono_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 8, 38, 30, 11, -37 },
  { 39, 13, 14, 30, 9, -41 },
  { 62, 26, 37, 30, 2, -37 },
  { 183, 23, 48, 30, 4, -42 },
  { 321, 28, 39, 30, 1, -38 },
  { 458, 26, 38, 30, 2, -38 },
  { 582, 4, 16, 30, 13, -41 },
  { 590, 16, 52, 30, 7, -42 },
  { 694, 16, 52, 30, 7, -42 },
  { 798, 23, 21, 30, 4, -37 },
  { 859, 24, 26, 30, 3, -29 },
  { 937, 12, 17, 30, 9, -8 },
  { 963, 12, 4, 30, 9, -17 },
  { 969, 8, 9, 30, 11, -8 },
  { 978, 21, 52, 30, 5, -42 },
  { 1115, 24, 39, 30, 3, -38 },
  { 1232, 21, 37, 30, 5, -37 },
  { 1330, 23, 38, 30, 4, -38 },
  { 1440, 23, 39, 30, 4, -38 },
  { 1553, 26, 37, 30, 2, -37 },
  { 1674, 22, 38, 30, 5, -37 },
  { 1779, 24, 39, 30, 3, -38 },
  { 1896, 24, 37, 30, 4, -37 },
  { 2007, 24, 39, 30, 3, -38 },
  { 2124, 24, 38, 30, 3, -38 },
  { 2238, 8, 29, 30, 11, -28 },
  { 2267, 12, 37, 30, 8, -28 },
  { 2323, 25, 23, 30, 3, -27 },
  { 2395, 24, 15, 30, 3, -23 },
  { 2440, 25, 23, 30, 3, -27 },
  { 2512, 18, 39, 30, 6, -38 },
  { 2600, 25, 46, 30, 3, -38 },
  { 2744, 29, 37, 30, 1, -37 },
  { 2879, 24, 38, 30, 3, -38 },
  { 2993, 25, 39, 30, 3, -38 },
  { 3115, 25, 38, 30, 3, -38 },
  { 3234, 22, 37, 30, 6, -37 },
  { 3336, 21, 37, 30, 6, -37 },
  { 3434, 24, 39, 30, 3, -38 },
  { 3551, 25, 37, 30, 3, -37 },
  { 3667, 18, 37, 30, 6, -37 },
  { 3751, 22, 38, 30, 3, -37 },
  { 3856, 26, 37, 30, 4, -37 },
  { 3977, 22, 37, 30, 6, -37 },
  { 4079, 26, 37, 30, 2, -37 },
  { 4200, 23, 37, 30, 4, -37 },
  { 4307, 27, 39, 30, 2, -38 },
  { 4439, 22, 38, 30, 5, -38 },
  { 4544, 27, 48, 30, 2, -38 },
  { 4706, 25, 38, 30, 3, -38 },
  { 4825, 23, 39, 30, 4, -38 },
  { 4938, 25, 37, 30, 3, -37 },
  { 5054, 24, 38, 30, 3, -37 },
  { 5168, 29, 37, 30, 1, -37 },
  { 5303, 26, 37, 30, 2, -37 },
  { 5424, 26, 37, 30, 2, -37 },
  { 5545, 29, 37, 30, 1, -37 },
  { 5680, 25, 37, 30, 3, -37 },
  { 5796, 14, 52, 30, 9, -42 },
  { 5887, 21, 52, 30, 5, -42 },
  { 6024, 14, 52, 30, 7, -42 },
  { 6115, 24, 20, 30, 3, -37 },
  { 6175, 30, 4, 30, 0, 6 },
  { 6190, 9, 11, 30, 10, -42 },
  { 6203, 22, 30, 30, 4, -29 },
  { 6286, 24, 43, 30, 4, -42 },
  { 6415, 24, 30, 30, 3, -29 },
  { 6505, 23, 43, 30, 3, -42 },
  { 6629, 24, 30, 30, 3, -29 },
  { 6719, 25, 42, 30, 4, -42 },
  { 6851, 23, 39, 30, 3, -29 },
  { 6964, 22, 42, 30, 4, -42 },
  { 7080, 23, 42, 30, 4, -41 },
  { 7201, 18, 51, 30, 5, -41 },
  { 7316, 25, 42, 30, 4, -42 },
  { 7448, 23, 43, 30, 4, -42 },
  { 7572, 25, 29, 30, 3, -29 },
  { 7663, 22, 29, 30, 4, -29 },
  { 7743, 25, 30, 30, 3, -29 },
  { 7837, 24, 39, 30, 4, -29 },
  { 7954, 23, 39, 30, 3, -29 },
  { 8067, 19, 29, 30, 7, -29 },
  { 8136, 22, 30, 30, 4, -29 },
  { 8219, 23, 38, 30, 4, -37 },
  { 8329, 22, 29, 30, 4, -28 },
  { 8409, 26, 28, 30, 2, -28 },
  { 8500, 28, 28, 30, 1, -28 },
  { 8598, 26, 28, 30, 2, -28 },
  { 8689, 26, 38, 30, 2, -28 },
  { 8813, 21, 28, 30, 5, -28 },
  { 8887, 21, 52, 30, 5, -42 },
  { 9024, 4, 52, 30, 13, -42 },
  { 9050, 20, 52, 30, 5, -42 },
  { 9180, 26, 8, 30, 2, -20 },
};

const GFXfont UbuntuSansMono_Regular54pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular54pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular54pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _UBUNTUSANSMONO_REGULAR54PT7B_H_
