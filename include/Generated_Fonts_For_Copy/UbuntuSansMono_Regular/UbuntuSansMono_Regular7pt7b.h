#ifndef _UBUNTUSANSMONO_REGULAR7PT7B_H_
#define _UBUNTUSANSMONO_REGULAR7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x5F, 0x6F, 0xA0, 0x71, 0x9E, 0x80, 0xDE, 0x47, 0xB0,
  0x6A, 0x5A, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0x5D, 0x80, 0x4F, 0x44,
  0x70, 0xC0, 0xC0, 0x56, 0xA0, 0x69, 0xD9, 0x60, 0x65, 0xC0, 0xE4, 0xAE,
  0x65, 0x9E, 0x26, 0xAF, 0x20, 0xED, 0xC0, 0x24, 0xE9, 0x60, 0xE9, 0x48,
  0x75, 0xDE, 0x75, 0x96, 0xC3, 0xC3, 0x80, 0x16, 0xE1, 0xFF, 0x86, 0x78,
  0xD6, 0x80, 0x6B, 0xDD, 0xB7, 0x46, 0x6E, 0x90, 0xEA, 0xE9, 0xE0, 0x78,
  0x88, 0x70, 0xE9, 0x99, 0xE0, 0xD3, 0x4E, 0xEE, 0x80, 0x78, 0x89, 0x70,
  0x99, 0xF9, 0x90, 0xEA, 0xC0, 0x64, 0x9E, 0xBA, 0x6A, 0x92, 0x4E, 0xAE,
  0xD9, 0x90, 0xBE, 0xDA, 0x69, 0x99, 0x60, 0xD7, 0x48, 0x69, 0x99, 0x62,
  0xE9, 0xEA, 0x90, 0x71, 0x9E, 0xF4, 0x44, 0x40, 0x99, 0x99, 0x60, 0x99,
  0x66, 0x60, 0x99, 0xDE, 0xA0, 0x96, 0x46, 0x90, 0x96, 0x64, 0x40, 0x72,
  0x44, 0xF0, 0xEA, 0xB0, 0xA9, 0x50, 0xD5, 0x70, 0x46, 0x90, 0xF0, 0x80,
  0x67, 0xF0, 0x9A, 0xDC, 0x68, 0x87, 0x2E, 0xD6, 0x69, 0xE7, 0xFA, 0x48,
  0x76, 0xB6, 0xBF, 0xC0, 0x59, 0x26, 0x75, 0x70, 0x97, 0x6A, 0xC9, 0x26,
  0xED, 0xD9, 0xFF, 0x69, 0x96, 0xD6, 0xE8, 0x76, 0xB2, 0xEA, 0xE7, 0xBA,
  0xC0, 0xFF, 0x9A, 0x64, 0x9D, 0xE6, 0x96, 0x69, 0x96, 0x62, 0xC0, 0xDB,
  0xEA, 0xB0, 0xFC, 0xD5, 0x70, 0xF0,
};

const GFXglyph UbuntuSansMono_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 1, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 6, 4, 0, -5 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 4, 1, -5 },
  { 16, 2, 6, 4, 1, -5 },
  { 18, 2, 6, 4, 1, -5 },
  { 20, 3, 3, 4, 0, -5 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 2, 2, 4, 1, -1 },
  { 25, 2, 1, 4, 1, -2 },
  { 26, 2, 1, 4, 1, -1 },
  { 27, 2, 6, 4, 1, -5 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 2, 5, 4, 1, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 2, 5, 4, 1, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 1, -5 },
  { 48, 3, 5, 4, 0, -5 },
  { 50, 3, 5, 4, 0, -5 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 2, 5, 4, 1, -4 },
  { 55, 4, 4, 4, 0, -4 },
  { 57, 4, 2, 4, 0, -3 },
  { 58, 4, 4, 4, 0, -4 },
  { 60, 2, 5, 4, 1, -5 },
  { 62, 4, 6, 4, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 2, 5, 4, 1, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 2, 5, 4, 1, -5 },
  { 89, 3, 5, 4, 0, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 3, 5, 4, 1, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 3, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 3, 5, 4, 1, -5 },
  { 105, 4, 6, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 3, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 2, 6, 4, 1, -5 },
  { 136, 2, 6, 4, 1, -5 },
  { 138, 2, 6, 4, 1, -5 },
  { 140, 4, 3, 4, 0, -5 },
  { 142, 4, 1, 4, 0, 1 },
  { 143, 1, 1, 4, 1, -5 },
  { 144, 3, 4, 4, 0, -4 },
  { 146, 3, 5, 4, 1, -5 },
  { 148, 4, 4, 4, 0, -4 },
  { 150, 3, 5, 4, 0, -5 },
  { 152, 4, 4, 4, 0, -4 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 3, 5, 4, 0, -4 },
  { 158, 2, 5, 4, 1, -5 },
  { 160, 3, 5, 4, 0, -5 },
  { 162, 2, 6, 4, 1, -5 },
  { 164, 3, 5, 4, 1, -5 },
  { 166, 3, 5, 4, 0, -5 },
  { 168, 4, 4, 4, 0, -4 },
  { 170, 2, 4, 4, 1, -4 },
  { 171, 4, 4, 4, 0, -4 },
  { 173, 3, 5, 4, 1, -4 },
  { 175, 3, 5, 4, 0, -4 },
  { 177, 2, 4, 4, 1, -4 },
  { 178, 2, 4, 4, 1, -4 },
  { 179, 2, 5, 4, 1, -5 },
  { 181, 2, 4, 4, 1, -4 },
  { 182, 4, 4, 4, 0, -4 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 5, 4, 0, -4 },
  { 191, 2, 4, 4, 1, -4 },
  { 192, 2, 6, 4, 1, -5 },
  { 194, 1, 6, 4, 1, -5 },
  { 195, 2, 6, 4, 1, -5 },
  { 197, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_Regular7pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular7pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _UBUNTUSANSMONO_REGULAR7PT7B_H_
