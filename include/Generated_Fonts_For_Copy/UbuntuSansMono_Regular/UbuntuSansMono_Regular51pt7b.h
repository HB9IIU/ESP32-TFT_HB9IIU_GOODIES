#ifndef _UBUNTUSANSMONO_REGULAR51PT7B_H_
#define _UBUNTUSANSMONO_REGULAR51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x0F, 0xBF, 0x7F, 0xFF, 0xF9, 0xF1, 0x80, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x76, 0x07, 0x60, 0x36, 0x03, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x38,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x1E, 0x03, 0x80, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xF0, 0x03, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF7, 0x00, 0x0F, 0x9F, 0xC3, 0xFC, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x4F, 0xF0, 0x01, 0xE3, 0xDE, 0x00,
  0x79, 0xE3, 0xC0, 0x3C, 0x70, 0x70, 0x0E, 0x3C, 0x1C, 0x07, 0x8E, 0x07,
  0x03, 0xC3, 0x81, 0xC0, 0xF0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x0F, 0x03, 0xC1, 0xC7, 0x80, 0x70, 0x71, 0xE0, 0x1C, 0x3C, 0xF0,
  0x07, 0x8E, 0x38, 0x00, 0xFF, 0x9E, 0x00, 0x1F, 0xCF, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x3C, 0xFF, 0x00,
  0x1E, 0x3F, 0xE0, 0x07, 0x9E, 0x38, 0x03, 0xC7, 0x07, 0x00, 0xE3, 0xC1,
  0xC0, 0x78, 0xF0, 0x70, 0x1C, 0x38, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x83,
  0x81, 0xC1, 0xC0, 0xE0, 0x70, 0xF0, 0x3C, 0x1C, 0x38, 0x0F, 0x07, 0x1E,
  0x01, 0xC3, 0xCF, 0x00, 0x78, 0xE3, 0x80, 0x0F, 0xF9, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xF1, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0x03, 0xFC, 0x07, 0x03, 0xFF, 0x03, 0x83, 0xE7, 0xC1, 0xC1, 0xE1, 0xF0,
  0xE1, 0xE0, 0x7C, 0xF0, 0xF0, 0x3F, 0x78, 0xF8, 0x0F, 0xB8, 0x78, 0x03,
  0xFC, 0x3C, 0x00, 0xFE, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x07, 0xC0,
  0x0F, 0xC3, 0xE0, 0x07, 0xF0, 0xF8, 0x0F, 0xF8, 0x7E, 0x0F, 0xFE, 0x1F,
  0xFF, 0xCF, 0x87, 0xFF, 0xC3, 0xC0, 0xFF, 0x81, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0x77, 0x70, 0x00, 0x08, 0x00, 0x30, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1E, 0x00,
  0x18, 0x20, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x80,
  0xE0, 0x27, 0x83, 0x87, 0x9F, 0xCE, 0x7F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xBC, 0x00,
  0x3C, 0xF8, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x0F, 0x80, 0xF0,
  0x3C, 0x00, 0x80, 0x60, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0x00, 0xF8, 0x3F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F,
  0x03, 0xE0, 0x78, 0x1F, 0x07, 0xCF, 0xF1, 0xFC, 0x3F, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xF7,
  0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x0E, 0x0F, 0xF8,
  0x3E, 0x1F, 0xF0, 0xFC, 0x3F, 0xE1, 0xFC, 0x7F, 0xC3, 0xF8, 0xFF, 0x83,
  0xE1, 0xFF, 0x07, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03,
  0xE7, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0xF8,
  0x1F, 0x83, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0x78, 0x0F, 0xC7, 0x80, 0xF0,
  0x78, 0x04, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0x7E, 0x30, 0x01, 0xF1, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0x00, 0x7E, 0x10, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xD0, 0x00, 0x3E, 0xE0, 0x07, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x79,
  0x00, 0x07, 0xCE, 0x00, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3D,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xF8, 0x07, 0xE7, 0x80,
  0x07, 0xCF, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x7C,
  0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xE0, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x1E, 0x7C, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0xE0, 0xF8,
  0x0F, 0xF7, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xE7, 0xF8, 0x1E,
  0x03, 0xF0, 0xF0, 0x07, 0xE7, 0xC0, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1E, 0x3E, 0x01, 0xF8, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE3, 0xF8, 0x3E, 0x01, 0xF1,
  0xF0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x3C, 0xF8, 0x01, 0xF3,
  0xFC, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x18, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x3E, 0x1C, 0x03, 0x00, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC3, 0xF8, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x7C, 0x1F, 0xC3,
  0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE3,
  0xF8, 0xFE, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x0F, 0xE4, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xF3, 0xF8, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x78, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0,
  0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0,
  0xF0, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0x78, 0x0F, 0x78,
  0x3C, 0x0F, 0x78, 0x3F, 0xFF, 0x7C, 0x1F, 0xFF, 0x7C, 0x07, 0xFE, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x08, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x70,
  0x07, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x07, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x3E,
  0x3C, 0x07, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3C,
  0x03, 0xFC, 0xF0, 0x01, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7E, 0xF0,
  0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xE0, 0xFC, 0x01,
  0xC3, 0xF0, 0x00, 0x87, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x02, 0x0F, 0xE0, 0x1C, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0x00, 0xFC, 0x1E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xFB, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x1F, 0x3C,
  0x00, 0x7C, 0x78, 0x03, 0xF0, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xC7, 0xE0, 0xFC, 0x01, 0xC1,
  0xF0, 0x00, 0x87, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7,
  0xC0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0xE0, 0x1E, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF9, 0x80,
  0x07, 0x8F, 0x00, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8,
  0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xF7, 0xE0, 0x00,
  0xF3, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0xF0, 0x3E, 0x00,
  0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0x70, 0xFE,
  0x03, 0xB8, 0x77, 0x01, 0xDC, 0x3B, 0x81, 0xCE, 0x1D, 0xE0, 0xE7, 0x0E,
  0x70, 0x73, 0x8F, 0x38, 0x71, 0xC7, 0x9E, 0x38, 0xE3, 0xC7, 0x1C, 0x71,
  0xE3, 0x9E, 0x3C, 0xF0, 0xEE, 0x1E, 0x78, 0x77, 0x0F, 0x3C, 0x3F, 0x87,
  0x9E, 0x0F, 0x83, 0xCE, 0x07, 0xC1, 0xE7, 0x03, 0xE0, 0xF3, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x78,
  0x01, 0xFD, 0xE0, 0x07, 0xF3, 0xC0, 0x1F, 0xCF, 0x00, 0x7F, 0x1E, 0x01,
  0xFC, 0x78, 0x07, 0xF0, 0xF0, 0x1F, 0xC3, 0xC0, 0x7F, 0x07, 0x81, 0xFC,
  0x1E, 0x07, 0xF0, 0x3C, 0x1F, 0xC0, 0xF0, 0x7F, 0x01, 0xC1, 0xFC, 0x07,
  0x87, 0xF0, 0x1E, 0x1F, 0xC0, 0x3C, 0x7F, 0x00, 0xF1, 0xFC, 0x01, 0xE7,
  0xF0, 0x07, 0x9F, 0xC0, 0x0E, 0x7F, 0x00, 0x3D, 0xFC, 0x00, 0x77, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xF0, 0x0F, 0xC1, 0xF0,
  0x03, 0xE0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1F,
  0x80, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0x00, 0x7E, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xF7,
  0x80, 0x1F, 0x3C, 0x03, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFC, 0xFF, 0x01, 0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x0F,
  0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07,
  0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1,
  0xE0, 0x07, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0,
  0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xF0, 0xFC, 0x3F, 0x00, 0x30, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xD8, 0x00, 0x1E, 0x78,
  0x01, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xF7, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F,
  0x9F, 0x00, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF3, 0x81, 0xE0,
  0x79, 0xC0, 0xF0, 0x3C, 0xE0, 0x7C, 0x1E, 0x78, 0x7E, 0x0F, 0x3C, 0x3F,
  0x87, 0x9E, 0x1D, 0xC3, 0x8F, 0x1C, 0xE1, 0xC7, 0x8E, 0x78, 0xE3, 0xC7,
  0x1C, 0x71, 0xE7, 0x0E, 0x38, 0xF3, 0x87, 0x9C, 0x79, 0xC1, 0xCE, 0x3D,
  0xE0, 0xE7, 0x0E, 0xE0, 0x7B, 0x87, 0x70, 0x1D, 0xC3, 0xF8, 0x0E, 0xE1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x01,
  0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x07, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xE0,
  0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xC0, 0x00, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20,
  0x60, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x06, 0x0F, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x3F, 0xC2, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x08,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC7,
  0xF0, 0x0F, 0x7F, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x0F,
  0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0x3C,
  0x00, 0xFC, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x02, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFC, 0x00, 0x87, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0,
  0x06, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x01, 0xFC, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7E, 0x03, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3D, 0xF0,
  0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xE0,
  0x03, 0xC7, 0xC0, 0x0F, 0x0F, 0xE0, 0x3C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xF3, 0xF8, 0x1F, 0x80, 0x7C, 0x1E, 0x00, 0x3C,
  0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x18, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x17, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0x80, 0xE0, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0x80, 0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0xFC,
  0x01, 0xF1, 0xFE, 0x7F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFC,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x18, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x01, 0x70, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x03, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x70, 0x1F, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x0F,
  0x83, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x1E, 0x1F, 0x80,
  0x3C, 0x7E, 0x00, 0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xBF, 0x00, 0x0F, 0x3F, 0x80, 0x1E, 0x1F, 0x80, 0x3C,
  0x1F, 0x80, 0x78, 0x1F, 0x80, 0xF0, 0x1F, 0x81, 0xE0, 0x0F, 0x83, 0xC0,
  0x0F, 0x87, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x03, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x3F, 0x83, 0xE1, 0xFF, 0xDF, 0xF3,
  0xFF, 0xFF, 0xF7, 0xC7, 0xF3, 0xFE, 0x07, 0xC1, 0xFC, 0x0F, 0x03, 0xF8,
  0x0E, 0x07, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80,
  0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E,
  0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x38,
  0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0x00,
  0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x80, 0xF8, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x0F,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x07,
  0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xCF,
  0x80, 0x1F, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0x7F,
  0xF0, 0x3C, 0x38, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0x80, 0x3C, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F,
  0x7C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x3C, 0x00, 0x3C,
  0xF8, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xF0, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFB, 0xC0, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xE0, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xC7, 0xC0, 0x02, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7D, 0x00, 0x03, 0xCF, 0x00,
  0x7E, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x03,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x3F, 0x00, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x0F, 0xBC, 0x00,
  0x07, 0x9E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE1, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xC3, 0xC0,
  0x01, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xF7, 0x80, 0xE0, 0x39, 0xE0, 0x78, 0x0E, 0x78, 0x1F, 0x07, 0x9E, 0x07,
  0xC1, 0xE3, 0x83, 0xF0, 0x78, 0xF0, 0xFE, 0x1E, 0x3C, 0x3B, 0x87, 0x8F,
  0x1E, 0xE1, 0xC3, 0xC7, 0x3C, 0x70, 0xF1, 0xC7, 0x3C, 0x1C, 0xF1, 0xCF,
  0x07, 0xB8, 0x7B, 0xC1, 0xFE, 0x0E, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x1E,
  0x07, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x0F, 0x80, 0x07, 0xC7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00,
  0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF1,
  0xE0, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xE0, 0x07, 0x3F, 0xF8, 0x07, 0x3D, 0xFE, 0x0E, 0x70, 0x3F,
  0xBE, 0x70, 0x1F, 0xFC, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF0,
};

const GFXglyph UbuntuSansMono_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 36, 29, 11, -35 },
  { 33, 12, 14, 29, 8, -39 },
  { 54, 25, 35, 29, 2, -35 },
  { 164, 22, 46, 29, 3, -40 },
  { 291, 26, 37, 29, 1, -36 },
  { 412, 25, 36, 29, 2, -36 },
  { 525, 4, 15, 29, 12, -39 },
  { 533, 15, 49, 29, 7, -40 },
  { 625, 15, 49, 29, 7, -40 },
  { 717, 22, 20, 29, 3, -35 },
  { 772, 23, 24, 29, 3, -27 },
  { 841, 11, 16, 29, 9, -8 },
  { 863, 12, 3, 29, 8, -16 },
  { 868, 8, 9, 29, 10, -8 },
  { 877, 20, 49, 29, 4, -40 },
  { 1000, 23, 37, 29, 3, -36 },
  { 1107, 20, 35, 29, 5, -35 },
  { 1195, 21, 36, 29, 4, -36 },
  { 1290, 21, 37, 29, 4, -36 },
  { 1388, 24, 35, 29, 2, -35 },
  { 1493, 21, 36, 29, 4, -35 },
  { 1588, 23, 37, 29, 3, -36 },
  { 1695, 22, 35, 29, 4, -35 },
  { 1792, 22, 37, 29, 3, -36 },
  { 1894, 22, 36, 29, 3, -36 },
  { 1993, 8, 28, 29, 10, -27 },
  { 2021, 11, 35, 29, 7, -27 },
  { 2070, 23, 23, 29, 3, -26 },
  { 2137, 23, 14, 29, 3, -22 },
  { 2178, 23, 23, 29, 3, -26 },
  { 2245, 17, 37, 29, 6, -36 },
  { 2324, 24, 44, 29, 3, -36 },
  { 2456, 27, 35, 29, 1, -35 },
  { 2575, 22, 36, 29, 3, -36 },
  { 2674, 23, 37, 29, 3, -36 },
  { 2781, 23, 36, 29, 3, -36 },
  { 2885, 20, 35, 29, 6, -35 },
  { 2973, 19, 35, 29, 6, -35 },
  { 3057, 23, 37, 29, 3, -36 },
  { 3164, 23, 35, 29, 3, -35 },
  { 3265, 17, 35, 29, 6, -35 },
  { 3340, 21, 36, 29, 3, -35 },
  { 3435, 24, 35, 29, 4, -35 },
  { 3540, 20, 35, 29, 6, -35 },
  { 3628, 25, 35, 29, 2, -35 },
  { 3738, 22, 35, 29, 3, -35 },
  { 3835, 25, 37, 29, 2, -36 },
  { 3951, 21, 36, 29, 5, -36 },
  { 4046, 25, 45, 29, 2, -36 },
  { 4187, 23, 36, 29, 3, -36 },
  { 4291, 22, 37, 29, 3, -36 },
  { 4393, 24, 35, 29, 2, -35 },
  { 4498, 23, 36, 29, 3, -35 },
  { 4602, 27, 35, 29, 1, -35 },
  { 4721, 25, 35, 29, 2, -35 },
  { 4831, 25, 35, 29, 2, -35 },
  { 4941, 27, 35, 29, 1, -35 },
  { 5060, 23, 35, 29, 3, -35 },
  { 5161, 13, 49, 29, 9, -40 },
  { 5241, 20, 49, 29, 4, -40 },
  { 5364, 13, 49, 29, 7, -40 },
  { 5444, 23, 18, 29, 3, -35 },
  { 5496, 28, 3, 29, 0, 6 },
  { 5507, 8, 10, 29, 10, -40 },
  { 5517, 21, 28, 29, 4, -27 },
  { 5591, 22, 41, 29, 4, -40 },
  { 5704, 23, 28, 29, 3, -27 },
  { 5785, 22, 41, 29, 2, -40 },
  { 5898, 24, 28, 29, 2, -27 },
  { 5982, 23, 40, 29, 4, -40 },
  { 6097, 22, 37, 29, 2, -27 },
  { 6199, 21, 40, 29, 4, -40 },
  { 6304, 22, 40, 29, 3, -39 },
  { 6414, 18, 49, 29, 4, -39 },
  { 6525, 23, 40, 29, 4, -40 },
  { 6640, 22, 40, 29, 3, -39 },
  { 6750, 23, 27, 29, 3, -27 },
  { 6828, 21, 27, 29, 4, -27 },
  { 6899, 24, 28, 29, 2, -27 },
  { 6983, 22, 36, 29, 4, -27 },
  { 7082, 22, 36, 29, 2, -27 },
  { 7181, 19, 27, 29, 6, -27 },
  { 7246, 21, 28, 29, 4, -27 },
  { 7320, 21, 36, 29, 4, -35 },
  { 7415, 20, 27, 29, 4, -26 },
  { 7483, 25, 26, 29, 2, -26 },
  { 7565, 26, 26, 29, 1, -26 },
  { 7650, 25, 26, 29, 2, -26 },
  { 7732, 24, 36, 29, 2, -26 },
  { 7840, 20, 26, 29, 4, -26 },
  { 7905, 19, 49, 29, 5, -40 },
  { 8022, 4, 49, 29, 12, -40 },
  { 8047, 20, 49, 29, 4, -40 },
  { 8170, 24, 8, 29, 2, -19 },
};

const GFXfont UbuntuSansMono_Regular51pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular51pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular51pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _UBUNTUSANSMONO_REGULAR51PT7B_H_
