#ifndef _UBUNTUSANSMONO_REGULAR33PT7B_H_
#define _UBUNTUSANSMONO_REGULAR33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x60, 0x00, 0x0F, 0xFF,
  0xF0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x43, 0x03, 0x06,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x06, 0x0C, 0x06, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x0C, 0x18, 0x0C, 0x18, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x18, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x70, 0x38, 0x70,
  0x38, 0x60, 0x30, 0x60, 0x30, 0x60, 0x70, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0xE0, 0x7F, 0xE3, 0xC7, 0x9C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x74, 0x03,
  0xFF, 0xFE, 0x7F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x7C, 0x03, 0x37, 0x03, 0x31, 0x83, 0x98, 0xE1, 0x8C, 0x31, 0xC6,
  0x18, 0xC3, 0x0C, 0xC1, 0x8E, 0xE0, 0xC6, 0x60, 0x3F, 0x70, 0x0F, 0x30,
  0x00, 0x30, 0x00, 0x39, 0xE0, 0x19, 0xF8, 0x1D, 0xCC, 0x0C, 0xC6, 0x0C,
  0x61, 0x8E, 0x30, 0xC6, 0x18, 0x67, 0x0C, 0x33, 0x06, 0x33, 0x01, 0x9B,
  0x80, 0xF8, 0x00, 0x10, 0x0F, 0xC0, 0x1F, 0xE0, 0x38, 0x70, 0x38, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x70, 0x38, 0x60, 0x1C, 0xE0, 0x1F, 0xC0,
  0x0F, 0x00, 0x1F, 0x06, 0x3B, 0x8E, 0x73, 0xCE, 0x71, 0xEC, 0x60, 0xEC,
  0xE0, 0x7C, 0xE0, 0x38, 0xE0, 0x3C, 0x70, 0x3C, 0x78, 0xFE, 0x3F, 0xE7,
  0x1F, 0xC7, 0xFF, 0xED, 0xB6, 0xC0, 0x00, 0x80, 0x60, 0x3C, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x20, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F,
  0x01, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x63, 0x1F, 0xFD,
  0xF7, 0xFF, 0x80, 0xE0, 0x07, 0xC0, 0x3B, 0x81, 0xCF, 0x0F, 0x1C, 0x18,
  0x70, 0x20, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x7C, 0xF9,
  0xF3, 0xE1, 0xC7, 0x1C, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0x77, 0xBF, 0xFF,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xE1, 0xE3, 0x81,
  0xC7, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x06, 0xE0, 0x0D, 0xC7, 0x1F,
  0x9E, 0x3F, 0x3C, 0x7E, 0x38, 0xFC, 0x01, 0xF8, 0x03, 0x70, 0x06, 0xE0,
  0x1C, 0xC0, 0x39, 0xC0, 0x73, 0x81, 0xC3, 0x87, 0x83, 0xFE, 0x03, 0xF8,
  0x00, 0x80, 0x01, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x07, 0xB8, 0x79, 0xC1,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0xCF, 0x07, 0x90, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF,
  0xC7, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0xFC, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x40, 0x79, 0xFF, 0xCF,
  0xFE, 0x01, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xD8, 0x03, 0x98, 0x07, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x18, 0x18,
  0x18, 0x38, 0x18, 0x30, 0x18, 0x70, 0x18, 0x60, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x3F, 0xF9, 0xFF, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x7C, 0x0F, 0x7F,
  0xF3, 0xFF, 0x01, 0x80, 0x00, 0x78, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xCF, 0x83, 0xFF,
  0xC7, 0xC3, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F,
  0xC0, 0x19, 0x80, 0x73, 0x80, 0xE3, 0x83, 0x87, 0xFF, 0x03, 0xF8, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0x83, 0x9C,
  0x07, 0x60, 0x1D, 0x80, 0x76, 0x01, 0xDC, 0x07, 0x70, 0x18, 0xE0, 0xE1,
  0xFF, 0x07, 0xF8, 0x39, 0xF9, 0xC0, 0xE6, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0x70, 0x3D, 0xFF, 0xE1, 0xFF, 0x00, 0xC0,
  0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x37, 0x00, 0xDF, 0x0F, 0x3F, 0xFC, 0x3F,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x07,
  0xC1, 0xFE, 0x07, 0xC0, 0x00, 0x77, 0xBF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x7B, 0xFF, 0xF0, 0x1C, 0x78, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC7, 0xCF, 0x9F, 0x3E, 0x1C, 0x71, 0xCF, 0x1C, 0x00,
  0x00, 0x02, 0x00, 0x18, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0x00, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x1E, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0x9F, 0xFA, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x7C, 0x07, 0x00, 0x07,
  0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x67, 0x00, 0xEE, 0x00, 0xD8, 0x01,
  0xF0, 0x1F, 0xE1, 0xFF, 0xC7, 0x9F, 0x8E, 0x1F, 0x38, 0x3E, 0x70, 0x7C,
  0xE0, 0xF9, 0xC1, 0xF3, 0x83, 0xE7, 0x07, 0xC6, 0x0F, 0x8E, 0x1F, 0x0F,
  0xF7, 0x0F, 0xEE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x10,
  0x1F, 0xE0, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0E,
  0xC0, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x71, 0x80, 0x18, 0x70, 0x06, 0x1C,
  0x03, 0x83, 0x00, 0xC0, 0xE0, 0x30, 0x38, 0x1C, 0x06, 0x06, 0x01, 0x81,
  0x80, 0x70, 0xFF, 0xFC, 0x3F, 0xFF, 0x0C, 0x00, 0xE3, 0x00, 0x39, 0xC0,
  0x06, 0x70, 0x01, 0x98, 0x00, 0x7E, 0x00, 0x1C, 0xFF, 0xC3, 0xFF, 0xCE,
  0x0F, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0xE0, 0x3B,
  0x83, 0xCF, 0xFE, 0x3F, 0xFC, 0xE0, 0x7B, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x7B, 0xFF, 0xCF, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x78, 0x31, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x43, 0xFF, 0xC1, 0xFF, 0x00, 0x20, 0xFF, 0x01,
  0xFF, 0xC3, 0x87, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x03, 0xB8, 0x07, 0x70,
  0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x06, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x01, 0xCE,
  0x0F, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0xB0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xF9,
  0xFF, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xEF, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x78,
  0x31, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0x60, 0x0E, 0xE0, 0x1D, 0xC0, 0x39, 0xC0, 0x71, 0xC0, 0xE1, 0xFF,
  0xC1, 0xFF, 0x80, 0x60, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0x80,
  0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x76, 0x07, 0x7F, 0xF9, 0xFF, 0x00, 0x80, 0xC0,
  0x1D, 0x80, 0x73, 0x01, 0xE6, 0x03, 0x8C, 0x0E, 0x18, 0x38, 0x30, 0xE0,
  0x63, 0x80, 0xCE, 0x01, 0xBC, 0x03, 0xF0, 0x07, 0xE0, 0x0D, 0xE0, 0x19,
  0xE0, 0x30, 0xE0, 0x60, 0xE0, 0xC0, 0xE1, 0x81, 0xE3, 0x01, 0xE6, 0x01,
  0xCC, 0x01, 0xD8, 0x03, 0xB0, 0x03, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x38,
  0x1E, 0x38, 0x1E, 0x3C, 0x1E, 0x2C, 0x1E, 0x6C, 0x36, 0x6E, 0x36, 0x66,
  0x36, 0x66, 0x66, 0x67, 0x66, 0x63, 0x67, 0x63, 0xC7, 0x61, 0xC7, 0x61,
  0xC7, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3E, 0xC0, 0xFB, 0x83, 0xE6, 0x0F, 0x9C,
  0x3E, 0x30, 0xF8, 0xE3, 0xE1, 0x8F, 0x87, 0x3E, 0x0C, 0xF8, 0x3B, 0xE0,
  0x6F, 0x81, 0xBE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xC0,
  0x07, 0xF0, 0x1F, 0xF8, 0x3C, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07,
  0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x07,
  0x70, 0x0E, 0x38, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x80,
  0xFF, 0x83, 0xFF, 0x8E, 0x0F, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0xB8, 0x3C, 0xFF, 0xE3, 0xFF,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3C, 0x1C, 0x38,
  0x0E, 0x70, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0x60, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x38, 0x0E, 0x3C, 0x1C, 0x1F,
  0xF8, 0x0F, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0E, 0xFF, 0xC1, 0xFF, 0xC3, 0x83, 0xC7, 0x01, 0xCE, 0x01,
  0x9C, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x33, 0x80, 0xE7,
  0x0F, 0x8F, 0xFE, 0x1F, 0xF8, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x61, 0xC0,
  0xE3, 0x80, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x80, 0x0F,
  0xF8, 0xFF, 0xF3, 0x81, 0x9C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x60, 0x3F,
  0xFF, 0xE7, 0xFE, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1B, 0x80,
  0x73, 0x80, 0xE7, 0x83, 0x87, 0xFF, 0x07, 0xFC, 0x00, 0x80, 0xE0, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x06, 0x30, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x30, 0xE0, 0x0C, 0x18, 0x07, 0x07, 0x01, 0x81, 0xC0, 0x60, 0x30,
  0x38, 0x0E, 0x0E, 0x03, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x07, 0x18,
  0x00, 0xCE, 0x00, 0x33, 0x80, 0x0E, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0x61, 0xC7, 0x63, 0xC7,
  0x63, 0xC7, 0x63, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x76, 0x6E, 0x36,
  0x6C, 0x36, 0x6C, 0x3E, 0x2C, 0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x0C,
  0xF0, 0x07, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x0E, 0x30, 0x06, 0x70, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x38, 0x18, 0x1C,
  0x38, 0x1C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xF0, 0x01,
  0xDC, 0x00, 0x67, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x07, 0x01, 0xC1,
  0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0E,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF, 0x03, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x76, 0x00, 0xCE, 0x03, 0x8C, 0x0E, 0x1C, 0x18,
  0x1C, 0x70, 0x18, 0xC0, 0x3B, 0x80, 0x36, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x43, 0x87, 0x0C, 0x38, 0x70, 0x80, 0x3F, 0xE0, 0xFF, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xFF, 0x3F, 0xFD,
  0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xCF, 0xFF,
  0x1F, 0xFC, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x7F, 0x0F, 0xFE, 0x3C, 0x1C, 0xC0,
  0x3B, 0x00, 0xEC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xEC, 0x07, 0xB0, 0x3C, 0xFF, 0xE3, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xF8, 0xF0, 0x13, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x01, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x7F, 0xF3, 0xFF, 0xDE, 0x0F, 0x70, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01,
  0xDF, 0x07, 0x3F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE3,
  0x80, 0xEE, 0x00, 0xDC, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x02, 0x1F, 0xFC,
  0x0F, 0xF8, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x70, 0x11, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x1F, 0xFC, 0xFF, 0xF7, 0x81, 0xDC, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x1D, 0xE0, 0xF3, 0xFF, 0xC7, 0xFF, 0x02, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x40, 0x79, 0xFF, 0xC7, 0xFC, 0x00, 0x20, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFE,
  0x3F, 0xF9, 0x80, 0xEC, 0x07, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x40, 0xFF, 0x01, 0xFC, 0x01,
  0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x7C, 0x1D, 0xFF, 0x9F, 0xC0, 0x20, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x7B, 0x01, 0xC6, 0x07, 0x0C, 0x1C, 0x18, 0x70, 0x33, 0xC0, 0x6F, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0x7C, 0x06, 0x3C, 0x0C, 0x3C, 0x18, 0x3C, 0x30,
  0x3C, 0x60, 0x3C, 0xC0, 0x3D, 0x80, 0x3C, 0xFF, 0x03, 0xFC, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x40,
  0xFF, 0x01, 0xFC, 0x10, 0x21, 0xFD, 0xF3, 0xFF, 0xF6, 0x1C, 0x7C, 0x38,
  0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0C, 0xFF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0xEC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x38, 0x0F, 0xE0, 0x7F, 0xE1, 0xE0, 0xE3, 0x80,
  0xEE, 0x01, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x6E, 0x01, 0xCE, 0x03, 0x9E, 0x1E, 0x1F, 0xF8, 0x0F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x8C, 0x0F, 0x30, 0x0E, 0xC0, 0x3B, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3B,
  0x00, 0xEF, 0x0F, 0x3F, 0xF8, 0xDF, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xF7, 0x81, 0xDC,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0x77, 0x83, 0xCF, 0xFF, 0x1F, 0xFC,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x3F, 0xF3, 0xFF, 0xB8, 0x05, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0x01, 0xFF, 0xFE, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x10, 0xFF, 0x83, 0xFC, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x1D, 0xC0, 0xEF, 0xFF, 0x1F, 0xF8, 0xE0, 0x07, 0x70,
  0x07, 0x70, 0x06, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x0C, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x07, 0x60, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xDC, 0x00, 0x6E, 0x18, 0x37, 0x0E, 0x19, 0x87, 0x1C, 0xC7, 0x8E,
  0x63, 0x67, 0x3B, 0xB3, 0x1D, 0x99, 0x8E, 0xC6, 0xC3, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x0C, 0x00, 0xF0, 0x0F, 0x38, 0x0E,
  0x3C, 0x1C, 0x1C, 0x38, 0x0E, 0x30, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x38, 0x1C, 0x1C, 0x38, 0x1C,
  0x38, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x18, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x1C,
  0x0E, 0x18, 0x06, 0x38, 0x07, 0x38, 0x03, 0x30, 0x03, 0xF0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x80,
  0x7F, 0x00, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x3F, 0xC1,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x1F, 0x00, 0xF8, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1F, 0x00, 0xF0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0xFE, 0x0F, 0xC0, 0x3C, 0x06, 0xFE, 0x0F,
  0x1F, 0x76, 0x0F, 0xE0, 0x07, 0x00,
};

const GFXglyph UbuntuSansMono_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 23, 18, 7, -23 },
  { 13, 8, 9, 18, 5, -25 },
  { 22, 16, 23, 18, 1, -23 },
  { 68, 14, 30, 18, 2, -26 },
  { 121, 17, 24, 18, 1, -23 },
  { 172, 16, 23, 18, 1, -23 },
  { 218, 3, 9, 18, 8, -25 },
  { 222, 10, 32, 18, 4, -26 },
  { 262, 10, 32, 18, 4, -26 },
  { 302, 14, 14, 18, 2, -23 },
  { 327, 15, 16, 18, 2, -18 },
  { 357, 7, 10, 18, 6, -5 },
  { 366, 8, 3, 18, 5, -11 },
  { 369, 5, 5, 18, 7, -5 },
  { 373, 13, 32, 18, 3, -26 },
  { 425, 15, 24, 18, 2, -23 },
  { 470, 13, 23, 18, 3, -23 },
  { 508, 14, 23, 18, 2, -23 },
  { 549, 14, 24, 18, 2, -23 },
  { 591, 16, 23, 18, 1, -23 },
  { 637, 13, 24, 18, 3, -23 },
  { 676, 15, 24, 18, 2, -23 },
  { 721, 14, 23, 18, 3, -23 },
  { 762, 14, 24, 18, 2, -23 },
  { 804, 14, 23, 18, 2, -23 },
  { 845, 5, 17, 18, 7, -17 },
  { 856, 7, 22, 18, 5, -17 },
  { 876, 15, 15, 18, 2, -17 },
  { 905, 15, 9, 18, 2, -14 },
  { 922, 15, 15, 18, 2, -17 },
  { 951, 11, 23, 18, 4, -23 },
  { 983, 15, 28, 18, 2, -23 },
  { 1036, 18, 23, 18, 0, -23 },
  { 1088, 14, 23, 18, 2, -23 },
  { 1129, 15, 24, 18, 2, -23 },
  { 1174, 15, 23, 18, 2, -23 },
  { 1218, 13, 23, 18, 4, -23 },
  { 1256, 12, 23, 18, 4, -23 },
  { 1291, 15, 24, 18, 2, -23 },
  { 1336, 15, 23, 18, 2, -23 },
  { 1380, 11, 23, 18, 4, -23 },
  { 1412, 13, 24, 18, 2, -23 },
  { 1451, 15, 23, 18, 3, -23 },
  { 1495, 13, 23, 18, 4, -23 },
  { 1533, 16, 23, 18, 1, -23 },
  { 1579, 14, 23, 18, 2, -23 },
  { 1620, 16, 24, 18, 1, -23 },
  { 1668, 14, 23, 18, 3, -23 },
  { 1709, 16, 29, 18, 1, -23 },
  { 1767, 15, 23, 18, 2, -23 },
  { 1811, 14, 24, 18, 2, -23 },
  { 1853, 15, 23, 18, 2, -23 },
  { 1897, 15, 24, 18, 2, -23 },
  { 1942, 18, 23, 18, 0, -23 },
  { 1994, 16, 23, 18, 1, -23 },
  { 2040, 16, 23, 18, 1, -23 },
  { 2086, 18, 23, 18, 0, -23 },
  { 2138, 15, 23, 18, 2, -23 },
  { 2182, 8, 32, 18, 6, -26 },
  { 2214, 13, 32, 18, 3, -26 },
  { 2266, 9, 32, 18, 4, -26 },
  { 2302, 15, 12, 18, 2, -23 },
  { 2325, 18, 2, 18, 0, 4 },
  { 2330, 6, 7, 18, 6, -26 },
  { 2336, 14, 17, 18, 2, -17 },
  { 2366, 14, 26, 18, 3, -26 },
  { 2412, 15, 17, 18, 2, -17 },
  { 2444, 14, 26, 18, 2, -26 },
  { 2490, 15, 17, 18, 2, -17 },
  { 2522, 15, 26, 18, 3, -26 },
  { 2571, 14, 23, 18, 2, -17 },
  { 2612, 13, 26, 18, 3, -26 },
  { 2655, 14, 25, 18, 2, -25 },
  { 2699, 11, 31, 18, 3, -25 },
  { 2742, 15, 26, 18, 3, -26 },
  { 2791, 14, 25, 18, 2, -25 },
  { 2835, 15, 18, 18, 2, -18 },
  { 2869, 13, 17, 18, 3, -17 },
  { 2897, 15, 17, 18, 2, -17 },
  { 2929, 14, 23, 18, 3, -17 },
  { 2970, 14, 23, 18, 2, -17 },
  { 3011, 12, 17, 18, 4, -17 },
  { 3037, 13, 17, 18, 3, -17 },
  { 3065, 13, 22, 18, 3, -22 },
  { 3101, 13, 17, 18, 3, -17 },
  { 3129, 16, 17, 18, 1, -17 },
  { 3163, 17, 17, 18, 1, -17 },
  { 3200, 16, 17, 18, 1, -17 },
  { 3234, 16, 23, 18, 1, -17 },
  { 3280, 13, 17, 18, 3, -17 },
  { 3308, 13, 32, 18, 3, -26 },
  { 3360, 2, 32, 18, 8, -26 },
  { 3368, 12, 32, 18, 3, -26 },
  { 3416, 15, 5, 18, 2, -12 },
};

const GFXfont UbuntuSansMono_Regular33pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular33pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular33pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUSANSMONO_REGULAR33PT7B_H_
