#ifndef _UBUNTUSANSMONO_REGULAR39PT7B_H_
#define _UBUNTUSANSMONO_REGULAR39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC3,
  0x0C, 0x30, 0xC0, 0x00, 0x00, 0x07, 0x3E, 0xFF, 0xE7, 0x88, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1B, 0x86, 0xE1, 0x90, 0x64, 0x08,
  0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x03, 0x83,
  0x80, 0x38, 0x38, 0x03, 0x83, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0xF0, 0x0E,
  0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0x81, 0xC0,
  0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x78, 0x04,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x0F,
  0xFC, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x08, 0x00, 0x03, 0xF0, 0x0E, 0x77, 0x00, 0xCE,
  0x38, 0x1C, 0xE1, 0x83, 0x8C, 0x18, 0x38, 0xC1, 0x87, 0x0C, 0x18, 0x60,
  0xC1, 0x8E, 0x0E, 0x19, 0xC0, 0xE3, 0x9C, 0x07, 0x33, 0x80, 0x7F, 0x30,
  0x01, 0xE7, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x78, 0x01, 0xCF, 0xC0, 0x19,
  0xCE, 0x03, 0x9C, 0x70, 0x71, 0x87, 0x07, 0x18, 0x70, 0xE1, 0x83, 0x0C,
  0x18, 0x31, 0xC1, 0x87, 0x38, 0x18, 0x73, 0x81, 0xC6, 0x70, 0x0E, 0xEE,
  0x00, 0xFC, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xE1, 0xC0, 0x1C, 0x1E, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1E, 0x38, 0x00, 0xE7, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0xC1, 0xDE, 0x1C, 0x38, 0xE1, 0x87,
  0x8F, 0x18, 0x70, 0x7B, 0x87, 0x03, 0xF8, 0x70, 0x1F, 0x0F, 0x00, 0xF0,
  0x70, 0x07, 0x07, 0x00, 0xF8, 0x78, 0x1F, 0xC3, 0xE7, 0xDC, 0x1F, 0xF9,
  0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x6D, 0xB0, 0x00, 0x40, 0x0C, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0xE0, 0x04, 0x20, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x70,
  0x02, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0xC1, 0x82,
  0xF1, 0x8F, 0xFD, 0xBF, 0x7F, 0xFE, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x3C, 0x18, 0x38, 0x08, 0x10, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F, 0x1F, 0x07,
  0x0E, 0x1E, 0xFC, 0xF8, 0xE0, 0xFF, 0xFF, 0xC0, 0x33, 0xEF, 0xFF, 0xFD,
  0xE2, 0x00, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x78, 0x78, 0x3C, 0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x79, 0xC0, 0x0E,
  0x70, 0x03, 0x9C, 0x00, 0xEF, 0x00, 0x3B, 0xC3, 0x0F, 0xF1, 0xE3, 0xFC,
  0xFC, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF0, 0xC3, 0xFC, 0x00, 0xFF, 0x00,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xE7, 0x80, 0x70, 0xE0, 0x1C,
  0x3C, 0x0F, 0x07, 0x87, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x03, 0xFC, 0x1F, 0x38, 0x38,
  0x70, 0x40, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0x07, 0x80, 0x3F, 0xF0, 0x7F, 0xF8, 0xF8, 0x7C, 0xE0,
  0x1E, 0x40, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x80, 0x3F, 0xF0, 0xFF, 0xF8, 0x70, 0x7C, 0x40, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x80,
  0x1E, 0xE0, 0x7E, 0xFF, 0xFC, 0x7F, 0xF0, 0x02, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1E, 0x70, 0x7E,
  0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xDF, 0xF0, 0x7F, 0xFE, 0x1F,
  0x07, 0xCF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xE7, 0x00,
  0x3D, 0xC0, 0x0F, 0x70, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x78, 0xF0, 0x1C,
  0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x07,
  0xFF, 0x87, 0x83, 0xE3, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x03, 0xB8, 0x03, 0xDE, 0x01, 0xC7, 0x81, 0xE1, 0xE1, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3C, 0xFC, 0x3C, 0x1F, 0x3C, 0x03, 0xDC, 0x00, 0xEE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x78, 0x07,
  0x9E, 0x07, 0x8F, 0xFF, 0x81, 0xFF, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00,
  0x3B, 0xC0, 0x1C, 0xF8, 0x7E, 0x3F, 0xFF, 0x0F, 0xFB, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x2F, 0xF8, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x33, 0xEF, 0xFF,
  0xFD, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3E, 0xFF, 0xFF, 0xDE,
  0x20, 0x0C, 0x3E, 0x3F, 0x3F, 0x3F, 0x1E, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x1E, 0x3F, 0x3F, 0x3F, 0x1F, 0x0F, 0x0E, 0x1E,
  0xFC, 0xF8, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x1C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x03,
  0xFF, 0x87, 0xFF, 0x18, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x04,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03,
  0x8F, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x01, 0xF7,
  0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0xF1, 0xFC, 0x78, 0x7F, 0x1C, 0x1F, 0x8F,
  0x07, 0xE3, 0xC1, 0xF8, 0xF0, 0x7F, 0x3C, 0x1F, 0xCF, 0x07, 0xF1, 0xC1,
  0xFC, 0x70, 0x77, 0x1E, 0x1D, 0xC3, 0xE7, 0x78, 0x7F, 0xDE, 0x0F, 0xE3,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x38,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x0E,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0x80,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B,
  0x80, 0x01, 0xFC, 0x00, 0x0E, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x3F, 0x9C,
  0x03, 0xEE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x07, 0xB8, 0x07, 0x9C, 0x3F, 0x8F, 0xFF, 0x07, 0xFF, 0xE3, 0x80,
  0xFD, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0, 0xFF, 0x7F, 0xFE,
  0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x3E, 0x0E,
  0x1E, 0x00, 0x8F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x43,
  0xE0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0E, 0x1F, 0xC3, 0x80, 0x78, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00,
  0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00,
  0xF3, 0x80, 0x78, 0xFB, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xE0,
  0x7F, 0xFC, 0x3E, 0x0E, 0x1E, 0x00, 0x8F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0x73, 0x80, 0x1C, 0xF0,
  0x07, 0x1E, 0x01, 0xC3, 0xE0, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x60, 0x1E, 0x78, 0x3E,
  0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0x00, 0xE0, 0x03, 0xF8, 0x01, 0xCE, 0x00,
  0xF3, 0x80, 0x78, 0xE0, 0x3C, 0x38, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC0,
  0xE1, 0xE0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xBC, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x0E, 0xF8, 0x03, 0x9F, 0x00, 0xE1, 0xE0, 0x38, 0x3C, 0x0E, 0x07,
  0x83, 0x80, 0xF0, 0xE0, 0x1C, 0x38, 0x07, 0x8E, 0x00, 0xF3, 0x80, 0x1E,
  0xE0, 0x07, 0xB8, 0x00, 0xFE, 0x00, 0x1C, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0x07, 0x1E, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x3E, 0x7C, 0x0D,
  0x9B, 0x03, 0x66, 0xE1, 0xD9, 0xB8, 0x66, 0x66, 0x19, 0x99, 0xCE, 0x6E,
  0x73, 0x1B, 0x8C, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87,
  0x87, 0xE0, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1C, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xDC, 0x07, 0xDC, 0x07, 0xCE, 0x07, 0xCF, 0x07, 0xC7, 0x07, 0xC7, 0x07,
  0xC3, 0x87, 0xC3, 0x87, 0xC1, 0xC7, 0xC1, 0xC7, 0xC0, 0xE7, 0xC0, 0xE7,
  0xC0, 0x77, 0xC0, 0x77, 0xC0, 0x37, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x60, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0x83, 0x80, 0x3C, 0x78,
  0x01, 0xC7, 0x00, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x1C, 0x03, 0x81, 0xF0,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3C, 0x1F, 0x9E, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x00, 0xEF, 0x00,
  0xF7, 0x81, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0x83, 0x80, 0x3C, 0x78, 0x01,
  0xC7, 0x00, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x3C, 0x3C, 0x03, 0x81, 0xF0, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0x0F, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x3C, 0x01,
  0xCF, 0x00, 0x73, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73,
  0xC0, 0x1C, 0xF0, 0x0E, 0x3C, 0x7F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xF0,
  0x70, 0x3C, 0x0E, 0x0F, 0x03, 0x83, 0xC0, 0x70, 0xF0, 0x1E, 0x3C, 0x03,
  0x8F, 0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1E, 0x70, 0x02, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x0F, 0xF0, 0x3E, 0xFF, 0xFC, 0x7F, 0xF8, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x39, 0xE0, 0x1E, 0x3E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0x80, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x3C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0,
  0x38, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x1C, 0x1F, 0x87,
  0x87, 0xE1, 0xE1, 0xF8, 0xF8, 0x7E, 0x37, 0x1B, 0x8C, 0xC6, 0xE7, 0x31,
  0xB9, 0xCE, 0x66, 0x61, 0x99, 0xB8, 0x66, 0x6E, 0x1D, 0x9B, 0x07, 0x67,
  0xC0, 0xD9, 0xF0, 0x3E, 0x78, 0x0F, 0x9E, 0x01, 0xC7, 0x80, 0x70, 0x70,
  0x01, 0xE3, 0x80, 0x1C, 0x38, 0x03, 0xC1, 0xC0, 0x38, 0x1E, 0x07, 0x80,
  0xE0, 0x70, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x9C, 0x00, 0x3B, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3B, 0xC0, 0x07, 0x9C, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0,
  0x70, 0x1E, 0x07, 0x01, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0x80, 0x1C, 0x78,
  0x01, 0xC7, 0x00, 0x1E, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0x70, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x1C, 0x3C, 0x03,
  0x81, 0xC0, 0x38, 0x1E, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x0E, 0x00, 0x71,
  0xE0, 0x03, 0x9C, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x0E,
  0x0E, 0x01, 0xC3, 0x80, 0x71, 0xC0, 0x0E, 0xE0, 0x03, 0x98, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x61, 0xE1, 0xC1, 0xC1, 0xC1, 0xC3,
  0x00, 0x03, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x20, 0x3E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F,
  0x7F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0x7C, 0x0F, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0xC0, 0x3B, 0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xE7, 0x80,
  0x73, 0x80, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0x70, 0x07, 0xB8, 0x07, 0x9F, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x06, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xFC, 0x38, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xE1, 0xC3, 0xFE, 0xE3, 0xFF,
  0xF3, 0xE1, 0xFB, 0xC0, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0x70, 0x03, 0xBC, 0x01, 0xCF, 0x00, 0xE3, 0xE1, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x3C,
  0x38, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0x7C, 0x1E, 0x01,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xC0, 0xF7, 0x80, 0x3B, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x78, 0x07, 0x9F,
  0xBF, 0xC7, 0xFF, 0xE1, 0xFF, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x3E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8,
  0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xE7, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x39, 0xE7, 0xE7, 0xFF, 0x3F, 0xF0,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x7B, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x1E, 0x0E, 0x0F, 0x03, 0x87, 0x80,
  0xE3, 0xC0, 0x3B, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xEF, 0x80, 0x39,
  0xF0, 0x0E, 0x1E, 0x03, 0x83, 0xC0, 0xE0, 0x78, 0x38, 0x0F, 0x0E, 0x01,
  0xE3, 0x80, 0x3C, 0xE0, 0x07, 0xB8, 0x00, 0xF0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xE7, 0x01, 0xFF, 0x00, 0xFF, 0x3C, 0x0C, 0x3F, 0xCF,
  0xCF, 0xFF, 0xFB, 0x87, 0x8F, 0xE1, 0xC1, 0xF8, 0x38, 0x7E, 0x0E, 0x1F,
  0x83, 0x87, 0xE0, 0xE1, 0xF8, 0x38, 0x7E, 0x0E, 0x1F, 0x83, 0x87, 0xE0,
  0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xFF, 0xF0,
  0xFF, 0xFC, 0xF0, 0x3E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x38,
  0x0F, 0x1C, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x39,
  0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x03, 0xC3, 0xF3, 0xE0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0x07, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1E, 0x0F, 0xCE, 0x01,
  0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0E,
  0xE0, 0x0F, 0x78, 0x0F, 0x3F, 0x9F, 0x9F, 0xFF, 0x8E, 0xFF, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0xF3, 0xC0,
  0x3B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0E, 0xE0, 0x07,
  0x78, 0x03, 0x9E, 0x03, 0xCF, 0xCF, 0xE3, 0xFF, 0xF0, 0x7F, 0xB8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x3F, 0xFE, 0x78, 0x04, 0x70,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x0F, 0xF0, 0x1E, 0xFF, 0xFC, 0x7F, 0xF8, 0x01, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE7, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78,
  0x07, 0x3E, 0x1F, 0x3F, 0xFF, 0x0F, 0xFE, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x3D, 0xC0, 0x0E, 0x70, 0x03, 0x9E, 0x01, 0xE3, 0x80, 0x70, 0xE0,
  0x1C, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0xCE, 0x00, 0x73, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x06, 0xE0, 0x00, 0x67, 0x06, 0x0E, 0x70, 0xF0, 0xE7, 0x0F, 0x0E,
  0x70, 0xF0, 0xE7, 0x1F, 0x8E, 0x71, 0x98, 0xC3, 0x19, 0x9C, 0x3B, 0x9D,
  0xC3, 0xB0, 0xDC, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x1C,
  0x07, 0x80, 0xE0, 0x70, 0x0F, 0x0E, 0x00, 0x79, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0x9E, 0x00, 0x70, 0xE0, 0x0E, 0x0F, 0x01, 0xE0, 0x78, 0x1C, 0x03,
  0x83, 0x80, 0x1C, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x01, 0xDC, 0x00,
  0xF7, 0x00, 0x39, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0xC0, 0x70,
  0x70, 0x1C, 0x1C, 0x0F, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x87, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x03, 0xFC, 0x0F, 0xF8, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0xDF, 0xF0, 0x76, 0x3E, 0x3B, 0x83, 0xFE, 0xC0, 0x3F, 0x00, 0x02,
  0x00,
};

const GFXglyph UbuntuSansMono_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 28, 22, 8, -27 },
  { 22, 10, 11, 22, 6, -30 },
  { 36, 20, 27, 22, 1, -27 },
  { 104, 16, 34, 22, 3, -30 },
  { 172, 20, 29, 22, 1, -28 },
  { 245, 20, 28, 22, 1, -28 },
  { 315, 3, 12, 22, 9, -30 },
  { 320, 12, 38, 22, 5, -31 },
  { 377, 12, 38, 22, 5, -31 },
  { 434, 16, 16, 22, 3, -27 },
  { 466, 18, 19, 22, 2, -21 },
  { 509, 8, 12, 22, 7, -6 },
  { 521, 9, 2, 22, 6, -12 },
  { 524, 6, 7, 22, 8, -6 },
  { 530, 16, 38, 22, 3, -31 },
  { 606, 18, 29, 22, 2, -28 },
  { 672, 15, 27, 22, 4, -27 },
  { 723, 16, 28, 22, 3, -28 },
  { 779, 16, 29, 22, 3, -28 },
  { 837, 18, 27, 22, 2, -27 },
  { 898, 16, 28, 22, 3, -27 },
  { 954, 18, 28, 22, 2, -27 },
  { 1017, 17, 27, 22, 3, -27 },
  { 1075, 17, 29, 22, 2, -28 },
  { 1137, 17, 28, 22, 2, -28 },
  { 1197, 6, 21, 22, 8, -20 },
  { 1213, 8, 26, 22, 6, -20 },
  { 1239, 18, 17, 22, 2, -20 },
  { 1278, 18, 11, 22, 2, -17 },
  { 1303, 18, 17, 22, 2, -20 },
  { 1342, 14, 29, 22, 4, -28 },
  { 1393, 18, 34, 22, 2, -28 },
  { 1470, 21, 27, 22, 0, -27 },
  { 1541, 17, 27, 22, 2, -27 },
  { 1599, 18, 29, 22, 2, -28 },
  { 1665, 18, 27, 22, 2, -27 },
  { 1726, 16, 27, 22, 4, -27 },
  { 1780, 15, 27, 22, 4, -27 },
  { 1831, 18, 29, 22, 2, -28 },
  { 1897, 18, 27, 22, 2, -27 },
  { 1958, 13, 27, 22, 4, -27 },
  { 2002, 16, 28, 22, 2, -27 },
  { 2058, 18, 27, 22, 3, -27 },
  { 2119, 16, 27, 22, 4, -27 },
  { 2173, 18, 27, 22, 2, -27 },
  { 2234, 16, 27, 22, 3, -27 },
  { 2288, 20, 29, 22, 1, -28 },
  { 2361, 17, 27, 22, 3, -27 },
  { 2419, 20, 35, 22, 1, -28 },
  { 2507, 18, 27, 22, 2, -27 },
  { 2568, 16, 29, 22, 3, -28 },
  { 2626, 18, 27, 22, 2, -27 },
  { 2687, 18, 28, 22, 2, -27 },
  { 2750, 20, 27, 22, 1, -27 },
  { 2818, 18, 27, 22, 2, -27 },
  { 2879, 20, 27, 22, 1, -27 },
  { 2947, 20, 27, 22, 1, -27 },
  { 3015, 18, 27, 22, 2, -27 },
  { 3076, 10, 38, 22, 7, -31 },
  { 3124, 15, 38, 22, 3, -31 },
  { 3196, 10, 38, 22, 5, -31 },
  { 3244, 18, 14, 22, 2, -27 },
  { 3276, 21, 2, 22, 0, 5 },
  { 3282, 7, 7, 22, 7, -30 },
  { 3289, 16, 21, 22, 3, -21 },
  { 3331, 17, 30, 22, 3, -30 },
  { 3395, 18, 21, 22, 2, -21 },
  { 3443, 17, 30, 22, 2, -30 },
  { 3507, 18, 21, 22, 2, -21 },
  { 3555, 18, 30, 22, 3, -30 },
  { 3623, 17, 28, 22, 2, -21 },
  { 3683, 16, 30, 22, 3, -30 },
  { 3743, 16, 29, 22, 3, -29 },
  { 3801, 14, 36, 22, 3, -29 },
  { 3864, 18, 30, 22, 3, -30 },
  { 3932, 16, 30, 22, 3, -30 },
  { 3992, 18, 21, 22, 2, -21 },
  { 4040, 16, 21, 22, 3, -21 },
  { 4082, 18, 21, 22, 2, -21 },
  { 4130, 17, 28, 22, 3, -21 },
  { 4190, 17, 28, 22, 2, -21 },
  { 4250, 14, 21, 22, 5, -21 },
  { 4287, 16, 21, 22, 3, -21 },
  { 4329, 16, 27, 22, 3, -27 },
  { 4383, 16, 20, 22, 3, -20 },
  { 4423, 18, 20, 22, 2, -20 },
  { 4468, 20, 20, 22, 1, -20 },
  { 4518, 20, 20, 22, 1, -20 },
  { 4568, 18, 27, 22, 2, -20 },
  { 4629, 16, 20, 22, 3, -20 },
  { 4669, 15, 38, 22, 4, -31 },
  { 4741, 2, 38, 22, 10, -31 },
  { 4751, 15, 38, 22, 3, -31 },
  { 4823, 18, 6, 22, 2, -14 },
};

const GFXfont UbuntuSansMono_Regular39pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular39pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular39pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUSANSMONO_REGULAR39PT7B_H_
