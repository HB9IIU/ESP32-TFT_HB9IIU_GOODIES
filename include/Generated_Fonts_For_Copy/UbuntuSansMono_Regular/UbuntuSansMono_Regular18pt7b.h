#ifndef _UBUNTUSANSMONO_REGULAR18PT7B_H_
#define _UBUNTUSANSMONO_REGULAR18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x0F, 0x99, 0x99, 0x90, 0x33, 0x32, 0x22, 0xFF, 0x26,
  0x26, 0x64, 0xFF, 0xFF, 0x44, 0x4C, 0xC8, 0x18, 0x18, 0x3E, 0x62, 0xC0,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x03, 0x03, 0xFE, 0x38, 0x18, 0x18, 0x30,
  0x14, 0x2C, 0x93, 0x2C, 0xCA, 0x15, 0x02, 0x40, 0x2E, 0x1A, 0x85, 0x92,
  0x44, 0x9B, 0x43, 0x80, 0x38, 0x6C, 0x44, 0x44, 0x4C, 0x78, 0x73, 0x5B,
  0xCA, 0x86, 0x86, 0xCF, 0x79, 0xFF, 0xD0, 0x08, 0x73, 0x08, 0x61, 0x04,
  0x30, 0xC3, 0x04, 0x10, 0x60, 0x83, 0x06, 0x0C, 0x43, 0x83, 0x04, 0x18,
  0x20, 0x83, 0x0C, 0x30, 0x82, 0x18, 0x43, 0x18, 0xC0, 0x18, 0x99, 0xEF,
  0x18, 0x3C, 0x66, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x27, 0x73, 0x6C, 0xFF, 0xFC, 0x06, 0x08, 0x30, 0x40, 0x83, 0x04,
  0x08, 0x30, 0x40, 0x83, 0x06, 0x08, 0x30, 0x60, 0x80, 0x18, 0x7E, 0x42,
  0xC3, 0xC3, 0xD9, 0xD9, 0xD9, 0xC3, 0xC3, 0x43, 0x66, 0x3C, 0x30, 0xE2,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x38, 0xFE, 0x82,
  0x02, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0x40, 0xFF, 0x38, 0x7E,
  0x02, 0x02, 0x02, 0x04, 0x1C, 0x06, 0x03, 0x03, 0x03, 0x86, 0xFC, 0x0E,
  0x0E, 0x16, 0x36, 0x26, 0x46, 0xC6, 0x86, 0xFF, 0x06, 0x06, 0x06, 0x7E,
  0x81, 0x06, 0x0E, 0x1F, 0x81, 0x03, 0x06, 0x0E, 0x37, 0xC0, 0x02, 0x1E,
  0x30, 0x60, 0x40, 0xD8, 0xFE, 0xC3, 0xC3, 0xC1, 0xC3, 0x62, 0x3E, 0xFF,
  0x03, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0x30, 0x1C,
  0x66, 0x43, 0xC3, 0xC3, 0x66, 0x3C, 0x66, 0xC3, 0xC1, 0xC3, 0xC3, 0x7E,
  0x38, 0x66, 0xC2, 0xC3, 0xC3, 0xC3, 0x63, 0x3F, 0x03, 0x02, 0x06, 0x1C,
  0x70, 0xFC, 0x03, 0xF0, 0x66, 0x60, 0x00, 0x02, 0x67, 0x2E, 0x80, 0x01,
  0x0E, 0x38, 0xE0, 0xE0, 0x38, 0x07, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x70, 0x1C, 0x03, 0x07, 0x1C, 0xE0, 0x80, 0x73, 0x70, 0x41, 0x0C,
  0x61, 0x08, 0x20, 0x00, 0x1C, 0x70, 0x1C, 0x3E, 0x61, 0x41, 0xC7, 0xCF,
  0xD9, 0xD1, 0xD1, 0xD1, 0xD9, 0xCF, 0x60, 0x60, 0x3E, 0x0E, 0x0C, 0x07,
  0x81, 0x20, 0x48, 0x33, 0x08, 0x42, 0x11, 0xFE, 0x7F, 0x90, 0x24, 0x0B,
  0x03, 0x70, 0xFE, 0x82, 0x82, 0x82, 0x86, 0xFC, 0x86, 0x83, 0x81, 0x83,
  0x86, 0xFC, 0x0E, 0x3F, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x71, 0x3F, 0x70, 0xFC, 0x86, 0x83, 0x83, 0x81, 0x81, 0x81, 0x81,
  0x83, 0x82, 0x86, 0xF8, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81,
  0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02,
  0x04, 0x00, 0x0E, 0x3F, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC1, 0xC1, 0xC1,
  0x41, 0x61, 0x3F, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3F,
  0x3E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x1F, 0xE0, 0xC3,
  0x63, 0x33, 0x1B, 0x0D, 0x07, 0x83, 0x61, 0x98, 0xC6, 0x61, 0x30, 0xD8,
  0x30, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0,
  0x43, 0xE7, 0xA5, 0xA5, 0x95, 0x99, 0x99, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC1, 0xE1, 0xA1, 0xB1, 0x91, 0x99, 0x89, 0x8D, 0x85, 0x87, 0x83, 0x83,
  0x1C, 0x3F, 0x30, 0xD0, 0x28, 0x14, 0x0A, 0x07, 0x02, 0x81, 0x40, 0xB0,
  0xC8, 0x43, 0xC0, 0x71, 0xFA, 0x1C, 0x18, 0x30, 0xE1, 0x7C, 0x81, 0x02,
  0x04, 0x08, 0x00, 0x1C, 0x3F, 0x30, 0xD0, 0x28, 0x14, 0x0A, 0x07, 0x02,
  0x81, 0x40, 0xB0, 0xC8, 0x43, 0xC0, 0xC0, 0x30, 0x0E, 0x70, 0xFE, 0xC2,
  0xC3, 0xC3, 0xC2, 0xC6, 0xFC, 0xCC, 0xC4, 0xC6, 0xC2, 0xC3, 0x1C, 0x76,
  0x40, 0x40, 0x40, 0x60, 0x38, 0x06, 0x03, 0x03, 0x03, 0x83, 0xFE, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x42, 0x7E, 0xC0,
  0xD0, 0x26, 0x09, 0x86, 0x21, 0x08, 0x43, 0x10, 0x4C, 0x12, 0x06, 0x80,
  0xE0, 0x30, 0x81, 0x81, 0x81, 0x81, 0x99, 0x99, 0x99, 0xA5, 0xA5, 0xA5,
  0xC3, 0x42, 0xC3, 0x42, 0x66, 0x24, 0x18, 0x18, 0x3C, 0x24, 0x66, 0x42,
  0xC3, 0x81, 0xC0, 0xD8, 0x62, 0x10, 0xCC, 0x12, 0x07, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10,
  0x30, 0x60, 0x40, 0xC0, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0xF8, 0x81, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30,
  0x20, 0x40, 0xC0, 0x81, 0x03, 0x02, 0x06, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0xF8, 0x18, 0x3C, 0x24, 0x62, 0x42, 0x81,
  0xFF, 0xC0, 0xC8, 0x90, 0x18, 0x7E, 0x02, 0x03, 0x1F, 0x7F, 0xC3, 0xC3,
  0xC3, 0x7F, 0xC0, 0xC0, 0xC0, 0xC0, 0xC8, 0xFE, 0xC3, 0xC3, 0xC1, 0xC1,
  0xC1, 0xC3, 0xC6, 0xFC, 0x0C, 0x3F, 0x60, 0xC0, 0xC0, 0x80, 0xC0, 0xC0,
  0x60, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x1B, 0x7F, 0x43, 0xC3, 0x83, 0x83,
  0x83, 0xC3, 0x63, 0x3F, 0x08, 0x7E, 0x43, 0xC1, 0xFF, 0xFF, 0x80, 0xC0,
  0x61, 0x3E, 0x0F, 0x8C, 0x4C, 0x06, 0x03, 0x07, 0xF8, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x18, 0x7F, 0xC3, 0xC3, 0x83, 0x83,
  0x83, 0xC3, 0x7F, 0x3B, 0x03, 0x02, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xD0,
  0xFE, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x10, 0x30, 0x30,
  0x00, 0x00, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x19, 0x0F, 0x08,
  0x61, 0x80, 0x03, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0xF8,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1B, 0x11, 0xB0, 0xF0, 0x78, 0x36,
  0x18, 0xCC, 0x26, 0x0C, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x19, 0x0F, 0x64, 0xFF, 0x99, 0x99, 0x99, 0x99,
  0x81, 0x81, 0x81, 0x81, 0x10, 0xFE, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x18, 0x7E, 0x43, 0xC3, 0x81, 0x81, 0x81, 0xC3, 0x66, 0x3C,
  0x10, 0xFE, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0xC2, 0xFC, 0xC0, 0xC0,
  0xC0, 0x08, 0x7F, 0x43, 0xC3, 0x83, 0x83, 0x83, 0xC3, 0x63, 0x3F, 0x03,
  0x03, 0x03, 0x19, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x18,
  0x7E, 0x40, 0x40, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xFE, 0x30, 0x30, 0x30,
  0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x11, 0x1F, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x43, 0x63, 0x3F, 0xC1, 0xC3, 0x42, 0x42, 0x66, 0x24,
  0x3C, 0x18, 0x18, 0xC0, 0xD0, 0x24, 0xC9, 0x32, 0x4C, 0x9C, 0xA7, 0x38,
  0xCC, 0x21, 0x00, 0xC3, 0x66, 0x34, 0x18, 0x18, 0x34, 0x66, 0x43, 0x81,
  0xC1, 0x43, 0x42, 0x62, 0x26, 0x36, 0x14, 0x1C, 0x18, 0x08, 0x18, 0xF0,
  0xFC, 0x18, 0x61, 0x82, 0x0C, 0x30, 0x40, 0xFE, 0x1E, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x30, 0xC0, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x41, 0x04, 0x10, 0x41, 0x06, 0x0C, 0x61,
  0x04, 0x10, 0x41, 0x04, 0xF0, 0x61, 0xF9, 0x8E,
};

const GFXglyph UbuntuSansMono_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -14 },
  { 7, 8, 12, 10, 1, -12 },
  { 19, 8, 16, 10, 1, -14 },
  { 35, 10, 13, 10, 0, -13 },
  { 52, 8, 13, 10, 1, -13 },
  { 65, 2, 6, 10, 4, -14 },
  { 67, 6, 17, 10, 2, -14 },
  { 80, 6, 17, 10, 2, -14 },
  { 93, 8, 7, 10, 1, -12 },
  { 100, 8, 9, 10, 1, -10 },
  { 109, 4, 6, 10, 3, -3 },
  { 112, 4, 2, 10, 3, -6 },
  { 113, 2, 3, 10, 4, -3 },
  { 114, 7, 17, 10, 2, -14 },
  { 129, 8, 13, 10, 1, -13 },
  { 142, 7, 12, 10, 2, -12 },
  { 153, 8, 13, 10, 1, -13 },
  { 166, 8, 13, 10, 1, -13 },
  { 179, 8, 12, 10, 1, -12 },
  { 191, 7, 12, 10, 2, -12 },
  { 202, 8, 13, 10, 1, -13 },
  { 215, 8, 12, 10, 1, -12 },
  { 227, 8, 13, 10, 1, -13 },
  { 240, 8, 13, 10, 1, -13 },
  { 253, 2, 10, 10, 4, -10 },
  { 256, 4, 13, 10, 3, -10 },
  { 263, 8, 8, 10, 1, -9 },
  { 271, 8, 5, 10, 1, -8 },
  { 276, 8, 8, 10, 1, -9 },
  { 284, 6, 13, 10, 2, -13 },
  { 294, 8, 16, 10, 1, -13 },
  { 310, 10, 12, 10, 0, -12 },
  { 325, 8, 13, 10, 1, -13 },
  { 338, 8, 13, 10, 1, -13 },
  { 351, 8, 13, 10, 1, -13 },
  { 364, 7, 12, 10, 2, -12 },
  { 375, 7, 12, 10, 2, -12 },
  { 386, 8, 13, 10, 1, -13 },
  { 399, 8, 12, 10, 1, -12 },
  { 411, 6, 12, 10, 2, -12 },
  { 420, 7, 12, 10, 1, -12 },
  { 431, 9, 12, 10, 1, -12 },
  { 445, 7, 12, 10, 2, -12 },
  { 456, 8, 12, 10, 1, -12 },
  { 468, 8, 12, 10, 1, -12 },
  { 480, 9, 13, 10, 1, -13 },
  { 495, 7, 13, 10, 2, -13 },
  { 507, 9, 16, 10, 1, -13 },
  { 525, 8, 13, 10, 1, -13 },
  { 538, 8, 13, 10, 1, -13 },
  { 551, 8, 12, 10, 1, -12 },
  { 563, 8, 12, 10, 1, -12 },
  { 575, 10, 12, 10, 0, -12 },
  { 590, 8, 12, 10, 1, -12 },
  { 602, 8, 12, 10, 1, -12 },
  { 614, 10, 12, 10, 0, -12 },
  { 629, 8, 12, 10, 1, -12 },
  { 641, 5, 17, 10, 3, -14 },
  { 652, 7, 17, 10, 2, -14 },
  { 667, 5, 17, 10, 2, -14 },
  { 678, 8, 6, 10, 1, -12 },
  { 684, 10, 1, 10, 0, 2 },
  { 686, 3, 4, 10, 3, -14 },
  { 688, 8, 10, 10, 1, -10 },
  { 698, 8, 14, 10, 1, -14 },
  { 712, 8, 10, 10, 1, -10 },
  { 722, 8, 14, 10, 1, -14 },
  { 736, 8, 10, 10, 1, -10 },
  { 746, 9, 14, 10, 1, -14 },
  { 762, 8, 13, 10, 1, -10 },
  { 775, 8, 14, 10, 1, -14 },
  { 789, 8, 14, 10, 1, -14 },
  { 803, 6, 17, 10, 2, -14 },
  { 816, 9, 14, 10, 1, -14 },
  { 832, 8, 14, 10, 1, -14 },
  { 846, 8, 10, 10, 1, -10 },
  { 856, 8, 10, 10, 1, -10 },
  { 866, 8, 10, 10, 1, -10 },
  { 876, 8, 13, 10, 1, -10 },
  { 889, 8, 13, 10, 1, -10 },
  { 902, 7, 10, 10, 2, -10 },
  { 911, 8, 10, 10, 1, -10 },
  { 921, 8, 12, 10, 1, -12 },
  { 933, 8, 9, 10, 1, -9 },
  { 942, 8, 9, 10, 1, -9 },
  { 951, 10, 9, 10, 0, -9 },
  { 963, 8, 9, 10, 1, -9 },
  { 972, 8, 12, 10, 1, -9 },
  { 984, 7, 9, 10, 2, -9 },
  { 992, 7, 17, 10, 2, -14 },
  { 1007, 2, 17, 10, 4, -14 },
  { 1012, 6, 17, 10, 2, -14 },
  { 1025, 8, 3, 10, 1, -7 },
};

const GFXfont UbuntuSansMono_Regular18pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular18pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular18pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUSANSMONO_REGULAR18PT7B_H_
