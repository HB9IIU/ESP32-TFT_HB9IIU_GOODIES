#ifndef _UBUNTUSANSMONO_REGULAR45PT7B_H_
#define _UBUNTUSANSMONO_REGULAR45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x71,
  0xF7, 0xEF, 0xEF, 0x9F, 0x08, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEC, 0x1D, 0x83, 0xB0, 0x20, 0x00, 0xF0,
  0x78, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x07,
  0x00, 0x3C, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0F, 0x00, 0x38, 0x1E, 0x00,
  0xF0, 0x38, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x0E,
  0x07, 0x80, 0x1C, 0x0E, 0x00, 0x78, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0E,
  0x00, 0x70, 0x3C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xC0,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0x07, 0x8F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x80, 0x07, 0xDC, 0x01, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x02, 0x7F, 0x00, 0x39, 0xEF, 0x00, 0xF3,
  0x8E, 0x01, 0xCE, 0x0C, 0x07, 0x1C, 0x1C, 0x1E, 0x38, 0x38, 0x38, 0x70,
  0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xC1, 0xC7, 0x03, 0x83, 0x9E, 0x07, 0x06,
  0x38, 0x07, 0x1C, 0xF0, 0x0F, 0x79, 0xC0, 0x0F, 0xE7, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x01, 0xCF, 0xE0, 0x07, 0x3D,
  0xE0, 0x1E, 0x71, 0xC0, 0x38, 0xE1, 0xC0, 0xF3, 0x83, 0x81, 0xC7, 0x07,
  0x07, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0xF0, 0x30, 0x71,
  0xC0, 0x70, 0xE7, 0x00, 0xE3, 0x8E, 0x00, 0xFF, 0x38, 0x00, 0xFC, 0x00,
  0x00, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xC7,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xE0, 0x07, 0x87, 0x00, 0x1E,
  0x3C, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x10, 0x1F, 0xC0,
  0x70, 0xF7, 0x83, 0x83, 0xCF, 0x0E, 0x1E, 0x1E, 0x38, 0x70, 0x7C, 0xE3,
  0xC0, 0xFB, 0x8F, 0x01, 0xFC, 0x3C, 0x03, 0xF0, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x7C, 0x3E, 0x03, 0xF8, 0x7C, 0x1F, 0xF1, 0xFF, 0xFB,
  0xC3, 0xFF, 0xC7, 0x83, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x20, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0x80, 0x0C, 0x20, 0x03, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE1, 0xC1, 0x9F, 0x39, 0xFF,
  0xFB, 0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00,
  0x7B, 0xC0, 0x1E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x0E, 0x0F, 0x00,
  0x80, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x02, 0x03, 0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x1E, 0x07, 0x83,
  0xC3, 0xE3, 0xF0, 0xF8, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xF1, 0xF0,
  0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1C, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x0F,
  0x0F, 0xE1, 0xF0, 0xFE, 0x1F, 0x8F, 0xE1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE0,
  0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC3, 0xC0, 0x7C,
  0x3E, 0x07, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xCF, 0x01, 0xC3, 0xC0, 0x40, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x07,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0x00, 0x78, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x1F,
  0xC2, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE4, 0x00, 0x7C,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x0E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x70,
  0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xF1,
  0xE0, 0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7B, 0x00, 0x3E, 0xFF,
  0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF1, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC0, 0xFC,
  0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1F, 0x9F, 0x80, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x3C, 0xF0, 0x07,
  0x9C, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xC0, 0x07,
  0x3C, 0x00, 0xE7, 0xC0, 0x3C, 0x7C, 0x0F, 0x07, 0xE3, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xCF, 0xF0, 0xF0, 0x3F, 0x3C, 0x01, 0xE7, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x80, 0x3C, 0xFE, 0x1F, 0x8F, 0xFF, 0xE0,
  0x7F, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0x07, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3B, 0xC0, 0x0F, 0x3F, 0x1F, 0xE3, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0x60, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x18, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x31, 0xF7, 0xFF, 0xFF, 0xFF, 0xBE, 0x10, 0x03, 0x03, 0xE1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF0, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xF8, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x3F, 0x03, 0xC0, 0xE0, 0x78, 0x7C, 0xFE, 0x1F, 0x07, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x0F, 0xC1, 0xFF, 0xF3, 0xFF, 0xF3, 0x03, 0xE8, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xC0, 0x02, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xF8, 0xF8, 0x0F, 0x80, 0xF0, 0x7C, 0x01, 0xC1, 0xE0, 0x07, 0x8F, 0x00,
  0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80, 0x0B, 0xDE, 0x03, 0xFF,
  0x78, 0x1F, 0xFD, 0xE0, 0xF9, 0xF7, 0x07, 0x83, 0xDC, 0x3C, 0x0F, 0xF0,
  0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0E, 0x03, 0xFC, 0x38, 0x0F, 0xF0, 0xE0,
  0x3F, 0xC3, 0x80, 0xF7, 0x0E, 0x03, 0xDE, 0x3C, 0x0F, 0x78, 0xF0, 0x3D,
  0xE1, 0xE0, 0xF7, 0x87, 0xC3, 0xDF, 0x0F, 0xFF, 0x3C, 0x1F, 0xFC, 0xF0,
  0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFE, 0x38, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x1C, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x07, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0x80, 0x00,
  0x3B, 0xC0, 0x00, 0x1E, 0x01, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7E,
  0x7F, 0x8E, 0x00, 0xF9, 0xC0, 0x0F, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0,
  0x03, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0,
  0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0x1C, 0x03, 0xF3, 0x80,
  0x0F, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEE, 0x00,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xF0, 0xFE, 0x3E, 0x1F, 0x00, 0x63, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x20, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xE0, 0x1F, 0x0E, 0x00, 0xF8, 0xE0, 0x03,
  0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x3C,
  0xE0, 0x07, 0xCE, 0x00, 0xF8, 0xE0, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFC, 0x1E, 0x1F, 0x00, 0x63, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x3C, 0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xFF, 0x7F, 0x07, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE4, 0x00, 0x79, 0x80, 0x3E, 0xFE, 0xFF, 0x3F, 0xFF, 0x83, 0xFF,
  0xC0, 0x0F, 0x00, 0xE0, 0x01, 0xF7, 0x00, 0x1E, 0x38, 0x01, 0xF1, 0xC0,
  0x0F, 0x0E, 0x00, 0xF0, 0x70, 0x0F, 0x03, 0x80, 0xF0, 0x1C, 0x0F, 0x80,
  0xE0, 0xF8, 0x07, 0x0F, 0x80, 0x38, 0xF8, 0x01, 0xCF, 0x80, 0x0E, 0x78,
  0x00, 0x77, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xEF, 0xC0, 0x07,
  0x3F, 0x00, 0x38, 0x7C, 0x01, 0xC1, 0xF0, 0x0E, 0x07, 0xC0, 0x70, 0x1F,
  0x03, 0x80, 0x78, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x87, 0x00, 0x3E, 0x38,
  0x00, 0xF1, 0xC0, 0x03, 0xCE, 0x00, 0x1F, 0x70, 0x00, 0x7B, 0x80, 0x03,
  0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3F,
  0x3F, 0x01, 0xF9, 0xDC, 0x0D, 0xCE, 0xE0, 0xEE, 0x77, 0x07, 0x73, 0x9C,
  0x33, 0x9C, 0xE3, 0x9C, 0xE7, 0x1C, 0xE7, 0x1C, 0xC7, 0x38, 0xEE, 0x3D,
  0xC3, 0x71, 0xEE, 0x1F, 0x0F, 0x70, 0xF8, 0x3F, 0x83, 0xC1, 0xFC, 0x1E,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFB,
  0xC0, 0x3F, 0x78, 0x07, 0xE7, 0x80, 0xFC, 0x70, 0x1F, 0x8F, 0x03, 0xF0,
  0xE0, 0x7E, 0x1E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x87, 0xE0,
  0x70, 0xFC, 0x0F, 0x1F, 0x80, 0xE3, 0xF0, 0x1E, 0x7E, 0x01, 0xCF, 0xC0,
  0x3D, 0xF8, 0x03, 0xBF, 0x00, 0x77, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7C, 0x1F, 0x01, 0xF0,
  0x1F, 0x03, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01,
  0xEE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE,
  0x00, 0x03, 0x9E, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x78,
  0x00, 0x70, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xF0, 0x1F, 0x01, 0xFD,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x80,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x00, 0xF9, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3C,
  0xF0, 0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7C,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x1C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x73, 0x80, 0x00,
  0xE7, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7,
  0x00, 0x01, 0xEE, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xF0,
  0x1F, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x01, 0x00, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x7C,
  0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00,
  0xF8, 0xE1, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0E, 0x07, 0x80, 0xE0,
  0x3C, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E,
  0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x1E,
  0xE0, 0x01, 0xEE, 0x00, 0x0F, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF,
  0x1F, 0x83, 0xE3, 0xC0, 0x08, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF6,
  0x00, 0x3D, 0xFE, 0x7F, 0xBF, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x00,
  0xEF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3C, 0x3F, 0x9F, 0x81, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38,
  0x1C, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0xF0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x01, 0xE0,
  0x07, 0x81, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83, 0x80,
  0x03, 0xC3, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xC7, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0x03, 0xF8, 0x7C, 0x3F, 0xC3, 0xE1, 0xEE, 0x1B, 0x0F, 0x71, 0xDC, 0x73,
  0x8E, 0xE3, 0x9C, 0x63, 0x1C, 0xE7, 0x1C, 0xE7, 0x38, 0xE7, 0x39, 0x83,
  0x39, 0xDC, 0x1D, 0xCE, 0xE0, 0xEE, 0x77, 0x03, 0x73, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x80, 0x78, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0xC1, 0xE0,
  0x03, 0x83, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x38,
  0x38, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0xBE, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0xC7,
  0x80, 0x01, 0xE7, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xE0,
  0x01, 0xC7, 0x00, 0x1E, 0x3C, 0x00, 0xE0, 0xE0, 0x0F, 0x03, 0x80, 0xF0,
  0x1E, 0x07, 0x00, 0x70, 0x78, 0x03, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x7B,
  0xC0, 0x01, 0xEE, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x20, 0x70, 0xF8, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x02,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0E, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x0F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x07, 0xDE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF7,
  0x80, 0x1E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xA0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x71, 0xF8, 0x0E, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x8F, 0xC7,
  0xC0, 0x7C, 0xE0, 0x07, 0xDC, 0x00, 0x7B, 0x80, 0x07, 0x70, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0xB8,
  0x01, 0xE7, 0x00, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0x1E,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x21, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x8F, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xCF, 0xF3, 0xE0, 0x1F, 0x3C, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x3E, 0x00, 0xF1, 0xF0,
  0x0F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0x0F, 0xC3, 0xE0, 0x1E,
  0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x70, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x02, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x28, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0x10, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xE7, 0xF3, 0xE0, 0x0E, 0x78, 0x01, 0xDE,
  0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x78,
  0x00, 0xEF, 0x00, 0x1C, 0xF0, 0x03, 0x9F, 0x81, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xB8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF2, 0x00, 0x7C, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x9F, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xE7, 0xF3, 0x80,
  0x3C, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x08, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xD0, 0x0F, 0x7F, 0xFE, 0xFF,
  0xF8, 0xFF, 0xE0, 0x14, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x03, 0xEE, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x3C, 0x0E,
  0x0F, 0x80, 0xE1, 0xF0, 0x0E, 0x3E, 0x00, 0xE7, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xEF, 0xC0, 0x0E, 0x3E, 0x00, 0xE1, 0xF0,
  0x0E, 0x0F, 0xC0, 0xE0, 0x3E, 0x0E, 0x01, 0xF0, 0xE0, 0x0F, 0x0E, 0x00,
  0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xE0, 0x01, 0xF0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x81, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x1F,
  0x07, 0x87, 0xFE, 0xFF, 0x3F, 0xFF, 0xFD, 0xE1, 0xF1, 0xFF, 0x07, 0x07,
  0xF8, 0x38, 0x1F, 0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83,
  0x81, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1F,
  0xC1, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0x0F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF1, 0xFC, 0xE0,
  0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03,
  0xC1, 0xF0, 0x3E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x20, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7E, 0x3F, 0x8E,
  0x00, 0xF9, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x78,
  0x03, 0xCF, 0x80, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0x7F, 0xC0, 0xE1,
  0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x3F,
  0xFF, 0x8F, 0xE3, 0xF3, 0xE0, 0x0E, 0x78, 0x01, 0xDE, 0x00, 0x3B, 0xC0,
  0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x00, 0xEF, 0x00,
  0x1D, 0xE0, 0x03, 0x9E, 0x00, 0x73, 0xE0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xF7, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x03, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFC, 0x02, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xFC,
  0x07, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0x1C, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x07, 0xBF, 0xDF, 0xEF,
  0xFF, 0xF1, 0xFF, 0xF0, 0x01, 0x40, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x01, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x20, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xDE, 0x00, 0xEF,
  0x80, 0x73, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x01, 0x80, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x1C,
  0x00, 0x78, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xF0, 0x78, 0x03, 0x83, 0xC0, 0x1E,
  0x1C, 0x00, 0xF1, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00,
  0x01, 0xEE, 0x07, 0x03, 0x9C, 0x0E, 0x07, 0x38, 0x1E, 0x0E, 0x78, 0x7C,
  0x1C, 0xF0, 0xF8, 0x38, 0xE1, 0xB8, 0xF1, 0xC7, 0x71, 0xE3, 0x8E, 0xE3,
  0x87, 0x18, 0xE7, 0x0E, 0x71, 0xCE, 0x1E, 0xE1, 0x9C, 0x1F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xC0, 0x1E, 0x03, 0x80, 0x38, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0x83,
  0xC0, 0x1E, 0x07, 0x80, 0xF0, 0x0F, 0x07, 0x80, 0x3E, 0x1E, 0x00, 0x7C,
  0xF0, 0x00, 0xF7, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x78, 0xF0, 0x01,
  0xE1, 0xE0, 0x0F, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00,
  0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x78, 0x0E,
  0x03, 0xC0, 0xF0, 0x0E, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x0E,
  0x1E, 0x00, 0x78, 0xE0, 0x01, 0xC7, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x01, 0xCF,
  0xF8, 0x0E, 0xE3, 0xF0, 0xE6, 0x07, 0xFF, 0x70, 0x0F, 0xF1, 0x80, 0x3F,
  0x00,
};

const GFXglyph UbuntuSansMono_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 32, 25, 9, -31 },
  { 29, 11, 12, 25, 7, -34 },
  { 46, 23, 31, 25, 1, -31 },
  { 136, 19, 40, 25, 3, -35 },
  { 231, 23, 33, 25, 1, -32 },
  { 326, 22, 32, 25, 2, -32 },
  { 414, 3, 13, 25, 11, -34 },
  { 419, 13, 43, 25, 6, -35 },
  { 489, 13, 43, 25, 6, -35 },
  { 559, 19, 18, 25, 3, -31 },
  { 602, 21, 22, 25, 2, -24 },
  { 660, 10, 14, 25, 8, -7 },
  { 678, 11, 3, 25, 7, -14 },
  { 683, 7, 8, 25, 9, -7 },
  { 690, 17, 43, 25, 4, -35 },
  { 782, 20, 33, 25, 3, -32 },
  { 865, 18, 31, 25, 4, -31 },
  { 935, 19, 32, 25, 3, -32 },
  { 1011, 19, 33, 25, 3, -32 },
  { 1090, 21, 31, 25, 2, -31 },
  { 1172, 18, 32, 25, 4, -31 },
  { 1244, 20, 32, 25, 3, -31 },
  { 1324, 20, 31, 25, 3, -31 },
  { 1402, 19, 33, 25, 3, -32 },
  { 1481, 19, 32, 25, 3, -32 },
  { 1557, 7, 25, 25, 9, -24 },
  { 1579, 10, 31, 25, 6, -24 },
  { 1618, 20, 20, 25, 3, -23 },
  { 1668, 21, 13, 25, 2, -20 },
  { 1703, 20, 20, 25, 3, -23 },
  { 1753, 15, 33, 25, 5, -32 },
  { 1815, 22, 39, 25, 2, -32 },
  { 1923, 25, 31, 25, 0, -31 },
  { 2020, 19, 32, 25, 3, -32 },
  { 2096, 20, 33, 25, 3, -32 },
  { 2179, 20, 32, 25, 3, -32 },
  { 2259, 18, 31, 25, 5, -31 },
  { 2329, 17, 31, 25, 5, -31 },
  { 2395, 20, 33, 25, 3, -32 },
  { 2478, 21, 31, 25, 2, -31 },
  { 2560, 15, 31, 25, 5, -31 },
  { 2619, 18, 32, 25, 3, -31 },
  { 2691, 21, 31, 25, 4, -31 },
  { 2773, 18, 31, 25, 5, -31 },
  { 2843, 21, 31, 25, 2, -31 },
  { 2925, 19, 31, 25, 3, -31 },
  { 2999, 23, 33, 25, 1, -32 },
  { 3094, 19, 32, 25, 4, -32 },
  { 3170, 23, 40, 25, 1, -32 },
  { 3285, 20, 32, 25, 3, -32 },
  { 3365, 19, 33, 25, 3, -32 },
  { 3444, 21, 31, 25, 2, -31 },
  { 3526, 20, 32, 25, 3, -31 },
  { 3606, 24, 31, 25, 1, -31 },
  { 3699, 21, 31, 25, 2, -31 },
  { 3781, 23, 31, 25, 1, -31 },
  { 3871, 24, 31, 25, 1, -31 },
  { 3964, 20, 31, 25, 3, -31 },
  { 4042, 11, 43, 25, 8, -35 },
  { 4102, 17, 43, 25, 4, -35 },
  { 4194, 12, 43, 25, 6, -35 },
  { 4259, 21, 16, 25, 2, -31 },
  { 4301, 25, 3, 25, 0, 5 },
  { 4311, 8, 9, 25, 8, -35 },
  { 4320, 19, 25, 25, 3, -24 },
  { 4380, 19, 36, 25, 4, -35 },
  { 4466, 20, 25, 25, 3, -24 },
  { 4529, 20, 36, 25, 2, -35 },
  { 4619, 21, 25, 25, 2, -24 },
  { 4685, 20, 35, 25, 4, -35 },
  { 4773, 19, 32, 25, 2, -24 },
  { 4849, 18, 35, 25, 4, -35 },
  { 4928, 19, 35, 25, 3, -34 },
  { 5012, 15, 43, 25, 4, -34 },
  { 5093, 20, 35, 25, 4, -35 },
  { 5181, 19, 36, 25, 3, -35 },
  { 5267, 21, 24, 25, 2, -24 },
  { 5330, 18, 24, 25, 4, -24 },
  { 5384, 21, 25, 25, 2, -24 },
  { 5450, 19, 32, 25, 4, -24 },
  { 5526, 19, 32, 25, 2, -24 },
  { 5602, 16, 24, 25, 6, -24 },
  { 5650, 18, 25, 25, 4, -24 },
  { 5707, 18, 32, 25, 4, -31 },
  { 5779, 17, 24, 25, 4, -23 },
  { 5830, 21, 23, 25, 2, -23 },
  { 5891, 23, 23, 25, 1, -23 },
  { 5958, 22, 23, 25, 2, -23 },
  { 6022, 21, 31, 25, 2, -23 },
  { 6104, 17, 23, 25, 4, -23 },
  { 6153, 17, 43, 25, 4, -35 },
  { 6245, 3, 43, 25, 11, -35 },
  { 6262, 17, 43, 25, 4, -35 },
  { 6354, 21, 7, 25, 2, -17 },
};

const GFXfont UbuntuSansMono_Regular45pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular45pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular45pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUSANSMONO_REGULAR45PT7B_H_
