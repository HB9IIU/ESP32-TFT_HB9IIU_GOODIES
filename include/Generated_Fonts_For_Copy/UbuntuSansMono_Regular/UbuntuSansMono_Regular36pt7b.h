#ifndef _UBUNTUSANSMONO_REGULAR36PT7B_H_
#define _UBUNTUSANSMONO_REGULAR36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x63, 0x18, 0xC6, 0x30,
  0x00, 0x03, 0x3F, 0xEF, 0x78, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x03, 0x83, 0x80, 0xE0, 0xC0, 0x38, 0x70, 0x0C, 0x1C, 0x07,
  0x07, 0x01, 0xC1, 0xC0, 0x70, 0x63, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x83,
  0x80, 0xE0, 0xE0, 0x38, 0x30, 0x0E, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0xC0,
  0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC3, 0x80, 0x60, 0xE0, 0x38,
  0x38, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFC, 0x78, 0x04, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x40, 0x0E, 0x70,
  0x3E, 0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x3E, 0x01, 0xDD, 0xC0, 0xEE, 0x30, 0x33, 0x0C, 0x1C,
  0xC3, 0x06, 0x30, 0xE3, 0x8C, 0x31, 0xC3, 0x0C, 0x60, 0xC3, 0x38, 0x39,
  0xCC, 0x07, 0xE7, 0x00, 0xF3, 0x80, 0x00, 0xC0, 0x00, 0x73, 0xC0, 0x19,
  0xF8, 0x0E, 0xE7, 0x07, 0x30, 0xC1, 0x8C, 0x30, 0xE3, 0x0C, 0x30, 0xC3,
  0x1C, 0x30, 0xCE, 0x0C, 0x33, 0x03, 0x8D, 0xC0, 0x66, 0xE0, 0x1F, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x70, 0xE0, 0x38,
  0x18, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x38, 0x38, 0x07, 0x1C,
  0x01, 0xCE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0xC3, 0xFC, 0x30,
  0xE7, 0x8C, 0x70, 0xE7, 0x1C, 0x1D, 0xC7, 0x03, 0xE3, 0x80, 0xF8, 0xF0,
  0x1E, 0x1C, 0x07, 0x87, 0x03, 0xF1, 0xF1, 0xFE, 0x3F, 0xF3, 0x87, 0xF0,
  0x70, 0xFF, 0x6D, 0xB6, 0xD8, 0x00, 0x80, 0x70, 0x3C, 0x1C, 0x0F, 0x07,
  0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60,
  0x08, 0x40, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x18, 0x04, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x61, 0x86, 0x79, 0x9E, 0xFF, 0xFF, 0x1F,
  0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x3C, 0x1C,
  0x38, 0x08, 0x10, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x07, 0x0E, 0x1E, 0xFC, 0x70, 0x40,
  0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE1, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F,
  0xF0, 0x00, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x3D, 0xC3,
  0xE7, 0x06, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0x3F, 0xFC, 0x03,
  0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0xF8, 0x3C, 0x60, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x02, 0x00, 0x7F, 0xC3, 0xFF, 0xC3, 0x03, 0xC4, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x7F, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x60, 0x3C,
  0xFF, 0xF1, 0xFF, 0xC0, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0C, 0x38, 0x0E,
  0x1C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x03, 0x83, 0x01, 0xC3, 0x80, 0xE1,
  0x80, 0x71, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0xB8, 0x1E, 0x7F, 0xFC, 0x7F, 0xE0, 0x04,
  0x00, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xFA, 0x0F, 0x80, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x77, 0xF0, 0xFF,
  0xFC, 0xFC, 0x3E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x0E, 0x3C, 0x1C, 0x1F,
  0xFC, 0x0F, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x38, 0x1C,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E,
  0x78, 0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF8, 0x1C, 0xFC, 0x38, 0x1E,
  0x70, 0x0E, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x01, 0x00, 0x0F, 0xF0,
  0x3F, 0xF8, 0x38, 0x3C, 0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x3E, 0x3F,
  0x1F, 0xFF, 0x0F, 0xE7, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7E, 0x00,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF,
  0xFD, 0xE0, 0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x1F, 0x3F, 0x3F, 0x1F, 0x07, 0x0E, 0x1C, 0xFC,
  0xF0, 0x40, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x06, 0x07, 0xFC, 0xFF, 0xE4, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x40, 0x03, 0xFC, 0x03, 0xFF, 0x03,
  0xC1, 0xC3, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xB8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x7E, 0x3C, 0x3F, 0x1C, 0x1F, 0x8E,
  0x0F, 0xC7, 0x07, 0xE3, 0x83, 0xF1, 0xC1, 0xF8, 0xE0, 0xFC, 0x70, 0x7F,
  0x38, 0x3B, 0x8E, 0x1D, 0xC3, 0xFE, 0xE0, 0xFE, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x20, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0x9C, 0x00,
  0x39, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x60,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x38, 0x01, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0,
  0x00, 0x70, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0xFC, 0xE0, 0x1C, 0xE0, 0x1E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0xF8,
  0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x7C,
  0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x20, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0x07,
  0x1C, 0x01, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1F, 0x03, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x30, 0xFF, 0x80,
  0xFF, 0xF0, 0xE1, 0xF8, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFD, 0xFF, 0xFB, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0x8F, 0xFF,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x0F,
  0xFF, 0x1F, 0x07, 0x1C, 0x01, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78,
  0x07, 0x38, 0x07, 0x3C, 0x07, 0x1F, 0x07, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0x30, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC8, 0x03, 0x9C, 0x1F,
  0x7F, 0xFC, 0x3F, 0xE0, 0x04, 0x00, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x07,
  0x1C, 0x07, 0x0E, 0x07, 0x87, 0x07, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE7,
  0x80, 0x77, 0x80, 0x3B, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0x78, 0x03,
  0x9E, 0x01, 0xC7, 0x80, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x1E, 0x1C, 0x07,
  0x8E, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x80,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x38,
  0x07, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E, 0x0F, 0x0F, 0x87,
  0xE3, 0x61, 0xB9, 0xD8, 0x6E, 0x77, 0x3B, 0x9C, 0xCC, 0xE7, 0x33, 0x19,
  0xCE, 0xC6, 0x71, 0xE1, 0x9C, 0x78, 0x67, 0x0E, 0x19, 0xC0, 0x06, 0x60,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xD8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xEC, 0x07, 0xEE, 0x07, 0xE6, 0x07,
  0xE7, 0x07, 0xE3, 0x07, 0xE3, 0x87, 0xE1, 0x87, 0xE1, 0xC7, 0xE0, 0xC7,
  0xE0, 0xE7, 0xE0, 0x67, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x37, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x78, 0x78, 0x38, 0x07, 0x0E, 0x01, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x03, 0x8E, 0x01, 0xE3,
  0x80, 0x70, 0x78, 0x78, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x04, 0x00, 0xFF,
  0xE1, 0xFF, 0xF3, 0x83, 0xF7, 0x00, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x07, 0xDF,
  0xFF, 0x3F, 0xF8, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x78, 0x78, 0x38, 0x07, 0x0E, 0x01, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x03, 0x8E, 0x01, 0xE3,
  0x80, 0x70, 0x78, 0x78, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x01,
  0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0xFC, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0,
  0x30, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0x00, 0xC0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0x0C, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x40,
  0x0E, 0x70, 0x1E, 0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x0F,
  0xF8, 0x00, 0x80, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x00, 0xE1, 0x80, 0x1C, 0x38, 0x03,
  0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x03, 0x03, 0x80, 0x70, 0x60, 0x0E, 0x1C, 0x00, 0xC3, 0x80, 0x1C, 0x60,
  0x03, 0x9C, 0x00, 0x33, 0x80, 0x07, 0x60, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07,
  0x60, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x70, 0x01, 0x9C,
  0x00, 0x67, 0x1E, 0x19, 0xC7, 0x86, 0x71, 0xE1, 0x9C, 0xFC, 0x67, 0x33,
  0x39, 0xCC, 0xCE, 0x77, 0x3B, 0x9D, 0x86, 0xE7, 0x61, 0xB8, 0xF8, 0x7C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x1C, 0x38, 0x07, 0x00,
  0x70, 0x03, 0xDE, 0x00, 0xE3, 0x80, 0x70, 0xF0, 0x1C, 0x1C, 0x0E, 0x03,
  0x87, 0x80, 0xE1, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7B, 0x80, 0x1C, 0xE0,
  0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x07, 0x0E,
  0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0E, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xFC,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x01, 0xC7, 0x80, 0x38, 0x70, 0x0E, 0x0F,
  0x01, 0xC0, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x03,
  0x9C, 0x00, 0x3B, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x30, 0x1C, 0x38, 0x18,
  0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x43, 0x8E, 0x1C, 0x38, 0x70,
  0x80, 0x7F, 0xE0, 0xFF, 0xC3, 0x8F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x1F, 0xFD, 0xFF, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1D, 0xFF, 0xF3, 0xFF, 0xC0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xDF, 0x83, 0xFF, 0xC7, 0xFF, 0xCF, 0x03, 0xDC,
  0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0E, 0xE0, 0x3D, 0xC1, 0xF3,
  0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xDE, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x3F, 0x03, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F,
  0xDC, 0x7F, 0xF9, 0xFF, 0xF7, 0x80, 0xEE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xB8, 0x07, 0x78, 0x0E, 0x7C, 0x1C, 0x7F, 0xF8, 0x3F, 0xF0, 0x07,
  0xF0, 0x0F, 0xF8, 0x3E, 0x3C, 0x78, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x06, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x01, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x3F,
  0xFC, 0xFF, 0xFB, 0xC0, 0x77, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xDC,
  0x03, 0xBE, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x04, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xD0, 0x0F, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0xE0, 0x3B, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0x07,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC3, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x40, 0xF7, 0xFE, 0xFF, 0xC1, 0xF0, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xE0,
  0xE3, 0xC0, 0xE7, 0x80, 0xEF, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xEF, 0x00,
  0xE7, 0x80, 0xE3, 0xC0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x1C,
  0xE0, 0x0E, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC3, 0x01, 0xFF, 0x00, 0xFF,
  0x7E, 0x7C, 0x7F, 0xFF, 0x38, 0xFB, 0xDC, 0x30, 0x6E, 0x1C, 0x3F, 0x0E,
  0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC,
  0x38, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xE0, 0x3F, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3C,
  0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x01,
  0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0E, 0xF8,
  0x79, 0xFF, 0xE3, 0xFF, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB,
  0xC0, 0x77, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xDC, 0x03, 0xBC, 0x07,
  0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x0F, 0xF8, 0xFF, 0xE7, 0xC3, 0xB8, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0xE0, 0x3F, 0xFF, 0xEF, 0xFF, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xE1, 0x83, 0xFF, 0x03, 0xFE, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xDC,
  0x07, 0x7C, 0x1C, 0xFF, 0xF1, 0xFF, 0xC0, 0xF0, 0x01, 0xDC, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0x3B, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x30, 0x76, 0x0E, 0x1D, 0xC7, 0x86, 0x71, 0xE1, 0x9C, 0x7C,
  0xE7, 0x33, 0x39, 0xCC, 0xCE, 0x37, 0x3B, 0x8D, 0x86, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x07, 0x03, 0xC1, 0x80, 0x60, 0x70, 0x03, 0x9E,
  0x01, 0xC3, 0xC0, 0x70, 0x70, 0x38, 0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x7B,
  0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0E, 0xE0,
  0x07, 0x3C, 0x03, 0x87, 0x01, 0xC0, 0xE0, 0xF0, 0x1C, 0x38, 0x07, 0x1C,
  0x00, 0xEF, 0x00, 0x3C, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x0C, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x70, 0x03, 0xF0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x70, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x78, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x80, 0xFC, 0x03,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFC, 0x01,
  0xF0, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0x7F, 0x83, 0xE3,
  0xE7, 0xC0, 0xFE, 0xC0, 0x7C,
};

const GFXglyph UbuntuSansMono_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 25, 20, 7, -25 },
  { 17, 8, 9, 20, 6, -27 },
  { 26, 18, 25, 20, 1, -25 },
  { 83, 16, 32, 20, 2, -28 },
  { 147, 18, 26, 20, 1, -25 },
  { 206, 18, 26, 20, 1, -26 },
  { 265, 3, 10, 20, 9, -27 },
  { 269, 10, 35, 20, 5, -28 },
  { 313, 10, 35, 20, 5, -28 },
  { 357, 16, 15, 20, 2, -25 },
  { 387, 16, 17, 20, 2, -19 },
  { 421, 8, 11, 20, 6, -5 },
  { 432, 8, 3, 20, 6, -12 },
  { 435, 6, 5, 20, 7, -5 },
  { 439, 14, 35, 20, 3, -28 },
  { 501, 16, 27, 20, 2, -26 },
  { 555, 14, 25, 20, 3, -25 },
  { 599, 16, 26, 20, 2, -26 },
  { 651, 15, 27, 20, 3, -26 },
  { 702, 17, 25, 20, 2, -25 },
  { 756, 15, 26, 20, 3, -25 },
  { 805, 16, 26, 20, 2, -25 },
  { 857, 15, 25, 20, 3, -25 },
  { 904, 16, 27, 20, 2, -26 },
  { 958, 16, 25, 20, 2, -25 },
  { 1008, 6, 18, 20, 7, -18 },
  { 1022, 8, 24, 20, 5, -18 },
  { 1046, 16, 16, 20, 2, -18 },
  { 1078, 16, 10, 20, 2, -16 },
  { 1098, 16, 16, 20, 2, -18 },
  { 1130, 12, 26, 20, 4, -26 },
  { 1169, 17, 31, 20, 2, -26 },
  { 1235, 20, 25, 20, 0, -25 },
  { 1298, 16, 25, 20, 2, -25 },
  { 1348, 16, 27, 20, 2, -26 },
  { 1402, 16, 25, 20, 2, -25 },
  { 1452, 15, 25, 20, 4, -25 },
  { 1499, 14, 25, 20, 4, -25 },
  { 1543, 16, 27, 20, 2, -26 },
  { 1597, 16, 25, 20, 2, -25 },
  { 1647, 12, 25, 20, 4, -25 },
  { 1685, 15, 26, 20, 2, -25 },
  { 1734, 17, 25, 20, 3, -25 },
  { 1788, 15, 25, 20, 4, -25 },
  { 1835, 18, 25, 20, 1, -25 },
  { 1892, 16, 25, 20, 2, -25 },
  { 1942, 18, 27, 20, 1, -26 },
  { 2003, 15, 25, 20, 3, -25 },
  { 2050, 18, 33, 20, 1, -26 },
  { 2125, 16, 25, 20, 2, -25 },
  { 2175, 16, 27, 20, 2, -26 },
  { 2229, 16, 25, 20, 2, -25 },
  { 2279, 16, 26, 20, 2, -25 },
  { 2331, 19, 25, 20, 1, -25 },
  { 2391, 18, 25, 20, 1, -25 },
  { 2448, 18, 25, 20, 1, -25 },
  { 2505, 19, 25, 20, 1, -25 },
  { 2565, 16, 25, 20, 2, -25 },
  { 2615, 9, 35, 20, 6, -28 },
  { 2655, 14, 35, 20, 3, -28 },
  { 2717, 9, 35, 20, 5, -28 },
  { 2757, 16, 13, 20, 2, -25 },
  { 2783, 20, 3, 20, 0, 4 },
  { 2791, 6, 7, 20, 7, -28 },
  { 2797, 14, 19, 20, 3, -19 },
  { 2831, 15, 28, 20, 3, -28 },
  { 2884, 16, 19, 20, 2, -19 },
  { 2922, 15, 28, 20, 2, -28 },
  { 2975, 16, 19, 20, 2, -19 },
  { 3013, 16, 28, 20, 3, -28 },
  { 3069, 15, 26, 20, 2, -19 },
  { 3118, 14, 28, 20, 3, -28 },
  { 3167, 16, 27, 20, 2, -27 },
  { 3221, 12, 34, 20, 3, -27 },
  { 3272, 16, 28, 20, 3, -28 },
  { 3328, 16, 28, 20, 2, -28 },
  { 3384, 17, 19, 20, 2, -19 },
  { 3425, 14, 19, 20, 3, -19 },
  { 3459, 16, 19, 20, 2, -19 },
  { 3497, 15, 26, 20, 3, -19 },
  { 3546, 15, 26, 20, 2, -19 },
  { 3595, 12, 19, 20, 5, -19 },
  { 3624, 14, 19, 20, 3, -19 },
  { 3658, 15, 25, 20, 3, -25 },
  { 3705, 14, 19, 20, 3, -19 },
  { 3739, 18, 19, 20, 1, -19 },
  { 3782, 18, 19, 20, 1, -19 },
  { 3825, 18, 19, 20, 1, -19 },
  { 3868, 16, 26, 20, 2, -19 },
  { 3920, 14, 19, 20, 3, -19 },
  { 3954, 14, 35, 20, 3, -28 },
  { 4016, 2, 35, 20, 9, -28 },
  { 4025, 14, 35, 20, 3, -28 },
  { 4087, 16, 5, 20, 2, -13 },
};

const GFXfont UbuntuSansMono_Regular36pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular36pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular36pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUSANSMONO_REGULAR36PT7B_H_
