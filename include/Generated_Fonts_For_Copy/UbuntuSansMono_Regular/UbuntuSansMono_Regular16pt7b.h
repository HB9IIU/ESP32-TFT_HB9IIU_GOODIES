#ifndef _UBUNTUSANSMONO_REGULAR16PT7B_H_
#define _UBUNTUSANSMONO_REGULAR16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x90, 0x1B, 0x80, 0xB6, 0xD0, 0x22, 0x4C, 0x97, 0xF6,
  0x48, 0x93, 0x7F, 0x49, 0x92, 0x60, 0x10, 0x31, 0xB6, 0x0C, 0x0C, 0x0E,
  0x06, 0x06, 0x0F, 0x33, 0xC1, 0x02, 0x00, 0x71, 0x49, 0x24, 0x92, 0x87,
  0xC0, 0x40, 0x5C, 0x29, 0x24, 0xB2, 0x91, 0xC0, 0x78, 0x93, 0x22, 0x47,
  0x0C, 0x65, 0x46, 0x8D, 0x1D, 0xE8, 0xF0, 0x08, 0xCC, 0xC4, 0x23, 0x10,
  0x84, 0x30, 0x86, 0x10, 0x43, 0x86, 0x18, 0x61, 0x08, 0x61, 0x08, 0xC6,
  0x23, 0x11, 0x10, 0x10, 0x23, 0xF8, 0x82, 0x8D, 0x80, 0x10, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x08, 0x6C, 0xE8, 0xE0, 0xFC, 0x06, 0x08, 0x10, 0x60,
  0x81, 0x06, 0x08, 0x10, 0x60, 0x81, 0x06, 0x08, 0x10, 0x60, 0x7C, 0x8B,
  0x1C, 0x19, 0x37, 0x60, 0xC1, 0xC6, 0x89, 0xE0, 0x18, 0x73, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x31, 0xF8, 0x7D, 0x08, 0x10, 0x20, 0xC1, 0x04,
  0x10, 0x41, 0x83, 0xF8, 0xFC, 0x08, 0x10, 0x21, 0x87, 0x81, 0x81, 0x02,
  0x0F, 0xF0, 0x0C, 0x38, 0xD1, 0x24, 0x48, 0xA1, 0x7F, 0x04, 0x08, 0x10,
  0x7E, 0x81, 0x02, 0x07, 0x03, 0x81, 0x81, 0x02, 0x0F, 0xF0, 0x1C, 0x61,
  0x06, 0x0B, 0x98, 0xA0, 0xC1, 0xC2, 0x8D, 0xF0, 0xFE, 0x0C, 0x10, 0x60,
  0x83, 0x04, 0x08, 0x30, 0x40, 0x80, 0x7D, 0x8E, 0x1E, 0x36, 0x47, 0x91,
  0xC1, 0x83, 0x8D, 0xF0, 0x7D, 0x8A, 0x1C, 0x18, 0x2D, 0xCD, 0x82, 0x04,
  0x33, 0xC0, 0xFC, 0x00, 0x3F, 0x77, 0x00, 0x00, 0x77, 0x2E, 0x80, 0x02,
  0x39, 0xC4, 0x07, 0x03, 0x80, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xC0,
  0xE0, 0x30, 0x11, 0xCE, 0x20, 0x00, 0xF8, 0x42, 0x11, 0x11, 0x80, 0x03,
  0x18, 0x3C, 0x87, 0x0E, 0x39, 0xB2, 0x6C, 0xD9, 0x93, 0xBD, 0x03, 0x03,
  0xC0, 0x1C, 0x0A, 0x05, 0x06, 0xC2, 0x21, 0x11, 0x8C, 0xFE, 0x41, 0x20,
  0xB0, 0x60, 0xF9, 0x0A, 0x14, 0x28, 0xDF, 0xA1, 0xC1, 0x83, 0x0F, 0xF0,
  0x3E, 0xC3, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0xC4, 0xF8, 0xF9, 0x1A,
  0x1C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x1B, 0xE0, 0xFE, 0x08, 0x20, 0x83,
  0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82,
  0x08, 0x00, 0x3E, 0xC3, 0x04, 0x08, 0x10, 0x20, 0xC1, 0xC2, 0xC4, 0xF8,
  0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x3E, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06,
  0x1F, 0x80, 0xC2, 0xC4, 0xC8, 0xD8, 0xF0, 0xE0, 0xD8, 0xC8, 0xC4, 0xC6,
  0xC3, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC7, 0x8F,
  0xAD, 0x5A, 0xB5, 0x64, 0xC1, 0x83, 0x06, 0x08, 0xC3, 0x86, 0x8D, 0x19,
  0x32, 0x62, 0xC5, 0x8F, 0x0E, 0x18, 0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x8D, 0xF0, 0xFD, 0x8F, 0x0E, 0x1C, 0x39, 0xBE, 0x60, 0xC1,
  0x83, 0x00, 0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x8D, 0xF0,
  0x81, 0x80, 0xC0, 0xF9, 0x0A, 0x1C, 0x38, 0x53, 0xBE, 0x44, 0x85, 0x0A,
  0x08, 0x7E, 0x83, 0x06, 0x06, 0x03, 0x01, 0x01, 0x03, 0x0F, 0xF0, 0xFE,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x8D, 0xF0, 0xC1, 0xA0, 0x90, 0x48, 0x22,
  0x21, 0x10, 0x88, 0x6C, 0x14, 0x0A, 0x06, 0x00, 0x83, 0x06, 0x0C, 0x19,
  0x36, 0x6A, 0xD5, 0xCF, 0x8F, 0x18, 0x82, 0x89, 0x31, 0x43, 0x87, 0x0A,
  0x36, 0x45, 0x8E, 0x08, 0xC1, 0xA0, 0x98, 0xC4, 0x43, 0x40, 0xA0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0xFE, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x30,
  0x41, 0x83, 0xF8, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0,
  0x81, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0x80, 0x81,
  0x03, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x51, 0xA2,
  0x2C, 0x70, 0x40, 0xFF, 0x80, 0xC8, 0x80, 0x7C, 0x0C, 0x1B, 0xFC, 0x70,
  0xF1, 0xBF, 0xC1, 0x83, 0x06, 0x0F, 0xD8, 0xF0, 0xE1, 0xC3, 0x87, 0x17,
  0xE0, 0x7F, 0x82, 0x04, 0x08, 0x18, 0x10, 0x1F, 0x06, 0x0C, 0x18, 0x37,
  0xF8, 0xE1, 0xC3, 0x87, 0x0F, 0x1B, 0xF0, 0x7D, 0x8E, 0x0F, 0xF8, 0x10,
  0x30, 0x3F, 0x1F, 0x30, 0x20, 0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x7F, 0x8E, 0x1C, 0x38, 0x70, 0xDB, 0x9F, 0x07, 0x0B, 0xE0,
  0xC1, 0x83, 0x06, 0x0F, 0xD8, 0xB1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0x30,
  0x60, 0x00, 0x0F, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xF0, 0x08, 0x70,
  0x00, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06, 0x3F, 0x80, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC6, 0xC8, 0xD0, 0xE0, 0xF0, 0xC8, 0xC4, 0xC3, 0xF0, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xF0, 0x45, 0xFE, 0x4C,
  0x99, 0x32, 0x60, 0xC1, 0x82, 0xFD, 0x8B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x71, 0x3E, 0xFD, 0x8F, 0x0E, 0x1C, 0x38,
  0x71, 0xFE, 0xC1, 0x83, 0x00, 0x7F, 0x8E, 0x1C, 0x38, 0x70, 0xF1, 0xBF,
  0x06, 0x0C, 0x18, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7D, 0x81, 0x03,
  0x80, 0xC0, 0xE1, 0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20,
  0x60, 0x78, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xD1, 0xBF, 0x83, 0x8D, 0x12,
  0x26, 0xC5, 0x0E, 0x08, 0xC1, 0xA0, 0x92, 0x4A, 0xA5, 0x52, 0xA9, 0x8C,
  0x44, 0xC6, 0xD8, 0xA0, 0x82, 0x8D, 0x91, 0xC1, 0xC3, 0x8D, 0x12, 0x22,
  0x45, 0x0E, 0x0C, 0x10, 0x63, 0x80, 0x7C, 0x18, 0x60, 0x82, 0x0C, 0x10,
  0x7F, 0x06, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xE0, 0x40, 0xC1, 0x83,
  0x06, 0x04, 0x0F, 0xFF, 0xFF, 0xC0, 0xC1, 0x86, 0x18, 0x61, 0x82, 0x0C,
  0x61, 0x86, 0x18, 0x61, 0x3C, 0x63, 0x3C, 0x10,
};

const GFXglyph UbuntuSansMono_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 3, 4, 9, 3, -12 },
  { 8, 7, 11, 9, 1, -11 },
  { 18, 7, 14, 9, 1, -12 },
  { 31, 9, 11, 9, 0, -11 },
  { 44, 7, 11, 9, 1, -11 },
  { 54, 1, 4, 9, 4, -12 },
  { 55, 5, 16, 9, 2, -13 },
  { 65, 5, 16, 9, 2, -13 },
  { 75, 7, 6, 9, 1, -11 },
  { 81, 7, 8, 9, 1, -9 },
  { 88, 3, 5, 9, 3, -2 },
  { 90, 3, 1, 9, 3, -5 },
  { 91, 3, 2, 9, 3, -2 },
  { 92, 7, 16, 9, 1, -13 },
  { 106, 7, 11, 9, 1, -11 },
  { 116, 7, 11, 9, 1, -11 },
  { 126, 7, 11, 9, 1, -11 },
  { 136, 7, 11, 9, 1, -11 },
  { 146, 7, 11, 9, 1, -11 },
  { 156, 7, 11, 9, 1, -11 },
  { 166, 7, 11, 9, 1, -11 },
  { 176, 7, 11, 9, 1, -11 },
  { 186, 7, 11, 9, 1, -11 },
  { 196, 7, 11, 9, 1, -11 },
  { 206, 3, 8, 9, 3, -8 },
  { 209, 4, 11, 9, 2, -8 },
  { 215, 7, 7, 9, 1, -8 },
  { 222, 7, 5, 9, 1, -7 },
  { 227, 7, 7, 9, 1, -8 },
  { 234, 5, 11, 9, 2, -11 },
  { 241, 7, 13, 9, 1, -11 },
  { 253, 9, 11, 9, 0, -11 },
  { 266, 7, 11, 9, 1, -11 },
  { 276, 7, 11, 9, 1, -11 },
  { 286, 7, 11, 9, 1, -11 },
  { 296, 6, 11, 9, 2, -11 },
  { 305, 6, 11, 9, 2, -11 },
  { 314, 7, 11, 9, 1, -11 },
  { 324, 7, 11, 9, 1, -11 },
  { 334, 5, 11, 9, 2, -11 },
  { 341, 6, 11, 9, 1, -11 },
  { 350, 8, 11, 9, 1, -11 },
  { 361, 6, 11, 9, 2, -11 },
  { 370, 7, 11, 9, 1, -11 },
  { 380, 7, 11, 9, 1, -11 },
  { 390, 7, 11, 9, 1, -11 },
  { 400, 7, 11, 9, 1, -11 },
  { 410, 7, 14, 9, 1, -11 },
  { 423, 7, 11, 9, 1, -11 },
  { 433, 7, 11, 9, 1, -11 },
  { 443, 7, 11, 9, 1, -11 },
  { 453, 7, 11, 9, 1, -11 },
  { 463, 9, 11, 9, 0, -11 },
  { 476, 7, 11, 9, 1, -11 },
  { 486, 7, 11, 9, 1, -11 },
  { 496, 9, 11, 9, 0, -11 },
  { 509, 7, 11, 9, 1, -11 },
  { 519, 4, 16, 9, 3, -13 },
  { 527, 7, 16, 9, 1, -13 },
  { 541, 4, 16, 9, 2, -13 },
  { 549, 7, 6, 9, 1, -11 },
  { 555, 9, 1, 9, 0, 2 },
  { 557, 3, 3, 9, 3, -12 },
  { 559, 7, 8, 9, 1, -8 },
  { 566, 7, 12, 9, 1, -12 },
  { 577, 7, 8, 9, 1, -8 },
  { 584, 7, 12, 9, 1, -12 },
  { 595, 7, 8, 9, 1, -8 },
  { 602, 8, 12, 9, 1, -12 },
  { 614, 7, 11, 9, 1, -8 },
  { 624, 7, 12, 9, 1, -12 },
  { 635, 7, 12, 9, 1, -12 },
  { 646, 6, 15, 9, 1, -12 },
  { 658, 8, 12, 9, 1, -12 },
  { 670, 7, 12, 9, 1, -12 },
  { 681, 7, 9, 9, 1, -9 },
  { 689, 7, 8, 9, 1, -8 },
  { 696, 7, 8, 9, 1, -8 },
  { 703, 7, 11, 9, 1, -8 },
  { 713, 7, 11, 9, 1, -8 },
  { 723, 6, 8, 9, 2, -8 },
  { 729, 7, 8, 9, 1, -8 },
  { 736, 7, 11, 9, 1, -11 },
  { 746, 7, 8, 9, 1, -8 },
  { 753, 7, 8, 9, 1, -8 },
  { 760, 9, 8, 9, 0, -8 },
  { 769, 7, 8, 9, 1, -8 },
  { 776, 7, 11, 9, 1, -8 },
  { 786, 7, 8, 9, 1, -8 },
  { 793, 7, 16, 9, 1, -13 },
  { 807, 1, 16, 9, 4, -13 },
  { 809, 6, 16, 9, 1, -13 },
  { 821, 7, 3, 9, 1, -6 },
};

const GFXfont UbuntuSansMono_Regular16pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular16pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUSANSMONO_REGULAR16PT7B_H_
