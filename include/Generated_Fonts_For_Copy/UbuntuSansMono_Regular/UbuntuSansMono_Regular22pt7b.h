#ifndef _UBUNTUSANSMONO_REGULAR22PT7B_H_
#define _UBUNTUSANSMONO_REGULAR22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xC8, 0x0D, 0xF0, 0xCF, 0x3C, 0xD3, 0x4D, 0x10,
  0x18, 0xC3, 0x10, 0x62, 0x08, 0xCF, 0xFE, 0x63, 0x0C, 0x41, 0x88, 0x23,
  0x1F, 0xFF, 0xFF, 0xB1, 0x06, 0x20, 0xCC, 0x11, 0x80, 0x0C, 0x03, 0x00,
  0xE0, 0xFE, 0x60, 0x18, 0x06, 0x01, 0x80, 0x38, 0x07, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x34, 0x1B, 0xFE, 0x1C, 0x03, 0x00, 0xC0, 0x10, 0x17, 0x86,
  0x4C, 0x44, 0xCC, 0xCC, 0x84, 0xD8, 0x4B, 0x03, 0xA0, 0x06, 0x00, 0x5E,
  0x0D, 0x31, 0x93, 0x11, 0x33, 0x13, 0x21, 0x36, 0x1E, 0x08, 0x07, 0xC1,
  0x8C, 0x31, 0x86, 0x30, 0xC4, 0x09, 0x81, 0xE0, 0x38, 0xCD, 0x93, 0x1A,
  0x61, 0xCC, 0x39, 0x87, 0x39, 0xB3, 0xE7, 0xFF, 0xF4, 0x0C, 0x71, 0x8C,
  0x61, 0x84, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x04, 0x18, 0x60, 0xC1, 0x83,
  0x04, 0xC3, 0x87, 0x0C, 0x18, 0x20, 0xC3, 0x04, 0x10, 0x41, 0x0C, 0x30,
  0xC6, 0x18, 0xC7, 0x38, 0x40, 0x0C, 0x03, 0x04, 0xCB, 0xDF, 0x1E, 0x07,
  0x81, 0xB0, 0xCE, 0x11, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xDE, 0x67, 0x70, 0xFF,
  0xC0, 0x7F, 0x70, 0x01, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0,
  0x0C, 0x0F, 0xC3, 0x19, 0x86, 0x60, 0xF0, 0x3C, 0x4F, 0x3B, 0xCE, 0xF1,
  0x3C, 0x0D, 0x03, 0x60, 0xD8, 0x63, 0x38, 0x7C, 0x0C, 0x0E, 0x1F, 0x19,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x61,
  0xFE, 0x18, 0x7F, 0x30, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0E,
  0x0E, 0x0E, 0x06, 0x06, 0x03, 0x01, 0xFF, 0x38, 0x7F, 0x20, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x78, 0x3E, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0E, 0x1D,
  0xFC, 0x03, 0x81, 0xE0, 0xD8, 0x26, 0x19, 0x8C, 0x62, 0x19, 0x86, 0x41,
  0xB0, 0x6F, 0xFC, 0x06, 0x01, 0x80, 0x60, 0x18, 0x7F, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0xF0, 0x1E, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x1C, 0x3B,
  0xF8, 0x07, 0x87, 0x03, 0x00, 0x80, 0x60, 0x18, 0x07, 0xF3, 0x86, 0xC0,
  0xF0, 0x3C, 0x0D, 0x03, 0x60, 0xCC, 0x61, 0xF0, 0xFF, 0x80, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x0C, 0x0F, 0xC6, 0x19, 0x83, 0x40, 0xD8, 0x26, 0x18, 0xEC, 0x3F,
  0x18, 0x64, 0x0F, 0x03, 0xC0, 0xD0, 0x36, 0x18, 0xFC, 0x0C, 0x0F, 0xC6,
  0x19, 0x02, 0xC0, 0xF0, 0x3C, 0x0D, 0x83, 0x7F, 0xC7, 0xB0, 0x0C, 0x06,
  0x01, 0x80, 0xC1, 0xE1, 0xE0, 0x7F, 0x70, 0x00, 0x00, 0x7F, 0x70, 0x3B,
  0xCE, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x33, 0x70, 0x00, 0x40, 0xF0, 0xF1,
  0xE0, 0xE0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x40, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xC0, 0xF0, 0xF0, 0xF0, 0xE0, 0x20, 0x00, 0x18, 0xFE, 0x83, 0x03, 0x03,
  0x03, 0x06, 0x0C, 0x18, 0x10, 0x10, 0x00, 0x00, 0x18, 0x38, 0x38, 0x06,
  0x03, 0xF0, 0xC3, 0x30, 0x66, 0x04, 0x81, 0xF1, 0xFE, 0x63, 0xCC, 0x79,
  0x8F, 0x21, 0xE6, 0x3C, 0xC6, 0xCD, 0xD8, 0xF3, 0x00, 0x30, 0x03, 0x90,
  0x3E, 0x00, 0x07, 0x00, 0xF0, 0x0D, 0x00, 0x98, 0x19, 0x81, 0x88, 0x10,
  0xC3, 0x0C, 0x30, 0x43, 0xFE, 0x7F, 0xE6, 0x06, 0x60, 0x24, 0x03, 0xC0,
  0x30, 0xFF, 0x30, 0xEC, 0x1B, 0x02, 0xC1, 0xB0, 0x6F, 0xF3, 0xFC, 0xC1,
  0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0xEF, 0xF0, 0x07, 0x07, 0xF3, 0x85,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x1C, 0x03, 0x8C, 0x7F, 0xFE, 0x30, 0xCC, 0x1B, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xB1, 0xCF, 0xE0, 0xFF,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0xFE, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFD,
  0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x07, 0x07, 0xF3,
  0x85, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x3C, 0x0D, 0x83,
  0x60, 0xDC, 0x33, 0x8C, 0x7F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0x3F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x1A, 0x1B, 0xFC, 0x81, 0xE0, 0xC8, 0x62,
  0x38, 0x8C, 0x26, 0x0B, 0x03, 0xC0, 0x98, 0x23, 0x08, 0x62, 0x0C, 0x81,
  0xA0, 0x68, 0x0C, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFE, 0x61, 0x98, 0x77, 0x1D,
  0xCF, 0x53, 0xF6, 0xBC, 0xAF, 0x39, 0xCC, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x04, 0xE0, 0xF8, 0x3F, 0x0F, 0x43, 0xD8, 0xF2, 0x3C, 0xCF,
  0x13, 0xC6, 0xF0, 0xBC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x0C, 0x0C, 0x07,
  0xE1, 0x86, 0x20, 0x6C, 0x0D, 0x80, 0xB0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x2C, 0x0C, 0xC1, 0x9C, 0x61, 0xF8, 0xFE, 0x61, 0xB0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x8E, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x0C, 0x07, 0xE1, 0x86, 0x20, 0x6C, 0x0D, 0x80, 0xB0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x2C, 0x0C, 0xC1, 0x9C, 0x61, 0xF8, 0x0C,
  0x00, 0xC0, 0x1E, 0x00, 0xE0, 0xFF, 0x30, 0xEC, 0x1B, 0x02, 0xC0, 0xF0,
  0x2C, 0x1B, 0xFC, 0xFE, 0x31, 0x8C, 0x33, 0x04, 0xC1, 0xB0, 0x2C, 0x0C,
  0x0E, 0x0F, 0xE7, 0x09, 0x80, 0x60, 0x18, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x36, 0x1B, 0xFC, 0xFF, 0xC3, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x60, 0xDC, 0x63, 0xF0, 0xC0, 0x36,
  0x03, 0x60, 0x26, 0x06, 0x20, 0x63, 0x04, 0x30, 0xC1, 0x0C, 0x18, 0xC1,
  0x88, 0x19, 0x80, 0x98, 0x0D, 0x00, 0xF0, 0x06, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0xC7, 0x39, 0xDA, 0xF4, 0xBD, 0x3D, 0xCF,
  0x61, 0xD8, 0x66, 0x18, 0xC0, 0xCC, 0x31, 0x86, 0x19, 0x81, 0x30, 0x3C,
  0x03, 0x00, 0x70, 0x1E, 0x06, 0x60, 0xC4, 0x30, 0xC6, 0x09, 0x81, 0xB0,
  0x38, 0xE0, 0x36, 0x06, 0x60, 0x63, 0x0C, 0x30, 0xC1, 0x98, 0x09, 0x80,
  0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x7F, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x0F, 0xFC, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0xC0, 0xC0, 0x40,
  0x60, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x04,
  0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFC, 0x0C, 0x07,
  0x81, 0xA0, 0xCC, 0x21, 0x98, 0x6C, 0x0D, 0x01, 0xFF, 0xF0, 0x4C, 0x63,
  0x3C, 0x3F, 0x80, 0xC0, 0x20, 0x19, 0xFF, 0xFF, 0x83, 0x81, 0xC0, 0xF8,
  0x6F, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xE3, 0xF9, 0x86, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x8E, 0xFE, 0x00, 0x07, 0x0F,
  0xF7, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x03, 0x84,
  0x7F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0x33, 0xFD, 0x87, 0x40,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x0D, 0xC3, 0x1F, 0xC0, 0x0E,
  0x0F, 0xE6, 0x19, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x18, 0x07,
  0x88, 0x7E, 0x0F, 0xC7, 0x33, 0x00, 0xC0, 0x30, 0x0C, 0x0F, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x0F, 0xF6, 0x0D, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8,
  0x73, 0xFC, 0x32, 0x00, 0x80, 0x66, 0x39, 0xF8, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0xC3, 0xF9, 0x86, 0xC1, 0x60, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0x80, 0x08, 0x07, 0x01, 0xC0, 0x20, 0x00, 0x00, 0x0F,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x39,
  0x07, 0xC0, 0x04, 0x1C, 0x38, 0x20, 0x00, 0x1F, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x1E, 0x7F, 0xC0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3B, 0x18, 0xCC, 0x36, 0x0F, 0x03, 0xC0,
  0xDC, 0x33, 0x8C, 0x73, 0x0E, 0xC1, 0xC0, 0xF8, 0x3E, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x31, 0x07, 0xC0, 0x73, 0x3F, 0xFC, 0xCF, 0x31, 0xCC, 0x73,
  0x1C, 0xC7, 0x31, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x38, 0x7F, 0x30, 0xD8,
  0x2C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x0C, 0x0F,
  0xC6, 0x19, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x37, 0x38,
  0x7C, 0x38, 0x7F, 0x30, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF9, 0xDF, 0xCC, 0x06, 0x03, 0x01, 0x80, 0x0E, 0x0F, 0xF7, 0x0D, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x37, 0x3C, 0xFF, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x1F, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1E, 0x3F, 0xB0, 0x18, 0x0C, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0x80, 0xF0, 0xDF, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x0F, 0xF9, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC4, 0x7E, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xB0, 0xDF, 0xE0, 0xC0,
  0xF0, 0x36, 0x0D, 0x86, 0x61, 0x8C, 0x43, 0x30, 0x4C, 0x1E, 0x03, 0x80,
  0xC0, 0x80, 0x70, 0x0F, 0x11, 0x66, 0x2C, 0xE5, 0x9D, 0x96, 0xB2, 0x9E,
  0x71, 0x8C, 0x31, 0x86, 0x00, 0xE0, 0xCE, 0x30, 0xCC, 0x0F, 0x00, 0xE0,
  0x1C, 0x06, 0xC1, 0x98, 0x61, 0x8C, 0x1B, 0x03, 0x80, 0xC0, 0xD8, 0x36,
  0x0D, 0x86, 0x31, 0x8C, 0x61, 0x10, 0x6C, 0x0B, 0x03, 0x80, 0x60, 0x10,
  0x0C, 0x26, 0x0F, 0x00, 0xFF, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0x60, 0xC0, 0xFF, 0x0F, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x30, 0xE0, 0x30, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x18, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x06, 0x07, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0xF0, 0x78, 0x73, 0xB8, 0x78,
};

const GFXglyph UbuntuSansMono_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 15, 12, 5, -15 },
  { 7, 6, 6, 12, 3, -17 },
  { 12, 11, 15, 12, 1, -15 },
  { 33, 10, 19, 12, 1, -17 },
  { 57, 12, 16, 12, 0, -16 },
  { 81, 11, 16, 12, 1, -16 },
  { 103, 2, 7, 12, 5, -17 },
  { 105, 6, 21, 12, 3, -17 },
  { 121, 6, 21, 12, 3, -17 },
  { 137, 10, 9, 12, 1, -15 },
  { 149, 10, 11, 12, 1, -12 },
  { 163, 5, 6, 12, 4, -3 },
  { 167, 5, 2, 12, 4, -7 },
  { 169, 4, 3, 12, 4, -3 },
  { 171, 8, 21, 12, 2, -17 },
  { 192, 10, 16, 12, 1, -16 },
  { 212, 9, 15, 12, 2, -15 },
  { 229, 9, 16, 12, 2, -16 },
  { 247, 9, 16, 12, 2, -16 },
  { 265, 10, 15, 12, 1, -15 },
  { 284, 9, 15, 12, 2, -15 },
  { 301, 10, 15, 12, 1, -15 },
  { 320, 9, 15, 12, 2, -15 },
  { 337, 10, 16, 12, 1, -16 },
  { 357, 10, 16, 12, 1, -16 },
  { 377, 4, 11, 12, 4, -11 },
  { 383, 5, 14, 12, 3, -11 },
  { 392, 10, 10, 12, 1, -11 },
  { 405, 10, 7, 12, 1, -10 },
  { 414, 10, 10, 12, 1, -11 },
  { 427, 8, 16, 12, 2, -16 },
  { 443, 11, 19, 12, 1, -16 },
  { 470, 12, 15, 12, 0, -15 },
  { 493, 10, 15, 12, 1, -15 },
  { 512, 10, 16, 12, 1, -16 },
  { 532, 10, 15, 12, 1, -15 },
  { 551, 9, 15, 12, 2, -15 },
  { 568, 9, 15, 12, 2, -15 },
  { 585, 10, 16, 12, 1, -16 },
  { 605, 10, 15, 12, 1, -15 },
  { 624, 8, 15, 12, 2, -15 },
  { 639, 9, 15, 12, 1, -15 },
  { 656, 10, 15, 12, 2, -15 },
  { 675, 9, 15, 12, 2, -15 },
  { 692, 10, 15, 12, 1, -15 },
  { 711, 10, 15, 12, 1, -15 },
  { 730, 11, 16, 12, 1, -16 },
  { 752, 9, 15, 12, 2, -15 },
  { 769, 11, 20, 12, 1, -16 },
  { 797, 10, 15, 12, 1, -15 },
  { 816, 10, 16, 12, 1, -16 },
  { 836, 10, 15, 12, 1, -15 },
  { 855, 10, 15, 12, 1, -15 },
  { 874, 12, 15, 12, 0, -15 },
  { 897, 10, 15, 12, 1, -15 },
  { 916, 11, 15, 12, 1, -15 },
  { 937, 12, 15, 12, 0, -15 },
  { 960, 10, 15, 12, 1, -15 },
  { 979, 5, 21, 12, 4, -17 },
  { 993, 8, 21, 12, 2, -17 },
  { 1014, 6, 21, 12, 3, -17 },
  { 1030, 10, 8, 12, 1, -15 },
  { 1040, 12, 1, 12, 0, 3 },
  { 1042, 4, 4, 12, 4, -17 },
  { 1044, 9, 12, 12, 2, -12 },
  { 1058, 9, 17, 12, 2, -17 },
  { 1078, 10, 12, 12, 1, -12 },
  { 1093, 10, 17, 12, 1, -17 },
  { 1115, 10, 12, 12, 1, -12 },
  { 1130, 10, 17, 12, 2, -17 },
  { 1152, 10, 16, 12, 1, -12 },
  { 1172, 9, 17, 12, 2, -17 },
  { 1192, 10, 17, 12, 1, -17 },
  { 1214, 7, 21, 12, 2, -17 },
  { 1233, 10, 17, 12, 2, -17 },
  { 1255, 10, 17, 12, 1, -17 },
  { 1277, 10, 12, 12, 1, -12 },
  { 1292, 9, 12, 12, 2, -12 },
  { 1306, 10, 12, 12, 1, -12 },
  { 1321, 9, 16, 12, 2, -12 },
  { 1339, 10, 16, 12, 1, -12 },
  { 1359, 8, 12, 12, 3, -12 },
  { 1371, 9, 12, 12, 2, -12 },
  { 1385, 9, 15, 12, 2, -15 },
  { 1402, 9, 11, 12, 2, -11 },
  { 1415, 10, 11, 12, 1, -11 },
  { 1429, 11, 11, 12, 1, -11 },
  { 1445, 11, 11, 12, 1, -11 },
  { 1461, 10, 15, 12, 1, -11 },
  { 1480, 8, 11, 12, 2, -11 },
  { 1491, 8, 21, 12, 2, -17 },
  { 1512, 2, 21, 12, 5, -17 },
  { 1518, 8, 21, 12, 2, -17 },
  { 1539, 10, 3, 12, 1, -8 },
};

const GFXfont UbuntuSansMono_Regular22pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular22pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUSANSMONO_REGULAR22PT7B_H_
