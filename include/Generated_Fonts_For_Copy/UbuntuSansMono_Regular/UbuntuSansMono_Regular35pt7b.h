#ifndef _UBUNTUSANSMONO_REGULAR35PT7B_H_
#define _UBUNTUSANSMONO_REGULAR35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x00,
  0x00, 0x47, 0xFF, 0xEF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x83, 0x03, 0x87, 0x01, 0x83, 0x80, 0xC1, 0xC0, 0xE0, 0xC0, 0x70,
  0x60, 0x38, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x0C, 0x07, 0x06, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0x61, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8C, 0x1C, 0x06, 0x0C, 0x07, 0x06, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xC1, 0xC0, 0xE0, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0xFF, 0x83, 0xFF, 0x8F, 0x07, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xB0, 0x1E, 0xFF, 0xFC, 0x7F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0xEE, 0x70, 0x33, 0x0C,
  0x1C, 0xC3, 0x0E, 0x30, 0xC3, 0x0C, 0x31, 0xC3, 0x0C, 0x60, 0xC3, 0x38,
  0x39, 0xCC, 0x07, 0xE6, 0x01, 0xFB, 0x80, 0x00, 0xC0, 0x00, 0x73, 0x00,
  0x19, 0xF0, 0x0C, 0xE6, 0x07, 0x31, 0x81, 0x8C, 0x70, 0xE7, 0x0C, 0x31,
  0xC3, 0x18, 0x70, 0xCE, 0x0C, 0x73, 0x03, 0x19, 0xC0, 0xEE, 0xE0, 0x1F,
  0x00, 0x01, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0x87, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x18, 0x70, 0x0E, 0x70,
  0x07, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x70, 0xFC, 0x38, 0xE7, 0x1C, 0xE3,
  0xCC, 0x70, 0xF6, 0x38, 0x3F, 0x38, 0x0F, 0x9C, 0x03, 0x8F, 0x01, 0xE3,
  0x81, 0xF1, 0xE1, 0xFC, 0x7F, 0xE7, 0x1F, 0xC3, 0x80, 0xFF, 0xFF, 0xFB,
  0x6C, 0x01, 0x80, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0x20, 0x40, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x83, 0xC0,
  0x60, 0x10, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x02, 0x0C, 0x17, 0x18,
  0xEF, 0xB7, 0xFF, 0xFF, 0x01, 0xC0, 0x07, 0xC0, 0x1D, 0xC0, 0x39, 0xC0,
  0xE3, 0xC3, 0xC3, 0x81, 0x04, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x1E, 0x1E, 0x3F, 0x3F, 0x1F, 0x0E, 0x0E, 0x3C,
  0xF8, 0xF0, 0x80, 0xFF, 0xFF, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x38, 0x3C, 0x78, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE3, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1,
  0x87, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x0E, 0x70,
  0x1C, 0x38, 0x1C, 0x3C, 0x38, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0x80, 0x01,
  0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0xFD, 0x81, 0xC6, 0x04, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x07, 0xFF, 0xDF, 0xFF, 0x07, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0x81,
  0xE4, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0x7F, 0xFE, 0x0F, 0x81, 0xFF, 0x8F, 0xFF, 0x10, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x03,
  0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xFC, 0x07, 0xBF, 0xFC, 0xFF, 0xE0,
  0x10, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1D, 0x80, 0x1C,
  0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x0E, 0x18, 0x06, 0x0C, 0x07, 0x06, 0x07,
  0x03, 0x03, 0x01, 0x83, 0x80, 0xC1, 0x80, 0x61, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x3F, 0xFC, 0xFF, 0xF3, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xF8, 0x07, 0xFC,
  0x1F, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0x01, 0xEF, 0xFF, 0x1F, 0xF8, 0x04,
  0x00, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x63, 0xC0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0,
  0x06, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x0F,
  0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xC0, 0xE7, 0x00, 0xEE, 0x01, 0xD8,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x38, 0xF0, 0xF0, 0xFB, 0xC0, 0xFE,
  0x03, 0xBF, 0x0E, 0x0F, 0x38, 0x0F, 0x60, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xEE, 0x01, 0xDE, 0x07, 0x1F, 0xFE, 0x1F, 0xF0, 0x06,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1B, 0x80, 0x37,
  0x81, 0xE7, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x03, 0xF8, 0x3F, 0xC0, 0x7C, 0x00,
  0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xBF,
  0xF9, 0xE0, 0x1E, 0x3E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x3E, 0x3F, 0x3F, 0x1F, 0x0E, 0x0E, 0x3C, 0xF8,
  0xF0, 0x80, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x80, 0x00, 0x1F, 0x0F, 0xFC, 0xFF, 0xE8, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1C, 0x0E,
  0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x03, 0x70, 0x1F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xE3, 0xC3, 0xE3, 0x83, 0xE3, 0x83, 0xE7, 0x03, 0xE7, 0x03,
  0xE7, 0x03, 0xE3, 0x03, 0xE3, 0x83, 0xE3, 0x83, 0xF1, 0xC3, 0x71, 0xFF,
  0x70, 0x7F, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x84,
  0x07, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xDC, 0x00, 0x39, 0x80, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x60, 0x06,
  0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38,
  0x06, 0x07, 0x00, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x00, 0x30, 0xC0,
  0x07, 0x18, 0x00, 0xE7, 0x00, 0x0C, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00,
  0x07, 0x04, 0x01, 0xFF, 0xC3, 0xFF, 0xE7, 0x03, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x03, 0x70, 0x06, 0xE0, 0x1D, 0xC0, 0x3B, 0x81, 0xE7, 0xFF, 0x8F,
  0xFF, 0x1C, 0x3F, 0x38, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0x7F, 0xFC, 0xFF, 0xE0,
  0x00, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x02, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x06, 0x0F, 0xFF,
  0x07, 0xFE, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xE0, 0xF8,
  0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C,
  0xE0, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xEE, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xFF, 0x3F, 0xFC, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1E, 0x02, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x38, 0x07, 0x3C, 0x07, 0x1E,
  0x07, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x40, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x40, 0x3D, 0x81, 0xEF, 0xFF, 0x0F,
  0xF8, 0x03, 0x00, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE0,
  0xF0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xEF, 0x00, 0xE3, 0xC0, 0xE1, 0xC0, 0xE0,
  0xE0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x38, 0x0F, 0x1C,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xB1, 0xF0, 0xD9, 0xD8, 0x6C,
  0xEC, 0x66, 0x77, 0x33, 0x39, 0x99, 0x9C, 0xDC, 0xEE, 0x3C, 0x76, 0x1E,
  0x3B, 0x0F, 0x1D, 0x83, 0x0E, 0xC0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xD8,
  0x00, 0xEC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7D, 0x80, 0xFB,
  0x81, 0xF3, 0x03, 0xE7, 0x07, 0xC6, 0x0F, 0x8E, 0x1F, 0x0C, 0x3E, 0x1C,
  0x7C, 0x18, 0xF8, 0x39, 0xF0, 0x33, 0xE0, 0x77, 0xC0, 0xEF, 0x80, 0xDF,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0x01, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x38, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x39, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x03, 0x98,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x0E, 0x03, 0xC1, 0xC1,
  0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x02, 0x01, 0xFF, 0xC3,
  0xFF, 0xC7, 0x03, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x00, 0xEE, 0x03, 0x9F, 0xFF, 0x3F, 0xF8,
  0x7F, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xF0, 0x38, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x39, 0xC0,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x03, 0x98, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x0E, 0x03, 0xC1, 0xC1, 0xE0, 0x7F,
  0xF0, 0x07, 0xF8, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x04, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0,
  0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x30, 0xE0, 0x38, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0x03, 0xF0, 0x3F, 0xF8, 0xFF,
  0xF1, 0xC0, 0x67, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xD8, 0x0F, 0x7F, 0xFC, 0x3F, 0xF0, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E,
  0x70, 0x0E, 0x78, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x01, 0x00, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x30, 0xC0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0x81, 0x80, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x00, 0xC1, 0xC0, 0x38, 0x70, 0x0E, 0x18,
  0x01, 0x8E, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x03, 0x70, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00,
  0x76, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x07, 0x60, 0x03, 0xB0,
  0xE1, 0xD8, 0x78, 0xEC, 0x3C, 0x77, 0x36, 0x33, 0x9B, 0x99, 0xCC, 0xCC,
  0xEE, 0x66, 0x76, 0x3B, 0x3B, 0x0D, 0x9F, 0x86, 0xC7, 0x83, 0xE3, 0xC0,
  0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x70, 0x03, 0x9C, 0x03, 0x8E,
  0x03, 0xC3, 0x81, 0xC1, 0xC1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x0E, 0x70,
  0x07, 0x70, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3B,
  0x80, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x87,
  0x01, 0xC3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC1,
  0xC0, 0xE0, 0x70, 0x30, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0x73, 0x80, 0x1D,
  0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xFF, 0xFF, 0x80, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x3C, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x0E, 0xE0, 0x0E, 0x70, 0x1C, 0x30, 0x18, 0x38, 0x38, 0x18, 0x30, 0x1C,
  0x70, 0x0C, 0xE0, 0x0E, 0xE0, 0x07, 0x40, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x47, 0x38, 0xE3, 0x8C, 0x40, 0x03, 0x00, 0x7F, 0xE0, 0x7F, 0xE1,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xFE, 0x3F,
  0xFD, 0xFD, 0xFB, 0x80, 0x77, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x07,
  0x78, 0x0E, 0x7F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE2, 0x01, 0xFF,
  0xC3, 0xFF, 0xC7, 0x83, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x03, 0x70, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xB8,
  0x07, 0x70, 0x1E, 0xE0, 0xF9, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x60, 0x07,
  0xFE, 0x1F, 0xFE, 0x3E, 0x02, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x02, 0x1F, 0xFE, 0x07, 0xFF, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x01, 0x0E, 0x1F, 0xFC, 0xFF, 0xF9, 0xC1, 0xF7, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xDC, 0x03, 0xBC, 0x07, 0x3C, 0x0E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x3C, 0x1C, 0x70, 0x0E,
  0x70, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x04,
  0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0x07, 0x86, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x40,
  0x1F, 0xFC, 0xFF, 0xFB, 0xE0, 0x77, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xDC, 0x03, 0xBE, 0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x04, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x90, 0x0F, 0x3F, 0xFC, 0x7F, 0xE0, 0x0C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE2, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0x6E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE1, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x74, 0x0E, 0xFF, 0xEF, 0xFC,
  0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0xE0, 0x38,
  0xE0, 0x70, 0xE0, 0xE0, 0xE1, 0xC0, 0xE7, 0x80, 0xEF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xE7, 0x80, 0xE3, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0,
  0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0F, 0xFF, 0x01, 0xFE, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC2, 0x03, 0xFC, 0x03, 0xF8, 0x10,
  0x10, 0xFE, 0xFC, 0xFF, 0xFE, 0xC3, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1,
  0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC1, 0x87, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x02, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x01,
  0x80, 0x0F, 0xF0, 0x3F, 0xF8, 0x38, 0x3C, 0x70, 0x1E, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F,
  0xE0, 0x02, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0x03, 0xCE, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xB8, 0x07, 0x70, 0x1E, 0xF8, 0x79, 0xFF, 0xE3, 0xFF,
  0x87, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x1F, 0xFC, 0x7F, 0xF9, 0xE0, 0x77, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x01, 0x80, 0xFF, 0xE7, 0xFF, 0xBC,
  0x02, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xE0, 0x3B,
  0xFF, 0xEF, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x10, 0x7F, 0xC0, 0xFF, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01,
  0xDE, 0x07, 0x3F, 0xFC, 0x7F, 0xF0, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01,
  0xCF, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0xE0, 0x38, 0x38, 0x1C, 0x1C,
  0x1C, 0x07, 0x0E, 0x03, 0x86, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x3B, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0xC1, 0x98, 0x70, 0x66, 0x1E,
  0x39, 0x87, 0x8E, 0x73, 0xE3, 0x9C, 0xDC, 0xC7, 0x33, 0x30, 0xDC, 0xCC,
  0x36, 0x3F, 0x0D, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x38, 0x3C, 0x0E, 0x06,
  0x03, 0x80, 0x70, 0x07, 0x9C, 0x07, 0x87, 0x03, 0x83, 0xC3, 0x80, 0xE3,
  0x80, 0x39, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xE7, 0x00, 0xE1, 0xC0, 0xE0, 0xF0, 0xE0, 0x38, 0x70, 0x0E,
  0x70, 0x07, 0xF0, 0x01, 0xC0, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x1C, 0x1C,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x30, 0x07, 0x70, 0x07, 0x70, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x20, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xFF, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07,
  0xF8, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x1F,
  0x00, 0x78, 0x07, 0xC0, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x1F, 0xE0, 0xFE, 0x00, 0x3C, 0x02, 0x7F, 0x03, 0xE7, 0xC6, 0xC1, 0xFE,
  0xC0, 0xFC,
};

const GFXglyph UbuntuSansMono_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 24, 20, 7, -24 },
  { 16, 8, 10, 20, 6, -27 },
  { 26, 17, 24, 20, 1, -24 },
  { 77, 15, 31, 20, 2, -27 },
  { 136, 18, 26, 20, 1, -25 },
  { 195, 17, 25, 20, 1, -25 },
  { 249, 3, 10, 20, 8, -27 },
  { 253, 10, 34, 20, 5, -27 },
  { 296, 10, 34, 20, 5, -27 },
  { 339, 15, 14, 20, 2, -24 },
  { 366, 16, 17, 20, 2, -19 },
  { 400, 8, 11, 20, 6, -5 },
  { 411, 8, 2, 20, 6, -11 },
  { 413, 6, 5, 20, 7, -5 },
  { 417, 14, 33, 20, 3, -27 },
  { 475, 16, 26, 20, 2, -25 },
  { 527, 14, 24, 20, 3, -24 },
  { 569, 15, 25, 20, 2, -25 },
  { 616, 14, 26, 20, 3, -25 },
  { 662, 17, 24, 20, 1, -24 },
  { 713, 14, 25, 20, 3, -24 },
  { 757, 16, 25, 20, 2, -24 },
  { 807, 15, 24, 20, 3, -24 },
  { 852, 15, 26, 20, 2, -25 },
  { 901, 15, 25, 20, 2, -25 },
  { 948, 6, 18, 20, 7, -18 },
  { 962, 8, 24, 20, 5, -18 },
  { 986, 16, 16, 20, 2, -18 },
  { 1018, 16, 10, 20, 2, -15 },
  { 1038, 16, 16, 20, 2, -18 },
  { 1070, 12, 25, 20, 4, -25 },
  { 1108, 16, 30, 20, 2, -25 },
  { 1168, 19, 24, 20, 0, -24 },
  { 1225, 15, 25, 20, 2, -25 },
  { 1272, 16, 26, 20, 2, -25 },
  { 1324, 16, 25, 20, 2, -25 },
  { 1374, 14, 24, 20, 4, -24 },
  { 1416, 13, 24, 20, 4, -24 },
  { 1455, 16, 26, 20, 2, -25 },
  { 1507, 16, 24, 20, 2, -24 },
  { 1555, 12, 24, 20, 4, -24 },
  { 1591, 14, 25, 20, 2, -24 },
  { 1635, 16, 24, 20, 3, -24 },
  { 1683, 14, 24, 20, 4, -24 },
  { 1725, 17, 24, 20, 1, -24 },
  { 1776, 15, 24, 20, 2, -24 },
  { 1821, 18, 26, 20, 1, -25 },
  { 1880, 15, 25, 20, 3, -25 },
  { 1927, 18, 31, 20, 1, -25 },
  { 1997, 16, 25, 20, 2, -25 },
  { 2047, 15, 26, 20, 2, -25 },
  { 2096, 16, 24, 20, 2, -24 },
  { 2144, 16, 25, 20, 2, -24 },
  { 2194, 18, 24, 20, 1, -24 },
  { 2248, 17, 24, 20, 1, -24 },
  { 2299, 17, 24, 20, 1, -24 },
  { 2350, 18, 24, 20, 1, -24 },
  { 2404, 16, 24, 20, 2, -24 },
  { 2452, 9, 33, 20, 6, -27 },
  { 2490, 14, 33, 20, 3, -27 },
  { 2548, 9, 33, 20, 5, -27 },
  { 2586, 16, 13, 20, 2, -24 },
  { 2612, 19, 2, 20, 0, 4 },
  { 2617, 5, 7, 20, 7, -27 },
  { 2622, 15, 19, 20, 2, -19 },
  { 2658, 15, 27, 20, 3, -27 },
  { 2709, 16, 19, 20, 2, -19 },
  { 2747, 15, 27, 20, 2, -27 },
  { 2798, 16, 19, 20, 2, -19 },
  { 2836, 16, 27, 20, 3, -27 },
  { 2890, 15, 26, 20, 2, -19 },
  { 2939, 14, 27, 20, 3, -27 },
  { 2987, 15, 26, 20, 2, -26 },
  { 3036, 12, 33, 20, 3, -26 },
  { 3086, 16, 27, 20, 3, -27 },
  { 3140, 15, 27, 20, 2, -27 },
  { 3191, 16, 19, 20, 2, -19 },
  { 3229, 14, 19, 20, 3, -19 },
  { 3263, 16, 19, 20, 2, -19 },
  { 3301, 15, 25, 20, 3, -19 },
  { 3348, 15, 25, 20, 2, -19 },
  { 3395, 13, 19, 20, 4, -19 },
  { 3426, 14, 19, 20, 3, -19 },
  { 3460, 14, 24, 20, 3, -24 },
  { 3502, 14, 18, 20, 3, -18 },
  { 3534, 17, 18, 20, 1, -18 },
  { 3573, 18, 18, 20, 1, -18 },
  { 3614, 17, 18, 20, 1, -18 },
  { 3653, 16, 25, 20, 2, -18 },
  { 3703, 14, 18, 20, 3, -18 },
  { 3735, 14, 33, 20, 3, -27 },
  { 3793, 2, 33, 20, 9, -27 },
  { 3802, 13, 33, 20, 3, -27 },
  { 3856, 16, 5, 20, 2, -13 },
};

const GFXfont UbuntuSansMono_Regular35pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular35pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular35pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUSANSMONO_REGULAR35PT7B_H_
