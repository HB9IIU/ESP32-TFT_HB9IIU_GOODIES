#ifndef _UBUNTUSANSMONO_REGULAR62PT7B_H_
#define _UBUNTUSANSMONO_REGULAR62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xF7, 0xFB, 0xFD, 0xFF, 0xFF, 0x7F,
  0x9F, 0x87, 0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xEF, 0x01, 0xDE, 0x03, 0x98, 0x07, 0x30, 0x0E, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x03, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x1F, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x1E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F,
  0x83, 0xF0, 0x00, 0x20, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x40,
  0x00, 0x0F, 0xCE, 0x00, 0x03, 0xF1, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x1F, 0xF8,
  0x00, 0x3E, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x3C, 0x00, 0x78, 0x78, 0x1E,
  0x00, 0xF8, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1E, 0x01, 0xF0, 0x70, 0x1E,
  0x03, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0E, 0x07, 0xC0, 0xF0, 0x0E,
  0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x80, 0x70, 0x1E, 0x1F, 0x00, 0x78, 0x1E,
  0x1E, 0x00, 0x78, 0x1E, 0x3E, 0x00, 0x78, 0x1E, 0x3C, 0x00, 0x3C, 0x3C,
  0x7C, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0x0F, 0xF1,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC1, 0xC0, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x0F, 0x8F, 0xFC, 0x00, 0x0F,
  0x1F, 0xFE, 0x00, 0x1F, 0x1E, 0x1E, 0x00, 0x3E, 0x3C, 0x1F, 0x00, 0x3C,
  0x3C, 0x0F, 0x00, 0x7C, 0x3C, 0x0F, 0x00, 0x78, 0x38, 0x0F, 0x00, 0xF8,
  0x78, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x07, 0xC0, 0x3C, 0x0F, 0x07, 0x80,
  0x3C, 0x0F, 0x0F, 0x00, 0x3C, 0x0F, 0x1F, 0x00, 0x3E, 0x1E, 0x1E, 0x00,
  0x1F, 0x3E, 0x3E, 0x00, 0x0F, 0xFC, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x1E, 0x01, 0xFF, 0x80, 0x3C, 0x07, 0xFF, 0x80, 0x78, 0x0F,
  0x9F, 0x81, 0xE0, 0x3E, 0x3F, 0x83, 0xC0, 0xFC, 0x3F, 0x07, 0x81, 0xF0,
  0x3F, 0x0F, 0x07, 0xE0, 0x3F, 0x1E, 0x0F, 0x80, 0x3F, 0x78, 0x1F, 0x00,
  0x3F, 0xF0, 0x3E, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x3F, 0xC1, 0xF8, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x01,
  0xFC, 0x0F, 0xC0, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xFC, 0x1F, 0xC0, 0xFE,
  0xF8, 0x1F, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF, 0x83,
  0xF0, 0x1F, 0xFC, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0x73, 0x80, 0x00, 0x03, 0x00,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x04,
  0x10, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0x80, 0xF0, 0x1C, 0x7E, 0x0E, 0x0F, 0x8F, 0xF1, 0xC7,
  0xFB, 0xFF, 0xBB, 0xFF, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1C, 0x01, 0xC0,
  0x01, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x07, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE, 0x07, 0xE0, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x3F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x7E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x70, 0x1F, 0x7C, 0x0F, 0x81, 0xF7,
  0xC1, 0xFC, 0x1F, 0xFC, 0x1F, 0xC1, 0xFF, 0xC3, 0xFC, 0x1F, 0xFC, 0x1F,
  0xC1, 0xFF, 0xC1, 0xFC, 0x1F, 0xFC, 0x1F, 0xC1, 0xF7, 0xC0, 0xF0, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xDF, 0x00, 0x7F, 0x9F, 0x00, 0xFE, 0x1F,
  0x00, 0xFC, 0x1F, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xE1, 0xFC, 0x01, 0xFE,
  0x1E, 0x00, 0x0F, 0xC1, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE,
  0xFF, 0xE0, 0x78, 0x01, 0xFC, 0x04, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x10, 0x00, 0x07, 0xE3, 0x80, 0x03, 0xF8,
  0x7F, 0xDF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x90, 0x00, 0x0F, 0xC7, 0x00, 0x0F, 0xF1,
  0xFF, 0x7F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x8F, 0xFC, 0x03, 0xEF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0,
  0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0,
  0x7F, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0x03,
  0xE0, 0x0F, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF8,
  0x00, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x0F, 0x9F, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xF0, 0x1F,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xF8, 0x03,
  0xFE, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x1C, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x7C, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xC1, 0xFF,
  0x20, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xF3, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x81,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x1D, 0xEF, 0xC0, 0x0F, 0xFF, 0x7C, 0x01, 0xFF, 0xFB,
  0xE0, 0x1F, 0xFF, 0xDF, 0x01, 0xFE, 0x3E, 0xF8, 0x1F, 0x80, 0xF7, 0xC0,
  0xF8, 0x07, 0xFE, 0x0F, 0xC0, 0x3F, 0xF0, 0x7C, 0x01, 0xFF, 0x83, 0xE0,
  0x0F, 0xFC, 0x3F, 0x00, 0x7F, 0xE1, 0xF0, 0x03, 0xFF, 0x0F, 0x80, 0x1F,
  0xF8, 0x7C, 0x00, 0xFF, 0xC3, 0xE0, 0x07, 0xFE, 0x1F, 0x00, 0x3F, 0xF0,
  0xF8, 0x01, 0xEF, 0x83, 0xE0, 0x0F, 0x7C, 0x1F, 0x00, 0x7B, 0xE0, 0xF8,
  0x03, 0xDF, 0x87, 0xE0, 0x1E, 0xFC, 0x1F, 0x80, 0xF7, 0xE0, 0x7E, 0x07,
  0x9F, 0x03, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0x1F,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0x80,
  0x1F, 0xE1, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x87, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFD, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x3F, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x41,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x20, 0x7F, 0x80, 0x1E, 0x03, 0xFF, 0xBF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x00,
  0x7F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xE0, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE,
  0x0F, 0xE0, 0x7F, 0x00, 0x1C, 0x0F, 0xE0, 0x00, 0x40, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x01,
  0xF0, 0x7F, 0x00, 0x1F, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF3, 0x00,
  0x03, 0xF1, 0xE0, 0x03, 0xF9, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xF8,
  0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0x81, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x3F, 0x80, 0x00,
  0xF8, 0xFE, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0,
  0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xFC, 0x7C,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0xFF, 0x07, 0x78, 0x03, 0xFC, 0x1D, 0xE0, 0x0F, 0xF0, 0x77, 0x80,
  0x7B, 0xC1, 0xCF, 0x01, 0xEF, 0x0F, 0x3C, 0x07, 0xBE, 0x3C, 0xF0, 0x3C,
  0x78, 0xF1, 0xE0, 0xF1, 0xE3, 0xC7, 0x83, 0xC7, 0x8F, 0x1E, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8F,
  0x07, 0xBC, 0x1E, 0x3C, 0x1E, 0xF0, 0x78, 0xF0, 0x3B, 0x81, 0xE3, 0xC0,
  0xFE, 0x07, 0x9F, 0x03, 0xF8, 0x1E, 0x7C, 0x07, 0xC0, 0x79, 0xF0, 0x1F,
  0x01, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0x7C, 0x00, 0x7F, 0xEF, 0x80, 0x0F, 0xFC, 0xF8, 0x01, 0xFF, 0x9F,
  0x00, 0x3F, 0xF1, 0xF0, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0xC3, 0xE0, 0x1F,
  0xF8, 0x7C, 0x03, 0xFF, 0x07, 0xC0, 0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x0F,
  0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0, 0x1F, 0x07, 0xFE, 0x03, 0xE0, 0xFF,
  0xC0, 0x3C, 0x1F, 0xF8, 0x07, 0xC3, 0xFF, 0x00, 0x78, 0x7F, 0xE0, 0x0F,
  0x8F, 0xFC, 0x00, 0xF1, 0xFF, 0x80, 0x1F, 0x3F, 0xF0, 0x03, 0xE7, 0xFE,
  0x00, 0x3C, 0xFF, 0xC0, 0x07, 0xDF, 0xF8, 0x00, 0x7B, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0x87, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0x00, 0x1F, 0xE7, 0x80, 0x03, 0xF3, 0xC0, 0x00,
  0xFD, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xDE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7, 0x80, 0x0F, 0xF3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x87,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x41, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x98, 0x00, 0x03, 0xF3, 0xC0,
  0x01, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x79, 0xF0, 0x1F, 0x01, 0xE7, 0xC0, 0xFC, 0x07, 0x9F, 0x03, 0xF8,
  0x1E, 0x7C, 0x0F, 0xE0, 0x78, 0xF0, 0x7F, 0x81, 0xE3, 0xC1, 0xEF, 0x07,
  0x8F, 0x07, 0x3C, 0x1E, 0x3C, 0x3C, 0xF0, 0x78, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x1E, 0x1E, 0x3C, 0x78, 0x3C, 0x70, 0xF1,
  0xE0, 0xF1, 0xC3, 0xCF, 0x03, 0xC7, 0x0F, 0x3C, 0x07, 0xBC, 0x3C, 0xF0,
  0x1E, 0xF0, 0xF7, 0x80, 0x7B, 0xC1, 0xDE, 0x00, 0xFF, 0x07, 0x78, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0xF8,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x30, 0x1C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xF0, 0x38, 0x04, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFF, 0x02, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0x7F, 0x00, 0x07, 0xCF, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC3, 0xF8, 0x00, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3E,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xFC, 0x7C, 0x00,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xE0, 0x01, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x0C, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x1F, 0x00, 0xFF, 0xFB, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFC, 0x01,
  0xFE, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C,
  0x7F, 0x00, 0x0F, 0x87, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x01, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0x02, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x07, 0xCF, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xFC, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xF8, 0x03, 0xFE, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xC0,
  0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F,
  0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x98, 0x01, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC1, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0x83, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0x9F, 0xC0, 0x00, 0xF8, 0xFF, 0x00, 0x0F, 0x87, 0xF8, 0x00,
  0xF8, 0x1F, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0xF8, 0x07, 0xF0, 0x0F, 0x80,
  0x3F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x60, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x03, 0xFF, 0xC7, 0xFC, 0x3F,
  0xFF, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xC3, 0xFE, 0x3F, 0x7C, 0x0F,
  0xC0, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xC0, 0x07, 0xF3, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xF0, 0x01, 0xFC,
  0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x8F, 0xF8, 0x0F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFB, 0xFF, 0xE0, 0x1F, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xF1, 0xFE, 0x03, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xF3,
  0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC0, 0x3B, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFE, 0x07,
  0xE3, 0xF0, 0x00, 0x11, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE8, 0x00, 0x03,
  0xF7, 0x80, 0x03, 0xF7, 0xFE, 0x3F, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x60,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xDF, 0x80, 0x03, 0xE7, 0xF0, 0x01, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x03, 0xE0, 0x1E,
  0x3C, 0x03, 0xE0, 0x1E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x07, 0xF0, 0x3E,
  0x3E, 0x07, 0xF0, 0x3E, 0x3E, 0x07, 0xF0, 0x3C, 0x3E, 0x0F, 0xF8, 0x3C,
  0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0x0F, 0x78, 0x7C, 0x1F, 0x1E, 0x3C, 0x7C,
  0x1F, 0x1E, 0x3C, 0x7C, 0x1F, 0x1E, 0x3C, 0x78, 0x1F, 0x3C, 0x1E, 0x78,
  0x0F, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x1E, 0xF8, 0x0F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0,
  0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x7E, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xCF, 0xFF, 0x80, 0x1C, 0x7F, 0xFE,
  0x01, 0xE7, 0xC3, 0xFC, 0x0F, 0x3C, 0x07, 0xFF, 0xF3, 0xC0, 0x1F, 0xFF,
  0x9E, 0x00, 0x3F, 0xF8, 0x20, 0x00, 0x7F, 0x00,
};

const GFXglyph UbuntuSansMono_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 44, 35, 13, -43 },
  { 51, 15, 16, 35, 10, -47 },
  { 81, 31, 43, 35, 2, -43 },
  { 248, 27, 55, 35, 4, -48 },
  { 434, 32, 45, 35, 1, -44 },
  { 614, 31, 45, 35, 2, -44 },
  { 789, 5, 18, 35, 15, -47 },
  { 801, 18, 60, 35, 8, -48 },
  { 936, 18, 60, 35, 8, -48 },
  { 1071, 27, 25, 35, 4, -43 },
  { 1156, 29, 30, 35, 3, -33 },
  { 1265, 13, 19, 35, 11, -9 },
  { 1296, 14, 5, 35, 10, -20 },
  { 1305, 9, 10, 35, 13, -9 },
  { 1317, 25, 60, 35, 5, -49 },
  { 1505, 28, 45, 35, 3, -44 },
  { 1663, 24, 43, 35, 6, -43 },
  { 1792, 27, 44, 35, 4, -44 },
  { 1941, 27, 45, 35, 4, -44 },
  { 2093, 29, 43, 35, 3, -43 },
  { 2249, 26, 44, 35, 5, -43 },
  { 2392, 27, 44, 35, 4, -43 },
  { 2541, 27, 43, 35, 5, -43 },
  { 2687, 27, 45, 35, 4, -44 },
  { 2839, 27, 44, 35, 4, -44 },
  { 2988, 9, 33, 35, 13, -32 },
  { 3026, 13, 42, 35, 9, -32 },
  { 3095, 28, 27, 35, 4, -31 },
  { 3190, 29, 17, 35, 3, -27 },
  { 3252, 28, 27, 35, 4, -31 },
  { 3347, 21, 45, 35, 7, -44 },
  { 3466, 29, 53, 35, 3, -44 },
  { 3659, 33, 43, 35, 1, -43 },
  { 3837, 27, 43, 35, 4, -43 },
  { 3983, 28, 45, 35, 4, -44 },
  { 4141, 28, 43, 35, 4, -43 },
  { 4292, 25, 43, 35, 7, -43 },
  { 4427, 24, 43, 35, 7, -43 },
  { 4556, 28, 45, 35, 4, -44 },
  { 4714, 29, 43, 35, 3, -43 },
  { 4870, 21, 43, 35, 7, -43 },
  { 4983, 25, 44, 35, 4, -43 },
  { 5121, 29, 43, 35, 5, -43 },
  { 5277, 25, 43, 35, 7, -43 },
  { 5412, 30, 43, 35, 2, -43 },
  { 5574, 27, 43, 35, 4, -43 },
  { 5720, 31, 45, 35, 2, -44 },
  { 5895, 25, 43, 35, 6, -43 },
  { 6030, 31, 55, 35, 2, -44 },
  { 6244, 28, 43, 35, 4, -43 },
  { 6395, 27, 45, 35, 4, -44 },
  { 6547, 29, 43, 35, 3, -43 },
  { 6703, 27, 44, 35, 4, -43 },
  { 6852, 33, 43, 35, 1, -43 },
  { 7030, 30, 43, 35, 2, -43 },
  { 7192, 31, 43, 35, 2, -43 },
  { 7359, 33, 43, 35, 1, -43 },
  { 7537, 28, 43, 35, 4, -43 },
  { 7688, 15, 60, 35, 11, -49 },
  { 7801, 24, 60, 35, 5, -49 },
  { 7981, 16, 60, 35, 8, -49 },
  { 8101, 28, 23, 35, 3, -43 },
  { 8182, 33, 4, 35, 1, 7 },
  { 8199, 10, 12, 35, 12, -48 },
  { 8214, 26, 34, 35, 4, -33 },
  { 8325, 27, 49, 35, 5, -48 },
  { 8491, 27, 34, 35, 4, -33 },
  { 8606, 27, 49, 35, 3, -48 },
  { 8772, 28, 34, 35, 3, -33 },
  { 8891, 28, 48, 35, 5, -48 },
  { 9059, 27, 45, 35, 3, -33 },
  { 9211, 25, 48, 35, 5, -48 },
  { 9361, 27, 48, 35, 4, -47 },
  { 9523, 21, 59, 35, 5, -47 },
  { 9678, 28, 48, 35, 5, -48 },
  { 9846, 27, 49, 35, 4, -48 },
  { 10012, 29, 33, 35, 3, -33 },
  { 10132, 25, 33, 35, 5, -33 },
  { 10236, 29, 34, 35, 3, -33 },
  { 10360, 27, 44, 35, 5, -33 },
  { 10509, 27, 44, 35, 3, -33 },
  { 10658, 22, 33, 35, 8, -33 },
  { 10749, 25, 34, 35, 5, -33 },
  { 10856, 26, 43, 35, 5, -42 },
  { 10996, 25, 33, 35, 5, -32 },
  { 11100, 30, 32, 35, 2, -32 },
  { 11220, 32, 32, 35, 1, -32 },
  { 11348, 31, 32, 35, 2, -32 },
  { 11472, 29, 44, 35, 3, -32 },
  { 11632, 24, 32, 35, 5, -32 },
  { 11728, 23, 60, 35, 6, -49 },
  { 11901, 5, 60, 35, 15, -49 },
  { 11939, 24, 60, 35, 5, -49 },
  { 12119, 29, 9, 35, 3, -23 },
};

const GFXfont UbuntuSansMono_Regular62pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular62pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular62pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _UBUNTUSANSMONO_REGULAR62PT7B_H_
