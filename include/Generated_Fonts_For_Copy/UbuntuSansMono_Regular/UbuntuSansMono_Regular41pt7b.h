#ifndef _UBUNTUSANSMONO_REGULAR41PT7B_H_
#define _UBUNTUSANSMONO_REGULAR41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x18, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xF2, 0x00, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0C, 0x01, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01,
  0xC0, 0xE0, 0x0E, 0x07, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80, 0x3C,
  0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83,
  0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3F,
  0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x02, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xF8, 0x01, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x03, 0x9C, 0xE0,
  0x39, 0xC3, 0x01, 0xCE, 0x1C, 0x1C, 0x70, 0xE0, 0xE3, 0x07, 0x0E, 0x18,
  0x38, 0xE0, 0xE1, 0xC7, 0x07, 0x0E, 0x70, 0x38, 0x63, 0x80, 0xE7, 0x38,
  0x07, 0xF3, 0x80, 0x1F, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0xE7, 0xE0, 0x0E, 0x7F, 0x80, 0x73, 0x8C, 0x07, 0x38, 0x70, 0x39, 0xC3,
  0x83, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0x38, 0xE0,
  0xE1, 0xCE, 0x03, 0x8C, 0xE0, 0x1F, 0xEF, 0x00, 0x7E, 0x00, 0x00, 0x40,
  0x07, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xC3, 0xC0, 0x38, 0x1C,
  0x03, 0x81, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83,
  0x80, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x81, 0xC3, 0xFC, 0x1C, 0x79, 0xE1, 0x87, 0x0F, 0x18, 0xF0, 0xF3, 0x8E,
  0x07, 0xB8, 0xE0, 0x3F, 0x0E, 0x01, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0,
  0xF0, 0x1F, 0x8F, 0x83, 0xFC, 0x7E, 0xF9, 0xC3, 0xFF, 0x1E, 0x1F, 0xE0,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x60, 0x02, 0x40, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x18, 0x02,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C, 0x17,
  0xCE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xDC,
  0x01, 0xEF, 0x01, 0xE3, 0xC1, 0xF1, 0xF0, 0x70, 0x70, 0x10, 0x10, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x1E, 0x0E, 0x0F, 0x3F, 0x3F, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0xFB, 0xFF, 0xF7, 0xCF, 0x84, 0x00,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x07, 0x83, 0xC0,
  0x78, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1E, 0x70, 0x01, 0xCE, 0x00,
  0x39, 0xC0, 0x07, 0x78, 0x30, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x7C,
  0x7F, 0x8F, 0x8F, 0xF0, 0xE1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x9E, 0x00, 0xF1, 0xC0, 0x1C, 0x3C, 0x07,
  0x83, 0x81, 0xE0, 0x7C, 0x7C, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x80,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFD,
  0xE0, 0xF1, 0xE0, 0x41, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xF0, 0x1F,
  0xFE, 0x1F, 0xFF, 0x9E, 0x07, 0xC6, 0x00, 0xF2, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x0E, 0x07, 0xC4, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xBC, 0x1F, 0x9F, 0xFF, 0x87, 0xFF,
  0x80, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x07, 0x07,
  0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x40, 0x0F, 0x3C, 0x3F, 0x9F, 0xFF, 0x9F, 0xFF, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE7, 0xF8, 0x3F, 0xFF, 0x8F, 0xF7, 0xF3, 0x80, 0x3C,
  0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF8,
  0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0x70, 0x07, 0x9E, 0x03, 0xC3, 0xE1,
  0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF0, 0x1E, 0x38, 0x03, 0x9E, 0x00,
  0xF7, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0xE3, 0x80, 0x38,
  0xF0, 0x1E, 0x1F, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFC, 0x1C,
  0x1F, 0x8E, 0x01, 0xE7, 0x80, 0x3D, 0xC0, 0x07, 0x70, 0x01, 0xFC, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0xF3, 0xE0, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x3D, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x07, 0x78, 0x01,
  0xDE, 0x00, 0x73, 0xE0, 0x7C, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0x78, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x38, 0xFB, 0xFF, 0xF7, 0xCF, 0x84, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x7D, 0xFF, 0xFB, 0xE7, 0xC2, 0x00, 0x0E, 0x0F, 0x8F,
  0xE7, 0xF1, 0xF0, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x1F, 0x0F, 0xCF, 0xE3, 0xF1, 0xF8, 0x38, 0x3C, 0x3C,
  0x7E, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xC7, 0xFF, 0x3F, 0xFD, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x02, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xE0, 0x1C,
  0x38, 0x03, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x7D,
  0xC0, 0xFF, 0xB8, 0x3F, 0xFF, 0x0F, 0x8F, 0xE1, 0xC1, 0xFC, 0x78, 0x3F,
  0x8E, 0x07, 0xF1, 0xC0, 0xFE, 0x38, 0x1F, 0xC7, 0x03, 0xF8, 0xE0, 0x7F,
  0x1C, 0x0F, 0xE3, 0xC1, 0xDC, 0x78, 0x3B, 0xC7, 0x87, 0x78, 0x7F, 0xEF,
  0x07, 0xFC, 0xF0, 0x7F, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x1E, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x1C, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x38, 0x01, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x3C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xF0, 0x1F, 0xC0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00,
  0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x73, 0xC0, 0x3C,
  0xF0, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC3, 0xFC, 0xF0, 0x07, 0xBC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0xCF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xC0,
  0xE1, 0xE0, 0x04, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x08, 0x3F, 0x8F, 0x83, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x30, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x78, 0x3F,
  0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x01,
  0xDE, 0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80, 0x3C,
  0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xC0, 0x61, 0xE0,
  0x04, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0x77, 0x80, 0x0E, 0xF0, 0x01, 0xCE, 0x00, 0x39, 0xE0, 0x07, 0x1E, 0x00,
  0xE3, 0xE0, 0x1C, 0x3F, 0x07, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC1,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x40, 0x1E, 0xF0, 0x7C, 0xFF, 0xFC,
  0x3F, 0xF0, 0x03, 0x00, 0xE0, 0x03, 0xEE, 0x00, 0x78, 0xE0, 0x0F, 0x0E,
  0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x00,
  0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xE7, 0xC0, 0x0E, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xEF, 0x80, 0x0E, 0x7C, 0x00, 0xE1, 0xE0, 0x0E, 0x0F,
  0x00, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xE0, 0x1E, 0x0E, 0x01, 0xF0, 0xE0,
  0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xEE,
  0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x38, 0x03, 0x87, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xE0, 0x7C, 0xFC, 0x1F, 0x9B, 0x83, 0xF3, 0x30, 0x66, 0x67, 0x1C, 0xCC,
  0xE3, 0x99, 0x8C, 0x63, 0x31, 0xDC, 0x6E, 0x1B, 0x8F, 0xC3, 0x61, 0xF8,
  0x7C, 0x3F, 0x07, 0x87, 0xE0, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x70, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xB8, 0x0F,
  0xDC, 0x07, 0xE7, 0x03, 0xF3, 0xC1, 0xF8, 0xE0, 0xFC, 0x70, 0x7E, 0x1C,
  0x3F, 0x0E, 0x1F, 0x83, 0x8F, 0xC1, 0xC7, 0xE0, 0x73, 0xF0, 0x39, 0xF8,
  0x0E, 0xFC, 0x07, 0x7E, 0x03, 0xBF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x0F, 0x83, 0xC0, 0x1C, 0x1E, 0x00,
  0xF0, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C,
  0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0,
  0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xE0, 0x03, 0xC7, 0x00, 0x1C,
  0x3C, 0x01, 0xE0, 0xF0, 0x1E, 0x03, 0xC3, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x07,
  0xCE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x79,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3C, 0x0F, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xF0, 0xE0, 0x03,
  0x8F, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x39, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x3C, 0x01, 0xE0,
  0xF0, 0x1E, 0x03, 0xC3, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0x80, 0xF8, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x0F, 0x38, 0x03, 0x8E, 0x03, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x01, 0xE3,
  0x80, 0x38, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0x80, 0xE7, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xA0, 0x03, 0xBE, 0x0F, 0xDF,
  0xFF, 0xC3, 0xFF, 0x80, 0x2E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0xC0, 0x1E, 0x3C, 0x07,
  0x87, 0xC1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38,
  0x00, 0x39, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xE0, 0x07,
  0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x07, 0x01, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x0F, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0F, 0x38, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x70, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x6C, 0x37,
  0x1D, 0xC6, 0xE3, 0x38, 0xCC, 0x63, 0x19, 0x9C, 0x73, 0x33, 0x8E, 0x66,
  0x60, 0xCC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0xF1, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0x78, 0x00, 0xF1, 0xC0, 0x07,
  0x0F, 0x00, 0x78, 0x38, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x1C,
  0x1C, 0x00, 0xF1, 0xE0, 0x03, 0x8E, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3B,
  0x80, 0x03, 0xDE, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x00,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x80, 0x3C, 0x38, 0x01,
  0xE3, 0xC0, 0x07, 0x1C, 0x00, 0x3D, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x01, 0xE3, 0x80, 0x0E, 0x1E, 0x00,
  0xF0, 0x70, 0x07, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x78, 0x3C, 0x01,
  0xC1, 0xC0, 0x0F, 0x1E, 0x00, 0x38, 0xE0, 0x01, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00,
  0x73, 0xC0, 0x0E, 0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x07, 0x07,
  0x80, 0xE0, 0xE0, 0x0E, 0x38, 0x01, 0xE7, 0x00, 0x1D, 0xC0, 0x01, 0xC8,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x41,
  0xC3, 0xC3, 0x83, 0x83, 0x87, 0x86, 0x07, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x86, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x81, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xC0, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0xC1,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x3E, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x8F,
  0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x1F, 0x3F, 0x1F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0x0F, 0xE0, 0xE3, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFB, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x3C, 0x1F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xC3, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0x70, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0,
  0x0F, 0x3E, 0x03, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xF0,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x38, 0xF0, 0x07,
  0x9C, 0x00, 0x77, 0x80, 0x0E, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF7, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xE0,
  0x70, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFC, 0x1F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x01, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE3, 0x01, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC,
  0x03, 0xF0, 0x00, 0x30, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xE1, 0xF3, 0xC0, 0x3D, 0xE0,
  0x0E, 0xF0, 0x07, 0x78, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x07,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F,
  0xF3, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1F, 0xC1, 0xEF, 0xFF, 0x7F, 0xF0, 0x7E, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xEF, 0x00, 0x71, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0,
  0xF0, 0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFF,
  0x00, 0x3D, 0xF0, 0x07, 0x9F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80,
  0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0xBC, 0x07, 0xFE, 0x01, 0xFF, 0x3E, 0x0E, 0x1F,
  0xF7, 0xF3, 0xFF, 0xFF, 0x70, 0xF8, 0xFE, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8,
  0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0,
  0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xC0, 0x07, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0x07, 0xCF, 0x00,
  0xF7, 0x80, 0x3B, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1C, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0x8F, 0x83, 0xC0,
  0x78, 0xF0, 0x07, 0x9C, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x7B, 0x80, 0x0E, 0x70, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xE0, 0xF8, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0E,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x80,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7C, 0x1F, 0x3C,
  0x03, 0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x7C, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0x8F, 0x80,
  0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xD0, 0x01, 0xEF, 0x83, 0xEF, 0xFF,
  0xE3, 0xFF, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xFB, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF0, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xE0,
  0x0F, 0x78, 0x07, 0xBC, 0x03, 0xCF, 0xEF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x80, 0x3C,
  0xF0, 0x07, 0x8E, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x03, 0x80, 0xE0,
  0x78, 0x3C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00,
  0x3D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x38, 0x38, 0x39, 0xC1, 0xC1, 0xCE, 0x0F, 0x0E, 0x70,
  0xF8, 0x73, 0x86, 0xC3, 0x9E, 0x37, 0x1C, 0x73, 0xB9, 0xC3, 0x98, 0xCE,
  0x1D, 0xC7, 0x70, 0xEE, 0x3B, 0x87, 0x60, 0xDC, 0x3F, 0x07, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xC0, 0x1C, 0x00, 0x78, 0x00,
  0xF1, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x03,
  0xC7, 0x80, 0x0F, 0x78, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xC7, 0x80, 0x1C,
  0x1C, 0x01, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x78,
  0xF0, 0x01, 0xEF, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0,
  0x07, 0x3C, 0x00, 0xE3, 0x80, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE0, 0xE0,
  0x1C, 0x1E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x87, 0x80, 0x70,
  0xE0, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x3F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0x80, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xF8, 0x00, 0x1F,
  0x00, 0x47, 0xF8, 0x1D, 0xFF, 0x83, 0x70, 0x7F, 0xEC, 0x07, 0xF8, 0x80,
  0x3E, 0x00,
};

const GFXglyph UbuntuSansMono_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 29, 23, 9, -28 },
  { 20, 10, 11, 23, 6, -31 },
  { 34, 21, 28, 23, 1, -28 },
  { 108, 17, 36, 23, 3, -32 },
  { 185, 21, 30, 23, 1, -29 },
  { 264, 20, 29, 23, 2, -29 },
  { 337, 3, 12, 23, 10, -31 },
  { 342, 12, 40, 23, 5, -32 },
  { 402, 11, 40, 23, 6, -32 },
  { 457, 17, 16, 23, 3, -28 },
  { 491, 19, 20, 23, 2, -22 },
  { 539, 9, 12, 23, 7, -6 },
  { 553, 9, 3, 23, 7, -13 },
  { 557, 7, 7, 23, 8, -6 },
  { 564, 17, 40, 23, 3, -32 },
  { 649, 19, 30, 23, 2, -29 },
  { 721, 16, 28, 23, 4, -28 },
  { 777, 17, 29, 23, 3, -29 },
  { 839, 17, 30, 23, 3, -29 },
  { 903, 19, 28, 23, 2, -28 },
  { 970, 17, 29, 23, 3, -28 },
  { 1032, 18, 30, 23, 3, -29 },
  { 1100, 18, 28, 23, 3, -28 },
  { 1163, 18, 30, 23, 2, -29 },
  { 1231, 18, 29, 23, 2, -29 },
  { 1297, 7, 22, 23, 8, -21 },
  { 1317, 9, 27, 23, 6, -21 },
  { 1348, 19, 18, 23, 2, -21 },
  { 1391, 19, 12, 23, 2, -18 },
  { 1420, 19, 18, 23, 2, -21 },
  { 1463, 13, 30, 23, 5, -29 },
  { 1512, 19, 35, 23, 2, -29 },
  { 1596, 23, 28, 23, 0, -28 },
  { 1677, 18, 29, 23, 2, -29 },
  { 1743, 19, 30, 23, 2, -29 },
  { 1815, 19, 29, 23, 2, -29 },
  { 1884, 16, 28, 23, 5, -28 },
  { 1940, 15, 28, 23, 5, -28 },
  { 1993, 19, 30, 23, 2, -29 },
  { 2065, 19, 28, 23, 2, -28 },
  { 2132, 13, 28, 23, 5, -28 },
  { 2178, 16, 29, 23, 3, -28 },
  { 2236, 20, 28, 23, 3, -28 },
  { 2306, 17, 28, 23, 4, -28 },
  { 2366, 19, 28, 23, 2, -28 },
  { 2433, 17, 28, 23, 3, -28 },
  { 2493, 21, 30, 23, 1, -29 },
  { 2572, 17, 29, 23, 4, -29 },
  { 2634, 21, 37, 23, 1, -29 },
  { 2732, 18, 29, 23, 3, -29 },
  { 2798, 17, 30, 23, 3, -29 },
  { 2862, 19, 28, 23, 2, -28 },
  { 2929, 19, 29, 23, 2, -28 },
  { 2998, 21, 28, 23, 1, -28 },
  { 3072, 19, 28, 23, 2, -28 },
  { 3139, 21, 28, 23, 1, -28 },
  { 3213, 21, 28, 23, 1, -28 },
  { 3287, 18, 28, 23, 3, -28 },
  { 3350, 10, 40, 23, 7, -32 },
  { 3400, 16, 40, 23, 3, -32 },
  { 3480, 10, 40, 23, 6, -32 },
  { 3530, 19, 15, 23, 2, -28 },
  { 3566, 23, 3, 23, 0, 5 },
  { 3575, 7, 8, 23, 8, -32 },
  { 3582, 17, 22, 23, 3, -22 },
  { 3629, 18, 32, 23, 3, -32 },
  { 3701, 19, 22, 23, 2, -22 },
  { 3754, 18, 32, 23, 2, -32 },
  { 3826, 19, 22, 23, 2, -22 },
  { 3879, 19, 32, 23, 3, -32 },
  { 3955, 18, 30, 23, 2, -22 },
  { 4023, 17, 32, 23, 3, -32 },
  { 4091, 17, 31, 23, 3, -31 },
  { 4157, 13, 39, 23, 4, -31 },
  { 4221, 19, 32, 23, 3, -32 },
  { 4297, 17, 32, 23, 3, -32 },
  { 4365, 19, 22, 23, 2, -22 },
  { 4418, 17, 22, 23, 3, -22 },
  { 4465, 19, 22, 23, 2, -22 },
  { 4518, 18, 30, 23, 3, -22 },
  { 4586, 18, 30, 23, 2, -22 },
  { 4654, 15, 22, 23, 5, -22 },
  { 4696, 17, 22, 23, 3, -22 },
  { 4743, 17, 28, 23, 3, -28 },
  { 4803, 17, 21, 23, 3, -21 },
  { 4848, 19, 21, 23, 2, -21 },
  { 4898, 21, 21, 23, 1, -21 },
  { 4954, 21, 21, 23, 1, -21 },
  { 5010, 19, 29, 23, 2, -21 },
  { 5079, 16, 21, 23, 3, -21 },
  { 5121, 15, 40, 23, 4, -32 },
  { 5196, 3, 40, 23, 10, -32 },
  { 5211, 16, 40, 23, 3, -32 },
  { 5291, 19, 6, 23, 2, -15 },
};

const GFXfont UbuntuSansMono_Regular41pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular41pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular41pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUSANSMONO_REGULAR41PT7B_H_
