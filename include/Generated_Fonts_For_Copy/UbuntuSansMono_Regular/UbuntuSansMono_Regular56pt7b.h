#ifndef _UBUNTUSANSMONO_REGULAR56PT7B_H_
#define _UBUNTUSANSMONO_REGULAR56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0x80,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xF0,
  0x01, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0x0F, 0x01,
  0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x40, 0x00, 0x7E, 0xF8, 0x00, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x7C, 0x79, 0xE0, 0x03, 0xC7,
  0x87, 0x80, 0x3C, 0x3C, 0x1C, 0x01, 0xE1, 0xC0, 0xE0, 0x1E, 0x1E, 0x07,
  0x81, 0xF0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0x78, 0x0F, 0x03, 0xC7, 0xC0, 0x38, 0x1C, 0x3C, 0x01,
  0xC0, 0xE3, 0xC0, 0x0F, 0x0F, 0x1E, 0x00, 0x3C, 0x79, 0xE0, 0x01, 0xFF,
  0x9F, 0x00, 0x07, 0xF8, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x7C, 0x7F, 0x00, 0x03, 0xC7, 0xFC,
  0x00, 0x3C, 0x79, 0xF0, 0x01, 0xE3, 0x87, 0x80, 0x1E, 0x3C, 0x1C, 0x01,
  0xF1, 0xE0, 0xF0, 0x0F, 0x0E, 0x07, 0x80, 0xF0, 0x70, 0x1C, 0x07, 0x83,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x07, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x03,
  0xC3, 0xC0, 0x38, 0x1E, 0x1E, 0x01, 0xE0, 0xF1, 0xE0, 0x0F, 0x07, 0x1F,
  0x00, 0x3C, 0x78, 0xF0, 0x00, 0xFF, 0x8F, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x60,
  0x07, 0xF8, 0x07, 0x80, 0xFF, 0xC0, 0x78, 0x1F, 0x7E, 0x07, 0x83, 0xE3,
  0xF0, 0x70, 0x3E, 0x1F, 0x87, 0x07, 0xC0, 0xFC, 0xF0, 0x7C, 0x07, 0xEF,
  0x07, 0x80, 0x3E, 0xF0, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0x0F, 0xE0, 0xF8,
  0x00, 0xFE, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xF0, 0x7C, 0x00, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x3F, 0xCF, 0xE7, 0xC1,
  0xFF, 0xFC, 0x7C, 0x0F, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0x3F, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0x39, 0xCE,
  0x70, 0x00, 0x04, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x20, 0x00, 0x70, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x40, 0x3C, 0x04, 0x78, 0x38, 0x1E, 0xFE, 0x38, 0xFE, 0xFF,
  0xBB, 0xFE, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0xE0, 0x0F, 0xC3, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xF8, 0x07,
  0x00, 0xC0, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xFE,
  0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0x80, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB,
  0xFD, 0xFC, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x7C, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x1E, 0x0F, 0xFC, 0x1F, 0x87, 0xFE, 0x1F, 0xC3, 0xFF, 0x0F, 0xE1,
  0xFF, 0x87, 0xF0, 0xFF, 0xC3, 0xF8, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x38,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x83,
  0xF0, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0xFD, 0xE0, 0x0F, 0xE7, 0x80, 0xFF, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xF8, 0x01,
  0xF8, 0x70, 0x00, 0xF8, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0x0F, 0xF0, 0x38, 0x01,
  0xF8, 0x20, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x40, 0x00, 0xFC, 0x78, 0x07, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFB,
  0x00, 0x07, 0xE7, 0xC0, 0x7F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x7D, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xC7, 0xC0, 0x03, 0xE7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x81, 0xF8, 0x1F, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0x7C, 0x03, 0xFE, 0x7C, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3E, 0x0F, 0xF0,
  0x3E, 0x01, 0xFC, 0x3E, 0x00, 0x3F, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x9F, 0x00,
  0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F,
  0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x01, 0xF1,
  0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x9E,
  0x00, 0x0C, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7E, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF1, 0xFC, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xE3, 0xF0, 0xE0,
  0x07, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x07, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0x7C, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0x81, 0xFC, 0x80, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xF8, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xDF, 0x00, 0x0F, 0xF7, 0xC0, 0x1F,
  0xFD, 0xE0, 0x1F, 0xFF, 0x78, 0x0F, 0xFF, 0xFE, 0x07, 0xE0, 0xFF, 0x83,
  0xF0, 0x3F, 0xE0, 0xF8, 0x0F, 0xF8, 0x7C, 0x03, 0xFE, 0x1F, 0x00, 0xFF,
  0x87, 0xC0, 0x3F, 0xE1, 0xF0, 0x0F, 0xF8, 0x7C, 0x03, 0xFE, 0x1F, 0x00,
  0xFF, 0x87, 0xC0, 0x3F, 0xE1, 0xF0, 0x0F, 0xF8, 0x7C, 0x03, 0xFE, 0x1F,
  0x00, 0xFF, 0x83, 0xC0, 0x3D, 0xF0, 0xF8, 0x0F, 0x7C, 0x1F, 0x03, 0xDF,
  0x07, 0xF1, 0xF7, 0xC0, 0xFF, 0xFC, 0xF8, 0x1F, 0xFF, 0x3E, 0x01, 0xFF,
  0x8F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0x9E, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x1F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3E, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xC0, 0x07, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0xBE, 0x00, 0x3F, 0x9F, 0x81, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xF8, 0x00,
  0xC0, 0xFC, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x06, 0x07, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1E,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x3F,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC1, 0xF8, 0x3F,
  0x00, 0x18, 0x3F, 0x00, 0x04, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0,
  0x00, 0x7B, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x1F,
  0x00, 0x07, 0x8F, 0xC0, 0x03, 0xC3, 0xF0, 0x01, 0xE0, 0xFC, 0x00, 0xF0,
  0x7F, 0x80, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF9, 0x00, 0x03, 0xE6, 0x00, 0x1F, 0x3F, 0x01, 0xFC, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF3, 0xF8, 0x00,
  0x3E, 0x3F, 0x80, 0x07, 0xC3, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x01,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x01,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFE, 0x01, 0xDC, 0x3F, 0xC0, 0x7B, 0x87, 0xB8, 0x0F,
  0x70, 0xE7, 0x81, 0xCF, 0x1C, 0xF0, 0x79, 0xE3, 0x8E, 0x0F, 0x3C, 0x71,
  0xE1, 0xC7, 0x8E, 0x3C, 0x38, 0xF1, 0xC3, 0x8F, 0x1E, 0x78, 0x79, 0xC3,
  0xCF, 0x07, 0x38, 0x79, 0xE0, 0xEF, 0x0F, 0x3C, 0x1F, 0xC1, 0xE7, 0x81,
  0xF8, 0x3C, 0xF0, 0x3F, 0x07, 0x9E, 0x07, 0xC0, 0xF3, 0xC0, 0x78, 0x1E,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xF7, 0x80, 0x0F, 0xF7, 0xC0, 0x0F, 0xF3, 0xC0, 0x0F,
  0xF3, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F,
  0xF0, 0xF8, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x0F, 0x0F,
  0xF0, 0x0F, 0x0F, 0xF0, 0x07, 0x8F, 0xF0, 0x07, 0x8F, 0xF0, 0x07, 0xCF,
  0xF0, 0x03, 0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x01, 0xEF, 0xF0, 0x01, 0xEF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0x00, 0x1F, 0x9E, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x03, 0xE7, 0x80, 0x1F, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x78,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x78,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0x00, 0x3F, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9E, 0x00,
  0x07, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x1E,
  0x01, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xF0,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xFB, 0xC0,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x60,
  0x00, 0x7C, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7D, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0,
  0x0F, 0x83, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0,
  0xF8, 0x1E, 0x78, 0x1F, 0x03, 0xCF, 0x03, 0xE0, 0x79, 0xE0, 0xFE, 0x0F,
  0x3C, 0x1D, 0xC1, 0xE7, 0x83, 0xB8, 0x3C, 0xF0, 0xF7, 0x87, 0x9E, 0x1E,
  0x70, 0xF3, 0xC3, 0x8E, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x1E, 0x1C, 0x78,
  0xE3, 0x83, 0xCE, 0x1C, 0xF0, 0x79, 0xC3, 0x9E, 0x07, 0x38, 0x73, 0x80,
  0xF7, 0x0F, 0xF0, 0x1E, 0xE1, 0xFE, 0x01, 0xDC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0xFC, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x07, 0x8F, 0x00,
  0x07, 0xC7, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x3C,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0xF1, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0x0C, 0x07, 0x83,
  0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xE0, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xC1, 0xE0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xE0, 0xFE, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x3D, 0xFE, 0x01, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0xF7, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF0, 0xFC, 0x01,
  0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x03,
  0xF8, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xF0, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x43, 0xFF, 0x87, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x1F, 0x01,
  0xFF, 0xDF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F,
  0x00, 0x7F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x1F,
  0x80, 0x1F, 0x0F, 0xF9, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0x07, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xF8, 0x00, 0x80, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3F, 0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x20,
  0x00, 0xFC, 0x3F, 0x87, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x5F,
  0xFF, 0x80, 0x00, 0xA0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC1, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE3, 0xFE, 0x7F, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x3E,
  0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0x00, 0x7F,
  0x0E, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF2, 0x00, 0x7E, 0x7C, 0x3F, 0x9F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0xFD, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x0F, 0x01, 0xF8,
  0x07, 0x81, 0xF8, 0x03, 0xC1, 0xF8, 0x01, 0xE1, 0xF0, 0x00, 0xF3, 0xF0,
  0x00, 0x7B, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xBF, 0x80, 0x03, 0xCF, 0xE0, 0x01, 0xE1, 0xF8, 0x00, 0xF0,
  0x7F, 0x00, 0x78, 0x1F, 0xC0, 0x3C, 0x03, 0xF0, 0x1E, 0x00, 0xFC, 0x0F,
  0x00, 0x3F, 0x07, 0x80, 0x0F, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0xBC, 0x00, 0x07, 0xE0, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0x00, 0x7F, 0x1E, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x70, 0x3F, 0xF8, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xF0,
  0x7F, 0x0F, 0xBC, 0x0F, 0x81, 0xFF, 0x01, 0xE0, 0x7F, 0xC0, 0x78, 0x0F,
  0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78,
  0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0,
  0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0x0F, 0xF3, 0xC0, 0x07, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xE3, 0xFC, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x81,
  0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xF0, 0xF0, 0x03, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFF, 0xDF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xF7, 0xFF, 0x00, 0xF0, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0x80, 0x1F, 0x3F, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x80, 0x7F, 0x1F, 0xF3,
  0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x2F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0x8F, 0x80, 0x01,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0xFD, 0xF8, 0x07,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x02, 0x00, 0xFF, 0x3E, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x3F, 0xC3,
  0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x1F, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0xF0, 0x1E, 0x7C, 0x07, 0x80, 0xF1,
  0xE0, 0x7C, 0x07, 0x8F, 0x03, 0xF0, 0x3C, 0x78, 0x1F, 0x83, 0xE3, 0xC1,
  0xFC, 0x1E, 0x1E, 0x0F, 0xF0, 0xF0, 0xF0, 0x77, 0x87, 0x87, 0xC7, 0x9C,
  0x3C, 0x1E, 0x38, 0xF1, 0xE0, 0xF1, 0xC7, 0x9F, 0x07, 0x9E, 0x1C, 0xF0,
  0x3C, 0xE0, 0xF7, 0x81, 0xEF, 0x07, 0xBC, 0x07, 0xF8, 0x1D, 0xE0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xE0,
  0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF8,
  0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x07, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x00, 0xF3, 0xFF, 0x80,
  0x39, 0xFF, 0xF8, 0x0E, 0x78, 0x7F, 0x07, 0xBC, 0x07, 0xFF, 0xCE, 0x00,
  0xFF, 0xE3, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 40, 31, 12, -39 },
  { 36, 13, 15, 31, 9, -43 },
  { 61, 28, 39, 31, 2, -39 },
  { 198, 24, 49, 31, 4, -43 },
  { 345, 29, 41, 31, 1, -40 },
  { 494, 28, 41, 31, 2, -40 },
  { 638, 5, 17, 31, 13, -43 },
  { 649, 17, 54, 31, 7, -44 },
  { 764, 16, 54, 31, 8, -44 },
  { 872, 24, 23, 31, 4, -39 },
  { 941, 26, 27, 31, 3, -30 },
  { 1029, 12, 17, 31, 10, -8 },
  { 1055, 13, 4, 31, 9, -18 },
  { 1062, 9, 9, 31, 11, -8 },
  { 1073, 22, 54, 31, 5, -44 },
  { 1222, 25, 41, 31, 3, -40 },
  { 1351, 22, 39, 31, 5, -39 },
  { 1459, 24, 40, 31, 4, -40 },
  { 1579, 24, 41, 31, 4, -40 },
  { 1702, 27, 39, 31, 2, -39 },
  { 1834, 23, 40, 31, 5, -39 },
  { 1949, 25, 40, 31, 3, -39 },
  { 2074, 25, 39, 31, 4, -39 },
  { 2196, 25, 41, 31, 3, -40 },
  { 2325, 25, 40, 31, 3, -40 },
  { 2450, 9, 30, 31, 11, -29 },
  { 2484, 12, 38, 31, 8, -29 },
  { 2541, 26, 24, 31, 3, -28 },
  { 2619, 26, 15, 31, 3, -24 },
  { 2668, 26, 24, 31, 3, -28 },
  { 2746, 19, 41, 31, 6, -40 },
  { 2844, 26, 48, 31, 3, -40 },
  { 3000, 30, 39, 31, 1, -39 },
  { 3147, 25, 39, 31, 3, -39 },
  { 3269, 26, 41, 31, 3, -40 },
  { 3403, 26, 39, 31, 3, -39 },
  { 3530, 23, 39, 31, 6, -39 },
  { 3643, 22, 39, 31, 6, -39 },
  { 3751, 25, 41, 31, 3, -40 },
  { 3880, 26, 39, 31, 3, -39 },
  { 4007, 19, 39, 31, 6, -39 },
  { 4100, 22, 40, 31, 4, -39 },
  { 4210, 27, 39, 31, 4, -39 },
  { 4342, 23, 39, 31, 6, -39 },
  { 4455, 27, 39, 31, 2, -39 },
  { 4587, 24, 39, 31, 4, -39 },
  { 4704, 28, 41, 31, 2, -40 },
  { 4848, 23, 39, 31, 5, -39 },
  { 4961, 28, 50, 31, 2, -40 },
  { 5136, 25, 39, 31, 4, -39 },
  { 5258, 24, 41, 31, 4, -40 },
  { 5381, 26, 39, 31, 3, -39 },
  { 5508, 25, 40, 31, 3, -39 },
  { 5633, 30, 39, 31, 1, -39 },
  { 5780, 27, 39, 31, 2, -39 },
  { 5912, 28, 39, 31, 2, -39 },
  { 6049, 30, 39, 31, 1, -39 },
  { 6196, 26, 39, 31, 3, -39 },
  { 6323, 14, 54, 31, 10, -44 },
  { 6418, 22, 54, 31, 5, -44 },
  { 6567, 14, 54, 31, 8, -44 },
  { 6662, 25, 21, 31, 3, -39 },
  { 6728, 31, 3, 31, 0, 7 },
  { 6740, 10, 11, 31, 10, -44 },
  { 6754, 23, 31, 31, 4, -30 },
  { 6844, 24, 44, 31, 5, -43 },
  { 6976, 25, 31, 31, 3, -30 },
  { 7073, 24, 44, 31, 3, -43 },
  { 7205, 25, 31, 31, 3, -30 },
  { 7302, 26, 43, 31, 4, -43 },
  { 7442, 24, 41, 31, 3, -30 },
  { 7565, 22, 43, 31, 5, -43 },
  { 7684, 24, 43, 31, 4, -42 },
  { 7813, 19, 53, 31, 5, -42 },
  { 7939, 25, 43, 31, 5, -43 },
  { 8074, 24, 44, 31, 4, -43 },
  { 8206, 26, 30, 31, 3, -30 },
  { 8304, 22, 30, 31, 5, -30 },
  { 8387, 26, 31, 31, 3, -30 },
  { 8488, 24, 40, 31, 5, -30 },
  { 8608, 24, 40, 31, 3, -30 },
  { 8728, 20, 30, 31, 7, -30 },
  { 8803, 23, 31, 31, 4, -30 },
  { 8893, 24, 39, 31, 4, -38 },
  { 9010, 23, 30, 31, 4, -29 },
  { 9097, 27, 29, 31, 2, -29 },
  { 9195, 29, 29, 31, 1, -29 },
  { 9301, 27, 29, 31, 2, -29 },
  { 9399, 26, 40, 31, 3, -29 },
  { 9529, 22, 29, 31, 5, -29 },
  { 9609, 22, 54, 31, 5, -44 },
  { 9758, 4, 54, 31, 14, -44 },
  { 9785, 21, 54, 31, 5, -44 },
  { 9927, 26, 9, 31, 3, -21 },
};

const GFXfont UbuntuSansMono_Regular56pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular56pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular56pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _UBUNTUSANSMONO_REGULAR56PT7B_H_
