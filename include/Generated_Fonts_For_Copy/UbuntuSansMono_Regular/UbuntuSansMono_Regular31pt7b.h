#ifndef _UBUNTUSANSMONO_REGULAR31PT7B_H_
#define _UBUNTUSANSMONO_REGULAR31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x8C, 0x62, 0x10, 0x00, 0x03,
  0x9F, 0xF7, 0x00, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC2, 0x07,
  0x0C, 0x0C, 0x38, 0x18, 0x70, 0x30, 0xC0, 0xE1, 0x9F, 0xFF, 0xFF, 0xFF,
  0x86, 0x1C, 0x0C, 0x38, 0x38, 0x60, 0x70, 0xC0, 0xC3, 0x81, 0x87, 0x1F,
  0xFF, 0xFF, 0xFF, 0x9C, 0x30, 0x30, 0x60, 0x61, 0xC0, 0xC3, 0x83, 0x86,
  0x07, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xFF, 0x1F,
  0xF9, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x74,
  0x03, 0xFF, 0xF9, 0xFF, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x38,
  0x00, 0x7C, 0x0E, 0xC6, 0x0C, 0xC6, 0x18, 0xC6, 0x18, 0xC6, 0x30, 0xC6,
  0x70, 0xC6, 0x60, 0xC6, 0xC0, 0x7C, 0xC0, 0x39, 0x80, 0x03, 0x80, 0x03,
  0x3C, 0x06, 0x66, 0x06, 0x66, 0x0C, 0xC3, 0x1C, 0xC3, 0x18, 0xC3, 0x30,
  0xC3, 0x30, 0xC6, 0x60, 0x66, 0xE0, 0x3C, 0x07, 0x80, 0x3F, 0x80, 0xE3,
  0x81, 0x83, 0x03, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x1C, 0x70, 0x19, 0xC0,
  0x3F, 0x00, 0x3C, 0x01, 0xF8, 0x63, 0x38, 0xCE, 0x73, 0x18, 0x76, 0x70,
  0x7C, 0xE0, 0x79, 0xC0, 0x73, 0x81, 0xE3, 0x87, 0xE7, 0xFC, 0xE3, 0xF1,
  0xC0, 0xFF, 0xFF, 0xDB, 0x60, 0x01, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0,
  0xE0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xF0, 0x38, 0x08, 0x60, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E, 0x1E, 0x06, 0x02,
  0x00, 0x07, 0x00, 0x38, 0x00, 0xC0, 0xC6, 0x3F, 0xBF, 0xBF, 0xFC, 0x1C,
  0x01, 0xF0, 0x1D, 0xC0, 0xE7, 0x0E, 0x3C, 0x20, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x08, 0x3C, 0xF9, 0xF1, 0xE1, 0xC3, 0x5E, 0x78, 0xC0, 0xFF, 0xFC, 0x23,
  0xFF, 0xF7, 0x80, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0x0F, 0x80, 0x7F, 0x83, 0x8E, 0x1C, 0x1C, 0x60, 0x3B, 0x80, 0xEE, 0x01,
  0xB8, 0x06, 0xE0, 0x1B, 0x1C, 0x7C, 0x79, 0xF1, 0xE7, 0xC7, 0x1F, 0x00,
  0x7E, 0x01, 0xB8, 0x06, 0xE0, 0x39, 0x80, 0xE7, 0x03, 0x0E, 0x1C, 0x3F,
  0xE0, 0x7F, 0x00, 0x07, 0x00, 0xF0, 0x1F, 0x07, 0xB0, 0xE3, 0x08, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x07, 0xFF, 0x7F, 0xF0, 0x1F,
  0x83, 0xFF, 0x3E, 0x3C, 0x80, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0xFF, 0xBF, 0xFC, 0x1F,
  0x83, 0xFF, 0x1C, 0x7C, 0x80, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x80, 0xEF, 0xFF, 0x3F, 0xE0, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xC6, 0x03, 0x8C,
  0x06, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x3F, 0xF7, 0xFF, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x7E, 0x07, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x80, 0xEF, 0xFE, 0xFF, 0x80, 0x00,
  0x30, 0x07, 0xC0, 0x7F, 0x07, 0x80, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x03, 0xBF, 0x0F, 0xFF, 0x3C, 0x1C, 0xE0, 0x3B, 0x80, 0x6E,
  0x01, 0xB8, 0x07, 0xE0, 0x1B, 0x80, 0x67, 0x03, 0x9C, 0x1C, 0x3F, 0xF0,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x0F, 0xC1, 0xFF, 0x1E, 0x1C, 0xC0, 0x7E, 0x03, 0xF0,
  0x0F, 0x80, 0xEC, 0x07, 0x70, 0x31, 0xC3, 0x87, 0xF0, 0x3F, 0xC3, 0x0F,
  0x30, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x06, 0xE0, 0x77,
  0xFF, 0x1F, 0xF0, 0x0F, 0x81, 0xFF, 0x1E, 0x3C, 0xC0, 0x6E, 0x03, 0xF0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xDC, 0x06, 0xFF, 0xF3, 0xFF,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x78, 0x0F, 0x87,
  0xF0, 0x3C, 0x00, 0x23, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x47, 0xFF,
  0xEF, 0x08, 0x3C, 0xF9, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x41,
  0xE7, 0xCF, 0x8F, 0x0E, 0x1A, 0xF3, 0xC6, 0x00, 0x00, 0x04, 0x00, 0x70,
  0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x00, 0x38, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x02, 0x00, 0x00,
  0x3F, 0x1F, 0xF9, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x3F, 0xC1, 0xC7,
  0x8E, 0x06, 0x70, 0x1D, 0x80, 0x36, 0x00, 0xF8, 0x1F, 0xE1, 0xFF, 0x8E,
  0x3C, 0x70, 0xF1, 0x83, 0xC6, 0x0F, 0x18, 0x3C, 0x60, 0xF1, 0x83, 0xE7,
  0x0F, 0x9C, 0x3E, 0x3D, 0xD8, 0x7F, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0xB0, 0x1F, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xDC, 0x00, 0x6E, 0x00, 0x73, 0x00, 0x31, 0xC0, 0x18, 0xE0, 0x1C, 0x30,
  0x0C, 0x18, 0x06, 0x0E, 0x07, 0x03, 0x03, 0x01, 0x81, 0x80, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x60, 0x0E, 0x30, 0x07, 0x38, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x7E, 0x00, 0x38, 0x7F, 0x07, 0xFE, 0x30, 0xF9, 0x80, 0xEC, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x76, 0x0F, 0x3F, 0xE1, 0xFF, 0xCC,
  0x07, 0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0xEF, 0xFF, 0x7F, 0xE0, 0x03, 0xF0, 0x3F, 0xF1, 0xE3, 0x8E, 0x02, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x02, 0x1F, 0xFC, 0x3F, 0xE0, 0x3C, 0x03, 0xFE, 0x0C, 0x7E,
  0x30, 0x3C, 0xC0, 0x73, 0x00, 0xEC, 0x01, 0xB0, 0x06, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xC0,
  0x3B, 0x00, 0xEC, 0x07, 0x30, 0x78, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xF7,
  0xFF, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xFF, 0x3F, 0xF9, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE,
  0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xE1, 0x8E, 0x02,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x1D, 0xC0,
  0x73, 0x81, 0xCF, 0x07, 0x1F, 0xFC, 0x3F, 0xF0, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1C, 0xFF, 0xFF, 0xFC,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F,
  0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x40, 0xFF, 0xFE, 0x7F, 0xC0, 0xE0, 0x1D,
  0xC0, 0x73, 0x81, 0xC7, 0x07, 0x0E, 0x1C, 0x1C, 0x78, 0x38, 0xE0, 0x73,
  0x80, 0xEE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0x78, 0x0E, 0x38, 0x1C, 0x38,
  0x38, 0x38, 0x70, 0x78, 0xE0, 0x71, 0xC0, 0x73, 0x80, 0x77, 0x00, 0xEE,
  0x00, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x38, 0x1C, 0x70, 0x39, 0xE0, 0xF3, 0xE1, 0xE6, 0xC3, 0xCD, 0x8D,
  0x9B, 0x1B, 0x33, 0x36, 0x66, 0xCE, 0xC5, 0x9D, 0x8F, 0x3B, 0x1C, 0x76,
  0x18, 0xEC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x60, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3D,
  0x81, 0xE6, 0x0F, 0x30, 0x78, 0xC3, 0xC6, 0x1E, 0x38, 0xF0, 0xC7, 0x87,
  0x3C, 0x19, 0xE0, 0xEF, 0x03, 0x78, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xF1, 0xE1, 0xC0, 0xE7,
  0x00, 0xCC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x60, 0x0E,
  0xE0, 0x19, 0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0x07,
  0xFE, 0x30, 0xF9, 0x80, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x36, 0x01, 0xB0, 0x1D, 0x87, 0xCF, 0xFC, 0x7F, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xF1, 0xE1, 0xC0, 0xE7, 0x00, 0xCC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0x60, 0x0E, 0xE0, 0x19, 0xC0, 0x71, 0xC1, 0xC1,
  0xFF, 0x81, 0xFC, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00,
  0xF0, 0x00, 0x20, 0x3E, 0x03, 0xFF, 0x0C, 0x3E, 0x30, 0x1C, 0xC0, 0x33,
  0x00, 0xEC, 0x03, 0xB0, 0x0E, 0xC0, 0x3B, 0x00, 0xCC, 0x07, 0x3F, 0xF8,
  0xFF, 0x83, 0x06, 0x0C, 0x1C, 0x30, 0x30, 0xC0, 0xE3, 0x01, 0xCC, 0x03,
  0x30, 0x0E, 0xC0, 0x3B, 0x00, 0x70, 0x0F, 0xE1, 0xFF, 0xCE, 0x1C, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x80, 0x7F, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xE0,
  0x1B, 0x80, 0xE7, 0x07, 0x9F, 0xFC, 0x1F, 0xE0, 0xE0, 0x03, 0xB8, 0x01,
  0x9C, 0x00, 0xCE, 0x00, 0xE3, 0x00, 0x71, 0xC0, 0x30, 0xE0, 0x18, 0x30,
  0x1C, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x83, 0x80, 0xE1, 0x80,
  0x30, 0xC0, 0x18, 0xE0, 0x0E, 0x60, 0x07, 0x30, 0x01, 0xB8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB0, 0x07, 0x63, 0x8E, 0xC7, 0x1D,
  0x8B, 0x3B, 0x36, 0x66, 0x6C, 0xCC, 0xCD, 0x9B, 0x1B, 0x36, 0x36, 0x6C,
  0x3C, 0xF0, 0x79, 0xE0, 0xF1, 0xC0, 0xE3, 0x01, 0xC0, 0xF0, 0x0E, 0xE0,
  0x38, 0xE0, 0x60, 0xC1, 0xC1, 0xC3, 0x01, 0x8E, 0x03, 0xB8, 0x03, 0x60,
  0x07, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x36, 0x00, 0xEE, 0x01, 0x8E, 0x07,
  0x0C, 0x0C, 0x1C, 0x38, 0x18, 0x60, 0x39, 0xC0, 0x33, 0x00, 0x7E, 0x00,
  0xE0, 0xF0, 0x03, 0xB8, 0x03, 0x8C, 0x01, 0xC7, 0x00, 0xC1, 0x80, 0xE0,
  0xE0, 0x60, 0x30, 0x70, 0x1C, 0x30, 0x06, 0x38, 0x03, 0xB8, 0x00, 0xD8,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x07, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x07, 0x00, 0x3E, 0x00,
  0xD8, 0x07, 0x30, 0x18, 0xE0, 0xE1, 0x83, 0x07, 0x18, 0x0C, 0xE0, 0x3B,
  0x00, 0x74, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x47, 0x18, 0x63,
  0x88, 0x3F, 0xE1, 0xFF, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0E,
  0xE7, 0xFF, 0x7C, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x1D,
  0xFF, 0xE3, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xFF, 0x87, 0xFF, 0x38, 0x39, 0x80, 0xEC, 0x03,
  0x60, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x6C,
  0x07, 0x60, 0x73, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0xE7, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x13, 0xFF, 0x83, 0xFF, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x1F,
  0xF9, 0xFF, 0xDC, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x76, 0x03, 0xBC, 0x1C, 0xFF, 0xE1,
  0xFF, 0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0xE7, 0x00, 0xCC, 0x01,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x80, 0x87, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x0F, 0xFC, 0x1C,
  0x10, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF, 0xF9,
  0xFF, 0xF0, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x7F, 0xF3, 0x81, 0xDC, 0x07, 0x70,
  0x1D, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x76, 0x01, 0xDC,
  0x07, 0x38, 0x1C, 0xFF, 0xF1, 0xFF, 0xC0, 0x47, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x8C, 0x3E, 0x3F, 0xF1, 0x7E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x8F, 0xFC, 0xC0, 0xEC,
  0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x81, 0xFC, 0x07, 0xE0, 0x03, 0x80, 0xF0,
  0x3C, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x7E, 0x3B, 0xFE, 0x3E, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x3E, 0x07, 0x30, 0x71, 0x87, 0x0C, 0x70, 0x67, 0x03, 0xF0, 0x1F, 0x00,
  0xFC, 0x06, 0x78, 0x31, 0xE1, 0x87, 0x8C, 0x0E, 0x60, 0x3B, 0x01, 0xD8,
  0x07, 0xFE, 0x07, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x84, 0x0F, 0xE0, 0x3F, 0xFD, 0xF3, 0xFF, 0xEC, 0x71, 0xF0, 0xC3, 0xC3,
  0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0xC0,
  0xEC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x1F, 0xC0, 0xFF, 0x87,
  0x07, 0x38, 0x0E, 0xE0, 0x1B, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x06, 0x60, 0x39, 0xC1, 0xC3, 0xFE, 0x07, 0xF0,
  0xFF, 0x87, 0xFE, 0x30, 0x39, 0x80, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x73, 0xFF,
  0x9F, 0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x0F, 0xFC, 0x7F, 0xF3, 0xC1, 0xDC, 0x07, 0x70, 0x1D, 0x80, 0x76, 0x01,
  0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x76, 0x01, 0xDC, 0x07, 0x70, 0x1C, 0xE0,
  0xF1, 0xFF, 0xC3, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x1F, 0xF1, 0xFF, 0x9C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xA0, 0x1D,
  0xFF, 0xDF, 0xFC, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x82, 0x0F, 0xF0,
  0x3F, 0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xC0, 0x77, 0x03, 0xBC,
  0x1C, 0xFF, 0xE3, 0xFF, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x33, 0x80, 0xE3,
  0x01, 0xC7, 0x03, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x30, 0x38, 0xE0, 0x39,
  0x80, 0x77, 0x00, 0x6C, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x06, 0xE1, 0x86, 0xE3, 0x86, 0x63, 0xCE,
  0x63, 0xCE, 0x66, 0xCC, 0x66, 0x6C, 0x74, 0x6C, 0x7C, 0x6C, 0x3C, 0x3C,
  0x38, 0x3C, 0x38, 0x38, 0x30, 0x18, 0xF0, 0x0E, 0x60, 0x38, 0xE0, 0xE0,
  0xE3, 0x80, 0xE6, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x0D,
  0xC0, 0x39, 0xC0, 0xE1, 0x83, 0x83, 0x86, 0x03, 0x9C, 0x03, 0x70, 0x07,
  0x70, 0x0E, 0xE0, 0x1C, 0xC0, 0x31, 0xC0, 0xE3, 0x81, 0xC3, 0x03, 0x06,
  0x06, 0x0E, 0x1C, 0x0C, 0x38, 0x1C, 0x60, 0x19, 0xC0, 0x33, 0x00, 0x76,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x04,
  0x38, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0xF0, 0x0F, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x1F, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x78, 0x0F, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x0F, 0xC1, 0xE0, 0x00, 0x3E, 0x06, 0xFF, 0x1D, 0x87, 0xF6, 0x07,
  0xC0,
};

const GFXglyph UbuntuSansMono_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 7, 9, 17, 5, -24 },
  { 23, 15, 21, 17, 1, -21 },
  { 63, 13, 27, 17, 2, -24 },
  { 107, 16, 22, 17, 1, -22 },
  { 151, 15, 22, 17, 1, -22 },
  { 193, 3, 9, 17, 7, -24 },
  { 197, 9, 30, 17, 4, -24 },
  { 231, 9, 30, 17, 4, -24 },
  { 265, 13, 12, 17, 2, -21 },
  { 285, 14, 15, 17, 2, -17 },
  { 312, 7, 10, 17, 5, -5 },
  { 321, 7, 2, 17, 5, -10 },
  { 323, 5, 5, 17, 6, -5 },
  { 327, 12, 30, 17, 3, -24 },
  { 372, 14, 22, 17, 2, -22 },
  { 411, 12, 21, 17, 3, -21 },
  { 443, 13, 22, 17, 2, -22 },
  { 479, 13, 22, 17, 2, -22 },
  { 515, 15, 21, 17, 1, -21 },
  { 555, 12, 21, 17, 3, -21 },
  { 587, 14, 22, 17, 2, -22 },
  { 626, 14, 21, 17, 2, -21 },
  { 663, 13, 22, 17, 2, -22 },
  { 699, 13, 22, 17, 2, -22 },
  { 735, 5, 16, 17, 6, -16 },
  { 745, 7, 21, 17, 4, -16 },
  { 764, 14, 14, 17, 2, -16 },
  { 789, 14, 8, 17, 2, -13 },
  { 803, 14, 14, 17, 2, -16 },
  { 828, 11, 22, 17, 3, -22 },
  { 859, 14, 27, 17, 2, -22 },
  { 907, 17, 21, 17, 0, -21 },
  { 952, 13, 22, 17, 2, -22 },
  { 988, 14, 22, 17, 2, -22 },
  { 1027, 14, 22, 17, 2, -22 },
  { 1066, 13, 21, 17, 3, -21 },
  { 1101, 12, 21, 17, 3, -21 },
  { 1133, 14, 22, 17, 2, -22 },
  { 1172, 14, 21, 17, 2, -21 },
  { 1209, 11, 21, 17, 3, -21 },
  { 1238, 12, 21, 17, 2, -21 },
  { 1270, 15, 21, 17, 2, -21 },
  { 1310, 13, 21, 17, 3, -21 },
  { 1345, 15, 21, 17, 1, -21 },
  { 1385, 13, 21, 17, 2, -21 },
  { 1420, 15, 22, 17, 1, -22 },
  { 1462, 13, 22, 17, 3, -22 },
  { 1498, 15, 28, 17, 1, -22 },
  { 1551, 14, 22, 17, 2, -22 },
  { 1590, 13, 22, 17, 2, -22 },
  { 1626, 14, 21, 17, 2, -21 },
  { 1663, 14, 21, 17, 2, -21 },
  { 1700, 17, 21, 17, 0, -21 },
  { 1745, 15, 21, 17, 1, -21 },
  { 1785, 15, 21, 17, 1, -21 },
  { 1825, 17, 21, 17, 0, -21 },
  { 1870, 14, 21, 17, 2, -21 },
  { 1907, 8, 30, 17, 5, -24 },
  { 1937, 12, 30, 17, 3, -24 },
  { 1982, 8, 30, 17, 4, -24 },
  { 2012, 14, 11, 17, 2, -21 },
  { 2032, 17, 2, 17, 0, 4 },
  { 2037, 5, 6, 17, 6, -24 },
  { 2041, 13, 16, 17, 2, -16 },
  { 2067, 13, 24, 17, 3, -24 },
  { 2106, 14, 16, 17, 2, -16 },
  { 2134, 13, 24, 17, 2, -24 },
  { 2173, 15, 16, 17, 1, -16 },
  { 2203, 15, 24, 17, 2, -24 },
  { 2248, 14, 22, 17, 1, -16 },
  { 2287, 12, 24, 17, 3, -24 },
  { 2323, 13, 23, 17, 2, -23 },
  { 2361, 10, 29, 17, 3, -23 },
  { 2398, 13, 24, 17, 3, -24 },
  { 2437, 13, 24, 17, 2, -24 },
  { 2476, 14, 16, 17, 2, -16 },
  { 2504, 12, 16, 17, 3, -16 },
  { 2528, 14, 16, 17, 2, -16 },
  { 2556, 13, 22, 17, 3, -16 },
  { 2592, 14, 22, 17, 1, -16 },
  { 2631, 11, 16, 17, 4, -16 },
  { 2653, 13, 16, 17, 2, -16 },
  { 2679, 13, 21, 17, 2, -21 },
  { 2714, 13, 16, 17, 2, -16 },
  { 2740, 15, 16, 17, 1, -16 },
  { 2770, 16, 16, 17, 1, -16 },
  { 2802, 15, 16, 17, 1, -16 },
  { 2832, 15, 22, 17, 1, -16 },
  { 2874, 12, 16, 17, 3, -16 },
  { 2898, 12, 30, 17, 3, -24 },
  { 2943, 2, 30, 17, 8, -24 },
  { 2951, 11, 30, 17, 3, -24 },
  { 2993, 15, 4, 17, 1, -11 },
};

const GFXfont UbuntuSansMono_Regular31pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular31pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular31pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUSANSMONO_REGULAR31PT7B_H_
