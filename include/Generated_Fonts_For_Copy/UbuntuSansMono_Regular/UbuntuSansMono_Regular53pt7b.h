#ifndef _UBUNTUSANSMONO_REGULAR53PT7B_H_
#define _UBUNTUSANSMONO_REGULAR53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC7, 0x00, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x76, 0x03, 0xB0, 0x18, 0x00, 0x78,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x01, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xBF, 0xC7, 0xE0, 0x02, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x7E, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3C, 0xFF, 0x80, 0x0F, 0x3E, 0x78, 0x03, 0xC7, 0x87,
  0x00, 0x78, 0xE0, 0xE0, 0x1E, 0x3C, 0x1E, 0x03, 0xC7, 0x81, 0xC0, 0xF0,
  0xF0, 0x38, 0x1C, 0x1C, 0x07, 0x07, 0x83, 0x80, 0xE1, 0xE0, 0x78, 0x1C,
  0x3C, 0x0F, 0x07, 0x8F, 0x00, 0xE0, 0xF1, 0xC0, 0x1C, 0x1C, 0x78, 0x03,
  0xC7, 0x9E, 0x00, 0x3F, 0xE3, 0xC0, 0x03, 0xF8, 0xF0, 0x00, 0x3E, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x7F, 0x00,
  0x0F, 0x1F, 0xF0, 0x01, 0xC7, 0x9E, 0x00, 0x79, 0xE1, 0xE0, 0x1E, 0x3C,
  0x1C, 0x03, 0xC7, 0x03, 0x80, 0xF0, 0xE0, 0x70, 0x1C, 0x1C, 0x0E, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0x70, 0x38, 0x3C, 0x0E, 0x07, 0x0F, 0x01, 0xC0,
  0xE1, 0xC0, 0x3C, 0x1C, 0x78, 0x07, 0x87, 0x9E, 0x00, 0x78, 0xE3, 0xC0,
  0x0F, 0xFC, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x87,
  0xE0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x7C,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x90, 0x3F,
  0xC0, 0x38, 0x0F, 0xF8, 0x0E, 0x07, 0x9F, 0x03, 0x83, 0xE3, 0xE0, 0xE1,
  0xF0, 0x7C, 0x78, 0x7C, 0x0F, 0x9E, 0x1E, 0x03, 0xF7, 0x0F, 0x80, 0x7D,
  0xC3, 0xE0, 0x0F, 0xF0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xFE, 0x1F, 0x00, 0xFF, 0x83,
  0xF0, 0xFD, 0xF0, 0xFF, 0xFE, 0x3E, 0x1F, 0xFF, 0x0F, 0x81, 0xFF, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x20, 0x30, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x06, 0x07, 0x81, 0xBE, 0x1E,
  0x1E, 0xFE, 0x73, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xF3, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x1F, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0E, 0x01,
  0x80, 0x08, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x7E, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0xFC, 0x7F, 0x8F, 0xF0, 0x7E, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x01, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x3C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF0, 0xFE, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7C, 0x1F,
  0xF8, 0x18, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0xF8,
  0x0F, 0x83, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7E, 0xF0, 0x0F, 0xE7, 0x80,
  0xFC, 0x3C, 0x03, 0x81, 0xE0, 0x10, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x50, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0xFE, 0x0F, 0xE3, 0xE0, 0x0F, 0xC6, 0x00, 0x1F,
  0x10, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x70, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7C, 0x0F, 0xE0, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFA, 0x00, 0x07, 0xEF,
  0x00, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x40, 0x01, 0xF9, 0xE0, 0x1F,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x79, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0xFF, 0x83, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x00,
  0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0x8F, 0x80, 0x1F,
  0x1F, 0x80, 0x7C, 0x1F, 0x81, 0xF0, 0x1F, 0xC7, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xE0, 0xFF, 0x07, 0x80, 0x7F, 0x1E,
  0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0xFC, 0x03, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x3F,
  0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3D,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x79, 0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE7, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF0, 0x7E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x87,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x7C, 0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x0F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x70, 0x1F, 0x90, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x7C, 0x00, 0x78,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x1F, 0xFD, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x07, 0xFC, 0x1F, 0x03, 0xFE, 0x1F,
  0x01, 0xFE, 0x0F, 0x00, 0xFF, 0x07, 0x80, 0x7F, 0x87, 0xC0, 0x3F, 0xC3,
  0xE0, 0x1F, 0xE1, 0xF0, 0x0F, 0xF0, 0xF8, 0x07, 0xFC, 0x7C, 0x03, 0xFE,
  0x3E, 0x01, 0xFF, 0x0F, 0x00, 0xFF, 0x87, 0x80, 0x7F, 0xC3, 0xE0, 0x3D,
  0xE0, 0xF0, 0x1E, 0xF8, 0x7E, 0x0F, 0x7C, 0x1F, 0xFF, 0xBE, 0x07, 0xFF,
  0xCF, 0x80, 0xFF, 0xC7, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xA0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0,
  0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xE1, 0xFF, 0x8F,
  0x00, 0x3F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0,
  0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00,
  0x07, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0x78, 0x03, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x1F,
  0x9E, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0xFD, 0xE0,
  0x1F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xF8, 0x3E, 0x0F, 0xC0, 0x06, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x02, 0x07, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF8, 0xF0, 0x03, 0xF0, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xF0,
  0x3E, 0x0F, 0xC0, 0x06, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x80,
  0x0F, 0x0F, 0xC0, 0x0F, 0x07, 0xF0, 0x1F, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x88,
  0x00, 0x3E, 0x30, 0x01, 0xF1, 0xF0, 0x1F, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x8F, 0x00, 0x0F, 0x87, 0x80,
  0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0x78,
  0x0F, 0xC0, 0x3C, 0x0F, 0xC0, 0x1E, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x07,
  0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0xFE, 0x00, 0x0F, 0x3F, 0x80,
  0x07, 0x87, 0xE0, 0x03, 0xC1, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0xF0, 0x1F,
  0x80, 0x78, 0x07, 0xE0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x00,
  0x1F, 0x07, 0x80, 0x0F, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x3E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xEE, 0x01, 0xDC, 0x3B, 0xC0, 0xF7, 0x0E, 0xF0,
  0x39, 0xC3, 0x9C, 0x0E, 0x70, 0xE7, 0x87, 0x9C, 0x39, 0xE1, 0xC7, 0x1E,
  0x38, 0x71, 0xC7, 0x8F, 0x3C, 0x71, 0xE3, 0xCE, 0x1E, 0x78, 0x73, 0x87,
  0x9E, 0x1D, 0xE1, 0xE7, 0x83, 0xF0, 0x79, 0xE0, 0xFC, 0x1E, 0x78, 0x3F,
  0x07, 0x9E, 0x07, 0x81, 0xE7, 0x81, 0xE0, 0x79, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFB, 0xC0, 0x0F, 0xF7, 0xC0, 0x1F, 0xE7, 0x80, 0x3F, 0xCF,
  0x80, 0x7F, 0x8F, 0x00, 0xFF, 0x1F, 0x01, 0xFE, 0x1E, 0x03, 0xFC, 0x3E,
  0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0, 0x78, 0x3F, 0xC0, 0xF0,
  0x7F, 0x80, 0xF0, 0xFF, 0x01, 0xE1, 0xFE, 0x01, 0xE3, 0xFC, 0x03, 0xC7,
  0xF8, 0x03, 0xCF, 0xF0, 0x07, 0x9F, 0xE0, 0x07, 0x3F, 0xC0, 0x0F, 0x7F,
  0x80, 0x0E, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0,
  0x03, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0,
  0x07, 0xCF, 0x00, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xC0,
  0x1F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x08, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C,
  0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C,
  0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0xF8, 0x03, 0xC0,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF0,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3C,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x81, 0xF0, 0xF8,
  0x00, 0xC7, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7D, 0x00, 0x03, 0xEF, 0x80, 0x3F, 0xBF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE7, 0x81, 0xE0, 0x79, 0xE0, 0xF8, 0x1E, 0x78, 0x3E, 0x07, 0x9E,
  0x0F, 0xC1, 0xE7, 0x87, 0xF0, 0x79, 0xE1, 0xDC, 0x1C, 0x78, 0x77, 0x87,
  0x1E, 0x3C, 0xE1, 0xC7, 0x8E, 0x38, 0x71, 0xE3, 0x8F, 0x1C, 0x79, 0xE1,
  0xC7, 0x0E, 0x70, 0x71, 0xC3, 0x9C, 0x1E, 0x70, 0xEF, 0x03, 0x9C, 0x3B,
  0xC0, 0xE7, 0x0E, 0xE0, 0x3D, 0xC3, 0xB8, 0x07, 0x70, 0xFE, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x78, 0x00,
  0xF8, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xF0,
  0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00,
  0x3D, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x03,
  0xC1, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0x78, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xE7, 0x80, 0x03,
  0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x20,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x38, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x1E, 0x07, 0x81, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xF7, 0xFC, 0x10, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x0E, 0x1F, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7E,
  0x00, 0x7C, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF1, 0xFC, 0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F,
  0x81, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xC0, 0x04, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x0E, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xFC, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F,
  0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x3F, 0x00, 0x3C, 0x7F,
  0x81, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xB8,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xF7,
  0xF8, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x78, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xF8, 0x03, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x01, 0xE3, 0xE0, 0x03,
  0xCF, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xE0, 0x03, 0xC7, 0xE0,
  0x1F, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFE,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x30, 0x01, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xE0, 0x0F, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07,
  0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x98, 0x07, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x02, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x7E, 0x00, 0xF8,
  0xFC, 0x00, 0xF9, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFB, 0xF8, 0x00, 0xF9, 0xFC, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xC0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xF0,
  0xFF, 0xE7, 0xFC, 0xFF, 0xFF, 0xFE, 0xF8, 0xFF, 0x3E, 0xF0, 0x7C, 0x1F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x0F, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78,
  0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7E,
  0x00, 0xFC, 0xFF, 0x87, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xDF,
  0xF8, 0x0F, 0x87, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0x80, 0x3C, 0xF8, 0x00, 0xF7,
  0xC0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0xC0,
  0x1F, 0x1F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xEF,
  0x00, 0x58, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xE1, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFB, 0xFC, 0x7C, 0x00,
  0x11, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x90, 0x00, 0x3E, 0x78, 0x01, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFC, 0x1C, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00, 0x3C, 0xF8,
  0x01, 0xE7, 0xF0, 0x1F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x00, 0x60, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x3E,
  0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xDE, 0x03, 0xC0, 0x7B, 0xC0, 0x78, 0x0E, 0x78, 0x0F,
  0x03, 0xC7, 0x83, 0xF0, 0x78, 0xF0, 0x7E, 0x0F, 0x1E, 0x0F, 0xC1, 0xE3,
  0xC3, 0xFC, 0x3C, 0x78, 0x77, 0x87, 0x8F, 0x0E, 0x71, 0xE0, 0xE3, 0xCF,
  0x3C, 0x1E, 0x70, 0xE7, 0x83, 0xDE, 0x1C, 0xF0, 0x7B, 0x83, 0xDE, 0x0F,
  0x70, 0x3B, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x1C,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0x81, 0xF0, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07,
  0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0,
  0x01, 0xC7, 0xFE, 0x00, 0xE7, 0xFF, 0xC0, 0xF7, 0x83, 0xF0, 0xF3, 0x80,
  0xFF, 0xF9, 0xC0, 0x1F, 0xF9, 0xC0, 0x03, 0xF8,
};

const GFXglyph UbuntuSansMono_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 7, 38, 30, 11, -37 },
  { 35, 13, 14, 30, 8, -40 },
  { 58, 26, 37, 30, 2, -37 },
  { 179, 22, 47, 30, 4, -41 },
  { 309, 27, 39, 30, 1, -38 },
  { 441, 26, 38, 30, 2, -38 },
  { 565, 4, 15, 30, 13, -40 },
  { 573, 15, 51, 30, 7, -41 },
  { 669, 16, 51, 30, 7, -41 },
  { 771, 22, 22, 30, 4, -37 },
  { 832, 24, 26, 30, 3, -29 },
  { 910, 12, 16, 30, 9, -8 },
  { 934, 12, 4, 30, 9, -17 },
  { 940, 8, 9, 30, 11, -8 },
  { 949, 21, 52, 30, 4, -42 },
  { 1086, 24, 39, 30, 3, -38 },
  { 1203, 21, 37, 30, 5, -37 },
  { 1301, 22, 38, 30, 4, -38 },
  { 1406, 22, 39, 30, 4, -38 },
  { 1514, 26, 37, 30, 2, -37 },
  { 1635, 22, 38, 30, 4, -37 },
  { 1740, 24, 38, 30, 3, -37 },
  { 1854, 23, 37, 30, 4, -37 },
  { 1961, 23, 39, 30, 3, -38 },
  { 2074, 23, 38, 30, 3, -38 },
  { 2184, 8, 29, 30, 11, -28 },
  { 2213, 11, 36, 30, 8, -28 },
  { 2263, 24, 23, 30, 3, -27 },
  { 2332, 24, 15, 30, 3, -23 },
  { 2377, 24, 23, 30, 3, -27 },
  { 2446, 18, 39, 30, 6, -38 },
  { 2534, 25, 46, 30, 3, -38 },
  { 2678, 28, 37, 30, 1, -37 },
  { 2808, 23, 37, 30, 3, -37 },
  { 2915, 24, 39, 30, 3, -38 },
  { 3032, 24, 37, 30, 3, -37 },
  { 3143, 21, 37, 30, 6, -37 },
  { 3241, 20, 37, 30, 6, -37 },
  { 3334, 24, 39, 30, 3, -38 },
  { 3451, 24, 37, 30, 3, -37 },
  { 3562, 18, 37, 30, 6, -37 },
  { 3646, 22, 38, 30, 3, -37 },
  { 3751, 25, 37, 30, 4, -37 },
  { 3867, 21, 37, 30, 6, -37 },
  { 3965, 26, 37, 30, 2, -37 },
  { 4086, 23, 37, 30, 3, -37 },
  { 4193, 26, 39, 30, 2, -38 },
  { 4320, 22, 37, 30, 5, -37 },
  { 4422, 26, 48, 30, 2, -38 },
  { 4578, 24, 37, 30, 3, -37 },
  { 4689, 22, 39, 30, 4, -38 },
  { 4797, 24, 37, 30, 3, -37 },
  { 4908, 24, 38, 30, 3, -37 },
  { 5022, 28, 37, 30, 1, -37 },
  { 5152, 26, 37, 30, 2, -37 },
  { 5273, 26, 37, 30, 2, -37 },
  { 5394, 28, 37, 30, 1, -37 },
  { 5524, 24, 37, 30, 3, -37 },
  { 5635, 14, 52, 30, 9, -42 },
  { 5726, 21, 52, 30, 4, -42 },
  { 5863, 14, 52, 30, 7, -42 },
  { 5954, 24, 20, 30, 3, -37 },
  { 6014, 29, 4, 30, 0, 6 },
  { 6029, 9, 10, 30, 10, -41 },
  { 6041, 22, 29, 30, 4, -28 },
  { 6121, 23, 42, 30, 4, -41 },
  { 6242, 24, 29, 30, 3, -28 },
  { 6329, 22, 42, 30, 3, -41 },
  { 6445, 24, 29, 30, 3, -28 },
  { 6532, 24, 41, 30, 4, -41 },
  { 6655, 23, 38, 30, 2, -28 },
  { 6765, 22, 41, 30, 4, -41 },
  { 6878, 23, 41, 30, 3, -40 },
  { 6996, 18, 50, 30, 5, -40 },
  { 7109, 24, 41, 30, 4, -41 },
  { 7232, 23, 42, 30, 3, -41 },
  { 7353, 24, 28, 30, 3, -28 },
  { 7437, 22, 28, 30, 4, -28 },
  { 7514, 24, 29, 30, 3, -28 },
  { 7601, 23, 38, 30, 4, -28 },
  { 7711, 22, 38, 30, 3, -28 },
  { 7816, 19, 28, 30, 7, -28 },
  { 7883, 22, 29, 30, 4, -28 },
  { 7963, 22, 37, 30, 4, -36 },
  { 8065, 21, 28, 30, 4, -27 },
  { 8139, 26, 27, 30, 2, -27 },
  { 8227, 27, 27, 30, 1, -27 },
  { 8319, 26, 27, 30, 2, -27 },
  { 8407, 25, 37, 30, 2, -27 },
  { 8523, 21, 27, 30, 4, -27 },
  { 8594, 20, 52, 30, 5, -42 },
  { 8724, 4, 52, 30, 13, -42 },
  { 8750, 21, 52, 30, 4, -42 },
  { 8887, 25, 8, 30, 2, -20 },
};

const GFXfont UbuntuSansMono_Regular53pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular53pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular53pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _UBUNTUSANSMONO_REGULAR53PT7B_H_
