#ifndef _UBUNTUSANSMONO_REGULAR43PT7B_H_
#define _UBUNTUSANSMONO_REGULAR43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9C, 0x30, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x21, 0xEF, 0xFF, 0xFD, 0xE2,
  0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x1E, 0x0F,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x70, 0x07, 0x83, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x03, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x1E, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0xFE, 0xFC, 0x78, 0x01, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x07, 0xBF, 0xFF, 0xEF, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x39, 0xFE, 0x00, 0xE7, 0x1C,
  0x07, 0x38, 0x70, 0x3C, 0xE1, 0xC0, 0xE3, 0x83, 0x07, 0x0E, 0x0C, 0x1C,
  0x38, 0x30, 0xE0, 0xE0, 0xC7, 0x83, 0x87, 0x1C, 0x0E, 0x1C, 0xE0, 0x1C,
  0x73, 0x80, 0x7F, 0x9C, 0x00, 0xFC, 0xF0, 0x00, 0xC3, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x73, 0xF0, 0x03, 0x9F, 0xE0, 0x1E, 0x73, 0x80, 0x73, 0x87,
  0x03, 0x8E, 0x1C, 0x0E, 0x38, 0x70, 0x70, 0xC1, 0xC3, 0xC3, 0x07, 0x0E,
  0x0C, 0x1C, 0x70, 0x38, 0x71, 0xC0, 0xE1, 0xCE, 0x03, 0x8E, 0x78, 0x07,
  0xF9, 0xC0, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xCF, 0x80, 0x78, 0x3C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0F, 0x00,
  0x3C, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x03, 0x83, 0xF8,
  0x1C, 0x3D, 0xE0, 0xC3, 0xC7, 0x8E, 0x1C, 0x3E, 0x71, 0xE0, 0xFB, 0x8F,
  0x03, 0xDC, 0x70, 0x0F, 0xC3, 0x80, 0x3E, 0x1C, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x7E, 0x1E, 0x07, 0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0x8F, 0x0F,
  0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x66, 0x60, 0x00, 0x20, 0x06,
  0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xE0, 0x02,
  0x40, 0x06, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80,
  0x70, 0x04, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x18, 0x30, 0x6F, 0x8C, 0x7F, 0xFB, 0x7F, 0x7F, 0xFF, 0x81,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x07, 0x3C, 0x03, 0xCF, 0x01, 0xE1,
  0xE0, 0xF8, 0x7C, 0x0C, 0x0C, 0x01, 0x02, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0x0F, 0x8F, 0xE7, 0xF3, 0xF8, 0xFC, 0x1C, 0x1E, 0x1E, 0x3F,
  0x3F, 0x1E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE1, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x78,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x06, 0x0E, 0xF0, 0xF0, 0xFF, 0x1F,
  0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF0, 0xF0, 0xFF, 0x02, 0x0F, 0x70,
  0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3,
  0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0x80, 0xF9, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF7, 0x03, 0xF3, 0x81, 0xE1,
  0xC0, 0x40, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x3C, 0x60, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xC0, 0x7C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE4, 0x00, 0xFB, 0xF1, 0xFC, 0xFF,
  0xFE, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x80,
  0x1E, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03,
  0x87, 0x00, 0x38, 0xF0, 0x03, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x07, 0xDF, 0x1F, 0xCF, 0xFF, 0xC3, 0xFF,
  0xC0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x3F, 0x81, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0xC0, 0x7C, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x0E,
  0x70, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1F, 0x0F, 0x81, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xF3, 0xF1,
  0xE0, 0x1E, 0x70, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xE7, 0x80, 0x39, 0xE0, 0x1E, 0x3E, 0x0F, 0x07, 0xE7,
  0x80, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x3F, 0x1E, 0x03, 0xE7, 0x00, 0x7F,
  0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7D, 0xF8, 0x7E, 0x3F, 0xFF, 0x07, 0xFF,
  0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x83, 0xF7, 0xF1, 0xE0, 0x3C,
  0x70, 0x07, 0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x80,
  0x3C, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE1, 0x00, 0x0F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83,
  0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xE0, 0x78, 0x1E, 0x0F,
  0x0F, 0x8F, 0xC1, 0xE0, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x40, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00,
  0x7F, 0xE3, 0xFF, 0xEF, 0x9F, 0xA0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1E, 0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x78, 0xF0,
  0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0x73, 0xC0, 0x0F, 0x9E, 0x07, 0xFE,
  0xE0, 0x7F, 0xF7, 0x07, 0xC7, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x3C,
  0x0F, 0xF1, 0xE0, 0x7F, 0x8F, 0x03, 0xFC, 0x78, 0x1F, 0xE3, 0xC0, 0xFF,
  0x1E, 0x07, 0xF8, 0xF0, 0x3D, 0xC3, 0x81, 0xEF, 0x1E, 0x0F, 0x78, 0x78,
  0x7B, 0xC3, 0xFF, 0xCF, 0x0F, 0xFE, 0x78, 0x1F, 0x83, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x7C,
  0xE0, 0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xB8,
  0x01, 0xEE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFC, 0xE0, 0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x80, 0x63, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x01, 0x07, 0xF3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x0E,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x70, 0x1F, 0x0E, 0x00,
  0xF1, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00,
  0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xE0, 0x07,
  0x9C, 0x01, 0xE3, 0x80, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDC, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xBF,
  0x0F, 0x80, 0x63, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xDC, 0x00, 0x7B,
  0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x7C, 0x07, 0x87, 0xF1, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x98, 0x07,
  0xDF, 0x0F, 0xCF, 0xFF, 0xC1, 0xFF, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0xF7,
  0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x0F,
  0x83, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x3C,
  0x78, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xE0,
  0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xF0,
  0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x01, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0x70, 0x6E, 0x77, 0x0E, 0xE7, 0x70, 0xEE, 0x73, 0x8C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0x67, 0x1D, 0x87, 0x71, 0xF8, 0x7F, 0x0F, 0x87,
  0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7E, 0xE0, 0x1F, 0xBC, 0x07, 0xE7, 0x01, 0xF9, 0xE0, 0x7E, 0x38, 0x1F,
  0x8F, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x0E, 0x1F, 0x83, 0x87, 0xE0,
  0x71, 0xF8, 0x1C, 0x7E, 0x03, 0x9F, 0x80, 0xE7, 0xE0, 0x3D, 0xF8, 0x07,
  0x7E, 0x01, 0xDF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0x80, 0xF8, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0x80, 0x07, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00,
  0x03, 0x9C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC,
  0x00, 0x0E, 0x70, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x8E, 0x00,
  0x1E, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xF3, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00,
  0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0xF3, 0x81, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0x80, 0xF8, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xF3, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x70, 0x0F, 0x8E,
  0x00, 0x79, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C,
  0x00, 0x7B, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x38,
  0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0x81, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0xC1, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x00, 0x78, 0xE0,
  0x07, 0x1C, 0x00, 0xF3, 0x80, 0x0E, 0x70, 0x01, 0xEE, 0x00, 0x1D, 0xC0,
  0x03, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFB, 0xF8, 0xF0, 0x0C, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF4, 0x00, 0x7B, 0xF0, 0xFE, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xF0,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x00, 0x03, 0x8F,
  0x00, 0x07, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0xF0, 0x03, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0xC0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0E, 0x07,
  0x80, 0x1C, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0,
  0x00, 0xE1, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xF1,
  0xF8, 0x7F, 0x1F, 0x86, 0x71, 0x98, 0x67, 0x39, 0xC6, 0x73, 0x9C, 0xE7,
  0x31, 0xCE, 0x77, 0x0E, 0xE7, 0x70, 0xEE, 0x77, 0x0E, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0x80, 0x1C, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x07,
  0x00, 0x38, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x3C, 0x01, 0xC1,
  0xE0, 0x07, 0x87, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0xE1, 0xC0, 0x07, 0x87,
  0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x70, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0x79, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0x9C, 0x00, 0x79, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0, 0x0E, 0x07, 0x01,
  0xE0, 0x78, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0E,
  0xF0, 0x00, 0xF2, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x61, 0xE1, 0xC1, 0xC3, 0xC3, 0xC3, 0x82, 0x07, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x60, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x7F, 0x0F, 0xCF, 0xFF, 0xF0, 0xFF,
  0xFC, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x3E, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0x0F, 0x8F, 0x00,
  0xF3, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x0F, 0x38, 0x07, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0x0E, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x02, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC7, 0x83, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3E, 0x1F, 0xCF, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01,
  0xEE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0xF3, 0xC0, 0x1E, 0x7C, 0x03, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x81, 0xF0, 0x7C, 0x3C, 0x03, 0xC3, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x04, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3C, 0x01, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xC3, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3C, 0xF8,
  0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFB, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x18, 0x07, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x39, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE3, 0xF3,
  0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x40, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x40,
  0x7B, 0xFF, 0xEF, 0xFF, 0x0F, 0xF0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x03, 0xEE, 0x00,
  0xF1, 0xC0, 0x3C, 0x38, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0xF0, 0x1C, 0x7C,
  0x03, 0x9F, 0x00, 0x77, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0x3E, 0x00, 0xE3, 0xE0, 0x1C, 0x1E, 0x03, 0x81, 0xE0, 0x70, 0x1E,
  0x0E, 0x01, 0xE1, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x00, 0x1E, 0xE0, 0x03,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x10, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x3F, 0x07, 0x0F, 0xFD, 0xFC, 0xFF,
  0xFF, 0xEE, 0x0F, 0x8F, 0xE0, 0xF0, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E,
  0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07,
  0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x70, 0x0F, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x0F,
  0xCE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xE7,
  0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC1, 0xF8,
  0xE0, 0x1F, 0x38, 0x03, 0xEE, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x7B, 0xE0, 0x7C,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0E, 0xFF, 0x83, 0x82, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xC1, 0xF3, 0xE0,
  0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x9F, 0x01,
  0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0x78, 0x03, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0xFC, 0x02, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0x0C, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3D, 0x80, 0x1E, 0x7E, 0x3F,
  0xBF, 0xFF, 0xC7, 0xFF, 0xC0, 0x02, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x10, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00,
  0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xC3, 0xC0,
  0x3C, 0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0F,
  0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x79, 0xE0, 0x03, 0x9C, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x70,
  0x00, 0x3D, 0xC0, 0xE0, 0xE7, 0x07, 0x83, 0x9C, 0x1E, 0x0E, 0x70, 0x78,
  0x39, 0xE3, 0xF0, 0xE7, 0x8F, 0xC7, 0x8E, 0x33, 0x1C, 0x39, 0xCE, 0x70,
  0xE7, 0x39, 0xC3, 0x98, 0x77, 0x0E, 0xE1, 0xDC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x30, 0x03,
  0x80, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0xF0,
  0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0x3C, 0x00, 0x38, 0x78, 0x01, 0xE0, 0xE0, 0x0F, 0x03, 0xC0,
  0x78, 0x07, 0x81, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0x7B, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE3, 0x80, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xE0, 0x3C, 0x1E, 0x03,
  0xC0, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0xF0, 0x78, 0x07, 0x07, 0x00, 0x78,
  0x70, 0x03, 0x8F, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0x00, 0x43, 0xFC, 0x07, 0x7F, 0xE0,
  0x77, 0x0F, 0x8E, 0xE0, 0x7F, 0xEE, 0x01, 0xFC, 0x00, 0x02, 0x00,
};

const GFXglyph UbuntuSansMono_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 31, 24, 9, -30 },
  { 25, 10, 12, 24, 7, -33 },
  { 40, 22, 30, 24, 1, -30 },
  { 123, 18, 38, 24, 3, -33 },
  { 209, 22, 31, 24, 1, -30 },
  { 295, 21, 30, 24, 2, -30 },
  { 374, 4, 13, 24, 10, -33 },
  { 381, 12, 42, 24, 6, -34 },
  { 444, 12, 42, 24, 6, -34 },
  { 507, 18, 18, 24, 3, -30 },
  { 548, 20, 21, 24, 2, -23 },
  { 601, 9, 13, 24, 8, -6 },
  { 616, 10, 3, 24, 7, -14 },
  { 620, 6, 7, 24, 9, -6 },
  { 626, 16, 42, 24, 4, -34 },
  { 710, 20, 31, 24, 2, -30 },
  { 788, 17, 30, 24, 4, -30 },
  { 852, 18, 30, 24, 3, -30 },
  { 920, 18, 31, 24, 3, -30 },
  { 990, 20, 30, 24, 2, -30 },
  { 1065, 17, 31, 24, 4, -30 },
  { 1131, 19, 31, 24, 3, -30 },
  { 1205, 19, 30, 24, 3, -30 },
  { 1277, 18, 31, 24, 3, -30 },
  { 1347, 18, 30, 24, 3, -30 },
  { 1415, 6, 23, 24, 9, -22 },
  { 1433, 10, 29, 24, 6, -22 },
  { 1470, 20, 19, 24, 2, -22 },
  { 1518, 20, 12, 24, 2, -19 },
  { 1548, 20, 19, 24, 2, -22 },
  { 1596, 14, 31, 24, 5, -30 },
  { 1651, 21, 37, 24, 2, -30 },
  { 1749, 24, 30, 24, 0, -30 },
  { 1839, 18, 30, 24, 3, -30 },
  { 1907, 19, 31, 24, 3, -30 },
  { 1981, 19, 30, 24, 3, -30 },
  { 2053, 17, 30, 24, 5, -30 },
  { 2117, 16, 30, 24, 5, -30 },
  { 2177, 19, 31, 24, 3, -30 },
  { 2251, 20, 30, 24, 2, -30 },
  { 2326, 14, 30, 24, 5, -30 },
  { 2379, 17, 31, 24, 3, -30 },
  { 2445, 21, 30, 24, 3, -30 },
  { 2524, 17, 30, 24, 5, -30 },
  { 2588, 20, 30, 24, 2, -30 },
  { 2663, 18, 30, 24, 3, -30 },
  { 2731, 22, 31, 24, 1, -30 },
  { 2817, 18, 30, 24, 4, -30 },
  { 2885, 22, 38, 24, 1, -30 },
  { 2990, 19, 30, 24, 3, -30 },
  { 3062, 18, 31, 24, 3, -30 },
  { 3132, 20, 30, 24, 2, -30 },
  { 3207, 20, 31, 24, 2, -30 },
  { 3285, 23, 30, 24, 1, -30 },
  { 3372, 20, 30, 24, 2, -30 },
  { 3447, 22, 30, 24, 1, -30 },
  { 3530, 23, 30, 24, 1, -30 },
  { 3617, 19, 30, 24, 3, -30 },
  { 3689, 11, 42, 24, 7, -34 },
  { 3747, 16, 42, 24, 4, -34 },
  { 3831, 11, 42, 24, 6, -34 },
  { 3889, 20, 16, 24, 2, -30 },
  { 3929, 24, 3, 24, 0, 5 },
  { 3938, 7, 8, 24, 8, -33 },
  { 3945, 18, 24, 24, 3, -23 },
  { 3999, 18, 34, 24, 4, -33 },
  { 4076, 20, 24, 24, 2, -23 },
  { 4136, 19, 34, 24, 2, -33 },
  { 4217, 20, 24, 24, 2, -23 },
  { 4277, 20, 33, 24, 3, -33 },
  { 4360, 19, 31, 24, 2, -23 },
  { 4434, 17, 33, 24, 4, -33 },
  { 4505, 18, 33, 24, 3, -32 },
  { 4580, 14, 40, 24, 4, -32 },
  { 4650, 19, 33, 24, 4, -33 },
  { 4729, 18, 34, 24, 3, -33 },
  { 4806, 20, 23, 24, 2, -23 },
  { 4864, 17, 23, 24, 4, -23 },
  { 4913, 20, 23, 24, 2, -23 },
  { 4971, 18, 31, 24, 4, -23 },
  { 5041, 19, 31, 24, 2, -23 },
  { 5115, 16, 23, 24, 5, -23 },
  { 5161, 18, 24, 24, 3, -23 },
  { 5215, 18, 30, 24, 3, -29 },
  { 5283, 18, 22, 24, 3, -22 },
  { 5333, 20, 22, 24, 2, -22 },
  { 5388, 22, 22, 24, 1, -22 },
  { 5449, 22, 22, 24, 1, -22 },
  { 5510, 20, 30, 24, 2, -22 },
  { 5585, 16, 22, 24, 4, -22 },
  { 5629, 16, 42, 24, 4, -34 },
  { 5713, 3, 42, 24, 11, -34 },
  { 5729, 16, 42, 24, 4, -34 },
  { 5813, 20, 7, 24, 2, -16 },
};

const GFXfont UbuntuSansMono_Regular43pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular43pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular43pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUSANSMONO_REGULAR43PT7B_H_
