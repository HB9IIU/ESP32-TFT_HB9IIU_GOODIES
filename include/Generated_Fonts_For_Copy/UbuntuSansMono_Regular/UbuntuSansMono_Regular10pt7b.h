#ifndef _UBUNTUSANSMONO_REGULAR10PT7B_H_
#define _UBUNTUSANSMONO_REGULAR10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xFC, 0x29, 0x7E, 0xAF, 0xA9, 0x40, 0x47, 0x88, 0x61, 0x1E,
  0x40, 0xED, 0xAC, 0xC3, 0xAF, 0x60, 0x72, 0x94, 0xD9, 0xC9, 0xE0, 0xE0,
  0x29, 0x49, 0x22, 0x64, 0x88, 0x92, 0x49, 0x50, 0x4F, 0x4A, 0x44, 0xF4,
  0x40, 0xD8, 0xC0, 0xC0, 0x12, 0x22, 0x44, 0x48, 0x88, 0xE9, 0x9D, 0x99,
  0xE0, 0x6A, 0x22, 0x22, 0xF0, 0xE1, 0x12, 0x48, 0xF0, 0xE1, 0x26, 0x11,
  0xE0, 0x11, 0x94, 0xAF, 0x88, 0x40, 0xF8, 0x86, 0x11, 0xE0, 0x78, 0x8F,
  0x99, 0xE0, 0xF1, 0x22, 0x44, 0x40, 0xE9, 0x96, 0x99, 0xF0, 0xE9, 0x9F,
  0x12, 0xC0, 0xC0, 0xC0, 0x60, 0x06, 0xA0, 0x3C, 0xC3, 0xFF, 0x86, 0x3C,
  0xE1, 0x24, 0x40, 0x40, 0x79, 0xBD, 0xDD, 0xA4, 0x30, 0x30, 0xC5, 0x12,
  0x7A, 0x28, 0xC0, 0xE9, 0x9E, 0x99, 0xE0, 0x78, 0x88, 0x88, 0x70, 0xE9,
  0x99, 0x99, 0xE0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x78,
  0x88, 0x99, 0x70, 0x8C, 0x63, 0xF8, 0xC6, 0x20, 0xE9, 0x24, 0xB8, 0xF1,
  0x11, 0x11, 0xE0, 0x95, 0x31, 0x8A, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0,
  0x4A, 0xEF, 0x58, 0xC6, 0x20, 0x99, 0xDD, 0xBB, 0x90, 0x72, 0x63, 0x18,
  0xA5, 0xC0, 0xE9, 0x9B, 0xC8, 0x80, 0x72, 0x63, 0x18, 0xA5, 0xC4, 0x18,
  0xE9, 0x9E, 0xAA, 0x90, 0xF8, 0x86, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10,
  0x80, 0x99, 0x99, 0x99, 0xE0, 0x8C, 0x52, 0x95, 0x18, 0x80, 0x8C, 0x63,
  0x5B, 0xAD, 0x20, 0xCA, 0x8C, 0x45, 0x26, 0x20, 0x8A, 0x54, 0x62, 0x10,
  0x80, 0xF1, 0x24, 0x48, 0xF0, 0xEA, 0xAA, 0xB0, 0x88, 0x84, 0x44, 0x22,
  0x21, 0xE4, 0x92, 0x49, 0x3C, 0x46, 0x99, 0xFC, 0xB0, 0xF1, 0xF9, 0xF0,
  0x88, 0x8F, 0x99, 0x9E, 0xF8, 0x88, 0xF0, 0x08, 0x42, 0xF4, 0xC5, 0x2F,
  0x7C, 0x7E, 0x87, 0x80, 0x34, 0x4F, 0x44, 0x44, 0x7C, 0x62, 0x97, 0x85,
  0xC0, 0x88, 0x8E, 0x99, 0x99, 0x44, 0x0C, 0x44, 0x47, 0x24, 0x72, 0x49,
  0x3C, 0x88, 0x8B, 0xCC, 0xA9, 0xC4, 0x44, 0x44, 0x47, 0xFD, 0x6B, 0x18,
  0x80, 0xE9, 0x99, 0x90, 0x7A, 0x62, 0x97, 0x00, 0xE9, 0x99, 0xE8, 0x80,
  0x7A, 0x62, 0x97, 0x84, 0x20, 0xF8, 0x88, 0x80, 0xF8, 0x61, 0xF0, 0x44,
  0xF4, 0x44, 0x70, 0x99, 0x99, 0xF0, 0xCA, 0x54, 0x62, 0x00, 0x8D, 0x6E,
  0xB4, 0x80, 0xC9, 0x8C, 0xAC, 0x80, 0x4A, 0x54, 0x63, 0x13, 0x00, 0xF2,
  0x48, 0xF0, 0x34, 0x44, 0x4C, 0x44, 0x43, 0xFF, 0xC0, 0xC2, 0x22, 0x23,
  0x22, 0x2C, 0x6C, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 7, 6, 2, -7 },
  { 2, 2, 3, 6, 2, -8 },
  { 3, 5, 7, 6, 0, -7 },
  { 8, 4, 9, 6, 1, -8 },
  { 13, 5, 7, 6, 0, -7 },
  { 18, 5, 7, 6, 0, -7 },
  { 23, 1, 3, 6, 2, -8 },
  { 24, 3, 10, 6, 1, -8 },
  { 28, 3, 10, 6, 1, -8 },
  { 32, 4, 4, 6, 1, -7 },
  { 34, 4, 5, 6, 1, -5 },
  { 37, 2, 3, 6, 2, -1 },
  { 38, 2, 1, 6, 2, -3 },
  { 39, 2, 1, 6, 2, -1 },
  { 40, 4, 10, 6, 1, -8 },
  { 45, 4, 7, 6, 1, -7 },
  { 49, 4, 7, 6, 1, -7 },
  { 53, 4, 7, 6, 1, -7 },
  { 57, 4, 7, 6, 1, -7 },
  { 61, 5, 7, 6, 0, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 4, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 2, 5, 6, 2, -5 },
  { 88, 3, 7, 6, 1, -5 },
  { 91, 4, 4, 6, 1, -5 },
  { 93, 4, 2, 6, 1, -4 },
  { 94, 4, 4, 6, 1, -5 },
  { 96, 4, 7, 6, 1, -7 },
  { 100, 4, 9, 6, 1, -7 },
  { 105, 6, 7, 6, 0, -7 },
  { 111, 4, 7, 6, 1, -7 },
  { 115, 4, 7, 6, 1, -7 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 5, 7, 6, 0, -7 },
  { 140, 3, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 5, 7, 6, 1, -7 },
  { 152, 4, 7, 6, 1, -7 },
  { 156, 5, 7, 6, 0, -7 },
  { 161, 4, 7, 6, 1, -7 },
  { 165, 5, 7, 6, 0, -7 },
  { 170, 4, 7, 6, 1, -7 },
  { 174, 5, 9, 6, 0, -7 },
  { 180, 4, 7, 6, 1, -7 },
  { 184, 4, 7, 6, 1, -7 },
  { 188, 5, 7, 6, 0, -7 },
  { 193, 4, 7, 6, 1, -7 },
  { 197, 5, 7, 6, 0, -7 },
  { 202, 5, 7, 6, 0, -7 },
  { 207, 5, 7, 6, 0, -7 },
  { 212, 5, 7, 6, 0, -7 },
  { 217, 4, 7, 6, 1, -7 },
  { 221, 2, 10, 6, 2, -8 },
  { 224, 4, 10, 6, 1, -8 },
  { 229, 3, 10, 6, 1, -8 },
  { 233, 4, 4, 6, 1, -7 },
  { 235, 6, 1, 6, 0, 1 },
  { 236, 2, 2, 6, 2, -8 },
  { 237, 4, 5, 6, 1, -5 },
  { 240, 4, 8, 6, 1, -8 },
  { 244, 4, 5, 6, 1, -5 },
  { 247, 5, 8, 6, 0, -8 },
  { 252, 5, 5, 6, 0, -5 },
  { 256, 4, 8, 6, 1, -8 },
  { 260, 5, 7, 6, 0, -5 },
  { 265, 4, 8, 6, 1, -8 },
  { 269, 4, 8, 6, 1, -8 },
  { 273, 3, 10, 6, 1, -8 },
  { 277, 4, 8, 6, 1, -8 },
  { 281, 4, 8, 6, 1, -8 },
  { 285, 5, 5, 6, 0, -5 },
  { 289, 4, 5, 6, 1, -5 },
  { 292, 5, 5, 6, 0, -5 },
  { 296, 4, 7, 6, 1, -5 },
  { 300, 5, 7, 6, 0, -5 },
  { 305, 4, 5, 6, 1, -5 },
  { 308, 4, 5, 6, 1, -5 },
  { 311, 4, 7, 6, 1, -7 },
  { 315, 4, 5, 6, 1, -5 },
  { 318, 5, 5, 6, 0, -5 },
  { 322, 5, 5, 6, 0, -5 },
  { 326, 5, 5, 6, 0, -5 },
  { 330, 5, 7, 6, 0, -5 },
  { 335, 4, 5, 6, 1, -5 },
  { 338, 4, 10, 6, 1, -8 },
  { 343, 1, 10, 6, 2, -8 },
  { 345, 4, 10, 6, 1, -8 },
  { 350, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_Regular10pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular10pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUSANSMONO_REGULAR10PT7B_H_
