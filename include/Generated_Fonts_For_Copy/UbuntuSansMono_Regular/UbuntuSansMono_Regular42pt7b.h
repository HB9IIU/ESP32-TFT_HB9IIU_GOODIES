#ifndef _UBUNTUSANSMONO_REGULAR42PT7B_H_
#define _UBUNTUSANSMONO_REGULAR42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC3, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xEF, 0xFE, 0xF8, 0x80,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x6C, 0x18, 0x01, 0xE0, 0xF0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81,
  0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x70, 0x38,
  0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x70,
  0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x07, 0x00,
  0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x0F, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7C, 0x03, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0xC0, 0x0F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00,
  0xFC, 0x00, 0xE7, 0xF8, 0x07, 0x18, 0x60, 0x38, 0xE1, 0xC0, 0xE3, 0x87,
  0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE0, 0xE1, 0xC7, 0x03, 0x87, 0x1C,
  0x0E, 0x1C, 0xE0, 0x18, 0x73, 0x80, 0x73, 0x9C, 0x00, 0xFC, 0xE0, 0x01,
  0xE3, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x73, 0xE0, 0x03, 0x9F, 0xC0, 0x1C,
  0xF7, 0x80, 0x73, 0x8E, 0x03, 0x8C, 0x18, 0x0E, 0x30, 0x60, 0x71, 0xC1,
  0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x1C, 0x70, 0x30, 0x61, 0xC0, 0xE1, 0x8E,
  0x03, 0x8E, 0x70, 0x07, 0x71, 0xC0, 0x1F, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xE3, 0xC0, 0x3C, 0x1E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0,
  0x3C, 0x3C, 0x01, 0xC7, 0x80, 0x1E, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC1,
  0x01, 0xFC, 0x1C, 0x3F, 0xC1, 0xC7, 0x9E, 0x1C, 0x70, 0xF1, 0xCF, 0x07,
  0x98, 0xF0, 0x3F, 0x8E, 0x01, 0xF8, 0xE0, 0x1F, 0x8E, 0x00, 0xF0, 0xF0,
  0x0F, 0x8F, 0x00, 0xFC, 0xF8, 0x3F, 0xC7, 0xEF, 0xDE, 0x3F, 0xF8, 0xE1,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xB0, 0x00, 0x40, 0x0E, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0E, 0x00, 0x40, 0x40, 0x06, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0x40, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x41, 0xC0, 0x9C, 0x70,
  0xEF, 0xCD, 0xFB, 0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x1D, 0xE0, 0x0F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xE0, 0x70, 0x70, 0x08,
  0x08, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x0F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xE0,
  0x38, 0x1E, 0x0F, 0x0F, 0x8F, 0xC1, 0xE0, 0x40, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x0F, 0x8F, 0x81, 0xE0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xF3, 0xC0, 0x0E,
  0x78, 0x01, 0xCE, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xFF, 0x0F, 0x1F,
  0xE3, 0xE1, 0xFC, 0x7E, 0x3F, 0x8F, 0x87, 0xF0, 0xF0, 0xFE, 0x0C, 0x1F,
  0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDE, 0x00, 0x73,
  0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0x70, 0x78, 0x1E, 0x0F, 0xCF, 0x80,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x7C, 0xE0, 0xF8, 0xE0, 0x60, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xE3,
  0xF0, 0xF8, 0x60, 0x0F, 0x10, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xE1, 0xE1, 0xF8, 0x20, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE8,
  0x00, 0xF3, 0xE1, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x77, 0x00,
  0x0F, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x70, 0x70,
  0x07, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x07,
  0x03, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x40, 0x0F, 0xBC, 0x3F, 0x9F, 0xFF, 0x87,
  0xFF, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0xEF, 0xFC, 0x3F, 0xFF, 0xCF,
  0xC1, 0xF3, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x07,
  0x9E, 0x01, 0xE3, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF0, 0x7C, 0x78, 0x07, 0x1C, 0x01, 0xEF, 0x00, 0x3B, 0x80, 0x0E,
  0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x39, 0xE0, 0x1C, 0x7C, 0x0F, 0x0F,
  0xC7, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x3E, 0x7F, 0x0E, 0x07, 0xC7, 0x00,
  0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x79, 0xF0, 0x7C, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0x07, 0x83, 0xC0, 0x78, 0xF0, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x01, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x79, 0xF8, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xBC, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x0F, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x1E,
  0x0E, 0x0F, 0x3F, 0x3F, 0x1E, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xE0,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x78,
  0x00, 0x06, 0x00, 0x00, 0x0F, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x40, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xF8, 0x7C, 0x1F, 0x01, 0xE1,
  0xE0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x07,
  0x78, 0x0F, 0xF7, 0x03, 0xFF, 0x70, 0x7F, 0xFF, 0x0F, 0x07, 0xF0, 0xF0,
  0x7F, 0x1E, 0x07, 0xF1, 0xE0, 0x7F, 0x1E, 0x07, 0xF1, 0xC0, 0x7F, 0x1C,
  0x07, 0xF1, 0xC0, 0x7F, 0x1E, 0x07, 0x71, 0xE0, 0x77, 0x0E, 0x07, 0x78,
  0xF0, 0x77, 0x87, 0xFF, 0x78, 0x3F, 0xF3, 0xC0, 0xFC, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x71,
  0xC0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x3C, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0E, 0x0F, 0xE3,
  0x80, 0x7C, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0x1E, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x78, 0xFF, 0xFC, 0x3F, 0xFC,
  0x0F, 0xFF, 0xE3, 0x80, 0xFC, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xB8, 0x03, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0x3E, 0x0F, 0x00, 0x41,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x20, 0xFF, 0x3E, 0x03, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x3F, 0xC3,
  0x80, 0xF8, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xE0,
  0x0F, 0x38, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xF0, 0xF0, 0x04, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x0E, 0xF0, 0x01, 0xCE, 0x00, 0x39, 0xE0, 0x07, 0x3C, 0x00, 0xE3, 0xC0,
  0x1C, 0x3C, 0x03, 0x87, 0xF0, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x07,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x40, 0x1E, 0xF8, 0x7E, 0xFF, 0xFC, 0x3F, 0xF8, 0x03,
  0x00, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F,
  0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xF8,
  0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7,
  0xC0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x6C, 0x7E, 0x0E, 0xE7, 0x70, 0xEE,
  0x77, 0x0C, 0xE7, 0x71, 0xCE, 0x73, 0x1C, 0xE6, 0x39, 0x8E, 0x61, 0x98,
  0xE6, 0x1B, 0x8E, 0xE1, 0xF0, 0xEE, 0x0F, 0x0E, 0xE0, 0xF0, 0xEE, 0x0E,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7E, 0xE0, 0x1F, 0xBC, 0x07, 0xE7,
  0x01, 0xF9, 0xE0, 0x7E, 0x38, 0x1F, 0x8F, 0x07, 0xE1, 0xC1, 0xF8, 0x70,
  0x7E, 0x0E, 0x1F, 0x83, 0x87, 0xE0, 0x71, 0xF8, 0x1C, 0x7E, 0x03, 0x9F,
  0x80, 0xE7, 0xE0, 0x39, 0xF8, 0x07, 0x7E, 0x01, 0xDF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x1E, 0x0F, 0x81, 0xE0, 0x1E,
  0x1E, 0x00, 0xF0, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x73, 0x80,
  0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x80, 0xF8, 0x1F, 0x1F,
  0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3E, 0x3F, 0x9C, 0x03, 0xEE, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x77, 0x00, 0x7B, 0x80, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x1E, 0x0F, 0x81, 0xE0, 0x1E,
  0x1E, 0x00, 0xF0, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x73, 0x80,
  0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xCF,
  0x00, 0x0E, 0x38, 0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x80, 0xF8, 0x1F, 0x1F,
  0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x10, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0x1F, 0xE3, 0x80, 0x7C,
  0xE0, 0x07, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xB8,
  0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x07, 0x8E, 0x1F,
  0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE0,
  0xE0, 0x1C, 0x38, 0x07, 0x8E, 0x00, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0x38,
  0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xF8, 0xF8, 0x3C, 0x78, 0x01, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE4, 0x00, 0x7B, 0xE0, 0xFC,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80,
  0x0F, 0x78, 0x01, 0xC7, 0x80, 0x78, 0xFC, 0x3E, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00,
  0x38, 0x1C, 0x01, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x0F, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x0E, 0x0E, 0xE0, 0xF0, 0xEE, 0x1F, 0x0E, 0xE1,
  0xF0, 0xEE, 0x1B, 0x8E, 0x63, 0xB8, 0xE6, 0x39, 0x8E, 0x73, 0x1C, 0xE7,
  0x71, 0xCE, 0x77, 0x0C, 0xE7, 0x60, 0xEC, 0x7E, 0x0E, 0xC7, 0xE0, 0x6C,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03,
  0xC0, 0x78, 0x00, 0x79, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x38, 0x03, 0xC1,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0, 0x03, 0x8F,
  0x00, 0x1E, 0x70, 0x00, 0x77, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDE, 0x00, 0x1E, 0x70,
  0x00, 0xE3, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x07, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x00, 0xEF, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xE7,
  0x00, 0x07, 0x9E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0,
  0x1E, 0x07, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x70, 0x78,
  0x01, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0F, 0x38, 0x00, 0x1D, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x01, 0xDC, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x03, 0xC3, 0x80,
  0x70, 0x70, 0x1E, 0x07, 0x03, 0x80, 0xF0, 0xF0, 0x0E, 0x1C, 0x00, 0xE7,
  0x00, 0x1D, 0xE0, 0x01, 0xD8, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0xC3, 0xC3, 0x83, 0x87, 0x87, 0x07, 0x04,
  0x1F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x83, 0xFF, 0xC7, 0xFF, 0xEF,
  0xFF, 0xF7, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xEF, 0xE1, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x01,
  0x00, 0x10, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7B, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x03,
  0xC7, 0x80, 0x3C, 0xF0, 0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00,
  0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x0E, 0xF0, 0x01,
  0xDE, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x1E,
  0x3F, 0xBF, 0xC7, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x80, 0x23, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x0F, 0xF7, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xE0, 0x7C, 0xF0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xE0, 0x07, 0x3C, 0x01, 0xCF, 0x80,
  0x71, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x08, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x03, 0xE3, 0xC0, 0x3C, 0xF0, 0x03,
  0xDC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0x1E, 0x03, 0xC0, 0x20, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xF8,
  0x07, 0x7C, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1D, 0xE0, 0x07, 0x78, 0x01, 0xCF, 0x01, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x07, 0xFD, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE3, 0x01, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xFC, 0x00,
  0x10, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x03,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x40, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0xE0, 0xFB, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0,
  0x10, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x07, 0x87,
  0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xCF, 0x80, 0x7B, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBF, 0x00, 0xF1, 0xF0, 0x1E,
  0x1F, 0x03, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C,
  0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x40, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0C, 0x00, 0x7F, 0x9F,
  0x8F, 0xFF, 0xFC, 0xFB, 0xFB, 0xEE, 0x0F, 0x0E, 0xE0, 0xE0, 0xFE, 0x0F,
  0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0,
  0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x3F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E,
  0x01, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1C, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x03, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x78, 0x01, 0xE7, 0x00, 0x78, 0xF8,
  0x1E, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x0F, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x3C,
  0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x78,
  0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0xF3, 0xE0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3C, 0x20, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0xF1, 0xFF, 0xFC, 0xF8, 0x07, 0x3C, 0x01, 0xDE, 0x00, 0x77, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x07, 0x78, 0x01, 0xDE,
  0x00, 0x73, 0xC0, 0x7C, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0x70, 0x04,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0x00, 0x27, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xD0, 0x01, 0xEF, 0xC3, 0xEF, 0xFF, 0xF3, 0xFF, 0xE0, 0x06, 0x00,
  0x01, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x02, 0x00, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xBC, 0x01, 0xDF, 0x00,
  0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x03,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x01, 0xE0,
  0x70, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x1E, 0x00, 0x79, 0xC0, 0x03,
  0xBC, 0x00, 0x3B, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00,
  0x0E, 0xF0, 0x00, 0x39, 0xC0, 0xC0, 0xE7, 0x07, 0x03, 0x9C, 0x1E, 0x0E,
  0x70, 0x78, 0x71, 0xC3, 0xE1, 0xC7, 0x8F, 0xC7, 0x0E, 0x37, 0x1C, 0x39,
  0xCC, 0x70, 0xE7, 0x39, 0xC3, 0xB8, 0xEE, 0x0E, 0xE1, 0xF8, 0x3B, 0x07,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x70, 0x07, 0x00, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x07, 0x80, 0x78, 0x3C,
  0x07, 0x80, 0xF0, 0x78, 0x03, 0xC3, 0x80, 0x0F, 0x3C, 0x00, 0x7B, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x3C, 0x00, 0xF0, 0xF0, 0x0F, 0x03, 0xC0,
  0xF0, 0x0E, 0x07, 0x00, 0x78, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x38,
  0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x3C, 0x1E, 0x03, 0x81,
  0xE0, 0x38, 0x0E, 0x07, 0x80, 0xF0, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0,
  0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0xDE, 0x00, 0x1D, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00,
  0x04, 0x00, 0x07, 0xF0, 0x0D, 0xFF, 0x81, 0xB8, 0xF8, 0x7E, 0x0F, 0xFD,
  0x80, 0x7F, 0x00, 0x03, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 30, 24, 9, -29 },
  { 24, 10, 11, 24, 7, -32 },
  { 38, 21, 29, 24, 1, -29 },
  { 115, 18, 38, 24, 3, -33 },
  { 201, 22, 31, 24, 1, -30 },
  { 287, 20, 30, 24, 2, -30 },
  { 362, 3, 12, 24, 10, -32 },
  { 367, 12, 41, 24, 6, -33 },
  { 429, 12, 41, 24, 6, -33 },
  { 491, 18, 17, 24, 3, -29 },
  { 530, 19, 21, 24, 2, -23 },
  { 580, 10, 13, 24, 7, -6 },
  { 597, 10, 3, 24, 7, -13 },
  { 601, 6, 7, 24, 9, -6 },
  { 607, 16, 41, 24, 4, -33 },
  { 689, 19, 31, 24, 2, -30 },
  { 763, 16, 29, 24, 4, -29 },
  { 821, 18, 30, 24, 3, -30 },
  { 889, 18, 31, 24, 3, -30 },
  { 959, 20, 29, 24, 2, -29 },
  { 1032, 17, 30, 24, 4, -29 },
  { 1096, 18, 30, 24, 3, -29 },
  { 1164, 18, 29, 24, 3, -29 },
  { 1230, 18, 31, 24, 3, -30 },
  { 1300, 19, 30, 24, 2, -30 },
  { 1372, 6, 23, 24, 9, -22 },
  { 1390, 9, 29, 24, 6, -22 },
  { 1423, 19, 18, 24, 2, -21 },
  { 1466, 19, 12, 24, 2, -18 },
  { 1495, 20, 18, 24, 2, -21 },
  { 1540, 14, 31, 24, 5, -30 },
  { 1595, 20, 36, 24, 2, -30 },
  { 1685, 23, 29, 24, 0, -29 },
  { 1769, 18, 29, 24, 3, -29 },
  { 1835, 20, 31, 24, 2, -30 },
  { 1913, 18, 29, 24, 3, -29 },
  { 1979, 17, 29, 24, 5, -29 },
  { 2041, 16, 29, 24, 5, -29 },
  { 2099, 19, 31, 24, 2, -30 },
  { 2173, 19, 29, 24, 2, -29 },
  { 2242, 14, 29, 24, 5, -29 },
  { 2293, 16, 30, 24, 3, -29 },
  { 2353, 20, 29, 24, 3, -29 },
  { 2426, 17, 29, 24, 5, -29 },
  { 2488, 20, 29, 24, 2, -29 },
  { 2561, 18, 29, 24, 3, -29 },
  { 2627, 21, 31, 24, 1, -30 },
  { 2709, 17, 29, 24, 4, -29 },
  { 2771, 21, 38, 24, 1, -30 },
  { 2871, 18, 29, 24, 3, -29 },
  { 2937, 18, 31, 24, 3, -30 },
  { 3007, 19, 29, 24, 2, -29 },
  { 3076, 19, 30, 24, 2, -29 },
  { 3148, 22, 29, 24, 1, -29 },
  { 3228, 20, 29, 24, 2, -29 },
  { 3301, 21, 29, 24, 1, -29 },
  { 3378, 22, 29, 24, 1, -29 },
  { 3458, 18, 29, 24, 3, -29 },
  { 3524, 11, 41, 24, 7, -33 },
  { 3581, 16, 41, 24, 4, -33 },
  { 3663, 10, 41, 24, 6, -33 },
  { 3715, 19, 15, 24, 2, -29 },
  { 3751, 23, 3, 24, 0, 5 },
  { 3760, 7, 9, 24, 8, -33 },
  { 3768, 17, 23, 24, 3, -22 },
  { 3817, 19, 34, 24, 3, -33 },
  { 3898, 19, 23, 24, 2, -22 },
  { 3953, 18, 34, 24, 2, -33 },
  { 4030, 19, 23, 24, 2, -22 },
  { 4085, 20, 33, 24, 3, -33 },
  { 4168, 18, 30, 24, 2, -22 },
  { 4236, 17, 33, 24, 3, -33 },
  { 4307, 18, 33, 24, 3, -32 },
  { 4382, 14, 40, 24, 4, -32 },
  { 4452, 19, 33, 24, 3, -33 },
  { 4531, 18, 33, 24, 3, -32 },
  { 4606, 20, 22, 24, 2, -22 },
  { 4661, 17, 22, 24, 3, -22 },
  { 4708, 19, 22, 24, 2, -22 },
  { 4761, 19, 30, 24, 3, -22 },
  { 4833, 18, 30, 24, 2, -22 },
  { 4901, 15, 22, 24, 5, -22 },
  { 4943, 17, 23, 24, 3, -22 },
  { 4992, 18, 30, 24, 3, -29 },
  { 5060, 17, 22, 24, 3, -22 },
  { 5107, 20, 22, 24, 2, -22 },
  { 5162, 22, 22, 24, 1, -22 },
  { 5223, 21, 22, 24, 1, -22 },
  { 5281, 20, 30, 24, 2, -22 },
  { 5356, 16, 22, 24, 4, -22 },
  { 5400, 16, 41, 24, 4, -33 },
  { 5482, 3, 41, 24, 10, -33 },
  { 5498, 16, 41, 24, 4, -33 },
  { 5580, 19, 7, 24, 2, -16 },
};

const GFXfont UbuntuSansMono_Regular42pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular42pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular42pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUSANSMONO_REGULAR42PT7B_H_
