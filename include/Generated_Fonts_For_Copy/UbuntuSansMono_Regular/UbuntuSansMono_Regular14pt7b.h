#ifndef _UBUNTUSANSMONO_REGULAR14PT7B_H_
#define _UBUNTUSANSMONO_REGULAR14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA8, 0xF0, 0x99, 0x99, 0x12, 0x24, 0xD7, 0xF2, 0x44, 0xBF,
  0xB4, 0x48, 0x90, 0x20, 0x87, 0xA0, 0x81, 0x83, 0x83, 0x06, 0x37, 0x08,
  0x20, 0x62, 0x92, 0x94, 0x98, 0x68, 0x16, 0x1A, 0x29, 0x49, 0xC6, 0x73,
  0x68, 0xB4, 0x63, 0x99, 0x66, 0x8F, 0xD0, 0xF0, 0x12, 0x44, 0x88, 0x88,
  0x88, 0x46, 0x31, 0x84, 0x62, 0x31, 0x11, 0x13, 0x26, 0xC8, 0x30, 0x8E,
  0xCC, 0x79, 0x20, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0x67, 0x2C, 0xF0,
  0xF0, 0x0C, 0x20, 0x86, 0x10, 0x43, 0x08, 0x21, 0x84, 0x10, 0x42, 0x00,
  0x71, 0x28, 0x61, 0xB6, 0xD8, 0x61, 0xC9, 0xE0, 0x10, 0xCD, 0x04, 0x10,
  0x41, 0x04, 0x11, 0xF0, 0x72, 0x20, 0xC2, 0x08, 0x42, 0x10, 0xC3, 0xF0,
  0x72, 0x20, 0x82, 0x30, 0x20, 0x41, 0x0F, 0xE0, 0x08, 0x62, 0x92, 0x4A,
  0x28, 0x9F, 0x08, 0x20, 0x7D, 0x04, 0x10, 0x70, 0x20, 0x41, 0x0F, 0xE0,
  0x18, 0x84, 0x20, 0xFA, 0x38, 0x61, 0xCD, 0xE0, 0xFC, 0x10, 0x86, 0x10,
  0x42, 0x08, 0x20, 0x80, 0x7B, 0x38, 0x61, 0x69, 0x68, 0x61, 0x85, 0xE0,
  0x73, 0x28, 0x61, 0x85, 0xF0, 0x42, 0x1B, 0x80, 0xF0, 0x3C, 0x6C, 0x00,
  0xD9, 0xC0, 0x04, 0xEC, 0x30, 0x38, 0x10, 0xFC, 0x00, 0x3F, 0x81, 0xC0,
  0xC3, 0x72, 0x00, 0xE1, 0x11, 0x24, 0x40, 0x46, 0x39, 0x18, 0x63, 0xB6,
  0x9A, 0x69, 0x9F, 0x06, 0x0E, 0x18, 0x18, 0x2C, 0x24, 0x24, 0x44, 0x7E,
  0x42, 0x42, 0x83, 0xF2, 0x28, 0xE2, 0xFA, 0x68, 0x61, 0x8F, 0xE0, 0x3D,
  0x1C, 0x20, 0x82, 0x08, 0x20, 0x40, 0xF0, 0xF2, 0x68, 0xE1, 0x86, 0x18,
  0x61, 0x8B, 0xC0, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x87, 0xC0, 0xFC, 0x21,
  0x0F, 0x42, 0x10, 0x84, 0x00, 0x3D, 0x1C, 0x20, 0x82, 0x18, 0x61, 0x44,
  0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xF4, 0x44, 0x44,
  0x44, 0x4F, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x0B, 0xE0, 0x85, 0x12,
  0x65, 0x8E, 0x14, 0x24, 0x44, 0x85, 0x0C, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x87, 0xC0, 0x8F, 0x3C, 0xF5, 0xB6, 0xD8, 0x61, 0x86, 0x10, 0x87, 0x1C,
  0x69, 0xA6, 0x59, 0x63, 0x8E, 0x30, 0x3C, 0xCD, 0x0A, 0x1C, 0x38, 0x50,
  0xA1, 0x46, 0x78, 0xF2, 0x38, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x00, 0x3C,
  0xCD, 0x0A, 0x1C, 0x38, 0x50, 0xA1, 0x46, 0x78, 0x60, 0x60, 0x20, 0xF2,
  0x28, 0x61, 0x8B, 0xC9, 0x22, 0x8A, 0x10, 0x7B, 0x18, 0x30, 0x60, 0x60,
  0xC1, 0x07, 0xE0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x83, 0x42, 0x42, 0x42, 0x44,
  0x24, 0x24, 0x2C, 0x18, 0x18, 0x86, 0x18, 0x61, 0xB6, 0xDD, 0x73, 0xCF,
  0x30, 0x42, 0x8C, 0x91, 0xC1, 0x83, 0x0B, 0x12, 0x47, 0x84, 0xC3, 0x42,
  0x46, 0x24, 0x2C, 0x18, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x10, 0x84, 0x10,
  0x86, 0x10, 0x83, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x81,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x40, 0x82, 0x08, 0x30, 0xE4, 0x92,
  0x49, 0x24, 0x93, 0xC0, 0x30, 0xC4, 0x92, 0x84, 0xFF, 0xA4, 0x78, 0x30,
  0x7F, 0x86, 0x17, 0xC0, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x3F,
  0x80, 0x7F, 0x08, 0x20, 0x83, 0x07, 0xC0, 0x04, 0x10, 0x41, 0x7E, 0x18,
  0x61, 0x87, 0x17, 0xC0, 0x7A, 0x18, 0x7F, 0x83, 0x07, 0xC0, 0x1C, 0x44,
  0x81, 0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x80, 0x7E, 0x18, 0x61, 0x87,
  0x37, 0x43, 0x89, 0xC0, 0x82, 0x08, 0x20, 0xFA, 0x38, 0x61, 0x86, 0x18,
  0x40, 0x21, 0x80, 0x00, 0xE0, 0x82, 0x08, 0x20, 0x81, 0xC0, 0x10, 0xC0,
  0x07, 0x84, 0x21, 0x08, 0x42, 0x19, 0xB0, 0x82, 0x08, 0x20, 0x8E, 0x4A,
  0x38, 0x92, 0x28, 0x40, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81,
  0xC0, 0xFE, 0xDB, 0x6D, 0x86, 0x18, 0x40, 0xFA, 0x38, 0x61, 0x86, 0x18,
  0x40, 0x7A, 0x18, 0x61, 0x86, 0x37, 0x80, 0xFA, 0x18, 0x61, 0x86, 0x3F,
  0xA0, 0x82, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x17, 0xC1, 0x04, 0x10, 0xFC,
  0x21, 0x08, 0x42, 0x00, 0x7A, 0x0C, 0x0E, 0x0C, 0x1F, 0x80, 0x20, 0x82,
  0x3F, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x86, 0x18, 0x61, 0x87, 0x17, 0xC0,
  0x86, 0x1C, 0x92, 0x58, 0xC3, 0x00, 0xC3, 0x52, 0x5A, 0x5A, 0x6A, 0x66,
  0x64, 0x66, 0x48, 0x60, 0xC2, 0xCC, 0xB0, 0x80, 0x87, 0x14, 0x92, 0x68,
  0xC3, 0x04, 0x23, 0x00, 0xFC, 0x61, 0x08, 0x61, 0x0F, 0xC0, 0x1C, 0x82,
  0x08, 0x20, 0x8E, 0x08, 0x20, 0x82, 0x08, 0x20, 0x70, 0xFF, 0xFC, 0xE0,
  0x41, 0x04, 0x10, 0x41, 0xC4, 0x10, 0x41, 0x04, 0x33, 0x00, 0xE6, 0x60,
};

const GFXglyph UbuntuSansMono_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -11 },
  { 6, 7, 10, 8, 0, -10 },
  { 15, 6, 13, 8, 1, -11 },
  { 25, 8, 10, 8, 0, -10 },
  { 35, 6, 10, 8, 1, -10 },
  { 43, 1, 4, 8, 3, -11 },
  { 44, 4, 14, 8, 2, -11 },
  { 51, 4, 14, 8, 2, -11 },
  { 58, 6, 6, 8, 1, -10 },
  { 63, 6, 7, 8, 1, -8 },
  { 69, 4, 4, 8, 2, -2 },
  { 71, 4, 1, 8, 2, -4 },
  { 72, 2, 2, 8, 3, -2 },
  { 73, 6, 14, 8, 1, -11 },
  { 84, 6, 10, 8, 1, -10 },
  { 92, 6, 10, 8, 1, -10 },
  { 100, 6, 10, 8, 1, -10 },
  { 108, 6, 10, 8, 1, -10 },
  { 116, 6, 10, 8, 1, -10 },
  { 124, 6, 10, 8, 1, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 6, 10, 8, 1, -10 },
  { 164, 2, 7, 8, 3, -7 },
  { 166, 3, 9, 8, 2, -7 },
  { 170, 6, 6, 8, 1, -7 },
  { 175, 6, 4, 8, 1, -6 },
  { 178, 6, 6, 8, 1, -7 },
  { 183, 4, 10, 8, 2, -10 },
  { 188, 6, 12, 8, 1, -10 },
  { 197, 8, 10, 8, 0, -10 },
  { 207, 6, 10, 8, 1, -10 },
  { 215, 6, 10, 8, 1, -10 },
  { 223, 6, 10, 8, 1, -10 },
  { 231, 5, 10, 8, 2, -10 },
  { 238, 5, 10, 8, 2, -10 },
  { 245, 6, 10, 8, 1, -10 },
  { 253, 6, 10, 8, 1, -10 },
  { 261, 4, 10, 8, 2, -10 },
  { 266, 6, 10, 8, 1, -10 },
  { 274, 7, 10, 8, 1, -10 },
  { 283, 5, 10, 8, 2, -10 },
  { 290, 6, 10, 8, 1, -10 },
  { 298, 6, 10, 8, 1, -10 },
  { 306, 7, 10, 8, 0, -10 },
  { 315, 6, 10, 8, 1, -10 },
  { 323, 7, 13, 8, 0, -10 },
  { 335, 6, 10, 8, 1, -10 },
  { 343, 6, 10, 8, 1, -10 },
  { 351, 6, 10, 8, 1, -10 },
  { 359, 6, 10, 8, 1, -10 },
  { 367, 8, 10, 8, 0, -10 },
  { 377, 6, 10, 8, 1, -10 },
  { 385, 7, 10, 8, 0, -10 },
  { 394, 8, 10, 8, 0, -10 },
  { 404, 6, 10, 8, 1, -10 },
  { 412, 4, 14, 8, 2, -11 },
  { 419, 6, 14, 8, 1, -11 },
  { 430, 3, 14, 8, 2, -11 },
  { 436, 6, 5, 8, 1, -10 },
  { 440, 8, 1, 8, 0, 2 },
  { 441, 2, 3, 8, 3, -11 },
  { 442, 6, 7, 8, 1, -7 },
  { 448, 6, 11, 8, 1, -11 },
  { 457, 6, 7, 8, 1, -7 },
  { 463, 6, 11, 8, 1, -11 },
  { 472, 6, 7, 8, 1, -7 },
  { 478, 7, 11, 8, 1, -11 },
  { 488, 6, 10, 8, 1, -7 },
  { 496, 6, 11, 8, 1, -11 },
  { 505, 6, 11, 8, 1, -11 },
  { 514, 5, 14, 8, 1, -11 },
  { 523, 6, 11, 8, 1, -11 },
  { 532, 6, 11, 8, 1, -11 },
  { 541, 6, 7, 8, 1, -7 },
  { 547, 6, 7, 8, 1, -7 },
  { 553, 6, 7, 8, 1, -7 },
  { 559, 6, 10, 8, 1, -7 },
  { 567, 6, 10, 8, 1, -7 },
  { 575, 5, 7, 8, 2, -7 },
  { 580, 6, 7, 8, 1, -7 },
  { 586, 6, 10, 8, 1, -10 },
  { 594, 6, 7, 8, 1, -7 },
  { 600, 6, 7, 8, 1, -7 },
  { 606, 8, 7, 8, 0, -7 },
  { 613, 7, 7, 8, 0, -7 },
  { 620, 6, 10, 8, 1, -7 },
  { 628, 6, 7, 8, 1, -7 },
  { 634, 6, 14, 8, 1, -11 },
  { 645, 1, 14, 8, 3, -11 },
  { 647, 6, 14, 8, 1, -11 },
  { 658, 6, 2, 8, 1, -5 },
};

const GFXfont UbuntuSansMono_Regular14pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular14pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular14pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUSANSMONO_REGULAR14PT7B_H_
