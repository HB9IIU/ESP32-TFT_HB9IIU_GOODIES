#ifndef _UBUNTUSANSMONO_REGULAR19PT7B_H_
#define _UBUNTUSANSMONO_REGULAR19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x64, 0x92, 0x40, 0x7C, 0x9C, 0xE7, 0x29, 0x00, 0x11, 0x08,
  0x8C, 0xDF, 0xFF, 0xF9, 0x10, 0x88, 0xCC, 0xFF, 0xA2, 0x11, 0x08, 0x8C,
  0xC0, 0x08, 0x08, 0x0C, 0x7F, 0x40, 0xC0, 0x40, 0x70, 0x1C, 0x07, 0x03,
  0x01, 0x01, 0xFF, 0x38, 0x08, 0x08, 0x70, 0xD2, 0x2C, 0x93, 0x2C, 0x4A,
  0x1D, 0x80, 0x40, 0x2F, 0x1A, 0x44, 0x93, 0x24, 0x89, 0x43, 0xC0, 0x7C,
  0x23, 0x11, 0x88, 0x86, 0xC1, 0xC1, 0xC5, 0xB2, 0xCF, 0x43, 0x20, 0xD9,
  0xE7, 0x98, 0xF8, 0x08, 0xCC, 0xC4, 0x62, 0x10, 0x84, 0x21, 0x0C, 0x61,
  0x8C, 0x30, 0xC2, 0x86, 0x18, 0x43, 0x08, 0x63, 0x08, 0x42, 0x31, 0x88,
  0xCC, 0x66, 0x20, 0x08, 0x08, 0x4B, 0xFF, 0x1C, 0x36, 0x66, 0x24, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x37, 0x31,
  0x7C, 0xF0, 0xDF, 0x80, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x10,
  0x20, 0xC1, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x00, 0x3E, 0x31, 0x90,
  0xD8, 0x2C, 0x16, 0xCF, 0x77, 0x93, 0xC1, 0x60, 0x90, 0xCC, 0x43, 0xE0,
  0x18, 0x73, 0xE4, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xCF, 0xE0,
  0x7E, 0xC3, 0x03, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x40,
  0x7F, 0x7E, 0x43, 0x03, 0x03, 0x02, 0x1C, 0x1E, 0x03, 0x01, 0x01, 0x01,
  0x83, 0xFE, 0x06, 0x07, 0x06, 0x82, 0x42, 0x23, 0x11, 0x09, 0x84, 0xFF,
  0xFF, 0xC0, 0x80, 0x40, 0x20, 0x7E, 0x81, 0x02, 0x04, 0x1F, 0x07, 0x03,
  0x02, 0x04, 0x0C, 0x3F, 0xC0, 0x0F, 0x0C, 0x08, 0x0C, 0x04, 0x07, 0xF3,
  0x8D, 0x82, 0xC1, 0xE0, 0x90, 0x4C, 0x63, 0xE0, 0xFF, 0x80, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x00, 0x3E,
  0x43, 0xC1, 0xC1, 0x43, 0x76, 0x3E, 0x63, 0xC1, 0xC1, 0xC1, 0x43, 0x7E,
  0x7E, 0x43, 0xC1, 0xC1, 0xC1, 0xC1, 0x77, 0x3D, 0x03, 0x03, 0x06, 0x1C,
  0x70, 0xDF, 0x80, 0x06, 0xFC, 0x67, 0x70, 0x00, 0x02, 0x77, 0x36, 0xC0,
  0x00, 0x81, 0xC3, 0x8E, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x80, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x18, 0x38,
  0x71, 0xC0, 0x80, 0x00, 0xFC, 0x08, 0x18, 0x20, 0xC3, 0x04, 0x18, 0x20,
  0x00, 0x01, 0x83, 0x00, 0x3F, 0x30, 0x98, 0x68, 0x3C, 0x7E, 0x6F, 0x67,
  0xB3, 0xD9, 0xEC, 0xF2, 0x68, 0xF6, 0x01, 0x80, 0xE4, 0x1E, 0x0E, 0x03,
  0x81, 0xA0, 0x4C, 0x11, 0x0C, 0x42, 0x18, 0x86, 0x7F, 0x98, 0x24, 0x0D,
  0x01, 0xC0, 0x40, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xFE, 0xFE, 0xC3, 0xC1,
  0xC1, 0xC1, 0xC7, 0xFE, 0x1F, 0x98, 0x58, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x20, 0x18, 0x06, 0x11, 0xF8, 0xFC, 0x63, 0x30, 0xD8, 0x2C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xB0, 0xD8, 0xCF, 0xC0, 0xFE, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0x83, 0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x1F,
  0x98, 0x98, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x83, 0xC1, 0xA0, 0xD8, 0x66,
  0x31, 0xF8, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x8F, 0xE0, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x46, 0xFC, 0xC1, 0xE1, 0xB1, 0x99, 0x8D, 0x87,
  0x83, 0xC1, 0xB0, 0xCC, 0x63, 0x30, 0xD8, 0x3C, 0x18, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x43, 0x31,
  0xB8, 0xDC, 0xAF, 0x54, 0xAE, 0x77, 0x13, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0xC1, 0xE1, 0xE1, 0xF1, 0xD1, 0xD9, 0xC9, 0xCD, 0xC5, 0xC7, 0xC3,
  0xC3, 0xC1, 0x3E, 0x31, 0xB0, 0x50, 0x38, 0x1C, 0x06, 0x03, 0x03, 0x81,
  0xE0, 0xF0, 0x4C, 0x63, 0xE0, 0xFC, 0x86, 0x82, 0x83, 0x83, 0x82, 0x8E,
  0xF8, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x31, 0xB0, 0x50, 0x38, 0x1C,
  0x06, 0x03, 0x03, 0x81, 0xE0, 0xF0, 0x4C, 0x63, 0xE0, 0xC0, 0x30, 0x0E,
  0xFE, 0x61, 0xB0, 0xD8, 0x2C, 0x36, 0x1B, 0xF9, 0xF8, 0xC4, 0x63, 0x30,
  0x98, 0x6C, 0x18, 0x3F, 0x61, 0x40, 0x40, 0x60, 0x30, 0x1C, 0x07, 0x01,
  0x01, 0x01, 0x43, 0xFE, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x4C, 0x63, 0xE0, 0xC0, 0x50,
  0x36, 0x0D, 0x82, 0x20, 0x88, 0x63, 0x18, 0xC4, 0x13, 0x06, 0xC1, 0xA0,
  0x38, 0x0C, 0x00, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xCE, 0x77, 0x2A,
  0xF5, 0x73, 0xB8, 0xCC, 0x64, 0x30, 0xC1, 0xA1, 0x98, 0x84, 0xC3, 0x40,
  0xE0, 0x70, 0x68, 0x26, 0x31, 0x10, 0xD8, 0x28, 0x18, 0xC0, 0xD8, 0x36,
  0x08, 0xC6, 0x31, 0x06, 0xC0, 0xA0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x7F, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30,
  0x30, 0x18, 0x18, 0x0F, 0xF8, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC7, 0xFE, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x08, 0x10,
  0x30, 0x20, 0x40, 0xC0, 0x81, 0x03, 0x02, 0x04, 0x0C, 0x18, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0, 0x18, 0x0E, 0x0D, 0x04,
  0x44, 0x36, 0x0A, 0x06, 0xFF, 0xFF, 0xF0, 0x91, 0x10, 0x7E, 0x43, 0x03,
  0x01, 0x3F, 0x63, 0xC1, 0xC1, 0x61, 0x7F, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFC, 0xCE, 0x82, 0x83, 0x83, 0x83, 0x83, 0x82, 0x8E, 0xFC, 0x1F, 0x38,
  0x90, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x70, 0x9F, 0xC0, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x3F, 0x63, 0xC1, 0xC1, 0xC1, 0x81, 0xC1, 0xC1, 0x61,
  0x3F, 0x3E, 0x31, 0xB0, 0x58, 0x3F, 0xFC, 0x03, 0x01, 0x80, 0x61, 0x1F,
  0x80, 0x0E, 0x3F, 0x20, 0x20, 0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x3F, 0x63, 0xC1, 0xC1, 0x81, 0x81, 0xC1, 0xC1,
  0x7F, 0x1D, 0x03, 0x03, 0x7E, 0x38, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xB3,
  0xC3, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x80, 0x38, 0x38, 0x00, 0x00,
  0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x19, 0x0F, 0x1C, 0x70,
  0x00, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0xF9, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x83, 0x84, 0x98, 0xB0, 0xE0, 0xF0, 0x98,
  0x8C, 0x86, 0x83, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x19, 0x0F, 0xF7, 0x4C, 0xE2, 0x71, 0x38, 0x9C,
  0x4E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xFD, 0x1E, 0x1C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x04, 0x3C, 0x33, 0xB0, 0x58, 0x38, 0x1C, 0x0F, 0x07, 0x82,
  0x63, 0x1F, 0x00, 0xF8, 0x8E, 0x86, 0x83, 0x83, 0x83, 0x83, 0x82, 0xC6,
  0xFC, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x63, 0xC1, 0xC1, 0x81, 0x81, 0xC1,
  0xC1, 0x63, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x7F, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x80, 0x3F, 0x61, 0x40, 0x60, 0x38, 0x0E, 0x03, 0x01,
  0x43, 0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x93, 0xE0, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x41, 0x61, 0x3F,
  0x81, 0xE0, 0xF0, 0x48, 0x66, 0x21, 0x30, 0xD8, 0x68, 0x1C, 0x0C, 0x00,
  0xC0, 0x50, 0x14, 0x05, 0x13, 0x4E, 0xDA, 0xA7, 0xA8, 0xCE, 0x31, 0x88,
  0x60, 0xC1, 0xB1, 0x89, 0x86, 0x81, 0x80, 0xE0, 0xD8, 0xC4, 0x43, 0x60,
  0xC0, 0xC1, 0xE0, 0x90, 0x4C, 0x62, 0x31, 0x10, 0xD8, 0x2C, 0x1C, 0x06,
  0x02, 0x03, 0x0F, 0x02, 0x00, 0xFE, 0x0C, 0x30, 0xC1, 0x06, 0x18, 0x60,
  0xC1, 0xFC, 0x1E, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x61, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x30, 0x3C, 0x18, 0xFF, 0xFF, 0xE0, 0xE0, 0x60,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x1C, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x11, 0xE3, 0x00, 0x70, 0xCE, 0xA1, 0x80,
};

const GFXglyph UbuntuSansMono_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -14 },
  { 10, 9, 13, 11, 1, -13 },
  { 25, 8, 17, 11, 1, -15 },
  { 42, 10, 13, 11, 0, -13 },
  { 59, 9, 13, 11, 1, -13 },
  { 74, 1, 5, 11, 5, -14 },
  { 75, 5, 19, 11, 3, -15 },
  { 87, 5, 19, 11, 3, -15 },
  { 99, 8, 8, 11, 1, -13 },
  { 107, 9, 9, 11, 1, -10 },
  { 118, 4, 6, 11, 3, -3 },
  { 121, 4, 1, 11, 3, -6 },
  { 122, 3, 3, 11, 4, -3 },
  { 124, 7, 19, 11, 2, -15 },
  { 141, 9, 13, 11, 1, -13 },
  { 156, 7, 13, 11, 2, -13 },
  { 168, 8, 13, 11, 1, -13 },
  { 181, 8, 13, 11, 1, -13 },
  { 194, 9, 13, 11, 1, -13 },
  { 209, 7, 13, 11, 2, -13 },
  { 221, 9, 13, 11, 1, -13 },
  { 236, 9, 13, 11, 1, -13 },
  { 251, 8, 13, 11, 1, -13 },
  { 264, 8, 13, 11, 1, -13 },
  { 277, 3, 10, 11, 4, -10 },
  { 281, 4, 13, 11, 3, -10 },
  { 288, 9, 9, 11, 1, -10 },
  { 299, 9, 5, 11, 1, -8 },
  { 305, 9, 9, 11, 1, -10 },
  { 316, 7, 13, 11, 2, -13 },
  { 328, 9, 16, 11, 1, -13 },
  { 346, 10, 13, 11, 0, -13 },
  { 363, 8, 13, 11, 1, -13 },
  { 376, 9, 13, 11, 1, -13 },
  { 391, 9, 13, 11, 1, -13 },
  { 406, 8, 13, 11, 2, -13 },
  { 419, 7, 13, 11, 2, -13 },
  { 431, 9, 13, 11, 1, -13 },
  { 446, 9, 13, 11, 1, -13 },
  { 461, 7, 13, 11, 2, -13 },
  { 473, 8, 13, 11, 1, -13 },
  { 486, 9, 13, 11, 1, -13 },
  { 501, 8, 13, 11, 2, -13 },
  { 514, 9, 13, 11, 1, -13 },
  { 529, 8, 13, 11, 1, -13 },
  { 542, 9, 13, 11, 1, -13 },
  { 557, 8, 13, 11, 2, -13 },
  { 570, 9, 16, 11, 1, -13 },
  { 588, 9, 13, 11, 1, -13 },
  { 603, 8, 13, 11, 1, -13 },
  { 616, 9, 13, 11, 1, -13 },
  { 631, 9, 13, 11, 1, -13 },
  { 646, 10, 13, 11, 0, -13 },
  { 663, 9, 13, 11, 1, -13 },
  { 678, 9, 13, 11, 1, -13 },
  { 693, 10, 13, 11, 0, -13 },
  { 710, 9, 13, 11, 1, -13 },
  { 725, 5, 19, 11, 3, -15 },
  { 737, 7, 19, 11, 2, -15 },
  { 754, 4, 19, 11, 3, -15 },
  { 764, 9, 7, 11, 1, -13 },
  { 772, 10, 2, 11, 0, 2 },
  { 775, 3, 4, 11, 4, -15 },
  { 777, 8, 10, 11, 1, -10 },
  { 787, 8, 15, 11, 2, -15 },
  { 802, 9, 10, 11, 1, -10 },
  { 814, 8, 15, 11, 1, -15 },
  { 829, 9, 10, 11, 1, -10 },
  { 841, 8, 15, 11, 2, -15 },
  { 856, 8, 14, 11, 1, -10 },
  { 870, 7, 15, 11, 2, -15 },
  { 884, 8, 14, 11, 1, -14 },
  { 898, 6, 18, 11, 2, -14 },
  { 912, 8, 15, 11, 2, -15 },
  { 927, 8, 15, 11, 1, -15 },
  { 942, 9, 10, 11, 1, -10 },
  { 954, 7, 10, 11, 2, -10 },
  { 963, 9, 10, 11, 1, -10 },
  { 975, 8, 14, 11, 2, -10 },
  { 989, 8, 14, 11, 1, -10 },
  { 1003, 7, 10, 11, 2, -10 },
  { 1012, 8, 10, 11, 1, -10 },
  { 1022, 7, 13, 11, 2, -13 },
  { 1034, 8, 10, 11, 1, -10 },
  { 1044, 9, 10, 11, 1, -10 },
  { 1056, 10, 10, 11, 0, -10 },
  { 1069, 9, 10, 11, 1, -10 },
  { 1081, 9, 14, 11, 1, -10 },
  { 1097, 7, 10, 11, 2, -10 },
  { 1106, 7, 19, 11, 2, -15 },
  { 1123, 1, 19, 11, 5, -15 },
  { 1126, 7, 19, 11, 2, -15 },
  { 1143, 9, 3, 11, 1, -7 },
};

const GFXfont UbuntuSansMono_Regular19pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular19pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular19pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUSANSMONO_REGULAR19PT7B_H_
