#ifndef _UBUNTUSANSMONO_REGULAR32PT7B_H_
#define _UBUNTUSANSMONO_REGULAR32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0xEF, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x07, 0x0E, 0x07, 0x0C,
  0x06, 0x0C, 0x06, 0x0C, 0x06, 0x1C, 0x0E, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0C, 0x18, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x18, 0x30, 0x18, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x60, 0x38, 0x60, 0x30, 0x60, 0x30, 0xE0,
  0x30, 0xE0, 0x70, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F,
  0xF8, 0xFF, 0xC7, 0x81, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1D, 0x00, 0xEF, 0xFF, 0x1F, 0xF8, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x7C, 0x07, 0xE6, 0x0E, 0xC6,
  0x0C, 0xC6, 0x1C, 0xC6, 0x18, 0xC6, 0x30, 0xC6, 0x70, 0xC6, 0x60, 0xEE,
  0xE0, 0x7C, 0xC0, 0x01, 0x80, 0x03, 0x88, 0x03, 0x3E, 0x07, 0x67, 0x06,
  0x63, 0x0C, 0x63, 0x1C, 0xC3, 0x18, 0x43, 0x38, 0x63, 0x30, 0x63, 0x60,
  0x66, 0xE0, 0x3E, 0x03, 0x00, 0x0F, 0xE0, 0x1D, 0xE0, 0x38, 0x70, 0x30,
  0x70, 0x30, 0x70, 0x30, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x1D, 0xC0, 0x0F,
  0x80, 0x1E, 0x0C, 0x3F, 0x0C, 0x33, 0x8C, 0x71, 0xCC, 0x60, 0xEC, 0xE0,
  0x78, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x7C, 0x70, 0xFC, 0x3F, 0xEE, 0x1F,
  0x87, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x03,
  0x80, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0xC0, 0xE0, 0x10, 0x40, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x04, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x10, 0xC2, 0x73, 0x3B, 0xFF, 0xF1, 0xFE, 0x01, 0xE0,
  0x0F, 0xC0, 0x73, 0x83, 0xCF, 0x0E, 0x1C, 0x08, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x18, 0x78, 0xF9, 0xF3, 0xC1, 0x87, 0x3C, 0xF1, 0x80, 0xFF, 0xFF, 0x33,
  0xFE, 0xF7, 0x80, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x0E, 0x1C, 0x70, 0x39, 0x80,
  0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x8C, 0x7E, 0x79, 0xF9, 0xE7, 0xE7,
  0x9F, 0x8C, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x66, 0x03, 0x9C,
  0x0E, 0x38, 0x70, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0x00, 0x70, 0x0F, 0x03,
  0xF0, 0xF3, 0x0C, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x7F, 0xF7, 0xFF, 0x0F, 0x00, 0xFF, 0x8F, 0xFF, 0x18, 0x1C, 0x40,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0x00, 0xFF,
  0x87, 0xFF, 0x08, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x40, 0x7B, 0xFF, 0xC7,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xD8, 0x03, 0x98,
  0x03, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x38, 0x18,
  0x30, 0x18, 0x70, 0x18, 0x60, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x3F, 0xF1,
  0xFF, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xFC, 0x1F, 0xF8, 0x03, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1D, 0x01, 0xEF, 0xFE, 0x7F, 0xE0, 0x00, 0xF8,
  0x1F, 0xE0, 0xF0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x01, 0x8E, 0x0E, 0x3F, 0xF0, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0x03, 0x80, 0x7F, 0x83, 0xCF, 0x1C, 0x0E, 0x60,
  0x1B, 0x80, 0x6E, 0x01, 0x98, 0x06, 0x70, 0x39, 0xE0, 0xC3, 0xCF, 0x07,
  0xF0, 0x3F, 0xF1, 0xC1, 0xE6, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x07, 0x70, 0x39, 0xFF, 0xE1, 0xFE, 0x00, 0x07, 0x00, 0x7F,
  0x83, 0xDF, 0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x0F, 0x3F, 0xFC, 0x7F, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x78, 0x07, 0xC1, 0xFC, 0x07,
  0xC0, 0x00, 0x33, 0xFE, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x03, 0x3F, 0xEF,
  0x78, 0x18, 0x79, 0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x87, 0x8F, 0x1F, 0x3C, 0x38, 0x73, 0xCF, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF0,
  0x02, 0x00, 0x00, 0x1E, 0x3F, 0xEF, 0x7C, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0xE0,
  0x7F, 0xE1, 0xC0, 0xE3, 0x00, 0xCE, 0x01, 0x98, 0x03, 0xF0, 0x07, 0xE0,
  0xFF, 0xC3, 0xFF, 0x8E, 0x3F, 0x38, 0x7E, 0x70, 0xF8, 0xC1, 0xF1, 0x83,
  0xF3, 0x07, 0xE7, 0x0F, 0xCE, 0x1F, 0x8E, 0x3F, 0x1F, 0xF7, 0x1F, 0xEE,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x30, 0x1F, 0xE0, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x01, 0xCE, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0E, 0x1C, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x70, 0x38, 0x18, 0x0E, 0x06, 0x01, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x30, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x39, 0x80, 0x0E, 0x60, 0x01,
  0xB8, 0x00, 0x70, 0xFF, 0xC3, 0xFF, 0xCC, 0x07, 0x30, 0x0E, 0xC0, 0x3B,
  0x00, 0xEC, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0xFF, 0x8F, 0xFE, 0x30, 0xFC,
  0xC0, 0x3B, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xB0, 0x1E, 0xFF, 0xF3, 0xFF, 0x00, 0x00, 0xE0, 0x1F, 0xF1, 0xFF, 0xCF,
  0x01, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x04, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0x8C, 0x0F, 0x30, 0x1C, 0xC0, 0x3B, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1B, 0x00, 0xEC, 0x07, 0x30, 0x3C, 0xFF, 0xC3,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x1F, 0xF1,
  0xFF, 0xCF, 0x02, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0D, 0xC0, 0x37, 0x00, 0xCE, 0x03, 0x3C, 0x0C, 0x7F, 0xF0, 0x7F,
  0xC0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x80, 0xEF, 0xFE, 0x3F, 0xE0, 0xC0, 0x3D, 0x80, 0x73,
  0x01, 0xC6, 0x07, 0x0C, 0x1C, 0x18, 0x70, 0x31, 0xC0, 0x67, 0x80, 0xDE,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0C, 0xF0, 0x18, 0xF0, 0x30, 0xF0,
  0x60, 0xE0, 0xC0, 0xE1, 0x80, 0xE3, 0x00, 0xE6, 0x01, 0xCC, 0x01, 0xD8,
  0x03, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x36, 0x6C, 0x36,
  0x6C, 0x36, 0x6E, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x63, 0xC6,
  0x63, 0xC6, 0x61, 0xC6, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xD8, 0x0F, 0x70, 0x3C, 0xC0, 0xF3, 0x83,
  0xC6, 0x0F, 0x1C, 0x3C, 0x30, 0xF0, 0xE3, 0xC1, 0x8F, 0x07, 0x3C, 0x0C,
  0xF0, 0x3B, 0xC0, 0x6F, 0x01, 0xBC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x70, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0C, 0x70,
  0x0E, 0x60, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60,
  0x06, 0x70, 0x0E, 0x30, 0x1C, 0x38, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF,
  0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1D, 0xFF, 0xCF, 0xFC, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0C, 0x70, 0x0E, 0x60,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x06, 0x70,
  0x0E, 0x70, 0x0C, 0x38, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x04, 0xFF, 0xC3, 0xFF,
  0x8E, 0x07, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0xE0,
  0x3B, 0x80, 0xEE, 0x0F, 0x3F, 0xF8, 0xFF, 0x83, 0x87, 0x0E, 0x0C, 0x38,
  0x38, 0xE0, 0x63, 0x81, 0xCE, 0x03, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x70,
  0x07, 0x80, 0x7F, 0xE3, 0xFF, 0x9C, 0x04, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x40,
  0x3B, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0x9C, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0xE0,
  0x01, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x30, 0x03, 0x0E, 0x00,
  0xC3, 0x80, 0x70, 0x60, 0x18, 0x18, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x30, 0x30, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x61, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x61, 0x86, 0x63, 0x86, 0x63, 0xC6, 0x63,
  0xC6, 0x66, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x6C, 0x76, 0x6C, 0x36, 0x6C,
  0x34, 0x78, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0xF0, 0x0F, 0x70,
  0x0E, 0x38, 0x1C, 0x38, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E,
  0x70, 0x0C, 0x70, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x30, 0x1C, 0x70,
  0x0E, 0x60, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xDC, 0x00, 0xE3, 0x00, 0x30,
  0xE0, 0x1C, 0x38, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x38, 0x70, 0x06,
  0x18, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x07, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0x30, 0x1C, 0xE0,
  0x61, 0x83, 0x87, 0x1C, 0x0C, 0x60, 0x3B, 0x80, 0x7C, 0x00, 0xD0, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x47, 0x18, 0x63, 0x8C, 0x1F, 0xC1, 0xFF,
  0x8C, 0x1E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x61, 0xFF, 0x3F, 0xFB,
  0xC1, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0D, 0xC0, 0x6F, 0xFF, 0x1F,
  0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xCF, 0x87, 0xFE, 0x3E, 0x79, 0x80, 0xEC, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x3B, 0x03, 0xDF, 0xFC, 0xFF, 0x80, 0x03, 0xF8, 0x7F, 0xF3, 0xE1, 0x9E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x47, 0xFF, 0x0F, 0xFC,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x0F, 0xD8, 0xFF, 0xCF, 0x3E, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xB8, 0x0D,
  0xE0, 0x67, 0xFF, 0x0F, 0xF8, 0x07, 0xC0, 0x7F, 0xC3, 0xC7, 0x9C, 0x0E,
  0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x8F, 0xFE, 0x0F, 0xF8, 0x01,
  0xF0, 0x1F, 0xF0, 0xF9, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xE3,
  0xCE, 0x03, 0x70, 0x0D, 0xC0, 0x36, 0x00, 0xD8, 0x03, 0xE0, 0x0D, 0x80,
  0x36, 0x00, 0xDC, 0x03, 0x70, 0x0C, 0xE0, 0x71, 0xFF, 0xC3, 0xFF, 0x01,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x30, 0x78, 0xFF, 0xC3, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xDF, 0x8F, 0xFC, 0xF1, 0xEC, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x30, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x10, 0x3F, 0xC0, 0x7F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x61, 0xEF, 0xF8,
  0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3B, 0x01, 0xCC, 0x0E, 0x30, 0x70, 0xC3,
  0x83, 0x1C, 0x0D, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0x78, 0x0C, 0xF0, 0x30,
  0xE0, 0xC1, 0xC3, 0x03, 0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x1C, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x40, 0xFF, 0x01, 0xFC, 0xFC, 0xF1, 0xFF, 0xF3, 0x1E, 0x76,
  0x18, 0x6C, 0x30, 0xF8, 0x61, 0xF0, 0xC3, 0xE1, 0x87, 0xC3, 0x0F, 0x86,
  0x1F, 0x0C, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0E, 0x7F, 0x8F, 0xFC, 0xE3, 0xEC, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x30, 0x0F, 0x80, 0x7F, 0x83, 0xCF, 0x1C, 0x0E, 0xE0,
  0x1F, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0xE0, 0x1D, 0xC0, 0xE7, 0x87, 0x8F, 0xFC, 0x0F, 0xC0, 0x7F, 0x07,
  0xFE, 0x38, 0xF9, 0x80, 0xEC, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3B, 0xC3, 0xDF, 0xFC,
  0xFF, 0xC6, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x07, 0xE0, 0xFF, 0xCF, 0x8E, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xB8, 0x0D, 0xE1,
  0xE7, 0xFF, 0x1F, 0xD8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x9E, 0x0C, 0xE0, 0x06, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x70, 0x01, 0x80,
  0x0D, 0x00, 0xEF, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x10, 0xFF, 0x83, 0xFC, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3E, 0x03, 0x70, 0x37, 0xFF, 0x3F, 0xF0, 0xE0, 0x07, 0x60, 0x06,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x18,
  0x1C, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0xE1, 0x87, 0xE1, 0x87, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6,
  0x66, 0x66, 0x76, 0x6E, 0x76, 0x6E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x3C,
  0x38, 0x1C, 0x38, 0x1C, 0x60, 0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x1C, 0x38,
  0x0E, 0x70, 0x0E, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x0E,
  0xE0, 0x07, 0x70, 0x06, 0xE0, 0x1D, 0xC0, 0x39, 0xC0, 0x73, 0x80, 0xC7,
  0x03, 0x86, 0x07, 0x0E, 0x0C, 0x0C, 0x18, 0x1C, 0x70, 0x38, 0xE0, 0x31,
  0x80, 0x77, 0x00, 0x6C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xF8, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x0F, 0xE0, 0xF8, 0x00, 0x1C, 0x04, 0x7E, 0x0D, 0xCF, 0x1B,
  0x0F, 0xEC, 0x07, 0x80,
};

const GFXglyph UbuntuSansMono_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 22, 18, 7, -22 },
  { 12, 8, 8, 18, 5, -24 },
  { 20, 16, 22, 18, 1, -22 },
  { 64, 14, 28, 18, 2, -25 },
  { 113, 16, 23, 18, 1, -23 },
  { 159, 16, 23, 18, 1, -23 },
  { 205, 2, 9, 18, 8, -24 },
  { 208, 10, 31, 18, 4, -25 },
  { 247, 10, 31, 18, 4, -25 },
  { 286, 14, 13, 18, 2, -22 },
  { 309, 14, 15, 18, 2, -17 },
  { 336, 7, 10, 18, 6, -5 },
  { 345, 8, 2, 18, 5, -10 },
  { 347, 5, 5, 18, 6, -5 },
  { 351, 12, 31, 18, 3, -25 },
  { 398, 14, 23, 18, 2, -23 },
  { 439, 12, 22, 18, 3, -22 },
  { 472, 14, 23, 18, 2, -23 },
  { 513, 14, 23, 18, 2, -23 },
  { 554, 16, 22, 18, 1, -22 },
  { 598, 13, 22, 18, 3, -22 },
  { 634, 14, 22, 18, 2, -22 },
  { 673, 14, 22, 18, 2, -22 },
  { 712, 14, 23, 18, 2, -23 },
  { 753, 14, 23, 18, 2, -23 },
  { 794, 5, 17, 18, 6, -17 },
  { 805, 7, 22, 18, 5, -17 },
  { 825, 14, 14, 18, 2, -16 },
  { 850, 14, 9, 18, 2, -14 },
  { 866, 14, 14, 18, 2, -16 },
  { 891, 10, 23, 18, 4, -23 },
  { 920, 15, 28, 18, 2, -23 },
  { 973, 18, 22, 18, 0, -22 },
  { 1023, 14, 22, 18, 2, -22 },
  { 1062, 14, 23, 18, 2, -23 },
  { 1103, 14, 22, 18, 2, -22 },
  { 1142, 12, 22, 18, 4, -22 },
  { 1175, 12, 22, 18, 4, -22 },
  { 1208, 14, 23, 18, 2, -23 },
  { 1249, 14, 22, 18, 2, -22 },
  { 1288, 10, 22, 18, 4, -22 },
  { 1316, 13, 22, 18, 2, -22 },
  { 1352, 15, 22, 18, 3, -22 },
  { 1394, 13, 22, 18, 3, -22 },
  { 1430, 16, 22, 18, 1, -22 },
  { 1474, 14, 22, 18, 2, -22 },
  { 1513, 16, 23, 18, 1, -23 },
  { 1559, 13, 22, 18, 3, -22 },
  { 1595, 16, 29, 18, 1, -23 },
  { 1653, 14, 22, 18, 2, -22 },
  { 1692, 14, 23, 18, 2, -23 },
  { 1733, 14, 22, 18, 2, -22 },
  { 1772, 14, 22, 18, 2, -22 },
  { 1811, 18, 22, 18, 0, -22 },
  { 1861, 16, 22, 18, 1, -22 },
  { 1905, 16, 22, 18, 1, -22 },
  { 1949, 18, 22, 18, 0, -22 },
  { 1999, 14, 22, 18, 2, -22 },
  { 2038, 9, 31, 18, 5, -25 },
  { 2073, 12, 31, 18, 3, -25 },
  { 2120, 8, 31, 18, 4, -25 },
  { 2151, 14, 12, 18, 2, -22 },
  { 2172, 18, 2, 18, 0, 4 },
  { 2177, 5, 6, 18, 6, -25 },
  { 2181, 13, 17, 18, 2, -17 },
  { 2209, 13, 25, 18, 3, -25 },
  { 2250, 14, 17, 18, 2, -17 },
  { 2280, 13, 25, 18, 2, -25 },
  { 2321, 14, 17, 18, 2, -17 },
  { 2351, 14, 25, 18, 3, -25 },
  { 2395, 14, 23, 18, 1, -17 },
  { 2436, 12, 25, 18, 3, -25 },
  { 2474, 14, 24, 18, 2, -24 },
  { 2516, 11, 30, 18, 3, -24 },
  { 2558, 14, 25, 18, 3, -25 },
  { 2602, 14, 25, 18, 2, -25 },
  { 2646, 15, 17, 18, 2, -17 },
  { 2678, 12, 17, 18, 3, -17 },
  { 2704, 14, 17, 18, 2, -17 },
  { 2734, 13, 23, 18, 3, -17 },
  { 2772, 13, 23, 18, 2, -17 },
  { 2810, 11, 17, 18, 4, -17 },
  { 2834, 13, 17, 18, 2, -17 },
  { 2862, 13, 22, 18, 3, -22 },
  { 2898, 12, 17, 18, 3, -17 },
  { 2924, 16, 17, 18, 1, -17 },
  { 2958, 16, 17, 18, 1, -17 },
  { 2992, 16, 17, 18, 1, -17 },
  { 3026, 15, 23, 18, 1, -17 },
  { 3070, 12, 17, 18, 3, -17 },
  { 3096, 12, 31, 18, 3, -25 },
  { 3143, 2, 31, 18, 8, -25 },
  { 3151, 12, 31, 18, 3, -25 },
  { 3198, 15, 5, 18, 1, -12 },
};

const GFXfont UbuntuSansMono_Regular32pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular32pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUSANSMONO_REGULAR32PT7B_H_
