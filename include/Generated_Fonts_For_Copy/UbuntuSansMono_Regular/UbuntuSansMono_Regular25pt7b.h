#ifndef _UBUNTUSANSMONO_REGULAR25PT7B_H_
#define _UBUNTUSANSMONO_REGULAR25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0xEF, 0xE0, 0xCF, 0x3C,
  0xF3, 0xCE, 0x18, 0x40, 0x0C, 0x60, 0xC6, 0x08, 0x61, 0x86, 0xFF, 0xFF,
  0xFF, 0x18, 0xC1, 0x0C, 0x30, 0xC3, 0x18, 0x31, 0x8F, 0xFF, 0x31, 0x86,
  0x18, 0x63, 0x06, 0x30, 0x63, 0x00, 0x0C, 0x03, 0x00, 0xE0, 0xFE, 0x60,
  0xB0, 0x0C, 0x03, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0xC1, 0xFF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x20, 0x0F,
  0x83, 0xC8, 0x68, 0xC4, 0x8C, 0xC8, 0xD8, 0x89, 0x8D, 0xB0, 0x72, 0x00,
  0x60, 0x0D, 0xE0, 0xDB, 0x19, 0x11, 0x31, 0x33, 0x16, 0x11, 0x61, 0x3C,
  0x1E, 0x0C, 0x03, 0xF0, 0x31, 0x86, 0x18, 0x61, 0x86, 0x18, 0x33, 0x03,
  0x60, 0x1C, 0x03, 0xC6, 0x6E, 0x6E, 0x76, 0xC3, 0xCC, 0x1C, 0xC0, 0xCE,
  0x1E, 0x7F, 0x63, 0xE3, 0xFF, 0xFC, 0x02, 0x06, 0x0E, 0x1C, 0x18, 0x30,
  0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x02, 0x40, 0xE0, 0x70, 0x38, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x18, 0x38, 0x70, 0xE0, 0x40, 0x0C, 0x03, 0x08, 0xC7,
  0xB7, 0xFF, 0xC3, 0x01, 0xE0, 0xCC, 0x73, 0x88, 0x40, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x18, 0xF3, 0xCF, 0x18, 0x6F, 0x10, 0xFF, 0xF0, 0x6F,
  0xFF, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xF8,
  0x39, 0xC7, 0x0E, 0x60, 0x66, 0x06, 0x60, 0x6E, 0x67, 0xEF, 0x7E, 0xF7,
  0xE6, 0x7E, 0x06, 0x60, 0x66, 0x06, 0x60, 0x63, 0x0C, 0x39, 0xC1, 0xF8,
  0x06, 0x03, 0x83, 0xE3, 0x98, 0x46, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x61, 0xFF, 0x7F, 0xC0, 0x1C, 0x1F,
  0xCC, 0x3A, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x06, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x3F, 0xC4,
  0x38, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x1E, 0x07, 0xE0, 0x1C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0xEF, 0xBF, 0xC0, 0x01, 0xC0, 0x3C, 0x06,
  0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x10, 0xC3, 0x0C, 0x60, 0xC6, 0x0C, 0xC0,
  0xCF, 0xFF, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3F, 0xC8,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFC, 0x07, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xDE, 0xFF, 0x00, 0x07, 0x83, 0xC0, 0xE0,
  0x30, 0x06, 0x01, 0x80, 0x31, 0x07, 0xFC, 0xE1, 0xD8, 0x1B, 0x03, 0x60,
  0x7C, 0x0D, 0x81, 0xB8, 0x33, 0x9C, 0x3F, 0x00, 0xFF, 0xE0, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x1F, 0xE6, 0x1B,
  0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x86, 0x7B, 0x0F, 0xC6, 0x3F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xF3, 0xDF, 0xE0, 0x0E, 0x07, 0xF1, 0xC3, 0x30,
  0x36, 0x07, 0xC0, 0xF8, 0x1B, 0x03, 0x60, 0x67, 0xFC, 0x7F, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x7F, 0x0F, 0x00, 0x6F, 0xFF, 0x00, 0x00,
  0x06, 0xFF, 0xF0, 0x33, 0xDE, 0xF0, 0x00, 0x00, 0x01, 0x9E, 0xF7, 0x8C,
  0xDC, 0xC0, 0x00, 0x10, 0x07, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x40, 0x0E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x00, 0xF0, 0x3C, 0x1F, 0x0F, 0x80, 0x60, 0x00, 0x3C,
  0xFE, 0x87, 0x03, 0x03, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x38, 0x38, 0x07, 0x01, 0xFC, 0x38, 0x63, 0x03, 0x70,
  0x36, 0x03, 0x61, 0xF6, 0x3F, 0xE6, 0x3E, 0x63, 0xEC, 0x3E, 0xC3, 0xEC,
  0x3E, 0x63, 0x66, 0x36, 0x3F, 0x71, 0xE3, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x30, 0x0C, 0xC0, 0x23,
  0x01, 0x86, 0x06, 0x18, 0x10, 0x60, 0xC0, 0xC3, 0x03, 0x0F, 0xFC, 0x60,
  0x11, 0x80, 0x66, 0x01, 0x98, 0x06, 0xC0, 0x0C, 0x08, 0x1F, 0xF3, 0x07,
  0x60, 0x6C, 0x07, 0x80, 0xF0, 0x36, 0x0E, 0xFF, 0x9F, 0xFB, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xDF, 0xF0, 0x03, 0x80, 0xFF,
  0x1C, 0x23, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1E, 0xF0, 0xFE,
  0x10, 0x0F, 0xF0, 0xC3, 0x8C, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x7C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x0C,
  0xFF, 0x8F, 0xE0, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFC, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0xFF, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x03, 0xC0, 0xFF,
  0x1C, 0x23, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x36, 0x03, 0x60, 0x36, 0x03, 0x70, 0x33, 0x83, 0x1E, 0x70, 0xFF,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x30, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3F, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x68, 0x1B, 0x9E, 0xFF, 0x00, 0xC0, 0xEC, 0x1C, 0xC1, 0x8C, 0x30, 0xC6,
  0x0C, 0xC0, 0xD8, 0x0F, 0x80, 0xF8, 0x0D, 0xC0, 0xCE, 0x0C, 0x70, 0xC3,
  0x8C, 0x1C, 0xC0, 0xCC, 0x06, 0xC0, 0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x67, 0x0E, 0x70, 0xE5, 0x0A, 0x59,
  0xA5, 0x9A, 0x49, 0x2C, 0xF3, 0xC7, 0x3C, 0x63, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xC0, 0x78, 0x1E, 0x06, 0xC1,
  0xB0, 0x66, 0x19, 0x86, 0x31, 0x8C, 0x61, 0x98, 0x66, 0x0D, 0x83, 0x60,
  0x58, 0x1E, 0x03, 0x80, 0xC0, 0x0F, 0x03, 0xFC, 0x70, 0xC6, 0x06, 0xE0,
  0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x60, 0x66, 0x06, 0x39, 0xC1, 0xF8, 0x08, 0x1F, 0xF3, 0x07,
  0x60, 0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x06, 0xC0, 0xD8, 0xF3, 0xFC, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0x03, 0xFC,
  0x70, 0xC6, 0x06, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x66, 0x06, 0x39, 0xC1, 0xF8,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x20, 0x10, 0x1F, 0xE3, 0x0E,
  0x60, 0xEC, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0x9F, 0xE3, 0xF8, 0x63,
  0x0C, 0x31, 0x86, 0x30, 0x66, 0x0E, 0xC0, 0xD8, 0x1C, 0x0E, 0x0F, 0xF6,
  0x0B, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xF3, 0xBF, 0xC0, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x66, 0x06, 0x60, 0x63, 0x9C, 0x1F, 0x80,
  0xE0, 0x1D, 0x80, 0x66, 0x01, 0x98, 0x06, 0x30, 0x30, 0xC0, 0xC3, 0x03,
  0x06, 0x0C, 0x18, 0x60, 0x61, 0x81, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x33,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC6, 0x3C, 0x63, 0xCF, 0x2C, 0xF2, 0x49, 0x25, 0x9A,
  0x59, 0xA5, 0x0A, 0x70, 0xE7, 0x0E, 0x60, 0x60, 0xE0, 0x76, 0x06, 0x30,
  0xC3, 0x0C, 0x19, 0x81, 0x98, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x19,
  0x83, 0x98, 0x30, 0xC7, 0x0E, 0x60, 0x6E, 0x06, 0xC0, 0x30, 0xE0, 0x1D,
  0x80, 0x63, 0x03, 0x0C, 0x0C, 0x18, 0x60, 0x61, 0x80, 0xCC, 0x03, 0x30,
  0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0xFF, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x7F, 0xFE, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0xFF, 0xFC,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xFE, 0x06, 0x00, 0xF0, 0x1B,
  0x01, 0x98, 0x30, 0xC3, 0x0C, 0x60, 0x66, 0x06, 0xC0, 0x30, 0xFF, 0xFF,
  0xFF, 0xF0, 0xCC, 0x63, 0x7F, 0x1C, 0xE0, 0x1C, 0x03, 0x00, 0xC7, 0xF7,
  0xFF, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0xC7, 0x3F, 0xC0, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xC7, 0xFC, 0xC1, 0xD8, 0x1B, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x06, 0xC1, 0xDE, 0xF3, 0xFC, 0x00,
  0x0F, 0xE3, 0xFE, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC7, 0xF9, 0xFF, 0x70, 0x6C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x1B, 0x03, 0x70, 0x67, 0xFC, 0x7F, 0x80, 0x1F,
  0x83, 0xDC, 0x70, 0x66, 0x06, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xCC, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x3F, 0xF7, 0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x1F, 0xE7,
  0xFD, 0xC1, 0xB0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x6C, 0x0D,
  0xE3, 0x9F, 0xF0, 0xE6, 0x00, 0xC0, 0x3A, 0x0E, 0x7F, 0x83, 0xC0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xF3, 0xFE, 0xC1, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x18,
  0x0F, 0x03, 0x80, 0x40, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0xF0, 0x7C, 0x03,
  0x03, 0x81, 0xC0, 0x40, 0x00, 0x01, 0xFE, 0xFF, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x32, 0x1B,
  0xF8, 0x70, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x3E,
  0x0C, 0xC3, 0x18, 0xC3, 0x70, 0x7C, 0x0F, 0x81, 0xB8, 0x31, 0x86, 0x18,
  0xC1, 0x98, 0x1B, 0x01, 0x80, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0xF0, 0x7C, 0xFF, 0xEE, 0xF7, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x30, 0xFF, 0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x76, 0x06, 0x70, 0xE3, 0xFC,
  0x1F, 0x80, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1B, 0x07, 0x7F, 0xCF, 0xF1, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0x1F, 0xE7, 0xFD, 0xC1, 0xB0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x6C, 0x0D, 0xC1, 0x9F, 0xF1, 0xFE, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x7F, 0xF8, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3F, 0x9E, 0xEC, 0x03, 0x00,
  0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x30, 0x0F, 0xDF, 0xFF, 0x80,
  0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0xFF, 0xF1, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7F, 0x0F, 0xC0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0D,
  0xFF, 0x3F, 0xC0, 0xC0, 0x3E, 0x07, 0x60, 0x66, 0x06, 0x70, 0xE3, 0x0C,
  0x30, 0xC1, 0x98, 0x19, 0x81, 0x98, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x63, 0xC6, 0x3C, 0x73, 0xCF, 0x34, 0x92, 0x79,
  0xE7, 0x9E, 0x70, 0xE7, 0x0E, 0x20, 0x40, 0xE0, 0x77, 0x0E, 0x30, 0xC1,
  0x98, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x19, 0x83, 0x0C, 0x70, 0xE6,
  0x06, 0xC0, 0x30, 0xE0, 0x36, 0x06, 0x60, 0x67, 0x06, 0x30, 0x63, 0x0C,
  0x18, 0xC1, 0x8C, 0x19, 0x80, 0xD8, 0x0D, 0x80, 0x70, 0x07, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0xF8, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x0C, 0x06,
  0x03, 0x81, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xC3, 0xF0, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0xF0, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x3F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x3F, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0xC1, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC3, 0xF0, 0xF0, 0x00, 0x7C, 0x36,
  0xE2, 0xC3, 0xE0, 0x08,
};

const GFXglyph UbuntuSansMono_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 6, 7, 14, 4, -19 },
  { 16, 12, 17, 14, 1, -17 },
  { 42, 10, 22, 14, 2, -19 },
  { 70, 12, 18, 14, 1, -18 },
  { 97, 12, 18, 14, 1, -18 },
  { 124, 2, 7, 14, 6, -19 },
  { 126, 8, 25, 14, 3, -20 },
  { 151, 8, 25, 14, 3, -20 },
  { 176, 10, 10, 14, 2, -17 },
  { 189, 12, 12, 14, 1, -13 },
  { 207, 6, 8, 14, 4, -4 },
  { 213, 6, 2, 14, 4, -8 },
  { 215, 4, 4, 14, 5, -4 },
  { 217, 10, 25, 14, 2, -20 },
  { 249, 12, 18, 14, 1, -18 },
  { 276, 10, 17, 14, 2, -17 },
  { 298, 10, 18, 14, 2, -18 },
  { 321, 10, 18, 14, 2, -18 },
  { 344, 12, 17, 14, 1, -17 },
  { 370, 10, 17, 14, 2, -17 },
  { 392, 11, 17, 14, 2, -17 },
  { 416, 11, 17, 14, 2, -17 },
  { 440, 10, 18, 14, 2, -18 },
  { 463, 11, 18, 14, 1, -18 },
  { 488, 4, 13, 14, 5, -13 },
  { 495, 5, 17, 14, 4, -13 },
  { 506, 12, 11, 14, 1, -13 },
  { 523, 12, 7, 14, 1, -11 },
  { 534, 12, 11, 14, 1, -13 },
  { 551, 8, 18, 14, 3, -18 },
  { 569, 12, 22, 14, 1, -18 },
  { 602, 14, 17, 14, 0, -17 },
  { 632, 11, 18, 14, 1, -18 },
  { 657, 12, 18, 14, 1, -18 },
  { 684, 12, 18, 14, 1, -18 },
  { 711, 10, 17, 14, 3, -17 },
  { 733, 9, 17, 14, 3, -17 },
  { 753, 12, 18, 14, 1, -18 },
  { 780, 12, 17, 14, 1, -17 },
  { 806, 8, 17, 14, 3, -17 },
  { 823, 10, 17, 14, 2, -17 },
  { 845, 12, 17, 14, 2, -17 },
  { 871, 10, 17, 14, 3, -17 },
  { 893, 12, 17, 14, 1, -17 },
  { 919, 10, 17, 14, 2, -17 },
  { 941, 12, 18, 14, 1, -18 },
  { 968, 11, 18, 14, 2, -18 },
  { 993, 12, 23, 14, 1, -18 },
  { 1028, 11, 18, 14, 2, -18 },
  { 1053, 10, 18, 14, 2, -18 },
  { 1076, 12, 17, 14, 1, -17 },
  { 1102, 12, 17, 14, 1, -17 },
  { 1128, 14, 17, 14, 0, -17 },
  { 1158, 12, 17, 14, 1, -17 },
  { 1184, 12, 17, 14, 1, -17 },
  { 1210, 14, 17, 14, 0, -17 },
  { 1240, 11, 17, 14, 2, -17 },
  { 1264, 7, 25, 14, 4, -20 },
  { 1286, 10, 25, 14, 2, -20 },
  { 1318, 7, 25, 14, 3, -20 },
  { 1340, 12, 9, 14, 1, -17 },
  { 1354, 14, 2, 14, 0, 3 },
  { 1358, 4, 4, 14, 5, -19 },
  { 1360, 10, 13, 14, 2, -13 },
  { 1377, 11, 19, 14, 2, -19 },
  { 1404, 12, 13, 14, 1, -13 },
  { 1424, 11, 19, 14, 1, -19 },
  { 1451, 12, 13, 14, 1, -13 },
  { 1471, 11, 19, 14, 2, -19 },
  { 1498, 11, 18, 14, 1, -13 },
  { 1523, 10, 19, 14, 2, -19 },
  { 1547, 10, 19, 14, 2, -19 },
  { 1571, 9, 24, 14, 2, -19 },
  { 1598, 11, 19, 14, 2, -19 },
  { 1625, 10, 19, 14, 2, -19 },
  { 1649, 12, 13, 14, 1, -13 },
  { 1669, 10, 13, 14, 2, -13 },
  { 1686, 12, 13, 14, 1, -13 },
  { 1706, 11, 18, 14, 2, -13 },
  { 1731, 11, 18, 14, 1, -13 },
  { 1756, 9, 13, 14, 3, -13 },
  { 1771, 10, 13, 14, 2, -13 },
  { 1788, 10, 17, 14, 2, -17 },
  { 1810, 10, 13, 14, 2, -13 },
  { 1827, 12, 13, 14, 1, -13 },
  { 1847, 12, 13, 14, 1, -13 },
  { 1867, 12, 13, 14, 1, -13 },
  { 1887, 12, 18, 14, 1, -13 },
  { 1914, 10, 13, 14, 2, -13 },
  { 1931, 10, 25, 14, 2, -20 },
  { 1963, 2, 25, 14, 6, -20 },
  { 1970, 10, 25, 14, 2, -20 },
  { 2002, 12, 4, 14, 1, -9 },
};

const GFXfont UbuntuSansMono_Regular25pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular25pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular25pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUSANSMONO_REGULAR25PT7B_H_
