#ifndef _UBUNTUSANSMONO_REGULAR44PT7B_H_
#define _UBUNTUSANSMONO_REGULAR44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x0C, 0x00, 0x00, 0x00, 0x31, 0xFF, 0xFF, 0xFD, 0xF1,
  0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x37, 0x06,
  0xE0, 0xDC, 0x19, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x1E,
  0x07, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0xF0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x00,
  0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0,
  0xF0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1E,
  0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0E,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7C,
  0x01, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x3D, 0xC0, 0x0F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x04, 0x7F, 0x00, 0x71, 0xCF, 0x00, 0xE3, 0x8E, 0x03,
  0x8E, 0x0C, 0x0F, 0x1C, 0x18, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0,
  0xE0, 0xE3, 0x81, 0xC1, 0x8F, 0x03, 0x87, 0x1C, 0x03, 0x8E, 0x70, 0x07,
  0x3C, 0xE0, 0x07, 0xF3, 0x80, 0x07, 0xCF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0xE7, 0xF0, 0x03, 0x9F, 0xE0, 0x0F, 0x38, 0xE0, 0x1C,
  0xE1, 0xC0, 0x71, 0xC1, 0x80, 0xE3, 0x83, 0x83, 0x87, 0x07, 0x0F, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x70, 0x38, 0x30, 0xE0, 0x70, 0xE3, 0x80, 0x71,
  0xCF, 0x00, 0xFF, 0x1C, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x03, 0xF0, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3C, 0x3C, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xE0, 0x70, 0x07,
  0x07, 0x00, 0x3C, 0x78, 0x00, 0xE7, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x1C, 0x1F, 0xE0, 0xE1, 0xEF, 0x87, 0x1E, 0x3C, 0x38, 0xE0,
  0xF1, 0x8F, 0x03, 0xDC, 0x78, 0x0F, 0xE3, 0x80, 0x3F, 0x1C, 0x01, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3E, 0x3C, 0x03, 0xF8, 0xF0, 0x3F, 0xC7, 0xFF,
  0xCF, 0x1F, 0xFC, 0x38, 0x3F, 0xC1, 0xE0, 0xFF, 0xFF, 0x77, 0x77, 0x77,
  0x76, 0x00, 0x60, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x01, 0x00, 0x60, 0x03,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0x70, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x04, 0x0E, 0x04, 0xF1, 0xC7, 0xBF, 0xBB, 0xF7,
  0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xDC, 0x00,
  0xF3, 0xC0, 0x1E, 0x3C, 0x07, 0x87, 0xC1, 0xF0, 0x78, 0x0C, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0x0F, 0xCF, 0xE7, 0xF1,
  0xF8, 0xFC, 0x1E, 0x0E, 0x0F, 0x1F, 0x3F, 0x1F, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x18, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xF0,
  0x78, 0x1E, 0x03, 0xC3, 0xC0, 0x1C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x00, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x70, 0xFF,
  0x0F, 0x8F, 0xF0, 0xF8, 0xFF, 0x0F, 0x8F, 0xF0, 0xF8, 0xFF, 0x07, 0x0F,
  0x70, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x1C, 0x03, 0xC1, 0xE0,
  0x7C, 0x0F, 0xDF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xF7, 0x83,
  0xE3, 0xC0, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7C, 0x0F,
  0x86, 0x00, 0x78, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1C, 0x0F, 0x82, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x20, 0x07, 0xC7,
  0xEF, 0xF9, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xB8, 0x00, 0x79,
  0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x01,
  0xC0, 0xE0, 0x1E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x07, 0x00, 0x70, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xEC, 0x00, 0xF3, 0xF7, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x04, 0x01, 0xEF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xF9, 0xFC, 0xF0, 0x07, 0xDC, 0x00, 0x7B, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x1E, 0x03, 0xC3, 0xF0, 0xF8, 0x3F,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1E, 0x07, 0xC7, 0x80, 0x3C, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x80,
  0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x39, 0xC0, 0x0F, 0x3C, 0x01, 0xC7, 0xC0,
  0x78, 0x7E, 0x1E, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0x83,
  0xF1, 0xE0, 0x1F, 0x38, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x3C, 0x01,
  0xE7, 0xE1, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0x80, 0x79, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x3F,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xC7, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00,
  0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x18, 0x02, 0x03, 0xE1,
  0xF8, 0x7F, 0x1F, 0xC7, 0xE0, 0xF8, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x7F, 0x1F, 0xC7,
  0xF0, 0xFC, 0x0E, 0x07, 0x83, 0xC3, 0xF3, 0xF8, 0x78, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0xF3, 0xFF, 0xE2, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0x03, 0xC0, 0xF0, 0x0F, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x0F,
  0x38, 0x00, 0x7B, 0xC0, 0x01, 0xDE, 0x01, 0xFE, 0xF0, 0x3F, 0xF7, 0x83,
  0xFF, 0xB8, 0x3C, 0x1D, 0xC3, 0xC0, 0xFE, 0x1E, 0x07, 0xF0, 0xE0, 0x3F,
  0x8F, 0x01, 0xFC, 0x78, 0x0F, 0xE3, 0xC0, 0x7F, 0x1E, 0x03, 0xF8, 0x70,
  0x1D, 0xC3, 0x80, 0xEF, 0x1E, 0x07, 0x78, 0xF0, 0x3B, 0xC3, 0xC1, 0xDE,
  0x0F, 0xFE, 0x78, 0x3F, 0xF3, 0xC0, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x30, 0x03,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xE7,
  0x80, 0x01, 0xE3, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xC1,
  0xC0, 0x03, 0x81, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00,
  0xF0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x78, 0x0E, 0x00, 0x38, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00,
  0x1E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x3F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x70, 0x1F, 0x8E, 0x00,
  0xF9, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0xF1, 0xC1, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0xE1, 0xFF, 0x1C, 0x00, 0xF3, 0x80, 0x0F, 0x70, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x07, 0xCF, 0xFF, 0xF9, 0xFF, 0xFC,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8,
  0x1E, 0x1E, 0x00, 0x43, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x06, 0x0F, 0xF7, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0x80, 0x3F,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x70, 0x3F, 0x0E, 0x01, 0xF1, 0xC0,
  0x0F, 0x38, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x03, 0xDC, 0x00,
  0xF3, 0x80, 0x3E, 0x70, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xC0, 0xE1, 0xE0,
  0x04, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00,
  0xE7, 0x80, 0x1C, 0xF8, 0x03, 0x8F, 0x80, 0x70, 0xFE, 0x7E, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xA0, 0x03,
  0xD8, 0x03, 0xDF, 0x8F, 0xEF, 0xFF, 0xE1, 0xFF, 0xC0, 0x0E, 0x00, 0xF0,
  0x01, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0,
  0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87,
  0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3C, 0x3E,
  0x01, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3E, 0x1E,
  0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x79, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x07,
  0xC7, 0xE0, 0x3E, 0x3F, 0x03, 0xB1, 0xDC, 0x1D, 0xCE, 0xE0, 0xEE, 0x77,
  0x0E, 0x73, 0x9C, 0x73, 0x9C, 0xE3, 0x9C, 0xE3, 0x18, 0xE7, 0x1D, 0xC7,
  0x38, 0xEE, 0x39, 0xC3, 0x61, 0xDE, 0x1F, 0x0E, 0xF0, 0xF8, 0x77, 0x83,
  0x83, 0xBC, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xDC, 0x01, 0xFB,
  0xC0, 0x3F, 0x38, 0x07, 0xE7, 0x80, 0xFC, 0x70, 0x1F, 0x8F, 0x03, 0xF0,
  0xE0, 0x7E, 0x1E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x03, 0x87, 0xE0,
  0x70, 0xFC, 0x0F, 0x1F, 0x80, 0xE3, 0xF0, 0x1E, 0x7E, 0x01, 0xCF, 0xC0,
  0x39, 0xF8, 0x03, 0xBF, 0x00, 0x77, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xC0, 0xF8, 0x1E, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xE0, 0x00,
  0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0xDE, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x0F, 0x07,
  0xC0, 0x78, 0x0F, 0xCF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0C,
  0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0xFC, 0xE0, 0x07,
  0xB8, 0x01, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7B, 0x80,
  0x3C, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xC0, 0xF8, 0x1E, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x39,
  0xE0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0,
  0x0F, 0x07, 0xC0, 0x78, 0x0F, 0xCF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x70, 0x1F, 0x8E, 0x00, 0xF9, 0xC0,
  0x0F, 0x38, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80,
  0x0F, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x01,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0xC1, 0xC0, 0x38, 0x38, 0x07, 0x87, 0x00, 0x78, 0xE0, 0x07, 0x1C, 0x00,
  0xF3, 0x80, 0x0E, 0x70, 0x01, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00,
  0x78, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x01, 0xC7, 0x80,
  0x08, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x30, 0x03, 0xEF, 0xE3, 0xF9, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xCE, 0x00, 0x79, 0xE0, 0x1F,
  0x1F, 0x8F, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xF0, 0x00, 0xF1, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xCF, 0x00, 0x03, 0xDC,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0xE0, 0xEF, 0x0F, 0x07, 0x78,
  0x7C, 0x3B, 0xC3, 0xE1, 0xCE, 0x3B, 0x0E, 0x71, 0xDC, 0x73, 0x8C, 0xE3,
  0x9C, 0xE3, 0x1C, 0xE7, 0x1C, 0xE7, 0x30, 0xE7, 0x3B, 0x87, 0x31, 0xDC,
  0x1D, 0x8E, 0xC0, 0xEC, 0x7E, 0x07, 0x63, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0x78, 0x07, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0xF0,
  0x01, 0xE1, 0xC0, 0x0F, 0x07, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0x70, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0F, 0x3C, 0x00,
  0x1E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0x3C, 0x00, 0x3C, 0x70,
  0x00, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x1E, 0x07,
  0x80, 0x78, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0, 0x07, 0x8E, 0x00,
  0x1E, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0E,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00,
  0x7B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x3D, 0xC0, 0x03, 0x9E, 0x00, 0x78, 0xE0, 0x07, 0x0F, 0x00, 0xF0,
  0x70, 0x0E, 0x07, 0x81, 0xE0, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x1E, 0x78,
  0x00, 0xE7, 0x00, 0x0F, 0xF0, 0x00, 0x72, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0xF0, 0x78, 0x38, 0x3C, 0x1E,
  0x0F, 0x06, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x40, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x7E,
  0x70, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x07, 0xDE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xE0, 0x07, 0x7F,
  0xBF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0x40, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x77, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0x00, 0x3C, 0xE0, 0x07,
  0x9C, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0F,
  0x70, 0x01, 0xEE, 0x00, 0x79, 0xC0, 0x1F, 0x38, 0x07, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x7F, 0xFF, 0x1F, 0x80, 0x27, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x11, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x81, 0xFE, 0x70, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0x80, 0xF9, 0xE0, 0x0F, 0x78, 0x00, 0xEF, 0x00, 0x1D,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xBC, 0x00, 0x77,
  0x80, 0x0E, 0x78, 0x01, 0xC7, 0xC0, 0x38, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xC1, 0xF0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xF7, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x04, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7C, 0x06, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0x80, 0xF3, 0xC0, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x00, 0xEF, 0x80,
  0x1C, 0xF8, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFD, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x10, 0x03,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xC0, 0x7D, 0xC0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x40, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC8, 0x0F, 0xBF, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x01, 0xFE, 0x00, 0x79, 0xC0, 0x1E, 0x38, 0x07, 0x87, 0x01,
  0xE0, 0xE0, 0x78, 0x1C, 0x3E, 0x03, 0x8F, 0x80, 0x73, 0xE0, 0x0E, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x7E, 0x00, 0xE7, 0xE0, 0x1C, 0x3E,
  0x03, 0x83, 0xE0, 0x70, 0x3E, 0x0E, 0x03, 0xE1, 0xC0, 0x3E, 0x38, 0x03,
  0xE7, 0x00, 0x3E, 0xE0, 0x03, 0xDC, 0x00, 0x3C, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x08, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x10, 0x00, 0x7F, 0x8F, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFD, 0xE1, 0xE0, 0xEF, 0x07, 0x07, 0xF8, 0x38, 0x3F,
  0xC1, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x7F, 0x83, 0x83, 0xFC, 0x1C,
  0x1F, 0xE0, 0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x38, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9C, 0x03, 0xEE, 0x00, 0xF7, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0x03, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xE0, 0x7C, 0x3C, 0x03, 0xE7, 0x80,
  0x1E, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x77,
  0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1E, 0x3C, 0x01, 0xE3, 0xE0, 0x7C,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x70, 0x0F, 0x8E, 0x00, 0xF9, 0xC0, 0x0F, 0x38, 0x00,
  0xF7, 0x00, 0x1E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03,
  0xDC, 0x00, 0x73, 0x80, 0x1E, 0x7C, 0x07, 0x8F, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3B, 0xFE, 0x07, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0x80, 0x73, 0xC0, 0x0E, 0xF0, 0x01,
  0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x07,
  0x78, 0x00, 0xEF, 0x00, 0x1C, 0xF0, 0x07, 0x9F, 0x01, 0xF1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0xB8, 0x01, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF9, 0xF0, 0x02, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1D, 0x80, 0x0F, 0x7F, 0x3F, 0xBF, 0xFF, 0xC3, 0xFF, 0xE0,
  0x02, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x04, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xC0,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1C, 0xF0, 0x07, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x7F, 0xF8, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1C,
  0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xC0, 0xE0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0xF1, 0xC0, 0x03, 0x9E,
  0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0x77, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x0E,
  0x07, 0x38, 0x1C, 0x1E, 0x70, 0x7C, 0x3C, 0xF0, 0xF8, 0x71, 0xE1, 0xF0,
  0xE1, 0xC7, 0x71, 0xC3, 0x8E, 0xE3, 0x87, 0x39, 0xC7, 0x0E, 0x71, 0xDE,
  0x1C, 0xE3, 0xB8, 0x3F, 0x83, 0x70, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x81, 0xE0,
  0x78, 0x07, 0x83, 0x80, 0x1E, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEF,
  0x00, 0x1E, 0x7C, 0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F,
  0x00, 0xF0, 0x78, 0x03, 0xC7, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x7B, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3,
  0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x00, 0x70, 0x38, 0x03,
  0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x70,
  0x00, 0x7B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x33, 0xFE, 0x03, 0x7F, 0xF0, 0x76,
  0x0F, 0xFF, 0xE0, 0x3F, 0xEE, 0x00, 0xFC,
};

const GFXglyph UbuntuSansMono_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 31, 25, 9, -30 },
  { 25, 11, 11, 25, 7, -33 },
  { 41, 22, 30, 25, 1, -30 },
  { 124, 19, 39, 25, 3, -34 },
  { 217, 23, 32, 25, 1, -31 },
  { 309, 21, 31, 25, 2, -31 },
  { 391, 4, 12, 25, 10, -33 },
  { 397, 13, 42, 25, 6, -34 },
  { 466, 13, 42, 25, 6, -34 },
  { 535, 19, 17, 25, 3, -30 },
  { 576, 20, 22, 25, 2, -24 },
  { 631, 9, 13, 25, 8, -6 },
  { 646, 10, 3, 25, 7, -14 },
  { 650, 7, 8, 25, 9, -7 },
  { 657, 17, 42, 25, 4, -34 },
  { 747, 20, 32, 25, 2, -31 },
  { 827, 17, 30, 25, 4, -30 },
  { 891, 19, 31, 25, 3, -31 },
  { 965, 19, 32, 25, 3, -31 },
  { 1041, 21, 30, 25, 2, -30 },
  { 1120, 18, 31, 25, 4, -30 },
  { 1190, 19, 32, 25, 3, -31 },
  { 1266, 19, 30, 25, 3, -30 },
  { 1338, 19, 32, 25, 3, -31 },
  { 1414, 19, 31, 25, 3, -31 },
  { 1488, 7, 24, 25, 9, -23 },
  { 1509, 10, 30, 25, 6, -23 },
  { 1547, 19, 19, 25, 3, -22 },
  { 1593, 20, 12, 25, 2, -19 },
  { 1623, 20, 19, 25, 3, -22 },
  { 1671, 15, 32, 25, 5, -31 },
  { 1731, 21, 38, 25, 2, -31 },
  { 1831, 24, 30, 25, 0, -30 },
  { 1921, 19, 31, 25, 3, -31 },
  { 1995, 20, 32, 25, 3, -31 },
  { 2075, 19, 31, 25, 3, -31 },
  { 2149, 18, 30, 25, 5, -30 },
  { 2217, 17, 30, 25, 5, -30 },
  { 2281, 19, 32, 25, 3, -31 },
  { 2357, 20, 30, 25, 2, -30 },
  { 2432, 15, 30, 25, 5, -30 },
  { 2489, 17, 31, 25, 3, -30 },
  { 2555, 21, 30, 25, 3, -30 },
  { 2634, 18, 30, 25, 5, -30 },
  { 2702, 21, 30, 25, 2, -30 },
  { 2781, 19, 30, 25, 3, -30 },
  { 2853, 22, 32, 25, 1, -31 },
  { 2941, 18, 31, 25, 4, -31 },
  { 3011, 22, 39, 25, 1, -31 },
  { 3119, 19, 31, 25, 3, -31 },
  { 3193, 19, 32, 25, 3, -31 },
  { 3269, 20, 30, 25, 2, -30 },
  { 3344, 19, 31, 25, 3, -30 },
  { 3418, 23, 30, 25, 1, -30 },
  { 3505, 21, 30, 25, 2, -30 },
  { 3584, 22, 30, 25, 1, -30 },
  { 3667, 23, 30, 25, 1, -30 },
  { 3754, 19, 30, 25, 3, -30 },
  { 3826, 12, 42, 25, 7, -34 },
  { 3889, 17, 42, 25, 4, -34 },
  { 3979, 11, 42, 25, 6, -34 },
  { 4037, 20, 16, 25, 2, -30 },
  { 4077, 24, 3, 25, 0, 5 },
  { 4086, 8, 8, 25, 8, -34 },
  { 4094, 18, 24, 25, 3, -23 },
  { 4148, 19, 35, 25, 4, -34 },
  { 4232, 19, 24, 25, 3, -23 },
  { 4289, 19, 35, 25, 2, -34 },
  { 4373, 20, 24, 25, 2, -23 },
  { 4433, 20, 34, 25, 4, -34 },
  { 4518, 19, 31, 25, 2, -23 },
  { 4592, 17, 34, 25, 4, -34 },
  { 4665, 19, 34, 25, 3, -33 },
  { 4746, 15, 41, 25, 4, -33 },
  { 4823, 19, 34, 25, 4, -34 },
  { 4904, 19, 35, 25, 3, -34 },
  { 4988, 21, 23, 25, 2, -23 },
  { 5049, 17, 23, 25, 4, -23 },
  { 5098, 20, 23, 25, 2, -23 },
  { 5156, 19, 31, 25, 4, -23 },
  { 5230, 19, 31, 25, 2, -23 },
  { 5304, 15, 23, 25, 6, -23 },
  { 5348, 18, 24, 25, 3, -23 },
  { 5402, 18, 31, 25, 4, -30 },
  { 5472, 18, 23, 25, 3, -23 },
  { 5524, 21, 23, 25, 2, -23 },
  { 5585, 23, 23, 25, 1, -23 },
  { 5652, 21, 23, 25, 2, -23 },
  { 5713, 21, 31, 25, 2, -23 },
  { 5795, 17, 23, 25, 4, -23 },
  { 5844, 17, 42, 25, 4, -34 },
  { 5934, 3, 42, 25, 11, -34 },
  { 5950, 17, 42, 25, 4, -34 },
  { 6040, 20, 6, 25, 2, -16 },
};

const GFXfont UbuntuSansMono_Regular44pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular44pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular44pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUSANSMONO_REGULAR44PT7B_H_
