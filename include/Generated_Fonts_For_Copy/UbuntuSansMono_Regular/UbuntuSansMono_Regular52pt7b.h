#ifndef _UBUNTUSANSMONO_REGULAR52PT7B_H_
#define _UBUNTUSANSMONO_REGULAR52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x1F, 0x7F, 0xFF, 0xFF, 0xFB, 0xE3, 0x00, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x81, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x18, 0x00, 0xF8, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0x00, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x80, 0x00, 0xF9, 0xC0, 0x03, 0xF3, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF,
  0x17, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x78, 0xFF, 0x80,
  0x1E, 0x3C, 0x78, 0x03, 0xC7, 0x07, 0x00, 0xF0, 0xE0, 0xE0, 0x1E, 0x3C,
  0x1E, 0x07, 0x87, 0x03, 0xC1, 0xE0, 0xE0, 0x78, 0x3C, 0x1C, 0x0F, 0x0F,
  0x03, 0x81, 0xE1, 0xE0, 0x78, 0x3C, 0x78, 0x0F, 0x07, 0x1E, 0x00, 0xE0,
  0xE3, 0xC0, 0x1E, 0x3C, 0xF0, 0x01, 0xEF, 0x1C, 0x00, 0x3F, 0xE7, 0x80,
  0x03, 0xF0, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC3, 0xF0, 0x00, 0x79, 0xFF, 0x00, 0x0E, 0x3D, 0xF0, 0x03, 0xCF, 0x0E,
  0x00, 0xF1, 0xC1, 0xC0, 0x1C, 0x38, 0x3C, 0x07, 0x87, 0x03, 0x80, 0xE1,
  0xE0, 0x70, 0x3C, 0x3C, 0x0E, 0x0F, 0x07, 0x81, 0xC1, 0xC0, 0xF0, 0x38,
  0x78, 0x0E, 0x0F, 0x0E, 0x01, 0xC1, 0xE3, 0xC0, 0x3C, 0x38, 0xF0, 0x07,
  0x8F, 0x1C, 0x00, 0x7F, 0xC7, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x7C, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0x81,
  0xFF, 0x03, 0xC1, 0xEF, 0xC1, 0xE1, 0xF3, 0xE0, 0xF0, 0xF0, 0xF8, 0x70,
  0xF0, 0x3E, 0x38, 0x78, 0x0F, 0x9C, 0x7C, 0x03, 0xFE, 0x3E, 0x00, 0xFE,
  0x1E, 0x00, 0x7F, 0x0F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xF1, 0xF0, 0x03, 0xF8, 0x7C, 0x03, 0xFE, 0x3F, 0x87, 0xEF, 0x0F, 0xFF,
  0xE7, 0xC3, 0xFF, 0xE1, 0xF0, 0x7F, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x08, 0x00, 0x30, 0x00, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0x20, 0x20, 0x00, 0x60, 0x01, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0x78, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x08, 0x07, 0x00, 0x9E,
  0x0E, 0x07, 0x3F, 0x1C, 0x7E, 0x7F, 0xBB, 0xFD, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x7B,
  0xE0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F,
  0xC0, 0x38, 0x0E, 0x00, 0x20, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0xF8, 0x3F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xC7,
  0xF1, 0xFC, 0x3F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38,
  0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x18, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF8, 0x3F,
  0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x7C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x3E, 0x0F, 0xF0, 0x7E, 0x1F, 0xE1,
  0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x07, 0xC1, 0xFE, 0x07,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F,
  0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0x78, 0x0F, 0xE7, 0x80, 0xF8, 0x78, 0x06, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x07, 0xE3, 0xC0, 0x0F, 0x86, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x78,
  0x07, 0xE0, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x80, 0x01, 0xF3, 0xC0, 0x1F, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1C,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x90, 0x00, 0x7C, 0x70, 0x07, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3,
  0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x8F, 0x00,
  0x1F, 0x1F, 0x00, 0x3C, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x81, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0,
  0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0xF8, 0x1F, 0xC3, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0xF8, 0xFF, 0x03, 0xC0, 0x3F, 0x0F, 0x00, 0x3F, 0x3C, 0x00, 0x3E,
  0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x7C,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x00,
  0x1E, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xFC, 0x01, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0x80, 0x2C, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x38, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x18, 0x03, 0x80, 0x7C, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x0F, 0xCF, 0xF8, 0x7F, 0x07, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE4,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0xFF, 0x78, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3E, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0xF8, 0x0F,
  0xF0, 0xF8, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F,
  0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0x78, 0x0F,
  0xF8, 0x78, 0x0F, 0xF8, 0x7C, 0x0F, 0x78, 0x3E, 0x0F, 0x7C, 0x1F, 0xFF,
  0x7C, 0x0F, 0xFF, 0x3C, 0x07, 0xFE, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x08, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x80, 0x7F, 0x8F, 0x00, 0x1F, 0x1E,
  0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0x80, 0x1F, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x0F,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC,
  0x00, 0x1F, 0x78, 0x00, 0x7C, 0xF0, 0x0F, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x1E, 0x0F, 0xC0, 0x04, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x07, 0xF0, 0x1E, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xF0, 0x1F, 0xE0, 0xF0,
  0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7E, 0x01, 0xC1, 0xF0, 0x00, 0x87, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x80, 0x0F,
  0x0F, 0x80, 0x1E, 0x0F, 0xC0, 0x3C, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC4, 0x00, 0x3E, 0x78,
  0x07, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x1E, 0x00,
  0x1F, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x1F, 0x01, 0xE0,
  0x1F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xCF, 0x80, 0x01,
  0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1E, 0x7E, 0x00, 0x0F, 0x1F, 0x80, 0x07, 0x87, 0xE0, 0x03, 0xC1, 0xF8,
  0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xE0, 0x3C, 0x01,
  0xF8, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0xDE, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F,
  0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF0,
  0xFE, 0x03, 0xF8, 0x77, 0x01, 0xDC, 0x3B, 0xC0, 0xEE, 0x1D, 0xE0, 0xF7,
  0x8E, 0x70, 0x73, 0xC7, 0x38, 0x39, 0xE7, 0x9E, 0x3C, 0xF3, 0xC7, 0x1C,
  0x79, 0xE3, 0x8E, 0x3C, 0xF0, 0xE7, 0x1E, 0x78, 0x77, 0x0F, 0x3C, 0x3B,
  0x87, 0x9E, 0x0F, 0xC1, 0xCF, 0x07, 0xC0, 0xE7, 0x83, 0xE0, 0x73, 0xC0,
  0xF0, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xB8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFB, 0xC0, 0x0F, 0xF7, 0xC0, 0x1F,
  0xE7, 0x80, 0x3F, 0xCF, 0x80, 0x7F, 0x8F, 0x00, 0xFF, 0x0F, 0x01, 0xFE,
  0x1E, 0x03, 0xFC, 0x1E, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x7C, 0x1F, 0xE0,
  0x78, 0x3F, 0xC0, 0xF0, 0x7F, 0x80, 0xF0, 0xFF, 0x01, 0xE1, 0xFE, 0x01,
  0xE3, 0xFC, 0x03, 0xC7, 0xF8, 0x03, 0xCF, 0xF0, 0x07, 0x9F, 0xE0, 0x07,
  0x3F, 0xC0, 0x0F, 0x7F, 0x80, 0x0E, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x1E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x3E, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0, 0x1F, 0xCF, 0x00, 0x3F, 0x78,
  0x00, 0xFB, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x07, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x7C,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC3, 0xC0,
  0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x20, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x07, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8, 0x07, 0x87, 0xC0, 0x02, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x20, 0x00, 0x7C, 0xF8, 0x03, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F, 0x00,
  0x1F, 0x1F, 0x00, 0x3E, 0x3F, 0x01, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x73, 0xC0, 0x00, 0x39, 0xE0, 0xF8, 0x1C, 0xF0, 0x7C, 0x0E, 0x78,
  0x3E, 0x0F, 0x3C, 0x3F, 0x87, 0x9E, 0x1D, 0xC3, 0xCF, 0x0E, 0xE1, 0xE7,
  0x8F, 0x78, 0xF3, 0xC7, 0x1C, 0x79, 0xE3, 0x8E, 0x3C, 0xF3, 0xC7, 0x9E,
  0x79, 0xC1, 0xCF, 0x3C, 0xE0, 0xE7, 0x0E, 0xF0, 0x7B, 0x87, 0x70, 0x1D,
  0xC3, 0xB8, 0x0E, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0x80, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87,
  0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x3C, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF8,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0x78, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE0,
  0xF8, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78,
  0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80,
  0x0F, 0x1F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3C, 0x80, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x78, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0x00, 0x00, 0x20, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF8,
  0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0x7E, 0x00,
  0x7B, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0B, 0xA0, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x02,
  0x00, 0x1E, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0x07,
  0xF1, 0xF8, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xE0,
  0x01, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x1F, 0x8F, 0x80, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x01,
  0xC3, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x0E, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x10, 0x3C, 0x0F, 0xFE,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x83, 0xFC, 0xF8, 0x03, 0xF7,
  0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xE0, 0x03, 0xCF, 0xC0,
  0x0F, 0x1F, 0xC0, 0x7C, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x3E,
  0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x1C, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFC, 0x1E, 0x01, 0xF0, 0x02, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFE, 0x07, 0xE3, 0xE0, 0x03, 0xCF,
  0x80, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0xE0, 0x1F,
  0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x30, 0x03, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x02, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFE, 0x07, 0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x60, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xEE, 0x01, 0xF7,
  0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0,
  0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x7E, 0x00,
  0xF0, 0xFC, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xF7, 0xF0, 0x00, 0xF1, 0xF8, 0x00,
  0xF0, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0xFF, 0xC7,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xF0, 0x7C, 0x1E, 0xF0, 0x78,
  0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x20, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xC0, 0xFE, 0x78, 0x00, 0xFB, 0xC0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x83, 0xF0,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E,
  0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F, 0x83, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1E, 0x00, 0x7E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF0,
  0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07,
  0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x7E, 0x00, 0xF8, 0xFF, 0x07, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xBF, 0xF8, 0x0F, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFE, 0x07, 0xE3, 0xF0, 0x03, 0xCF, 0xC0, 0x07, 0x9F, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0xF7,
  0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x07, 0x8F, 0x80, 0x3F, 0x0F,
  0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0xF0, 0x03,
  0xC1, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x06, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE8, 0x00, 0x1F, 0x78, 0x01,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x06, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00,
  0x3D, 0xF8, 0x01, 0xE7, 0xF0, 0x1F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x00, 0x68, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x78, 0x1E, 0x78, 0x0F, 0x03,
  0xCF, 0x03, 0xE0, 0x78, 0xF0, 0x7C, 0x0F, 0x1E, 0x0F, 0xC1, 0xC3, 0xC3,
  0xB8, 0x78, 0x78, 0x77, 0x0F, 0x0F, 0x1E, 0xF1, 0xE1, 0xE3, 0x8E, 0x3C,
  0x1C, 0x71, 0xE7, 0x83, 0xDE, 0x3C, 0xE0, 0x7B, 0x83, 0xBC, 0x0F, 0x70,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x1F, 0x07, 0xC0,
  0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF0,
  0x7C, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x78,
  0x00, 0xF8, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x02, 0x0F, 0xF8, 0x03, 0xCF, 0xFF, 0x01, 0xCF, 0x0F, 0xE1, 0xE7, 0x01,
  0xFF, 0xE3, 0x80, 0x7F, 0xF3, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 37, 29, 11, -36 },
  { 34, 13, 14, 29, 8, -40 },
  { 57, 25, 36, 29, 2, -36 },
  { 170, 23, 46, 29, 3, -40 },
  { 303, 27, 38, 29, 1, -37 },
  { 432, 25, 37, 29, 2, -37 },
  { 548, 5, 15, 29, 12, -40 },
  { 558, 15, 51, 29, 7, -41 },
  { 654, 15, 51, 29, 7, -41 },
  { 750, 23, 21, 29, 3, -36 },
  { 811, 23, 25, 29, 3, -28 },
  { 883, 11, 16, 29, 9, -8 },
  { 905, 11, 4, 29, 9, -17 },
  { 911, 8, 9, 29, 11, -8 },
  { 920, 21, 51, 29, 4, -41 },
  { 1054, 23, 38, 29, 3, -37 },
  { 1164, 20, 36, 29, 5, -36 },
  { 1254, 22, 37, 29, 4, -37 },
  { 1356, 22, 38, 29, 4, -37 },
  { 1461, 25, 36, 29, 2, -36 },
  { 1574, 22, 37, 29, 4, -36 },
  { 1676, 23, 37, 29, 3, -36 },
  { 1783, 23, 36, 29, 4, -36 },
  { 1887, 23, 38, 29, 3, -37 },
  { 1997, 23, 37, 29, 3, -37 },
  { 2104, 8, 28, 29, 11, -27 },
  { 2132, 12, 35, 29, 7, -27 },
  { 2185, 24, 23, 29, 3, -26 },
  { 2254, 23, 15, 29, 3, -23 },
  { 2298, 24, 23, 29, 3, -26 },
  { 2367, 17, 38, 29, 6, -37 },
  { 2448, 24, 45, 29, 3, -37 },
  { 2583, 28, 36, 29, 1, -36 },
  { 2709, 23, 36, 29, 3, -36 },
  { 2813, 24, 38, 29, 3, -37 },
  { 2927, 24, 36, 29, 3, -36 },
  { 3035, 21, 36, 29, 6, -36 },
  { 3130, 20, 36, 29, 6, -36 },
  { 3220, 23, 38, 29, 3, -37 },
  { 3330, 24, 36, 29, 3, -36 },
  { 3438, 17, 36, 29, 6, -36 },
  { 3515, 21, 37, 29, 3, -36 },
  { 3613, 25, 36, 29, 4, -36 },
  { 3726, 21, 36, 29, 6, -36 },
  { 3821, 25, 36, 29, 2, -36 },
  { 3934, 23, 36, 29, 3, -36 },
  { 4038, 26, 38, 29, 2, -37 },
  { 4162, 21, 36, 29, 5, -36 },
  { 4257, 26, 47, 29, 2, -37 },
  { 4410, 24, 36, 29, 3, -36 },
  { 4518, 23, 38, 29, 3, -37 },
  { 4628, 24, 36, 29, 3, -36 },
  { 4736, 23, 37, 29, 3, -36 },
  { 4843, 27, 36, 29, 1, -36 },
  { 4965, 25, 36, 29, 2, -36 },
  { 5078, 25, 36, 29, 2, -36 },
  { 5191, 27, 36, 29, 1, -36 },
  { 5313, 24, 36, 29, 3, -36 },
  { 5421, 13, 51, 29, 9, -41 },
  { 5504, 21, 51, 29, 4, -41 },
  { 5638, 13, 51, 29, 7, -41 },
  { 5721, 23, 19, 29, 3, -36 },
  { 5776, 29, 4, 29, 0, 6 },
  { 5791, 9, 10, 29, 10, -40 },
  { 5803, 21, 29, 29, 4, -28 },
  { 5880, 23, 41, 29, 4, -40 },
  { 5998, 23, 29, 29, 3, -28 },
  { 6082, 22, 41, 29, 3, -40 },
  { 6195, 24, 29, 29, 2, -28 },
  { 6282, 24, 40, 29, 4, -40 },
  { 6402, 23, 38, 29, 2, -28 },
  { 6512, 21, 40, 29, 4, -40 },
  { 6617, 23, 40, 29, 3, -39 },
  { 6732, 17, 49, 29, 5, -39 },
  { 6837, 24, 40, 29, 4, -40 },
  { 6957, 23, 41, 29, 3, -40 },
  { 7075, 24, 28, 29, 3, -28 },
  { 7159, 21, 28, 29, 4, -28 },
  { 7233, 24, 29, 29, 3, -28 },
  { 7320, 23, 38, 29, 4, -28 },
  { 7430, 23, 38, 29, 2, -28 },
  { 7540, 18, 28, 29, 7, -28 },
  { 7603, 21, 29, 29, 4, -28 },
  { 7680, 22, 36, 29, 4, -35 },
  { 7779, 21, 28, 29, 4, -27 },
  { 7853, 25, 27, 29, 2, -27 },
  { 7938, 27, 27, 29, 1, -27 },
  { 8030, 25, 27, 29, 2, -27 },
  { 8115, 25, 37, 29, 2, -27 },
  { 8231, 21, 27, 29, 4, -27 },
  { 8302, 20, 51, 29, 5, -41 },
  { 8430, 3, 51, 29, 13, -41 },
  { 8450, 20, 51, 29, 4, -41 },
  { 8578, 25, 8, 29, 2, -19 },
};

const GFXfont UbuntuSansMono_Regular52pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular52pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular52pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUSANSMONO_REGULAR52PT7B_H_
