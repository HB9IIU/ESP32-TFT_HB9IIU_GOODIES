#ifndef _UBUNTUSANSMONO_REGULAR13PT7B_H_
#define _UBUNTUSANSMONO_REGULAR13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA2, 0xC0, 0xB6, 0xD0, 0x14, 0x4B, 0xF9, 0x22, 0x45, 0x3F,
  0xA4, 0x48, 0x21, 0xB3, 0x0C, 0x38, 0x21, 0x8F, 0x88, 0x63, 0x4A, 0x63,
  0x41, 0x03, 0xCA, 0xA5, 0xCE, 0x38, 0x91, 0x21, 0x83, 0x4A, 0xB3, 0x26,
  0x7E, 0xF0, 0x26, 0x48, 0x88, 0x88, 0x84, 0x43, 0x84, 0x62, 0x21, 0x12,
  0x22, 0x48, 0x25, 0x7E, 0x65, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x80, 0x6C,
  0xE0, 0xE0, 0xB0, 0x08, 0x44, 0x21, 0x10, 0x84, 0x42, 0x11, 0x00, 0x72,
  0x28, 0xAB, 0xBE, 0x38, 0xA2, 0x70, 0x33, 0xA4, 0x21, 0x08, 0x42, 0x78,
  0xF4, 0x42, 0x11, 0x11, 0x10, 0xF8, 0xF0, 0x42, 0x23, 0x04, 0x21, 0xF8,
  0x18, 0xA2, 0x92, 0x8A, 0x2F, 0xC2, 0x08, 0x7A, 0x10, 0x83, 0x84, 0x21,
  0xF8, 0x39, 0x08, 0x28, 0xDA, 0x28, 0xE2, 0x78, 0xFC, 0x21, 0x84, 0x30,
  0x82, 0x08, 0x40, 0x7C, 0x63, 0x97, 0x46, 0x31, 0xF8, 0x74, 0x63, 0x1F,
  0x84, 0x22, 0xE0, 0xB0, 0x2C, 0x4C, 0x00, 0x9A, 0xC0, 0x04, 0x66, 0x20,
  0x70, 0x30, 0xFC, 0x00, 0x3F, 0x83, 0x81, 0x83, 0x33, 0x00, 0xF0, 0x42,
  0x22, 0x10, 0x04, 0x60, 0x7B, 0x18, 0x6F, 0xA6, 0x9A, 0x6F, 0xC1, 0x03,
  0x80, 0x18, 0x50, 0xA1, 0x24, 0x48, 0x9F, 0x21, 0x82, 0xF4, 0x63, 0x3F,
  0x46, 0x31, 0xF0, 0x7F, 0x08, 0x20, 0x82, 0x08, 0x30, 0x7C, 0xF2, 0x28,
  0xA1, 0x86, 0x18, 0xA2, 0xF0, 0xFA, 0x08, 0x20, 0xFA, 0x08, 0x20, 0xFC,
  0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x7F, 0x08, 0x20, 0x82, 0x18, 0x71,
  0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0xF8, 0x78, 0x42, 0x10, 0x84, 0x21, 0xF0, 0x8E, 0x69, 0x28, 0xE2,
  0xC9, 0xA2, 0x84, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x44, 0xC9,
  0xB3, 0x55, 0x2A, 0x50, 0xA1, 0xC2, 0x8E, 0x73, 0x5A, 0xCE, 0x71, 0x88,
  0x3C, 0x89, 0x0E, 0x18, 0x38, 0x50, 0xA2, 0x3C, 0xFA, 0x28, 0x62, 0x9B,
  0x88, 0x20, 0x80, 0x3C, 0x89, 0x0E, 0x18, 0x38, 0x50, 0xA2, 0x3C, 0x20,
  0x30, 0xF2, 0x28, 0xA2, 0xF2, 0x49, 0x22, 0x8C, 0x7C, 0x21, 0x83, 0x04,
  0x21, 0xF8, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x18, 0x61,
  0x86, 0x18, 0xE2, 0x78, 0x82, 0x85, 0x12, 0x24, 0x44, 0x8A, 0x14, 0x10,
  0xC2, 0x85, 0x0A, 0x95, 0x2D, 0x5B, 0x32, 0x44, 0x46, 0xC8, 0xA0, 0xC1,
  0x05, 0x09, 0x22, 0xC6, 0xC2, 0x89, 0x11, 0x43, 0x82, 0x04, 0x08, 0x10,
  0xFC, 0x21, 0x04, 0x21, 0x04, 0x20, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0xE4, 0x92, 0x49,
  0x24, 0xF0, 0x21, 0x45, 0x22, 0x8C, 0xFE, 0xCC, 0x70, 0x42, 0xF8, 0xC5,
  0xE0, 0x82, 0x08, 0x3C, 0x8A, 0x38, 0x61, 0x8B, 0xC0, 0x3B, 0x08, 0x20,
  0x82, 0x07, 0xC0, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8B, 0xC0, 0x72, 0x28,
  0xFF, 0x82, 0x07, 0x80, 0x3C, 0x84, 0x3E, 0x41, 0x04, 0x10, 0x41, 0x00,
  0x7C, 0x63, 0x18, 0xC5, 0xE1, 0xF8, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C,
  0x40, 0x63, 0x01, 0xC2, 0x10, 0x84, 0x21, 0xC0, 0x10, 0x80, 0xF1, 0x8C,
  0x63, 0x18, 0xC7, 0xE0, 0x82, 0x08, 0x23, 0x92, 0x8E, 0x2C, 0x9A, 0x30,
  0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0xC0, 0xDA, 0x9A, 0x69, 0x86, 0x18,
  0x40, 0xF4, 0x63, 0x18, 0xC6, 0x20, 0x72, 0x28, 0xE1, 0x86, 0x27, 0x00,
  0xF2, 0x28, 0xE1, 0x86, 0x2F, 0xA0, 0x80, 0x7E, 0x63, 0x18, 0xC5, 0xE1,
  0x08, 0xF8, 0x88, 0x88, 0x80, 0x7C, 0x20, 0xE0, 0x87, 0xE0, 0x42, 0x3E,
  0x84, 0x21, 0x04, 0x38, 0x8C, 0x63, 0x18, 0xC5, 0xE0, 0xC2, 0x89, 0x11,
  0x22, 0x87, 0x04, 0x00, 0x83, 0x05, 0x4A, 0xD6, 0xCD, 0x91, 0x00, 0x46,
  0x48, 0xE0, 0x82, 0x8C, 0xB1, 0x80, 0x86, 0x2C, 0x92, 0x50, 0xC3, 0x08,
  0xE0, 0xF8, 0xC4, 0x44, 0x23, 0xE0, 0x39, 0x08, 0x42, 0x23, 0x04, 0x21,
  0x08, 0x70, 0xFF, 0xF0, 0xE1, 0x04, 0x21, 0x08, 0x62, 0x10, 0x85, 0xC0,
  0xC6, 0xE0,
};

const GFXglyph UbuntuSansMono_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 9, 7, 3, -9 },
  { 4, 3, 4, 7, 2, -10 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 11, 7, 1, -10 },
  { 21, 7, 9, 7, 0, -9 },
  { 29, 7, 9, 7, 0, -9 },
  { 37, 1, 4, 7, 3, -10 },
  { 38, 4, 12, 7, 2, -10 },
  { 44, 4, 12, 7, 2, -10 },
  { 50, 5, 5, 7, 1, -9 },
  { 54, 6, 6, 7, 1, -7 },
  { 59, 3, 4, 7, 2, -2 },
  { 61, 3, 1, 7, 2, -4 },
  { 62, 2, 2, 7, 3, -2 },
  { 63, 5, 12, 7, 1, -10 },
  { 71, 6, 9, 7, 1, -9 },
  { 78, 5, 9, 7, 1, -9 },
  { 84, 5, 9, 7, 1, -9 },
  { 90, 5, 9, 7, 1, -9 },
  { 96, 6, 9, 7, 1, -9 },
  { 103, 5, 9, 7, 1, -9 },
  { 109, 6, 9, 7, 1, -9 },
  { 116, 6, 9, 7, 1, -9 },
  { 123, 5, 9, 7, 1, -9 },
  { 129, 5, 9, 7, 1, -9 },
  { 135, 2, 7, 7, 3, -7 },
  { 137, 3, 9, 7, 2, -7 },
  { 141, 6, 6, 7, 1, -7 },
  { 146, 6, 4, 7, 1, -6 },
  { 149, 6, 6, 7, 1, -7 },
  { 154, 5, 9, 7, 1, -9 },
  { 160, 6, 11, 7, 1, -9 },
  { 169, 7, 9, 7, 0, -9 },
  { 177, 5, 9, 7, 1, -9 },
  { 183, 6, 9, 7, 1, -9 },
  { 190, 6, 9, 7, 1, -9 },
  { 197, 6, 9, 7, 1, -9 },
  { 204, 5, 9, 7, 1, -9 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 6, 9, 7, 1, -9 },
  { 224, 5, 9, 7, 1, -9 },
  { 230, 5, 9, 7, 1, -9 },
  { 236, 6, 9, 7, 1, -9 },
  { 243, 6, 9, 7, 1, -9 },
  { 250, 7, 9, 7, 0, -9 },
  { 258, 5, 9, 7, 1, -9 },
  { 264, 7, 9, 7, 0, -9 },
  { 272, 6, 9, 7, 1, -9 },
  { 279, 7, 11, 7, 0, -9 },
  { 289, 6, 9, 7, 1, -9 },
  { 296, 5, 9, 7, 1, -9 },
  { 302, 6, 9, 7, 1, -9 },
  { 309, 6, 9, 7, 1, -9 },
  { 316, 7, 9, 7, 0, -9 },
  { 324, 7, 9, 7, 0, -9 },
  { 332, 7, 9, 7, 0, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 6, 9, 7, 1, -9 },
  { 355, 4, 12, 7, 2, -10 },
  { 361, 5, 12, 7, 1, -10 },
  { 369, 3, 12, 7, 2, -10 },
  { 374, 6, 5, 7, 1, -9 },
  { 378, 7, 1, 7, 0, 1 },
  { 379, 3, 2, 7, 2, -10 },
  { 380, 5, 7, 7, 1, -7 },
  { 385, 6, 10, 7, 1, -10 },
  { 393, 6, 7, 7, 1, -7 },
  { 399, 5, 10, 7, 1, -10 },
  { 406, 6, 7, 7, 1, -7 },
  { 412, 6, 10, 7, 1, -10 },
  { 420, 5, 9, 7, 1, -7 },
  { 426, 5, 10, 7, 1, -10 },
  { 433, 5, 10, 7, 1, -10 },
  { 440, 5, 12, 7, 1, -10 },
  { 448, 6, 10, 7, 1, -10 },
  { 456, 5, 10, 7, 1, -10 },
  { 463, 6, 7, 7, 1, -7 },
  { 469, 5, 7, 7, 1, -7 },
  { 474, 6, 7, 7, 1, -7 },
  { 480, 6, 9, 7, 1, -7 },
  { 487, 5, 9, 7, 1, -7 },
  { 493, 4, 7, 7, 2, -7 },
  { 497, 5, 7, 7, 1, -7 },
  { 502, 5, 9, 7, 1, -9 },
  { 508, 5, 7, 7, 1, -7 },
  { 513, 7, 7, 7, 0, -7 },
  { 520, 7, 7, 7, 0, -7 },
  { 527, 7, 7, 7, 0, -7 },
  { 534, 6, 9, 7, 1, -7 },
  { 541, 5, 7, 7, 1, -7 },
  { 546, 5, 12, 7, 1, -10 },
  { 554, 1, 12, 7, 3, -10 },
  { 556, 5, 12, 7, 1, -10 },
  { 564, 6, 2, 7, 1, -5 },
};

const GFXfont UbuntuSansMono_Regular13pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular13pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular13pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUSANSMONO_REGULAR13PT7B_H_
