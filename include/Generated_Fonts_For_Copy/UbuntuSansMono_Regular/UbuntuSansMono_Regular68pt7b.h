#ifndef _UBUNTUSANSMONO_REGULAR68PT7B_H_
#define _UBUNTUSANSMONO_REGULAR68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0xFC, 0x7F, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xF0,
  0x78, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70,
  0x06, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x01, 0xC1,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE8, 0x00, 0x00, 0x3F, 0x30, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x43, 0xFE, 0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x00, 0x3E,
  0x3F, 0x3E, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x3C, 0x00,
  0x7C, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0xF0, 0x1F,
  0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x1E, 0x0F, 0x80,
  0x3C, 0x03, 0xC3, 0xE0, 0x07, 0x80, 0xF8, 0x7C, 0x00, 0xF0, 0x1E, 0x1F,
  0x00, 0x1F, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0xF8, 0x00, 0x3E, 0x1E,
  0x3E, 0x00, 0x03, 0xFF, 0xC7, 0xC0, 0x00, 0x3F, 0xF1, 0xF0, 0x00, 0x03,
  0xFC, 0x3E, 0x00, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x03, 0xE3,
  0xFF, 0x80, 0x00, 0xF8, 0xFF, 0xF0, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x07,
  0xC7, 0xC1, 0xE0, 0x01, 0xF0, 0xF0, 0x3E, 0x00, 0x3E, 0x1E, 0x03, 0xC0,
  0x0F, 0x87, 0xC0, 0x78, 0x03, 0xE0, 0xF8, 0x0F, 0x00, 0x7C, 0x1E, 0x01,
  0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x3E, 0x03, 0xC1, 0xF0,
  0x03, 0xC0, 0x78, 0x3E, 0x00, 0x78, 0x0F, 0x0F, 0x80, 0x0F, 0x83, 0xE1,
  0xE0, 0x01, 0xF0, 0x78, 0x7C, 0x00, 0x1F, 0xBF, 0x1F, 0x00, 0x01, 0xFF,
  0xC7, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0xF8, 0x07, 0xFF, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x3C, 0x07, 0xE7, 0xE0,
  0x1E, 0x03, 0xE1, 0xF8, 0x0F, 0x03, 0xF0, 0xFE, 0x07, 0x83, 0xF0, 0x3F,
  0x87, 0xC1, 0xF8, 0x0F, 0xE3, 0xE0, 0xF8, 0x03, 0xF9, 0xE0, 0xFC, 0x00,
  0xFE, 0xF0, 0x7E, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x0F, 0xF8, 0x1F, 0x00,
  0x03, 0xFC, 0x0F, 0x80, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0x07, 0xF8, 0x3F, 0xDF, 0x83,
  0xFF, 0xFF, 0xC7, 0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x03,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x06, 0x00, 0xF0, 0x06, 0x78, 0x0F,
  0x01, 0xE7, 0xE0, 0xF0, 0x7E, 0xFF, 0xCF, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01,
  0xE0, 0x01, 0x80, 0x18, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0xE1, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x01, 0xF0, 0x3F, 0xFC,
  0x0F, 0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x07,
  0xFC, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC0, 0xFE,
  0x0F, 0xFF, 0x01, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xE7, 0xC0, 0x1F, 0xF8, 0xF8, 0x01, 0xFC, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0x7C, 0x00, 0x1F, 0xC7, 0x00, 0x00, 0xFC, 0x20, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xF8,
  0x38, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x60, 0x00, 0x1F, 0xC7, 0x80, 0x07,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC4, 0x00, 0x03, 0xFC, 0xF8, 0x00, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x3C, 0x00, 0x1F, 0x9F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xBF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x07,
  0xF0, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF0, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7E, 0x0F, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0x80, 0x0F,
  0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x1F, 0xF0,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xBE, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x9F, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC7, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xF8,
  0x78, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87,
  0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F,
  0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0x8C, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xBF, 0x7E, 0x00, 0x1F,
  0xFF, 0x7C, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0,
  0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80,
  0x3F, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x3F, 0x00,
  0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x1F, 0x00,
  0x3F, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x1F, 0x00, 0x3F, 0xFC, 0x1F, 0x00,
  0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x0F, 0xC0,
  0x3F, 0x7E, 0x0F, 0xC0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x7E, 0x03, 0xFF,
  0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0x3F, 0x00, 0x7F,
  0xFC, 0x3F, 0x80, 0x03, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF3, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83,
  0xE0, 0x03, 0xFF, 0x0F, 0x80, 0x03, 0xFC, 0x3E, 0x00, 0x03, 0xF8, 0xF8,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x01, 0xFE, 0x3E, 0x00,
  0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x03, 0xFB, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xFF, 0x3E, 0x00,
  0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0x81, 0xFE, 0x00, 0x06, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x30, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x7F, 0xE0, 0x3E, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x0F, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x3F, 0x83, 0xE0, 0x01,
  0xFE, 0x07, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0x01, 0xFE, 0x00, 0x06,
  0x03, 0xF0, 0x00, 0x04, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0xE0, 0x00, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xF0, 0x03, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x20, 0x00, 0x0F,
  0xC3, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0xFC, 0x7F, 0x80,
  0x00, 0xFC, 0x3F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0,
  0x07, 0xFC, 0x3D, 0xE0, 0x07, 0xBC, 0x3D, 0xF0, 0x07, 0xBC, 0x3D, 0xF0,
  0x0F, 0xBC, 0x3C, 0xF0, 0x0F, 0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x3C, 0xF8,
  0x1F, 0x3E, 0x3C, 0x78, 0x1E, 0x3E, 0x3C, 0x78, 0x1E, 0x3E, 0x3C, 0x7C,
  0x3E, 0x3E, 0x7C, 0x3C, 0x3C, 0x3E, 0x7C, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E,
  0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x3E, 0x7C, 0x1E, 0x78, 0x3E, 0x7C, 0x0F,
  0x78, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x7C, 0x07,
  0xF0, 0x3E, 0x7C, 0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x7C, 0x03,
  0xE0, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xE0, 0x00, 0x7F,
  0xEF, 0xC0, 0x01, 0xFF, 0x9F, 0x00, 0x07, 0xFE, 0x7E, 0x00, 0x1F, 0xF8,
  0xF8, 0x00, 0x7F, 0xE3, 0xF0, 0x01, 0xFF, 0x87, 0xC0, 0x07, 0xFE, 0x1F,
  0x80, 0x1F, 0xF8, 0x3E, 0x00, 0x7F, 0xE0, 0xFC, 0x01, 0xFF, 0x81, 0xF0,
  0x07, 0xFE, 0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3F, 0x01,
  0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x03, 0xE0, 0x7F,
  0xE0, 0x0F, 0x81, 0xFF, 0x80, 0x1F, 0x07, 0xFE, 0x00, 0x7C, 0x1F, 0xF8,
  0x00, 0xF8, 0x7F, 0xE0, 0x03, 0xE1, 0xFF, 0x80, 0x07, 0xC7, 0xFE, 0x00,
  0x1F, 0x1F, 0xF8, 0x00, 0x7C, 0x7F, 0xE0, 0x00, 0xF9, 0xFF, 0x80, 0x03,
  0xE7, 0xFE, 0x00, 0x07, 0xDF, 0xF8, 0x00, 0x1F, 0x7F, 0xE0, 0x00, 0x3D,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F,
  0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F,
  0xEF, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x03, 0xE0, 0xFE,
  0x00, 0x02, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF2, 0x00, 0x00, 0x1F, 0x9C, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x7C,
  0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x7C,
  0x0F, 0xF0, 0x3E, 0x7C, 0x1E, 0xF8, 0x3E, 0x7C, 0x1E, 0x78, 0x3E, 0x7C,
  0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C, 0x3E, 0x7C,
  0x3C, 0x3C, 0x3E, 0x7C, 0x7C, 0x3E, 0x3C, 0x7C, 0x78, 0x1E, 0x3C, 0x7C,
  0x78, 0x1E, 0x3C, 0x3C, 0xF8, 0x1F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C, 0x3C,
  0xF0, 0x0F, 0x3C, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xE0, 0x07, 0xBC, 0x3D,
  0xE0, 0x07, 0xBC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xDC, 0x00, 0x00,
  0x1E, 0x10, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x06, 0x01, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x18, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0x7F, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xFC,
  0x00, 0x3F, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC3, 0xFE,
  0x00, 0x3E, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xF8,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x7F, 0x1F, 0x00,
  0x07, 0xF0, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0xC0, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x43, 0xFF, 0x80, 0x1E,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xC3, 0xF0, 0x07, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xC3, 0xF0, 0x00,
  0xFF, 0x1F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x3F, 0x07, 0xFC, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x04, 0x03, 0xFF, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0xFC,
  0x7F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0xF9, 0xF8,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x3E, 0x7F, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x8F,
  0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xF7, 0xC0, 0x07, 0xFC, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x84, 0x00,
  0x01, 0xFC, 0x3C, 0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xC0, 0x01, 0xFC, 0xF8, 0x00, 0x1F,
  0x9F, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x20, 0x00, 0xFF, 0x03, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x80, 0x03,
  0xF9, 0xE0, 0x0F, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x2F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80,
  0xF8, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x3E,
  0x03, 0xF8, 0x00, 0xF8, 0x3F, 0x80, 0x03, 0xE1, 0xFC, 0x00, 0x0F, 0x8F,
  0xE0, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFB, 0xFE, 0x00,
  0x03, 0xE7, 0xFC, 0x00, 0x0F, 0x87, 0xF8, 0x00, 0x3E, 0x0F, 0xF0, 0x00,
  0xF8, 0x1F, 0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x3E,
  0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFE, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0x80,
  0x03, 0xF8, 0x3E, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0x1F, 0xCF, 0x80, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01,
  0xFC, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x03, 0xF8,
  0x0E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xC0,
  0x7F, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x3F, 0xF8, 0xFE, 0xFC, 0x07, 0xF0, 0x7E, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F,
  0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F,
  0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F,
  0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F,
  0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xF8, 0x01, 0xFF, 0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFE, 0xF8,
  0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0xC3,
  0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xE7, 0xC0,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFE, 0x7E,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xF3, 0xFF, 0xE0,
  0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x03, 0xE3, 0xF8, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0x00,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF9, 0xF0, 0x00,
  0xFE, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x3E, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x18, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF4, 0x00, 0x00, 0x3F, 0x70, 0x00, 0x07, 0xE7, 0xE0,
  0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x10, 0x03, 0xFC, 0x03, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x3E, 0x7F, 0x00, 0x07, 0xC7, 0xFC, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x01, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC0, 0x3E,
  0x7C, 0x03, 0xF8, 0x0F, 0x9F, 0x80, 0xFE, 0x03, 0xE3, 0xE0, 0x7F, 0x80,
  0xF8, 0xF8, 0x1F, 0xF0, 0x7C, 0x3E, 0x07, 0xFC, 0x1F, 0x0F, 0x83, 0xCF,
  0x07, 0xC3, 0xE0, 0xF3, 0xE1, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x1F, 0x1E,
  0x1E, 0x1F, 0x07, 0xC7, 0x87, 0xCF, 0x81, 0xF3, 0xE0, 0xF3, 0xE0, 0x7C,
  0xF0, 0x3C, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x01, 0xEF, 0x80,
  0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07,
  0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0B, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x08,
  0x0F, 0xFE, 0x00, 0x0F, 0x1F, 0xFF, 0x00, 0x1F, 0x3F, 0xFF, 0xC0, 0x1E,
  0x3E, 0x1F, 0xF0, 0x3E, 0x7C, 0x07, 0xFC, 0x7C, 0x78, 0x03, 0xFF, 0xFC,
  0xF0, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0xF0, 0x10, 0x00, 0x1F, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 10, 48, 38, 14, -47 },
  { 61, 16, 18, 38, 11, -52 },
  { 97, 34, 47, 38, 2, -47 },
  { 297, 29, 60, 38, 5, -53 },
  { 515, 35, 49, 38, 2, -48 },
  { 730, 33, 49, 38, 3, -48 },
  { 933, 6, 20, 38, 16, -52 },
  { 948, 20, 66, 38, 9, -53 },
  { 1113, 20, 66, 38, 9, -53 },
  { 1278, 28, 27, 38, 5, -47 },
  { 1373, 31, 34, 38, 4, -37 },
  { 1505, 15, 21, 38, 12, -10 },
  { 1545, 16, 5, 38, 11, -22 },
  { 1555, 10, 11, 38, 14, -10 },
  { 1569, 26, 66, 38, 6, -53 },
  { 1784, 30, 49, 38, 4, -48 },
  { 1968, 27, 47, 38, 6, -47 },
  { 2127, 28, 48, 38, 5, -48 },
  { 2295, 28, 49, 38, 5, -48 },
  { 2467, 32, 47, 38, 3, -47 },
  { 2655, 28, 48, 38, 6, -47 },
  { 2823, 30, 48, 38, 4, -47 },
  { 3003, 30, 47, 38, 5, -47 },
  { 3180, 30, 49, 38, 4, -48 },
  { 3364, 30, 48, 38, 4, -48 },
  { 3544, 10, 36, 38, 14, -35 },
  { 3589, 15, 46, 38, 10, -35 },
  { 3676, 31, 29, 38, 4, -34 },
  { 3789, 31, 20, 38, 4, -30 },
  { 3867, 31, 29, 38, 4, -34 },
  { 3980, 23, 49, 38, 8, -48 },
  { 4121, 32, 58, 38, 4, -48 },
  { 4353, 36, 47, 38, 1, -47 },
  { 4565, 30, 48, 38, 4, -48 },
  { 4745, 31, 49, 38, 4, -48 },
  { 4935, 31, 48, 38, 4, -48 },
  { 5121, 27, 47, 38, 8, -47 },
  { 5280, 26, 47, 38, 8, -47 },
  { 5433, 31, 49, 38, 4, -48 },
  { 5623, 32, 47, 38, 3, -47 },
  { 5811, 22, 47, 38, 8, -47 },
  { 5941, 28, 48, 38, 4, -47 },
  { 6109, 32, 47, 38, 5, -47 },
  { 6297, 28, 47, 38, 7, -47 },
  { 6462, 32, 47, 38, 3, -47 },
  { 6650, 30, 47, 38, 4, -47 },
  { 6827, 34, 49, 38, 2, -48 },
  { 7036, 28, 48, 38, 6, -48 },
  { 7204, 34, 60, 38, 2, -48 },
  { 7459, 31, 48, 38, 4, -48 },
  { 7645, 29, 49, 38, 5, -48 },
  { 7823, 32, 47, 38, 3, -47 },
  { 8011, 30, 48, 38, 4, -47 },
  { 8191, 36, 47, 38, 1, -47 },
  { 8403, 32, 47, 38, 3, -47 },
  { 8591, 34, 47, 38, 2, -47 },
  { 8791, 36, 47, 38, 1, -47 },
  { 9003, 31, 47, 38, 4, -47 },
  { 9186, 17, 66, 38, 12, -53 },
  { 9327, 26, 66, 38, 6, -53 },
  { 9542, 18, 66, 38, 9, -53 },
  { 9691, 30, 25, 38, 4, -47 },
  { 9785, 36, 5, 38, 1, 8 },
  { 9808, 11, 13, 38, 13, -53 },
  { 9826, 28, 37, 38, 5, -36 },
  { 9956, 29, 54, 38, 6, -53 },
  { 10152, 30, 37, 38, 4, -36 },
  { 10291, 30, 54, 38, 3, -53 },
  { 10494, 31, 37, 38, 3, -36 },
  { 10638, 32, 53, 38, 5, -53 },
  { 10850, 29, 49, 38, 3, -36 },
  { 11028, 27, 53, 38, 6, -53 },
  { 11207, 30, 52, 38, 4, -51 },
  { 11402, 23, 64, 38, 6, -51 },
  { 11586, 30, 53, 38, 6, -53 },
  { 11785, 30, 53, 38, 4, -52 },
  { 11984, 32, 36, 38, 3, -36 },
  { 12128, 27, 36, 38, 6, -36 },
  { 12250, 32, 37, 38, 3, -36 },
  { 12398, 29, 49, 38, 6, -36 },
  { 12576, 29, 49, 38, 3, -36 },
  { 12754, 24, 36, 38, 9, -36 },
  { 12862, 28, 37, 38, 5, -36 },
  { 12992, 29, 47, 38, 5, -46 },
  { 13163, 27, 36, 38, 5, -35 },
  { 13285, 32, 35, 38, 3, -35 },
  { 13425, 34, 35, 38, 2, -35 },
  { 13574, 34, 35, 38, 2, -35 },
  { 13723, 32, 48, 38, 3, -35 },
  { 13915, 26, 35, 38, 6, -35 },
  { 14029, 26, 66, 38, 6, -53 },
  { 14244, 4, 66, 38, 17, -53 },
  { 14277, 26, 66, 38, 6, -53 },
  { 14492, 32, 10, 38, 3, -25 },
};

const GFXfont UbuntuSansMono_Regular68pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular68pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular68pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _UBUNTUSANSMONO_REGULAR68PT7B_H_
