#ifndef _UBUNTUSANSMONO_REGULAR6PT7B_H_
#define _UBUNTUSANSMONO_REGULAR6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xE0, 0x57, 0x1E, 0x80, 0xF9, 0xD0, 0xEA, 0xF0,
  0xC0, 0x6A, 0xB0, 0xA5, 0x60, 0xEC, 0x5D, 0x00, 0xC0, 0x80, 0x80, 0x25,
  0x25, 0x00, 0xFE, 0xF0, 0xAB, 0xE5, 0x70, 0x6C, 0xF0, 0x2F, 0x90, 0xE7,
  0x7A, 0xF0, 0xE5, 0x20, 0xFE, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0, 0x38, 0x80,
  0xFC, 0xCE, 0x00, 0xDA, 0xF7, 0xD6, 0x57, 0xD0, 0xFE, 0xF0, 0xF2, 0x30,
  0xF6, 0xF0, 0xFB, 0xFA, 0xF2, 0xB0, 0xBE, 0xD0, 0xEB, 0x64, 0xF0, 0xBB,
  0x50, 0xAB, 0xBE, 0xD0, 0xBE, 0xD0, 0xF6, 0xF0, 0xFA, 0xF6, 0xD6, 0xF7,
  0xD0, 0xE8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0xB5, 0xA0, 0xBE, 0xD0, 0xA9,
  0x50, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xB0, 0xAA, 0x50, 0xFC, 0x54, 0xE0,
  0xC0, 0x6F, 0x80, 0x93, 0xDE, 0xF1, 0x80, 0x27, 0xDE, 0xFF, 0x80, 0x2B,
  0xA4, 0xF5, 0xF0, 0x93, 0xDA, 0x43, 0x26, 0x4D, 0x70, 0x92, 0xEA, 0xC9,
  0x26, 0xFE, 0x80, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8,
  0xEB, 0x80, 0x5D, 0x30, 0xB7, 0x80, 0xAD, 0x00, 0xBE, 0x80, 0xEA, 0x80,
  0xAD, 0x60, 0x6B, 0x80, 0x6A, 0xB0, 0xFC, 0xA9, 0xA0, 0xE0,
};

const GFXglyph UbuntuSansMono_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 4, 3, 1, -4 },
  { 2, 1, 2, 3, 1, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 3, 4, 3, 0, -4 },
  { 10, 3, 4, 3, 0, -4 },
  { 12, 1, 2, 3, 1, -5 },
  { 13, 2, 6, 3, 1, -5 },
  { 15, 2, 6, 3, 1, -5 },
  { 17, 3, 2, 3, 0, -4 },
  { 18, 3, 3, 3, 0, -3 },
  { 20, 1, 2, 3, 1, -1 },
  { 21, 1, 1, 3, 1, -2 },
  { 22, 1, 1, 3, 1, -1 },
  { 23, 3, 6, 3, 0, -5 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 1, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 2, 4, 3, 1, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 3, 1, -3 },
  { 45, 1, 4, 3, 1, -3 },
  { 46, 3, 3, 3, 0, -3 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -3 },
  { 51, 2, 4, 3, 1, -4 },
  { 52, 3, 5, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 2, 4, 3, 1, -4 },
  { 63, 2, 4, 3, 1, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 2, 4, 3, 1, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 2, 4, 3, 1, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 2, 4, 3, 1, -4 },
  { 81, 3, 5, 3, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 2, 6, 3, 1, -5 },
  { 103, 2, 6, 3, 1, -5 },
  { 105, 1, 6, 3, 1, -5 },
  { 106, 3, 2, 3, 0, -4 },
  { 107, 3, 1, 3, 0, 0 },
  { 108, 1, 2, 3, 1, -5 },
  { 109, 3, 3, 3, 0, -3 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 3, 4, 3, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 3, 5, 3, 0, -5 },
  { 127, 2, 6, 3, 1, -5 },
  { 129, 3, 5, 3, 0, -5 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 3, 3, 3, 0, -3 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 3, 3, 3, 0, -3 },
  { 139, 3, 4, 3, 0, -3 },
  { 141, 3, 4, 3, 0, -3 },
  { 143, 2, 3, 3, 1, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 4, 3, 0, -4 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 3, 3, 3, 0, -3 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 3, 4, 3, 0, -3 },
  { 158, 3, 3, 3, 0, -3 },
  { 160, 2, 6, 3, 1, -5 },
  { 162, 1, 6, 3, 1, -5 },
  { 163, 2, 6, 3, 1, -5 },
  { 165, 3, 1, 3, 0, -2 },
};

const GFXfont UbuntuSansMono_Regular6pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular6pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _UBUNTUSANSMONO_REGULAR6PT7B_H_
