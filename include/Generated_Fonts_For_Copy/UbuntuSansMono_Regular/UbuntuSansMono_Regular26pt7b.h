#ifndef _UBUNTUSANSMONO_REGULAR26PT7B_H_
#define _UBUNTUSANSMONO_REGULAR26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x62, 0x00, 0x07, 0xF7, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x40, 0x0C, 0x30, 0x63, 0x03, 0x18, 0x18, 0xC1, 0x86,
  0x7F, 0xFC, 0x63, 0x83, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x31, 0xFF, 0xFF,
  0xFF, 0x98, 0xC0, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x30, 0x1F, 0xE7, 0xFD, 0xC0, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0xFC, 0x3B, 0xFE,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x78, 0x3E, 0x41, 0xA3, 0x19, 0x18,
  0x88, 0xCC, 0x46, 0xC3, 0x36, 0x1F, 0x60, 0x22, 0x00, 0x33, 0x03, 0x3C,
  0x1B, 0x31, 0x91, 0x88, 0x8C, 0xC4, 0x6C, 0x33, 0x61, 0x9E, 0x07, 0x80,
  0x1F, 0x01, 0xDC, 0x1C, 0x60, 0xC1, 0x06, 0x18, 0x18, 0xC0, 0xCC, 0x03,
  0xC0, 0x1C, 0x31, 0xF1, 0x19, 0x89, 0xC6, 0xCC, 0x1E, 0x60, 0xE3, 0x03,
  0x9C, 0x3C, 0x7F, 0xB1, 0xF9, 0xC0, 0xFF, 0xFD, 0x02, 0x07, 0x0E, 0x1C,
  0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0x60, 0x60, 0x60,
  0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x02, 0xC1, 0xC1, 0xC1,
  0x83, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C,
  0x18, 0x70, 0xC3, 0x8E, 0x38, 0x60, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x66,
  0x6F, 0xFE, 0x3E, 0x03, 0x80, 0xD8, 0x33, 0x8E, 0x30, 0x84, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x33, 0xDE, 0xF1, 0x9B, 0x98,
  0xFF, 0xF0, 0x6F, 0xF7, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x00,
  0x1F, 0x83, 0xDC, 0x30, 0xE6, 0x06, 0x60, 0x76, 0x03, 0x60, 0x3E, 0x73,
  0xE7, 0x3E, 0x73, 0xE0, 0x36, 0x03, 0x60, 0x36, 0x07, 0x70, 0x63, 0x0E,
  0x3D, 0xC1, 0xF8, 0x06, 0x01, 0xC0, 0x78, 0x7B, 0x06, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x7F, 0xEF, 0xFC, 0x7F, 0x1E, 0xF3, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18,
  0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0x1E, 0xF1, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x60, 0x78, 0x1F, 0x00, 0x70, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0xFF, 0xDF, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x0D,
  0x80, 0xCC, 0x06, 0x60, 0x63, 0x06, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x31,
  0x81, 0x8F, 0xFF, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x3F, 0xC7, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0xF0, 0x7F,
  0x80, 0x78, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x38, 0x06, 0xF7, 0xDF,
  0xE0, 0x03, 0xC1, 0xF8, 0x70, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0xF8,
  0xFF, 0xD8, 0x1B, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1B, 0x06, 0x71,
  0xC7, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x3F, 0x8E, 0x3B, 0x83, 0x60, 0x6C, 0x07, 0x81, 0xB8,
  0x33, 0x8C, 0x3F, 0x07, 0xF1, 0x87, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xF3, 0xC7, 0xF0, 0x3F, 0x0E, 0x73, 0x83, 0x60, 0x6C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xE0, 0xEF, 0xFC, 0x79, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x38, 0xFE, 0x1F, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x6F, 0xF7,
  0x33, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x0C, 0xF7, 0x9C, 0x67, 0xF6, 0x00,
  0x00, 0x30, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x30, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xC0, 0x78, 0x7C, 0x3E, 0x1E, 0x03, 0x00, 0x00, 0xFE, 0x63, 0x80, 0xE0,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x38, 0x1C, 0x00, 0x0F, 0xC0, 0xE7, 0x0E, 0x0C, 0x60, 0x66,
  0x03, 0x30, 0x0D, 0x87, 0xEC, 0x73, 0xE6, 0x1F, 0x30, 0xF9, 0x87, 0xCC,
  0x3E, 0x61, 0xB3, 0x0D, 0x9C, 0x6C, 0x7F, 0x70, 0xE1, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x6C, 0x01, 0xB0,
  0x0C, 0xC0, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18, 0x30, 0x60, 0xC3, 0x03,
  0x0F, 0xFE, 0x3F, 0xF9, 0x80, 0x66, 0x01, 0x98, 0x03, 0x60, 0x0F, 0x00,
  0x30, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x76, 0x3C,
  0xFF, 0x18, 0xFB, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x06, 0xFF,
  0xDF, 0xE0, 0x1F, 0xE7, 0x9D, 0xC0, 0xB0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x3F, 0xE3, 0xFC, 0xFE, 0x1F, 0xE3, 0x06, 0x60, 0x6C, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x36,
  0x0C, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x00, 0x1F, 0xE7, 0x9D, 0xC0, 0xB0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD8, 0x1B, 0x83,
  0x3C, 0xE3, 0xFC, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xC6, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x07, 0xF7,
  0xBF, 0xC0, 0xC0, 0x7C, 0x0E, 0xC1, 0xCC, 0x38, 0xC3, 0x0C, 0x60, 0xCC,
  0x0D, 0x80, 0xF8, 0x0F, 0xC0, 0xCE, 0x0C, 0x70, 0xC3, 0x8C, 0x1C, 0xC0,
  0xCC, 0x0E, 0xC0, 0x7C, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0xFF, 0xF0, 0x70, 0x63, 0x83, 0x1C, 0x3C, 0xF1, 0xE5, 0x8B,
  0x2C, 0xD9, 0x26, 0xC9, 0xA6, 0x45, 0x36, 0x39, 0xB1, 0x8D, 0x80, 0x6C,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xC0, 0xC0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xB0, 0xF6, 0x1E, 0x63, 0xCC, 0x78, 0xCF,
  0x19, 0xE1, 0xBC, 0x37, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1C, 0x1F,
  0xC1, 0xCF, 0x1C, 0x18, 0xC0, 0x6E, 0x03, 0x60, 0x1B, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0x70, 0x19, 0x80, 0xCE,
  0x0C, 0x39, 0xE0, 0xFC, 0x00, 0xFF, 0x1F, 0xFB, 0x03, 0x60, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xDF, 0xFB, 0xFC, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x1F, 0xC1, 0xCF, 0x1C, 0x18, 0xC0,
  0x6E, 0x03, 0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0x70, 0x19, 0x80, 0xCE, 0x0C, 0x39, 0xE0, 0xFC, 0x01,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x80, 0xFF, 0x1F, 0xF3, 0x07,
  0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0x9F, 0xE3, 0xF8, 0x61,
  0x8C, 0x31, 0x83, 0x30, 0x66, 0x06, 0xC0, 0xF8, 0x0C, 0x3F, 0xCF, 0x79,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x06, 0xF7, 0xDF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x37,
  0x06, 0x3D, 0xE1, 0xFC, 0xE0, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x06, 0x30,
  0x18, 0xC0, 0x63, 0x03, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x03,
  0x18, 0x0C, 0x60, 0x33, 0x00, 0x6C, 0x01, 0xB0, 0x07, 0x80, 0x0E, 0x00,
  0xC0, 0x3E, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0xC6, 0xC7, 0x32, 0x79, 0x93, 0x4C, 0x93, 0x65, 0x9B, 0x2C, 0x59, 0x43,
  0xCE, 0x1C, 0x70, 0x63, 0x83, 0x00, 0xE0, 0x33, 0x03, 0x8C, 0x18, 0x61,
  0x81, 0x8C, 0x0C, 0xC0, 0x36, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x60,
  0x33, 0x03, 0x8C, 0x18, 0x71, 0xC1, 0x8C, 0x0E, 0x60, 0x36, 0x01, 0xC0,
  0xE0, 0x0D, 0x80, 0x77, 0x01, 0x8C, 0x0E, 0x38, 0x30, 0x61, 0xC1, 0xC6,
  0x03, 0x38, 0x06, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFE, 0xE0, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0x06, 0x00,
  0xF0, 0x0D, 0x81, 0x98, 0x18, 0xC3, 0x0C, 0x30, 0x66, 0x06, 0xE0, 0x34,
  0x02, 0xFF, 0xFF, 0xFF, 0xF0, 0xCE, 0x63, 0x10, 0x3E, 0x0F, 0xF1, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xCF, 0xFB, 0xFF, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x77, 0x9E, 0x7F, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x33, 0x87, 0xFC, 0xE1, 0xD8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0xFE, 0x7F, 0x80, 0x03, 0xE1, 0xFF, 0x3C,
  0x17, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x80, 0x3F, 0xF0, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC3, 0xD8, 0xFF, 0x38, 0xEC, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1B, 0x03, 0x60, 0x6E, 0x0C, 0xFF, 0x8F, 0xF0, 0x07, 0x01, 0xFC,
  0x38, 0xE6, 0x07, 0x60, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x3F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x0F, 0xFC, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0F, 0xC7, 0xFC, 0xE1, 0xB0, 0x36, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x7C, 0x0D, 0x81, 0xBC, 0x73, 0xFE, 0x0E, 0xC0, 0x18, 0x03, 0x40, 0xEF,
  0xF8, 0xFC, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x37,
  0x87, 0xFC, 0xE1, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x70, 0x18, 0x07, 0x80, 0xF0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0x83, 0xF0, 0x03,
  0x03, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0xFE, 0x7F, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0D,
  0x0F, 0xFE, 0x7E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x2C, 0x0C, 0xC1, 0x8C, 0x30, 0xCE, 0x0D, 0xC0, 0xF8, 0x0F,
  0xC0, 0xCE, 0x0C, 0x70, 0xC3, 0x8C, 0x1C, 0xC0, 0xEC, 0x07, 0xFC, 0x1F,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F,
  0x83, 0xF0, 0x78, 0xCF, 0xFF, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x3E,
  0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0x0F, 0x01, 0xFC, 0x38, 0xE6,
  0x06, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x03, 0x60, 0x77,
  0x06, 0x3F, 0xC1, 0xF8, 0x3E, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x6F, 0xFD, 0xFE, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x07, 0x83, 0xFC, 0xE1, 0xB8,
  0x36, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0D, 0x81, 0xB8, 0x33,
  0xFE, 0x3F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x1F, 0xFF,
  0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x0F, 0x8F, 0xF9, 0x81, 0x60, 0x0C, 0x00, 0xE0,
  0x0F, 0x00, 0xFC, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x6F, 0xFD, 0xFF, 0x00,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xFF, 0xC6, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xE1,
  0xFC, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x36, 0x0D, 0xFF, 0x3F, 0xC0, 0xE0, 0x3B, 0x01, 0x98, 0x1C, 0xC0,
  0xC3, 0x06, 0x18, 0x70, 0xE3, 0x03, 0x18, 0x19, 0x80, 0x6C, 0x03, 0xC0,
  0x0E, 0x00, 0x60, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x8C, 0x2C, 0x73,
  0x63, 0x99, 0xB4, 0xCD, 0xB6, 0x69, 0xB3, 0xC5, 0x1C, 0x38, 0xE0, 0xC3,
  0x06, 0x00, 0xE0, 0x71, 0x87, 0x0E, 0x30, 0x3B, 0x00, 0xF8, 0x03, 0x80,
  0x1C, 0x01, 0xB0, 0x19, 0xC1, 0xC6, 0x1C, 0x18, 0xC0, 0xEC, 0x03, 0x80,
  0x60, 0x36, 0x03, 0x70, 0x73, 0x06, 0x30, 0x63, 0x86, 0x18, 0xC1, 0x8C,
  0x0C, 0xC0, 0xD8, 0x07, 0x80, 0x78, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0xFC, 0x0F, 0x00, 0x7F, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0,
  0x60, 0x30, 0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC3, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x83, 0xE0, 0xF0,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x0F, 0x03, 0xC0, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x63, 0xF0, 0xF8, 0x00, 0x18, 0x07, 0xE1, 0x47, 0xFC,
  0x3E,
};

const GFXglyph UbuntuSansMono_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 18, 15, 5, -18 },
  { 10, 6, 7, 15, 4, -20 },
  { 16, 13, 18, 15, 1, -18 },
  { 46, 11, 23, 15, 2, -20 },
  { 78, 13, 18, 15, 1, -18 },
  { 108, 13, 18, 15, 1, -18 },
  { 138, 2, 8, 15, 6, -20 },
  { 140, 8, 25, 15, 3, -20 },
  { 165, 7, 25, 15, 4, -20 },
  { 187, 11, 11, 15, 2, -18 },
  { 203, 12, 13, 15, 1, -14 },
  { 223, 5, 8, 15, 5, -4 },
  { 228, 6, 2, 15, 4, -8 },
  { 230, 4, 4, 15, 5, -4 },
  { 232, 10, 25, 15, 2, -20 },
  { 264, 12, 18, 15, 1, -18 },
  { 291, 11, 18, 15, 2, -18 },
  { 316, 11, 18, 15, 2, -18 },
  { 341, 11, 18, 15, 2, -18 },
  { 366, 13, 18, 15, 1, -18 },
  { 396, 11, 18, 15, 2, -18 },
  { 421, 11, 18, 15, 2, -18 },
  { 446, 11, 18, 15, 2, -18 },
  { 471, 11, 18, 15, 2, -18 },
  { 496, 11, 18, 15, 2, -18 },
  { 521, 4, 14, 15, 5, -14 },
  { 528, 5, 18, 15, 4, -14 },
  { 540, 12, 11, 15, 1, -13 },
  { 557, 12, 7, 15, 1, -11 },
  { 568, 11, 11, 15, 2, -13 },
  { 584, 9, 18, 15, 3, -18 },
  { 605, 13, 22, 15, 1, -18 },
  { 641, 14, 18, 15, 0, -18 },
  { 673, 11, 18, 15, 2, -18 },
  { 698, 11, 18, 15, 2, -18 },
  { 723, 11, 18, 15, 2, -18 },
  { 748, 10, 18, 15, 3, -18 },
  { 771, 10, 18, 15, 3, -18 },
  { 794, 11, 18, 15, 2, -18 },
  { 819, 12, 18, 15, 1, -18 },
  { 846, 9, 18, 15, 3, -18 },
  { 867, 10, 18, 15, 2, -18 },
  { 890, 12, 18, 15, 2, -18 },
  { 917, 10, 18, 15, 3, -18 },
  { 940, 13, 18, 15, 1, -18 },
  { 970, 11, 18, 15, 2, -18 },
  { 995, 13, 18, 15, 1, -18 },
  { 1025, 11, 18, 15, 2, -18 },
  { 1050, 13, 23, 15, 1, -18 },
  { 1088, 11, 18, 15, 2, -18 },
  { 1113, 11, 18, 15, 2, -18 },
  { 1138, 12, 18, 15, 1, -18 },
  { 1165, 12, 18, 15, 1, -18 },
  { 1192, 14, 18, 15, 0, -18 },
  { 1224, 13, 18, 15, 1, -18 },
  { 1254, 13, 18, 15, 1, -18 },
  { 1284, 14, 18, 15, 0, -18 },
  { 1316, 11, 18, 15, 2, -18 },
  { 1341, 7, 25, 15, 4, -20 },
  { 1363, 10, 25, 15, 2, -20 },
  { 1395, 6, 25, 15, 4, -20 },
  { 1414, 12, 10, 15, 1, -18 },
  { 1429, 14, 2, 15, 0, 3 },
  { 1433, 4, 5, 15, 5, -20 },
  { 1436, 11, 14, 15, 2, -14 },
  { 1456, 11, 20, 15, 2, -20 },
  { 1484, 12, 14, 15, 1, -14 },
  { 1505, 11, 20, 15, 1, -20 },
  { 1533, 12, 14, 15, 1, -14 },
  { 1554, 12, 20, 15, 2, -20 },
  { 1584, 11, 19, 15, 1, -14 },
  { 1611, 11, 20, 15, 2, -20 },
  { 1639, 11, 20, 15, 2, -20 },
  { 1667, 9, 25, 15, 2, -20 },
  { 1696, 12, 20, 15, 2, -20 },
  { 1726, 11, 20, 15, 2, -20 },
  { 1754, 12, 14, 15, 1, -14 },
  { 1775, 11, 14, 15, 2, -14 },
  { 1795, 12, 14, 15, 1, -14 },
  { 1816, 11, 19, 15, 2, -14 },
  { 1843, 11, 19, 15, 1, -14 },
  { 1870, 10, 14, 15, 3, -14 },
  { 1888, 11, 14, 15, 2, -14 },
  { 1908, 11, 18, 15, 2, -18 },
  { 1933, 10, 13, 15, 2, -13 },
  { 1950, 13, 13, 15, 1, -13 },
  { 1972, 13, 13, 15, 1, -13 },
  { 1994, 13, 13, 15, 1, -13 },
  { 2016, 12, 18, 15, 1, -13 },
  { 2043, 10, 13, 15, 2, -13 },
  { 2060, 10, 25, 15, 2, -20 },
  { 2092, 2, 25, 15, 6, -20 },
  { 2099, 10, 25, 15, 2, -20 },
  { 2131, 12, 4, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_Regular26pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular26pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular26pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUSANSMONO_REGULAR26PT7B_H_
