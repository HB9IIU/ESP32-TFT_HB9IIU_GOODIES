#ifndef _UBUNTUSANSMONO_REGULAR63PT7B_H_
#define _UBUNTUSANSMONO_REGULAR63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xCF, 0xE1, 0xC0, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xEE, 0x03, 0xDC, 0x03, 0xB8, 0x06, 0x60, 0x0C,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x30, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE8, 0x00, 0x01,
  0xF9, 0xE0, 0x00, 0x7F, 0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x87, 0xFE, 0x00, 0x07,
  0x87, 0xFF, 0x80, 0x07, 0xC3, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0xF0, 0x03,
  0xC1, 0xE0, 0x78, 0x03, 0xE0, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x1E, 0x01,
  0xF0, 0x78, 0x07, 0x81, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0,
  0xF8, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0x80, 0x78, 0x7C, 0x01, 0xE0, 0x78,
  0x7C, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x3E, 0x00, 0x3E, 0x1F,
  0x1E, 0x00, 0x0F, 0x0F, 0x1F, 0x00, 0x07, 0xFF, 0x9F, 0x00, 0x01, 0xFF,
  0x8F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xC3, 0xFE, 0x00,
  0x03, 0xE3, 0xFF, 0x80, 0x01, 0xE3, 0xE7, 0xC0, 0x01, 0xF1, 0xE1, 0xF0,
  0x00, 0xF1, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF8, 0x78, 0x0F,
  0x00, 0x78, 0x3C, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0,
  0x3C, 0x1F, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x3E,
  0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x87, 0x80, 0x07, 0xCF, 0x87, 0xC0, 0x01,
  0xFF, 0xC7, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x3C, 0x03, 0xFF, 0x80, 0x78, 0x0F, 0xFF, 0x00, 0xF0, 0x1F,
  0x3F, 0x01, 0xE0, 0x7C, 0x3F, 0x03, 0xC1, 0xF8, 0x3F, 0x0F, 0x03, 0xE0,
  0x3F, 0x1E, 0x0F, 0xC0, 0x3F, 0x3C, 0x1F, 0x00, 0x7F, 0x78, 0x3E, 0x00,
  0x7F, 0xF0, 0x7C, 0x00, 0x7F, 0xC1, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03,
  0xFC, 0x1F, 0x80, 0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xF8, 0x3F, 0x81, 0xFD,
  0xF8, 0x3F, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0xFF, 0x03,
  0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEE, 0x73, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x20, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0x00, 0x78, 0x04, 0x7C, 0x0F, 0x07, 0xCF, 0xE1,
  0xE3, 0xF9, 0xFF, 0x39, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x01,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0x20, 0x02, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0,
  0x3F, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x01, 0xF0, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xCF, 0xFB, 0xFE,
  0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x0F,
  0x03, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x3F, 0x83, 0xFF, 0x83, 0xFC, 0x3F,
  0xF8, 0x3F, 0xC3, 0xFF, 0x83, 0xFC, 0x3F, 0xF8, 0x3F, 0x83, 0xFF, 0x81,
  0xF8, 0x3F, 0xF8, 0x0E, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xDF, 0x00, 0xFF, 0x1F, 0x00, 0xFE, 0x1F, 0x00, 0x78, 0x1F, 0x00,
  0x40, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0x00, 0x0F, 0xC1,
  0xC0, 0x00, 0xFC, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0x00, 0x7F, 0x83, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFA, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C,
  0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE4, 0x00, 0x03, 0xF9, 0xC0, 0x03, 0xFC, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x20, 0x00, 0x7C, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0x80,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7E,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFE, 0x00,
  0x7C, 0x0F, 0xE0, 0x1F, 0x00, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xEF, 0xFE, 0x03, 0xF0, 0x1F,
  0xF0, 0x7C, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0x7F, 0x00, 0x1F, 0xC7, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xCF,
  0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xCF, 0x80, 0x17, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xCF, 0xFB, 0xFE, 0xFF, 0xFF,
  0xEF, 0xF9, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F,
  0x3F, 0xEF, 0xFB, 0xFF, 0xFF, 0xBF, 0xE7, 0xF9, 0xFC, 0x1C, 0x00, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81,
  0xFE, 0x07, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x0F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7C, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x30, 0x03, 0xF9, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xFF, 0x7E, 0x00, 0xFF, 0xFD,
  0xF0, 0x07, 0xFF, 0xF7, 0xC0, 0x3F, 0xFF, 0xDF, 0x01, 0xFC, 0x1F, 0x7C,
  0x0F, 0xC0, 0x7D, 0xF0, 0x3E, 0x01, 0xF7, 0xC1, 0xF8, 0x07, 0xFF, 0x07,
  0xC0, 0x1F, 0xFC, 0x1F, 0x00, 0x7F, 0xF0, 0x7C, 0x01, 0xFF, 0xC3, 0xF0,
  0x07, 0xFF, 0x0F, 0xC0, 0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0xFC, 0x01,
  0xFF, 0xC1, 0xF0, 0x07, 0xDF, 0x07, 0xC0, 0x1F, 0x7C, 0x1F, 0x00, 0x7D,
  0xF0, 0x7C, 0x01, 0xF7, 0xE1, 0xF8, 0x07, 0xDF, 0x83, 0xE0, 0x1F, 0x7E,
  0x0F, 0xC0, 0x7C, 0xF8, 0x1F, 0xC1, 0xF3, 0xF0, 0x3F, 0xFF, 0xCF, 0xC0,
  0x7F, 0xFF, 0x3F, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xE1, 0xF0,
  0x00, 0xFE, 0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x07, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87,
  0xC0, 0x1F, 0xF8, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xBE, 0x00, 0x07, 0xF7, 0xC0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x3E, 0x07, 0xF0, 0x00, 0xE0,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x02, 0x07, 0xF8, 0x00, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0x1F,
  0xE0, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x7F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0x3E, 0x07, 0xF0, 0x00, 0xC0, 0xFC, 0x00, 0x04,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0xFE, 0x00, 0x1F, 0x07, 0xF8, 0x01, 0xF0, 0x3F, 0xF9, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF1, 0x00, 0x01, 0xF8,
  0xC0, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0x7F, 0x87, 0xFE, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xF0,
  0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0,
  0x7F, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0xF8, 0xFE,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3E, 0xFF, 0x00, 0x00, 0xF9, 0xFE, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x0F,
  0x83, 0xF8, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0x03, 0xE0,
  0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E,
  0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xFC, 0x0E, 0xF0, 0x07, 0xBC, 0x1D, 0xE0, 0x0F, 0x78,
  0x3B, 0xE0, 0x1E, 0xF0, 0x73, 0xC0, 0x3D, 0xE0, 0xE7, 0x80, 0xF3, 0xC3,
  0xCF, 0x81, 0xE7, 0x87, 0x8F, 0x03, 0xCF, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xF1, 0xE1, 0xF1, 0xE0, 0xF3, 0xC3, 0xE3, 0xC1, 0xEF, 0x07, 0xC7, 0x81,
  0xDE, 0x0F, 0x8F, 0x03, 0xFC, 0x1F, 0x1E, 0x07, 0xF0, 0x3E, 0x7C, 0x07,
  0xE0, 0x7C, 0xF8, 0x0F, 0xC0, 0xF9, 0xF0, 0x1F, 0x01, 0xF3, 0xE0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x7C,
  0x00, 0x3F, 0xEF, 0x80, 0x07, 0xFC, 0xF8, 0x00, 0xFF, 0x9F, 0x00, 0x1F,
  0xF1, 0xF0, 0x03, 0xFE, 0x3E, 0x00, 0x7F, 0xC3, 0xE0, 0x0F, 0xF8, 0x7C,
  0x01, 0xFF, 0x07, 0xC0, 0x3F, 0xE0, 0xF8, 0x07, 0xFC, 0x0F, 0x80, 0xFF,
  0x81, 0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0x3C,
  0x0F, 0xF8, 0x07, 0xC1, 0xFF, 0x00, 0x78, 0x3F, 0xE0, 0x0F, 0x87, 0xFC,
  0x01, 0xF0, 0xFF, 0x80, 0x1F, 0x1F, 0xF0, 0x03, 0xE3, 0xFE, 0x00, 0x3C,
  0x7F, 0xC0, 0x07, 0xCF, 0xF8, 0x00, 0x79, 0xFF, 0x00, 0x0F, 0xBF, 0xE0,
  0x00, 0xF7, 0xFC, 0x00, 0x1E, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xFE,
  0x3E, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x10,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xF8, 0x03, 0xFE, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0x07, 0xE0, 0x00, 0xC1, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF1, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x3F, 0x8F, 0xFC, 0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xF1,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C,
  0xF8, 0x0F, 0x80, 0xF9, 0xF0, 0x1F, 0x01, 0xF3, 0xE0, 0x7F, 0x03, 0xE7,
  0xC0, 0xFE, 0x07, 0xC7, 0x81, 0xFC, 0x0F, 0x8F, 0x07, 0xBC, 0x1F, 0x1E,
  0x0F, 0x78, 0x3C, 0x3C, 0x1E, 0xF0, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xF1, 0xE1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC3, 0xC7, 0x83, 0xC7, 0x87, 0x8F,
  0x07, 0x8F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x78, 0x0F, 0x3C, 0x3C, 0xF0,
  0x1E, 0x78, 0x79, 0xE0, 0x3C, 0xF0, 0x73, 0xC0, 0x3D, 0xE0, 0xEF, 0x00,
  0x7B, 0x81, 0xFE, 0x00, 0xF7, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0x81, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x10, 0x0C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3C, 0x06, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0E, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF1,
  0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x3F, 0x80,
  0x07, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0xFF, 0xC0, 0x1F, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x8F, 0x80,
  0x0F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x01,
  0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x60, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x7F, 0xF3, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0xE0, 0x01, 0xF0, 0xFF,
  0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFC, 0x7F, 0x00, 0x7F, 0x00, 0x18, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF,
  0x81, 0xFE, 0x3F, 0x80, 0x07, 0xCF, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F,
  0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xF0, 0x00,
  0x7C, 0x7F, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xC0, 0x01, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xF8, 0x1F, 0xE7, 0xC0,
  0x03, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x30, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF9, 0x80,
  0x1F, 0x9F, 0xEF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0xFE,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x9F, 0xC0, 0x00,
  0x7D, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xDF, 0xE0, 0x00, 0x3E, 0x7F, 0x80, 0x01, 0xF0, 0xFE,
  0x00, 0x0F, 0x83, 0xF8, 0x00, 0x7C, 0x0F, 0xE0, 0x03, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x3E,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x03,
  0xF8, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x06, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x3F, 0xF0, 0x7F, 0x83, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xF8, 0x1F, 0xC1, 0xFB, 0xE0, 0x3E, 0x03,
  0xEF, 0x80, 0xF8, 0x0F, 0xBE, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F,
  0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF8,
  0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x03,
  0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8,
  0x07, 0xFE, 0x03, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xE7, 0xC0, 0x03,
  0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0xE1, 0xF0,
  0x00, 0xFE, 0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x7E, 0x7F, 0x00, 0x1F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xF9, 0xFF, 0xE0, 0x1F, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0xFE, 0x3F, 0xC0, 0x07, 0xC7, 0xE0,
  0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x03,
  0xF0, 0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xF3, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xE3, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE8, 0x00, 0x01, 0xF7, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x0C, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x03, 0xC0, 0x3E, 0x78, 0x03,
  0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x3E, 0x7C, 0x07, 0xE0, 0x3C, 0x7C, 0x07,
  0xE0, 0x3C, 0x7C, 0x0F, 0xE0, 0x7C, 0x7C, 0x0F, 0xF0, 0x7C, 0x3C, 0x0E,
  0xF0, 0x7C, 0x3C, 0x1E, 0xF0, 0x7C, 0x3E, 0x1E, 0x78, 0x78, 0x3E, 0x3C,
  0x78, 0x78, 0x3E, 0x3C, 0x78, 0xF8, 0x3E, 0x3C, 0x3C, 0xF8, 0x1E, 0x78,
  0x3C, 0xF8, 0x1E, 0x78, 0x3C, 0xF8, 0x1E, 0x78, 0x1E, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x63, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0xFF,
  0xE0, 0x03, 0xCF, 0xFF, 0x80, 0x1E, 0x7F, 0xFF, 0x01, 0xF7, 0x81, 0xFE,
  0x0F, 0x3C, 0x07, 0xFF, 0xFB, 0xC0, 0x0F, 0xFF, 0x9E, 0x00, 0x1F, 0xF8,
  0x20, 0x00, 0x7F, 0x00,
};

const GFXglyph UbuntuSansMono_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 45, 35, 13, -44 },
  { 52, 15, 17, 35, 10, -48 },
  { 84, 31, 44, 35, 2, -44 },
  { 255, 27, 56, 35, 4, -49 },
  { 444, 33, 46, 35, 1, -45 },
  { 634, 31, 46, 35, 2, -45 },
  { 813, 5, 18, 35, 15, -48 },
  { 825, 19, 61, 35, 8, -49 },
  { 970, 18, 61, 35, 9, -49 },
  { 1108, 27, 26, 35, 4, -44 },
  { 1196, 29, 31, 35, 3, -34 },
  { 1309, 14, 19, 35, 11, -9 },
  { 1343, 15, 4, 35, 10, -20 },
  { 1351, 10, 10, 35, 13, -9 },
  { 1364, 25, 61, 35, 5, -49 },
  { 1555, 28, 46, 35, 4, -45 },
  { 1716, 24, 44, 35, 6, -44 },
  { 1848, 27, 45, 35, 4, -45 },
  { 2000, 26, 46, 35, 5, -45 },
  { 2150, 30, 44, 35, 3, -44 },
  { 2315, 26, 45, 35, 5, -44 },
  { 2462, 28, 45, 35, 4, -44 },
  { 2620, 27, 44, 35, 5, -44 },
  { 2769, 27, 46, 35, 4, -45 },
  { 2925, 27, 45, 35, 4, -45 },
  { 3077, 10, 33, 35, 13, -32 },
  { 3119, 14, 42, 35, 9, -32 },
  { 3193, 28, 28, 35, 4, -32 },
  { 3291, 29, 17, 35, 3, -27 },
  { 3353, 28, 28, 35, 4, -32 },
  { 3451, 21, 46, 35, 7, -45 },
  { 3572, 30, 55, 35, 3, -45 },
  { 3779, 34, 44, 35, 1, -44 },
  { 3966, 27, 44, 35, 4, -44 },
  { 4115, 28, 46, 35, 4, -45 },
  { 4276, 28, 44, 35, 4, -44 },
  { 4430, 25, 44, 35, 7, -44 },
  { 4568, 24, 44, 35, 7, -44 },
  { 4700, 28, 46, 35, 4, -45 },
  { 4861, 29, 44, 35, 3, -44 },
  { 5021, 21, 44, 35, 7, -44 },
  { 5137, 25, 45, 35, 4, -44 },
  { 5278, 30, 44, 35, 5, -44 },
  { 5443, 25, 44, 35, 7, -44 },
  { 5581, 31, 44, 35, 2, -44 },
  { 5752, 27, 44, 35, 4, -44 },
  { 5901, 31, 46, 35, 2, -45 },
  { 6080, 26, 44, 35, 6, -44 },
  { 6223, 31, 57, 35, 2, -45 },
  { 6444, 28, 44, 35, 4, -44 },
  { 6598, 27, 46, 35, 4, -45 },
  { 6754, 29, 44, 35, 3, -44 },
  { 6914, 28, 45, 35, 4, -44 },
  { 7072, 33, 44, 35, 1, -44 },
  { 7254, 31, 44, 35, 2, -44 },
  { 7425, 31, 44, 35, 2, -44 },
  { 7596, 33, 44, 35, 1, -44 },
  { 7778, 28, 44, 35, 4, -44 },
  { 7932, 16, 61, 35, 11, -49 },
  { 8054, 25, 61, 35, 5, -49 },
  { 8245, 17, 61, 35, 8, -49 },
  { 8375, 29, 24, 35, 3, -44 },
  { 8462, 34, 5, 35, 1, 7 },
  { 8484, 10, 12, 35, 12, -49 },
  { 8499, 26, 34, 35, 4, -33 },
  { 8610, 27, 50, 35, 5, -49 },
  { 8779, 28, 34, 35, 4, -33 },
  { 8898, 27, 50, 35, 3, -49 },
  { 9067, 29, 34, 35, 3, -33 },
  { 9191, 29, 49, 35, 5, -49 },
  { 9369, 27, 45, 35, 3, -33 },
  { 9521, 25, 49, 35, 5, -49 },
  { 9675, 27, 49, 35, 4, -48 },
  { 9841, 21, 60, 35, 6, -48 },
  { 9999, 29, 49, 35, 5, -49 },
  { 10177, 27, 50, 35, 4, -49 },
  { 10346, 30, 33, 35, 3, -33 },
  { 10470, 25, 33, 35, 5, -33 },
  { 10574, 29, 34, 35, 3, -33 },
  { 10698, 27, 45, 35, 5, -33 },
  { 10850, 27, 45, 35, 3, -33 },
  { 11002, 22, 33, 35, 8, -33 },
  { 11093, 25, 34, 35, 5, -33 },
  { 11200, 26, 44, 35, 5, -43 },
  { 11343, 25, 34, 35, 5, -33 },
  { 11450, 31, 33, 35, 2, -33 },
  { 11578, 32, 33, 35, 2, -33 },
  { 11710, 31, 33, 35, 2, -33 },
  { 11838, 29, 45, 35, 3, -33 },
  { 12002, 25, 33, 35, 5, -33 },
  { 12106, 24, 61, 35, 6, -49 },
  { 12289, 5, 61, 35, 15, -49 },
  { 12328, 24, 61, 35, 5, -49 },
  { 12511, 29, 9, 35, 3, -23 },
};

const GFXfont UbuntuSansMono_Regular63pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular63pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular63pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _UBUNTUSANSMONO_REGULAR63PT7B_H_
