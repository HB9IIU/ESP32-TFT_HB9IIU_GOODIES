#ifndef _UBUNTUSANSMONO_REGULAR47PT7B_H_
#define _UBUNTUSANSMONO_REGULAR47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE3, 0x8C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x7C, 0xC0, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0x70, 0x77, 0x07, 0x60, 0x76, 0x06, 0x60, 0x66, 0x06, 0x60, 0x60, 0x00,
  0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x1E,
  0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81,
  0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x01, 0xC7, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x40, 0x01, 0xF7, 0x80, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x0F, 0x3F, 0xC0, 0x1E, 0x79,
  0xC0, 0x1C, 0x70, 0xE0, 0x3C, 0xE0, 0xE0, 0x38, 0xE0, 0xE0, 0x78, 0xE0,
  0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xE0, 0xE0, 0xE1, 0xC0, 0xE0,
  0xE3, 0xC0, 0xF0, 0xE3, 0x80, 0x70, 0xE7, 0x00, 0x7B, 0xCF, 0x00, 0x3F,
  0xCE, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x79, 0xFC, 0x00, 0x73, 0xFE, 0x00, 0xF3, 0x8E, 0x00, 0xE7, 0x87, 0x01,
  0xC7, 0x07, 0x03, 0xC7, 0x07, 0x03, 0x87, 0x07, 0x07, 0x87, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x07, 0x07, 0x1E, 0x07, 0x07, 0x1C, 0x07, 0x87, 0x3C,
  0x03, 0x8E, 0x38, 0x03, 0xFE, 0x70, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x78, 0x01, 0xE0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0,
  0x01, 0xEF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x78,
  0x3F, 0xE0, 0xE0, 0xF3, 0xC1, 0xC3, 0xC3, 0xC3, 0x87, 0x83, 0xC7, 0x1E,
  0x07, 0xCE, 0x3C, 0x07, 0xF8, 0x78, 0x07, 0xF0, 0xF0, 0x07, 0xE1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x8F, 0x80, 0x7F, 0x0F, 0x83,
  0xEF, 0x0F, 0xFF, 0x9E, 0x0F, 0xFE, 0x1E, 0x0F, 0xF8, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x77, 0x66, 0x00, 0x10, 0x00, 0xE0, 0x07, 0x80, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x38,
  0x00, 0x40, 0x20, 0x00, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04,
  0x07, 0x02, 0x70, 0x70, 0xE7, 0xE7, 0x3F, 0xFF, 0xEF, 0xF7, 0xFF, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3D, 0xE0, 0x07, 0x9F,
  0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0x7C, 0x06, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0x83, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x7C, 0x7F, 0x07, 0xC0, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3E, 0x1F, 0x83, 0xE0, 0x3C, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x78, 0x3F, 0xC3, 0xE1, 0xFE, 0x3F, 0x0F, 0xF1, 0xF8,
  0x7F, 0x8F, 0xC3, 0xFC, 0x3C, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x78, 0xF8, 0x03, 0xC3, 0xC0, 0x3C, 0x0F, 0x03, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xDE, 0x07, 0xE3, 0xC0, 0x70, 0x78, 0x08, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF,
  0x8F, 0xC0, 0xFC, 0x70, 0x03, 0xC2, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xC0, 0xFC, 0x20, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE6, 0x00, 0x7E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0x9C,
  0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0x70, 0x1C, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70,
  0x70, 0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0xC0, 0x1F, 0xBF,
  0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x7C, 0x03, 0xDF, 0xFC,
  0x1F, 0xFF, 0xF8, 0xFF, 0x9F, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0x7D, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x73, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0,
  0x1E, 0x1F, 0x01, 0xF0, 0x7F, 0x7F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C,
  0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0x00, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x7C, 0x01, 0xE3, 0xE0,
  0x3C, 0x1F, 0x87, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1E,
  0x0F, 0xC3, 0xC0, 0x3E, 0x78, 0x01, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x3F, 0x9F, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0,
  0x7C, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0x78, 0x00, 0x77, 0x80, 0x0F, 0x3E, 0x03, 0xF3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x3F, 0xCF, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xFF, 0xFF, 0xFF, 0x3E, 0x10,
  0x0F, 0x07, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF8, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xF8,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x03, 0x81, 0xE0, 0xF0, 0xFC, 0xFE,
  0x3F, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x01,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE,
  0x60, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x03, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3E,
  0x07, 0x80, 0xF8, 0x07, 0x83, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0xC0, 0x3F,
  0xF7, 0x81, 0xFF, 0xEF, 0x07, 0xFF, 0xDE, 0x1F, 0x07, 0xBC, 0x3C, 0x0F,
  0x78, 0x78, 0x1E, 0xF1, 0xE0, 0x3F, 0xE3, 0xC0, 0x7F, 0xC7, 0x80, 0xFF,
  0x8F, 0x01, 0xEF, 0x1E, 0x03, 0xDE, 0x3C, 0x07, 0xBC, 0x78, 0x0F, 0x78,
  0xF0, 0x1E, 0xF0, 0xF0, 0x3D, 0xE1, 0xF0, 0x7B, 0xE1, 0xF1, 0xF3, 0xC1,
  0xFF, 0xE7, 0x81, 0xFF, 0xCF, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x82,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x3C,
  0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x03, 0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3E,
  0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01,
  0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x0E, 0x0F, 0xFC, 0xE0, 0x03, 0xEE, 0x00, 0x1E, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xEE, 0x00, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x81, 0xE1, 0xF0, 0x01, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x18, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xC1, 0xFE,
  0x0E, 0x00, 0xF8, 0x70, 0x03, 0xE3, 0x80, 0x0F, 0x9C, 0x00, 0x3C, 0xE0,
  0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0xB8, 0x00,
  0x79, 0xC0, 0x07, 0x8E, 0x00, 0x7C, 0x70, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0x81, 0xE1, 0xF0, 0x03, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xCF,
  0x00, 0x1E, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE4, 0x00, 0x3C, 0xE0, 0x1F, 0x3F, 0xFF, 0xE7,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xFB, 0x80, 0x03,
  0xCE, 0x00, 0x1E, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0xC3, 0x80, 0x3E, 0x0E,
  0x01, 0xF0, 0x38, 0x07, 0x80, 0xE0, 0x3C, 0x03, 0x81, 0xE0, 0x0E, 0x0F,
  0x80, 0x38, 0x7C, 0x00, 0xE3, 0xE0, 0x03, 0x9F, 0x00, 0x0E, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xBF, 0x00, 0x0E, 0x7E, 0x00, 0x38,
  0x7C, 0x00, 0xE0, 0xF8, 0x03, 0x81, 0xF0, 0x0E, 0x03, 0xE0, 0x38, 0x07,
  0xC0, 0xE0, 0x0F, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x7C, 0x38, 0x00, 0xF8,
  0xE0, 0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0xB8, 0x00, 0x1E, 0xE0,
  0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0x70, 0x1F, 0x8D, 0xC0, 0xEE, 0x77, 0x83, 0xB9, 0xCE, 0x0E,
  0xE7, 0x38, 0x73, 0x9C, 0xE1, 0xCE, 0x71, 0xC7, 0x39, 0xC7, 0x38, 0xE7,
  0x1C, 0xE3, 0xDC, 0x3B, 0x8F, 0x70, 0xFC, 0x3D, 0xC1, 0xF0, 0xF7, 0x07,
  0xC3, 0xDC, 0x1E, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xEE, 0x00, 0x7E, 0xF0, 0x07,
  0xE7, 0x80, 0x7E, 0x78, 0x07, 0xE3, 0xC0, 0x7E, 0x3C, 0x07, 0xE1, 0xE0,
  0x7E, 0x1E, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0x70, 0x7E, 0x07,
  0x87, 0xE0, 0x38, 0x7E, 0x03, 0xC7, 0xE0, 0x1C, 0x7E, 0x01, 0xE7, 0xE0,
  0x0E, 0x7E, 0x00, 0xE7, 0xE0, 0x0F, 0x7E, 0x00, 0x77, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x1F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0x03, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x1F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x77,
  0x80, 0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xE0, 0x03,
  0xC3, 0xC0, 0x0F, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x10, 0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xE0, 0x7F, 0x0F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x01,
  0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0,
  0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x38, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0x03, 0xFF, 0x80, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xF0, 0x1C, 0x3C, 0x00, 0x47, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x40, 0x01, 0xF7, 0x00, 0x3E, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x77, 0x80, 0x03,
  0xBC, 0x00, 0x3D, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x3E, 0x01, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x81,
  0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1C,
  0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1C,
  0xF0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xE0, 0xF7, 0x07, 0x83, 0xDC,
  0x3F, 0x0F, 0x70, 0xFC, 0x3D, 0xC3, 0xF0, 0xE7, 0x0C, 0xE3, 0x9C, 0x73,
  0x8E, 0x71, 0xCE, 0x39, 0xC6, 0x1C, 0xE7, 0x38, 0x73, 0x9C, 0xE1, 0xCE,
  0x73, 0x83, 0xB9, 0xDC, 0x0E, 0xE7, 0x70, 0x3B, 0x8D, 0xC0, 0x7E, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE1, 0xE0, 0x07,
  0xC3, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x81, 0xE0,
  0x07, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x78, 0x00,
  0x1C, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0x70, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x1C, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0x3C, 0x00, 0x3C, 0x70, 0x01, 0xE1, 0xE0, 0x07,
  0x83, 0x80, 0x3C, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x78, 0x1C, 0x00,
  0xF0, 0xF0, 0x01, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0xF0, 0x00, 0x3C,
  0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x20, 0x60, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x04, 0x07,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xE0, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xFC, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7C, 0x00,
  0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x03, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x3F, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0x3F, 0x8F, 0x80, 0x7C, 0xF0, 0x03, 0xCF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x7C,
  0xF0, 0x0F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xE3, 0xE3,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x08, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xF8, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F,
  0xBF, 0xE3, 0xC0, 0x3F, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x1F, 0x80,
  0x78, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xF1, 0xF8, 0x1F,
  0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x39, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC0, 0x30, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x00, 0x73,
  0xC0, 0x07, 0x7C, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x7C, 0x00, 0x73, 0xE0,
  0x0F, 0x3F, 0x83, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xE7, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF2,
  0x00, 0x3E, 0x3F, 0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0x80,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x79, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xDF, 0xE7,
  0x80, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0xEF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x81, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x40, 0x1E, 0x7C, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x2F, 0x00, 0x1E, 0x78, 0x01,
  0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x83, 0xE0, 0x3C,
  0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xBF, 0x00, 0x3C, 0x7E, 0x01, 0xE1,
  0xF8, 0x0F, 0x07, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF8,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x7D, 0xE0, 0x01, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x10, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x1F, 0x83, 0xC3, 0xFF,
  0xBF, 0xCF, 0xFF, 0xFF, 0xBC, 0x3F, 0x1F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x7F,
  0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03,
  0x81, 0xFC, 0x0E, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1C, 0x0F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xBF, 0xCF, 0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E,
  0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x07, 0xFB, 0xF8, 0x1F, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x07,
  0x9E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3E,
  0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xF7, 0xF8, 0xF0, 0x0F, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0xC0, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x0C, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x00, 0x73, 0xE0, 0x07, 0x7C, 0x00, 0x77,
  0x80, 0x07, 0x78, 0x00, 0x77, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x78, 0x00,
  0x77, 0x80, 0x07, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x3E, 0x00, 0xF1, 0xF0,
  0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0x70, 0x01, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x03, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xC0, 0x2F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x03, 0xCF, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F, 0xFE,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x02,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x04, 0x00, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xE0, 0x07, 0x7C, 0x01, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0,
  0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x78,
  0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x1C, 0x0E, 0x78, 0x1C, 0x0E, 0x78, 0x3C,
  0x0E, 0x78, 0x3E, 0x0E, 0x78, 0x3E, 0x1E, 0x38, 0x7E, 0x1E, 0x38, 0x7F,
  0x1E, 0x38, 0x77, 0x1C, 0x3C, 0xE7, 0x1C, 0x3C, 0xE3, 0x9C, 0x3D, 0xC3,
  0xBC, 0x1D, 0xC3, 0xBC, 0x1D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x0E, 0x00,
  0x70, 0xF8, 0x00, 0x7C, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0xF0, 0x0F,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xF1, 0xE0, 0x01, 0xF7, 0x80,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE3, 0xC0, 0x07,
  0x83, 0xC0, 0x1E, 0x07, 0xC0, 0x78, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xC0,
  0x0F, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x3C,
  0x03, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xC0, 0x1E, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x9E, 0x00,
  0x0E, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x3E, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x18,
  0xFF, 0x80, 0x77, 0xFF, 0x83, 0xDC, 0x1F, 0x9E, 0xE0, 0x3F, 0xF3, 0x80,
  0x3F, 0xC0, 0x00, 0x3C, 0x00,
};

const GFXglyph UbuntuSansMono_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 34, 26, 10, -33 },
  { 27, 12, 13, 26, 7, -36 },
  { 47, 23, 33, 26, 2, -33 },
  { 142, 20, 41, 26, 3, -36 },
  { 245, 24, 34, 26, 1, -33 },
  { 347, 23, 33, 26, 2, -33 },
  { 442, 4, 14, 26, 11, -36 },
  { 449, 14, 46, 26, 6, -37 },
  { 530, 14, 46, 26, 6, -37 },
  { 611, 20, 19, 26, 3, -33 },
  { 659, 21, 23, 26, 3, -25 },
  { 720, 11, 14, 26, 8, -7 },
  { 740, 11, 3, 26, 8, -15 },
  { 745, 7, 8, 26, 10, -7 },
  { 752, 18, 46, 26, 4, -37 },
  { 856, 21, 34, 26, 3, -33 },
  { 946, 19, 33, 26, 4, -33 },
  { 1025, 20, 33, 26, 3, -33 },
  { 1108, 20, 34, 26, 3, -33 },
  { 1193, 22, 33, 26, 2, -33 },
  { 1284, 19, 34, 26, 4, -33 },
  { 1365, 21, 34, 26, 3, -33 },
  { 1455, 20, 33, 26, 4, -33 },
  { 1538, 20, 34, 26, 3, -33 },
  { 1623, 20, 33, 26, 3, -33 },
  { 1706, 7, 25, 26, 10, -24 },
  { 1728, 10, 31, 26, 7, -24 },
  { 1767, 21, 21, 26, 3, -24 },
  { 1823, 21, 13, 26, 3, -20 },
  { 1858, 21, 21, 26, 3, -24 },
  { 1914, 16, 34, 26, 5, -33 },
  { 1982, 23, 40, 26, 2, -33 },
  { 2097, 26, 33, 26, 0, -33 },
  { 2205, 20, 33, 26, 3, -33 },
  { 2288, 21, 34, 26, 3, -33 },
  { 2378, 21, 33, 26, 3, -33 },
  { 2465, 19, 33, 26, 5, -33 },
  { 2544, 18, 33, 26, 5, -33 },
  { 2619, 21, 34, 26, 3, -33 },
  { 2709, 22, 33, 26, 2, -33 },
  { 2800, 16, 33, 26, 5, -33 },
  { 2866, 19, 34, 26, 3, -33 },
  { 2947, 22, 33, 26, 4, -33 },
  { 3038, 19, 33, 26, 5, -33 },
  { 3117, 22, 33, 26, 2, -33 },
  { 3208, 20, 33, 26, 3, -33 },
  { 3291, 23, 34, 26, 2, -33 },
  { 3389, 20, 33, 26, 4, -33 },
  { 3472, 23, 42, 26, 2, -33 },
  { 3593, 21, 33, 26, 3, -33 },
  { 3680, 20, 34, 26, 3, -33 },
  { 3765, 22, 33, 26, 2, -33 },
  { 3856, 21, 34, 26, 3, -33 },
  { 3946, 25, 33, 26, 1, -33 },
  { 4050, 22, 33, 26, 2, -33 },
  { 4141, 23, 33, 26, 2, -33 },
  { 4236, 25, 33, 26, 1, -33 },
  { 4340, 21, 33, 26, 3, -33 },
  { 4427, 12, 46, 26, 8, -37 },
  { 4496, 18, 46, 26, 4, -37 },
  { 4600, 12, 46, 26, 6, -37 },
  { 4669, 22, 18, 26, 2, -33 },
  { 4719, 26, 3, 26, 0, 6 },
  { 4729, 8, 10, 26, 9, -37 },
  { 4739, 20, 26, 26, 3, -25 },
  { 4804, 20, 37, 26, 4, -36 },
  { 4897, 21, 26, 26, 3, -25 },
  { 4966, 21, 37, 26, 2, -36 },
  { 5064, 22, 26, 26, 2, -25 },
  { 5136, 21, 36, 26, 4, -36 },
  { 5231, 20, 34, 26, 2, -25 },
  { 5316, 19, 36, 26, 4, -36 },
  { 5402, 20, 36, 26, 3, -35 },
  { 5492, 16, 44, 26, 4, -35 },
  { 5580, 21, 36, 26, 4, -36 },
  { 5675, 20, 37, 26, 3, -36 },
  { 5768, 22, 25, 26, 2, -25 },
  { 5837, 19, 25, 26, 4, -25 },
  { 5897, 22, 26, 26, 2, -25 },
  { 5969, 20, 34, 26, 4, -25 },
  { 6054, 20, 34, 26, 2, -25 },
  { 6139, 17, 25, 26, 6, -25 },
  { 6193, 19, 26, 26, 4, -25 },
  { 6255, 19, 33, 26, 4, -32 },
  { 6334, 18, 25, 26, 4, -24 },
  { 6391, 22, 24, 26, 2, -24 },
  { 6457, 24, 24, 26, 1, -24 },
  { 6529, 23, 24, 26, 2, -24 },
  { 6598, 22, 33, 26, 2, -24 },
  { 6689, 18, 24, 26, 4, -24 },
  { 6743, 18, 46, 26, 4, -37 },
  { 6847, 3, 46, 26, 12, -37 },
  { 6865, 18, 46, 26, 4, -37 },
  { 6969, 22, 7, 26, 2, -17 },
};

const GFXfont UbuntuSansMono_Regular47pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular47pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular47pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UBUNTUSANSMONO_REGULAR47PT7B_H_
