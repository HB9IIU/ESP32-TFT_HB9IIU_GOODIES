#ifndef _UBUNTUSANSMONO_REGULAR64PT7B_H_
#define _UBUNTUSANSMONO_REGULAR64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular64pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xE7, 0xE1, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x3E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0x03, 0xF8, 0x00, 0x10, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x60, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0x87, 0xFF, 0x00, 0x07, 0x87, 0xC7, 0x80, 0x07, 0xC7, 0xC1,
  0xE0, 0x07, 0xC3, 0xC0, 0xF0, 0x03, 0xE1, 0xE0, 0x78, 0x03, 0xE0, 0xF0,
  0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x3C,
  0x03, 0xC0, 0xF8, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x00, 0xF0, 0x78, 0x03,
  0xC0, 0x78, 0x7C, 0x01, 0xE0, 0x3C, 0x7C, 0x00, 0xF0, 0x3C, 0x3E, 0x00,
  0x78, 0x1E, 0x3E, 0x00, 0x1E, 0x1F, 0x1E, 0x00, 0x0F, 0x9F, 0x1F, 0x00,
  0x03, 0xFF, 0x8F, 0x00, 0x00, 0xFF, 0x8F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC3,
  0xF8, 0x00, 0x03, 0xE3, 0xFE, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x01, 0xE3,
  0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF8,
  0xF8, 0x1E, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x7C,
  0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x3E,
  0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x1F, 0x00, 0xF0, 0x1E, 0x0F,
  0x00, 0x7C, 0x0F, 0x0F, 0x80, 0x1E, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0x87,
  0x80, 0x03, 0xE7, 0xC7, 0xC0, 0x01, 0xFF, 0xC7, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x40, 0x03, 0xFE, 0x00, 0xF8,
  0x07, 0xFF, 0x00, 0xF8, 0x0F, 0xDF, 0x80, 0xF0, 0x1F, 0x8F, 0xC0, 0xF0,
  0x1F, 0x0F, 0xE0, 0xF0, 0x3F, 0x07, 0xF0, 0xF0, 0x3E, 0x03, 0xF8, 0xF0,
  0x7E, 0x01, 0xF9, 0xE0, 0x7C, 0x00, 0xFD, 0xE0, 0x7C, 0x00, 0x7F, 0xE0,
  0x7C, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0,
  0x7E, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x3F, 0xC1, 0xFE, 0xF8,
  0x1F, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xF8, 0x7C, 0x07, 0xFF, 0xE0, 0x7E,
  0x01, 0xFF, 0x80, 0x3F, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x00, 0x02, 0x00, 0x01,
  0xC0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0x00, 0x00, 0x40, 0x20, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x03, 0xC0, 0x11,
  0xC0, 0x78, 0x0E, 0x7E, 0x0F, 0x07, 0xCF, 0xF1, 0xE7, 0xFD, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x01, 0xE0, 0x01, 0x80, 0x18,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x01, 0xF8, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x0F, 0xC7,
  0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC1, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x60, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xFC, 0x1F, 0xF8,
  0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x83, 0xFC,
  0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x02, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xDF, 0x00, 0x7F, 0x8F, 0x80, 0x7F, 0x87,
  0xC0, 0x1F, 0x03, 0xE0, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFC, 0x00, 0x7F, 0x0E, 0x00, 0x07, 0xE1,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xFE,
  0x0E, 0x00, 0x1F, 0x82, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFA, 0x00, 0x00, 0xFE, 0xF0, 0x00, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x10, 0x00, 0x0F, 0xE3, 0xC0,
  0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1F,
  0xE0, 0x07, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0x8F, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xEF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0xFF, 0x0F, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xF8, 0x00,
  0xF8, 0x1F, 0xC0, 0x1F, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xFC, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE3,
  0xFF, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0xFE,
  0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC3, 0xFF, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0xC0, 0x1F, 0xF1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x08, 0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC1,
  0xE0, 0x00, 0x80, 0x0F, 0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x81, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0xF0, 0xFF,
  0x81, 0xFC, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x78, 0x07, 0xF9, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7F, 0x1F, 0x00, 0x1F, 0xFF, 0x7E,
  0x00, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xFD, 0xF0, 0x0F, 0xFF, 0xFB, 0xE0,
  0x3F, 0x03, 0xF7, 0xC0, 0xFC, 0x07, 0xEF, 0x81, 0xF0, 0x0F, 0xDF, 0x07,
  0xE0, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F, 0xFC, 0x1F, 0x00, 0x7F, 0xF8, 0x3E,
  0x00, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0xC1, 0xF0,
  0x07, 0xFF, 0x83, 0xE0, 0x0F, 0xFF, 0x07, 0xC0, 0x1F, 0xBE, 0x0F, 0x80,
  0x3F, 0x7C, 0x1F, 0x00, 0x7E, 0xF8, 0x3F, 0x00, 0xFD, 0xF8, 0x3E, 0x01,
  0xFB, 0xF0, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x07, 0xE7, 0xC0, 0xFE, 0x0F,
  0xCF, 0xC0, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xFF, 0x1F, 0x00, 0x7F, 0xFC,
  0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1E,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0x0F, 0x80, 0x0F, 0xF0, 0xF8,
  0x00, 0x3F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x7F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x01, 0xFC, 0xF8, 0x00,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x03, 0xF8,
  0x00, 0x70, 0x3F, 0x80, 0x00, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x06, 0x07, 0xFC, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0xFF,
  0x03, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0xE0, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7E, 0x03, 0xF8,
  0x00, 0x70, 0x3F, 0x80, 0x00, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x03, 0xE1, 0xFC, 0x00, 0x1F, 0x07, 0xF8, 0x01, 0xF8, 0x1F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x88, 0x00, 0x07, 0xE3, 0x00, 0x03, 0xF1, 0xF0, 0x03, 0xFC, 0x7F,
  0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7F, 0x00, 0x0F, 0x83, 0xF8, 0x00,
  0x3E, 0x1F, 0xC0, 0x00, 0xF8, 0xFE, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x0F,
  0xBF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x7F, 0x80, 0x00, 0xF8, 0xFF,
  0x00, 0x03, 0xE1, 0xFE, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x3E, 0x03, 0xF8,
  0x00, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x80,
  0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xFC, 0x0F,
  0x80, 0x03, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x03, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0x78, 0x3D,
  0xE0, 0x1E, 0xF0, 0x7B, 0xC0, 0x3D, 0xE0, 0xF7, 0xC0, 0xF3, 0xC3, 0xE7,
  0x81, 0xE7, 0xC7, 0x8F, 0x03, 0xCF, 0x8F, 0x1F, 0x0F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x7C, 0x70, 0x78, 0xF0, 0x79,
  0xE0, 0xF1, 0xE0, 0xF3, 0xC1, 0xE3, 0xC0, 0xE7, 0x03, 0xC7, 0x81, 0xFE,
  0x07, 0x8F, 0x03, 0xFC, 0x0F, 0x1E, 0x03, 0xF8, 0x1E, 0x3C, 0x07, 0xE0,
  0x3C, 0xF8, 0x0F, 0xC0, 0x79, 0xF0, 0x0F, 0x80, 0xFB, 0xE0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xE0, 0x01, 0xFF, 0xBE,
  0x00, 0x1F, 0xF9, 0xF0, 0x01, 0xFF, 0x9F, 0x00, 0x1F, 0xF8, 0xF8, 0x01,
  0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0x7C, 0x01, 0xFF, 0x87, 0xC0, 0x1F, 0xF8,
  0x3E, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0,
  0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x07, 0xC1, 0xFF,
  0x80, 0x7C, 0x1F, 0xF8, 0x03, 0xC1, 0xFF, 0x80, 0x3E, 0x1F, 0xF8, 0x03,
  0xE1, 0xFF, 0x80, 0x1F, 0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0x80, 0x0F, 0x1F,
  0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x07, 0x9F, 0xF8, 0x00, 0x7D, 0xFF, 0x80,
  0x03, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x3F,
  0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xF3, 0xE0, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7C, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0x81, 0xF8, 0x00,
  0x38, 0x3F, 0x00, 0x00, 0x83, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE2, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x1F, 0xC7, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF8,
  0x01, 0xFC, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x0F, 0x80,
  0x79, 0xF0, 0x1F, 0x80, 0xF3, 0xE0, 0x3F, 0x01, 0xE3, 0xC0, 0xFE, 0x03,
  0xC7, 0x81, 0xFE, 0x07, 0x8F, 0x03, 0xBC, 0x0F, 0x1E, 0x0F, 0x78, 0x1E,
  0x3C, 0x1E, 0x78, 0x3C, 0x78, 0x38, 0xF0, 0x78, 0xF0, 0xF1, 0xE0, 0xF1,
  0xE1, 0xE1, 0xE3, 0xE3, 0xC3, 0xC3, 0xC7, 0xC7, 0x8F, 0x07, 0x8F, 0x0F,
  0x1E, 0x07, 0x9E, 0x1F, 0x3C, 0x0F, 0x3C, 0x3E, 0xF0, 0x1F, 0x78, 0x3D,
  0xE0, 0x1E, 0xF0, 0x7B, 0xC0, 0x3D, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x06, 0x01, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xE0, 0x10, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0x1F, 0xF8, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFC,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xE1, 0xFF, 0x9F, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E,
  0x7F, 0x00, 0x07, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x0F, 0x9F, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x8F, 0xC0,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0x80, 0x04, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x06, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE1, 0xF0, 0x0F,
  0xFF, 0x9F, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFE, 0x01, 0xFF, 0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0xC0, 0x01,
  0xF0, 0xFF, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xE7, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0x80, 0x3C, 0x03, 0xF0, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0x00,
  0x3F, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x10, 0x00, 0x1F, 0xC1, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x08, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0xCF,
  0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x06, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF9, 0x80, 0x0F, 0xDF,
  0xC7, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xBE, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0,
  0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x7F, 0x00, 0x3E,
  0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x7C, 0xFE,
  0x00, 0x03, 0xEF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3E, 0xFF, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x0F,
  0x87, 0xF8, 0x00, 0x7C, 0x1F, 0xE0, 0x03, 0xE0, 0x3F, 0x80, 0x1F, 0x00,
  0xFE, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x3F,
  0x81, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xE3,
  0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x0F, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x60, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xE0,
  0x1F, 0x01, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFC, 0x3F, 0xF3, 0xFB, 0xE0, 0x3F, 0x03, 0xEF, 0x80, 0xF8, 0x07,
  0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0,
  0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x1F, 0xF8, 0x07,
  0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0,
  0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3E, 0x00,
  0x1F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x0F, 0x80, 0x0F, 0xF0, 0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0x9F, 0xFE, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0x1F,
  0xC0, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x01,
  0xF3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x9F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x01, 0xDF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xF0,
  0xFF, 0x1F, 0xC0, 0x00, 0x87, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x60, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x06, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0xC0, 0x0F, 0xC7, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x7C, 0x03,
  0xC0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07,
  0xE0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F,
  0xF0, 0x3C, 0x3E, 0x1E, 0x78, 0x7C, 0x3E, 0x1E, 0x78, 0x7C, 0x3E, 0x1E,
  0x78, 0x7C, 0x3E, 0x3C, 0x3C, 0x7C, 0x3E, 0x3C, 0x3C, 0x78, 0x1E, 0x7C,
  0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0x78, 0x1E, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0,
  0x03, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x41, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xE1, 0xFF, 0xE0, 0x03, 0xCF, 0xFF, 0xC0,
  0x1E, 0x7E, 0xFF, 0xC0, 0x79, 0xE0, 0x7F, 0xC3, 0xE7, 0x00, 0x7F, 0xFF,
  0x3C, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph UbuntuSansMono_Regular64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 9, 45, 36, 13, -44 },
  { 52, 16, 17, 36, 10, -49 },
  { 86, 32, 44, 36, 2, -44 },
  { 262, 28, 57, 36, 4, -50 },
  { 462, 33, 46, 36, 1, -45 },
  { 652, 32, 46, 36, 2, -45 },
  { 836, 5, 19, 36, 15, -49 },
  { 848, 18, 62, 36, 9, -50 },
  { 988, 18, 62, 36, 9, -50 },
  { 1128, 27, 26, 36, 4, -44 },
  { 1216, 30, 32, 36, 3, -35 },
  { 1336, 14, 19, 36, 11, -9 },
  { 1370, 14, 4, 36, 11, -20 },
  { 1377, 10, 11, 36, 13, -10 },
  { 1391, 25, 62, 36, 5, -50 },
  { 1585, 28, 46, 36, 4, -45 },
  { 1746, 25, 44, 36, 6, -44 },
  { 1884, 27, 45, 36, 4, -45 },
  { 2036, 26, 46, 36, 5, -45 },
  { 2186, 30, 44, 36, 3, -44 },
  { 2351, 27, 45, 36, 5, -44 },
  { 2503, 28, 46, 36, 4, -45 },
  { 2664, 28, 44, 36, 5, -44 },
  { 2818, 28, 46, 36, 4, -45 },
  { 2979, 28, 45, 36, 4, -45 },
  { 3137, 10, 35, 36, 13, -34 },
  { 3181, 14, 44, 36, 9, -34 },
  { 3258, 29, 28, 36, 4, -32 },
  { 3360, 30, 18, 36, 3, -28 },
  { 3428, 29, 28, 36, 4, -32 },
  { 3530, 22, 46, 36, 7, -45 },
  { 3657, 31, 55, 36, 3, -45 },
  { 3871, 34, 44, 36, 1, -44 },
  { 4058, 28, 45, 36, 4, -45 },
  { 4216, 29, 46, 36, 4, -45 },
  { 4383, 29, 45, 36, 4, -45 },
  { 4547, 26, 44, 36, 7, -44 },
  { 4690, 25, 44, 36, 7, -44 },
  { 4828, 29, 46, 36, 4, -45 },
  { 4995, 30, 44, 36, 3, -44 },
  { 5160, 22, 44, 36, 7, -44 },
  { 5281, 26, 45, 36, 4, -44 },
  { 5428, 30, 44, 36, 5, -44 },
  { 5593, 26, 44, 36, 7, -44 },
  { 5736, 31, 44, 36, 2, -44 },
  { 5907, 28, 44, 36, 4, -44 },
  { 6061, 32, 46, 36, 2, -45 },
  { 6245, 26, 45, 36, 6, -45 },
  { 6392, 32, 57, 36, 2, -45 },
  { 6620, 29, 45, 36, 4, -45 },
  { 6784, 28, 46, 36, 4, -45 },
  { 6945, 30, 44, 36, 3, -44 },
  { 7110, 28, 45, 36, 4, -44 },
  { 7268, 34, 44, 36, 1, -44 },
  { 7455, 31, 44, 36, 2, -44 },
  { 7626, 32, 44, 36, 2, -44 },
  { 7802, 34, 44, 36, 1, -44 },
  { 7989, 29, 44, 36, 4, -44 },
  { 8149, 16, 62, 36, 11, -50 },
  { 8273, 25, 62, 36, 5, -50 },
  { 8467, 16, 62, 36, 9, -50 },
  { 8591, 29, 23, 36, 3, -44 },
  { 8675, 34, 4, 36, 1, 8 },
  { 8692, 11, 13, 36, 12, -50 },
  { 8710, 27, 35, 36, 4, -34 },
  { 8829, 28, 51, 36, 5, -50 },
  { 9008, 28, 35, 36, 4, -34 },
  { 9131, 28, 51, 36, 3, -50 },
  { 9310, 29, 35, 36, 3, -34 },
  { 9437, 29, 50, 36, 5, -50 },
  { 9619, 28, 46, 36, 3, -34 },
  { 9780, 26, 50, 36, 5, -50 },
  { 9943, 28, 49, 36, 4, -48 },
  { 10115, 21, 60, 36, 6, -48 },
  { 10273, 29, 50, 36, 5, -50 },
  { 10455, 28, 50, 36, 4, -49 },
  { 10630, 30, 34, 36, 3, -34 },
  { 10758, 26, 34, 36, 5, -34 },
  { 10869, 30, 35, 36, 3, -34 },
  { 11001, 28, 46, 36, 5, -34 },
  { 11162, 28, 46, 36, 3, -34 },
  { 11323, 23, 34, 36, 8, -34 },
  { 11421, 26, 35, 36, 5, -34 },
  { 11535, 27, 45, 36, 5, -44 },
  { 11687, 26, 34, 36, 5, -33 },
  { 11798, 31, 33, 36, 2, -33 },
  { 11926, 32, 33, 36, 2, -33 },
  { 12058, 32, 33, 36, 2, -33 },
  { 12190, 30, 45, 36, 3, -33 },
  { 12359, 25, 33, 36, 5, -33 },
  { 12463, 24, 62, 36, 6, -50 },
  { 12649, 4, 62, 36, 16, -50 },
  { 12680, 25, 62, 36, 5, -50 },
  { 12874, 30, 10, 36, 3, -24 },
};

const GFXfont UbuntuSansMono_Regular64pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular64pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular64pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _UBUNTUSANSMONO_REGULAR64PT7B_H_
