#ifndef _UBUNTUSANSMONO_REGULAR50PT7B_H_
#define _UBUNTUSANSMONO_REGULAR50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x9F, 0xFF, 0xFE, 0xFD, 0xF0, 0xC0, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x06, 0x60, 0x60, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x38, 0x01,
  0xE0, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E,
  0x03, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x3C, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFE, 0x0F, 0x83, 0xE0, 0x02, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x79, 0x80, 0x03, 0xE7,
  0xE0, 0x7F, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0x8F, 0xF0, 0x01, 0xC7, 0x9E, 0x00,
  0xF1, 0xC3, 0x80, 0x38, 0x70, 0x70, 0x1E, 0x38, 0x1C, 0x0F, 0x0E, 0x07,
  0x03, 0x83, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x3C, 0x0E,
  0x07, 0x1E, 0x03, 0xC1, 0xC7, 0x00, 0x70, 0xF3, 0xC0, 0x1C, 0x38, 0xE0,
  0x03, 0xFE, 0x78, 0x00, 0xFF, 0x3C, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF3, 0xF8, 0x00, 0x79, 0xFF, 0x00,
  0x1C, 0x79, 0xE0, 0x0F, 0x3C, 0x38, 0x03, 0x8E, 0x0E, 0x01, 0xE3, 0x81,
  0xC0, 0xF0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x03,
  0x81, 0xC3, 0xC0, 0xE0, 0x71, 0xE0, 0x38, 0x3C, 0x70, 0x0F, 0x0E, 0x3C,
  0x01, 0xC7, 0x8E, 0x00, 0x7F, 0xC7, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x07, 0xC0,
  0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x1F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x20, 0x0F, 0xE0, 0x1C, 0x1F, 0xF0, 0x1C, 0x3E, 0xF8, 0x3C,
  0x3C, 0x7C, 0x3C, 0x78, 0x3E, 0x38, 0x78, 0x1F, 0x38, 0xF8, 0x0F, 0xB8,
  0xF0, 0x07, 0xF8, 0xF0, 0x03, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF8, 0x7C, 0x07, 0xFC, 0x7E, 0x0F, 0xBC,
  0x3F, 0xFF, 0x1E, 0x1F, 0xFE, 0x1F, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE6, 0x00, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0x80, 0x04, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x07, 0x83, 0x9F,
  0x0E, 0x3E, 0x7F, 0x33, 0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0,
  0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x80, 0xF0, 0x3C, 0x01, 0x80, 0x60, 0x02,
  0x01, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x83, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x7C, 0x7F, 0x8F, 0xE1, 0xF0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8, 0x1E, 0x01, 0xE0,
  0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3E, 0x78, 0x00, 0x79, 0xE0,
  0x01, 0xEF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x40,
  0xFF, 0x07, 0x83, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0xC3, 0xF0, 0xFF,
  0x0F, 0xC3, 0xFC, 0x1E, 0x0F, 0xF0, 0x30, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07,
  0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x0F, 0xDE, 0x07, 0xF3, 0xC0, 0xF8, 0x78, 0x1C, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0x83, 0xF8,
  0x78, 0x03, 0xE0, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF0, 0x3F,
  0x86, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFA, 0x00, 0x0F, 0x9C,
  0x00, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF9, 0x00, 0x0F, 0xCE, 0x00, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x8F, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFE, 0x1F, 0xCF, 0x80,
  0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x87, 0xC0,
  0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xC0, 0xFC,
  0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x7C, 0x00,
  0xF0, 0xF8, 0x03, 0xC3, 0xF0, 0x1E, 0x07, 0xF1, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC1, 0xFC, 0x3C, 0x01, 0xF1, 0xF0,
  0x03, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7,
  0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xC0, 0xF8, 0x3C, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0xBE,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x7C, 0x00, 0x3C, 0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03,
  0xFE, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0x0F, 0xC1, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFE, 0x1F, 0x83, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xE1, 0xFE,
  0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xF9, 0xFE,
  0x3F, 0x83, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x40, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0x07, 0x83,
  0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xC7, 0xF8, 0x3E, 0x0F, 0xF0, 0x78, 0x1F, 0xE1, 0xF0,
  0x3F, 0xC3, 0xC0, 0x7F, 0x87, 0x80, 0xFF, 0x0F, 0x01, 0xFE, 0x1E, 0x03,
  0xFC, 0x3C, 0x07, 0xF8, 0x78, 0x0F, 0xF0, 0xF0, 0x1F, 0xE1, 0xE0, 0x3F,
  0xE3, 0xE0, 0x7F, 0xC3, 0xC0, 0xFF, 0x87, 0xC1, 0xEF, 0x07, 0xFF, 0xDF,
  0x07, 0xFF, 0xBE, 0x07, 0xFF, 0x3C, 0x00, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC,
  0x04, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x3C, 0x07, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x7C, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3C, 0x00, 0xFC, 0xF0,
  0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7B,
  0xC0, 0x03, 0xEF, 0x00, 0x1F, 0xBC, 0x01, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0x83, 0xE0, 0xF8, 0x00, 0x83, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0x07, 0xF0,
  0x0E, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0x87, 0xFC,
  0x0F, 0x00, 0xFC, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x7C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F,
  0x1E, 0x00, 0x3E, 0x3C, 0x01, 0xF8, 0x78, 0x0F, 0xE0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x80, 0x08,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x03,
  0xCF, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF8, 0x03, 0xC3,
  0xF0, 0x0F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07,
  0xE0, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x60,
  0x03, 0xE7, 0x80, 0x7E, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF0,
  0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF0,
  0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xF3,
  0xF0, 0x00, 0xF1, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0xF0,
  0x3F, 0x00, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x3B, 0x81, 0xDC, 0x3B, 0x81,
  0xDE, 0x7B, 0xC3, 0xDE, 0x79, 0xC3, 0x9E, 0x79, 0xC3, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0xE7, 0x0E, 0x78, 0xE7, 0x0E, 0x70, 0x77, 0x0E, 0x70, 0x7E,
  0x0E, 0x70, 0x7E, 0x0E, 0x70, 0x3E, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x3C,
  0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFD,
  0xE0, 0x0F, 0xF7, 0x80, 0x3F, 0xCF, 0x00, 0xFF, 0x3C, 0x03, 0xFC, 0x78,
  0x0F, 0xF1, 0xE0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x1E, 0x0F,
  0xF0, 0x78, 0x3F, 0xC0, 0xE0, 0xFF, 0x03, 0xC3, 0xFC, 0x07, 0x0F, 0xF0,
  0x1E, 0x3F, 0xC0, 0x78, 0xFF, 0x00, 0xF3, 0xFC, 0x03, 0xCF, 0xF0, 0x07,
  0x3F, 0xC0, 0x1E, 0xFF, 0x00, 0x3B, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xF0, 0x7F, 0xCF, 0x00, 0x3F, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0xF0,
  0x01, 0xF7, 0x80, 0x1F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81,
  0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x81,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1C, 0x3F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xC1, 0xFE,
  0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0,
  0x03, 0xE1, 0xE0, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07,
  0x81, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xE0, 0x7C, 0x3E, 0x00, 0x20, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE4, 0x00, 0x0F, 0x9E, 0x00, 0x7C, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x78,
  0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x3C, 0x0E,
  0x70, 0x7C, 0x0E, 0x70, 0x7E, 0x0E, 0x70, 0x7E, 0x0E, 0x70, 0xFE, 0x0E,
  0x70, 0xE7, 0x0E, 0x78, 0xE7, 0x0E, 0x79, 0xE7, 0x1E, 0x79, 0xC3, 0x9E,
  0x79, 0xC3, 0x9E, 0x79, 0xC3, 0x9C, 0x7B, 0x83, 0xDC, 0x3B, 0x81, 0xDC,
  0x3B, 0x81, 0xDC, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x07, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80,
  0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xE7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1F,
  0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xE0,
  0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x0F, 0x01,
  0xE0, 0x1C, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80,
  0x07, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x72, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0x18, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x80,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xC0, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xF0, 0x01,
  0xEF, 0xC0, 0x0F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00,
  0x34, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x20, 0x03, 0xDF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x07,
  0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x3E, 0x3C, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0xB0, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xE0, 0x18, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x10, 0x3C, 0x07, 0xFE, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x81, 0xFC, 0x7C, 0x01, 0xF3, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0xF1, 0xF0, 0x03, 0xC3, 0xF0, 0x0F,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8,
  0x1F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x0C, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x40, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xC0, 0xFC, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0xFC,
  0x01, 0xF1, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFC,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x3C, 0x03, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x0F, 0xCF, 0x00,
  0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xD0,
  0x03, 0xEE, 0x07, 0xE7, 0xFF, 0xE7, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0x00,
  0x30, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x03,
  0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x07, 0xC0,
  0x1E, 0x3F, 0x00, 0x3C, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0x9F, 0x80, 0x0F, 0x1F, 0x80, 0x1E,
  0x1F, 0x80, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xE0,
  0x0F, 0x83, 0xC0, 0x0F, 0x87, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x9E, 0x00,
  0x0F, 0xBC, 0x00, 0x0F, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x02, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x06, 0x00, 0x40, 0x7F, 0xE3,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xF0, 0x7E, 0x1E, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0x80, 0xFC, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF0,
  0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x03, 0xF0, 0xF0, 0x03, 0xE3, 0xC0,
  0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xE0, 0x7E,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xDF, 0xF8, 0x0F, 0x06, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x1F, 0x1F, 0x00, 0x3C,
  0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xCF, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF8,
  0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFE, 0xF0, 0x01, 0xC3,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x10, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7C, 0x00,
  0xC7, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x40, 0x00, 0xFF, 0x00, 0x3E,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x40, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x02, 0xE0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0,
  0x0F, 0x3F, 0x00, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00,
  0x28, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xE7, 0x80, 0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x78, 0x1E,
  0x07, 0x9E, 0x07, 0xC1, 0xE3, 0x83, 0xF0, 0x70, 0xE0, 0xFC, 0x1C, 0x3C,
  0x3F, 0x8F, 0x0F, 0x1C, 0xE3, 0xC3, 0xC7, 0x38, 0xF0, 0xF1, 0xCF, 0x3C,
  0x1C, 0xE1, 0xCE, 0x07, 0x38, 0x73, 0x81, 0xDE, 0x1F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0x1E,
  0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0x01, 0xE7, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0,
  0x03, 0xC3, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF8,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0xF8, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0,
  0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF3, 0xC0,
  0x00, 0xF3, 0xC0, 0x00, 0xF3, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x81, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x3F,
  0xF0, 0x0E, 0x3F, 0xFC, 0x0E, 0x78, 0x7F, 0x1E, 0x70, 0x1F, 0xFC, 0xE0,
  0x0F, 0xF8, 0x20, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 36, 28, 10, -35 },
  { 33, 12, 13, 28, 8, -38 },
  { 53, 24, 35, 28, 2, -35 },
  { 158, 22, 44, 28, 3, -39 },
  { 279, 26, 36, 28, 1, -35 },
  { 396, 24, 35, 28, 2, -35 },
  { 501, 4, 14, 28, 12, -38 },
  { 508, 14, 48, 28, 7, -39 },
  { 592, 14, 48, 28, 7, -39 },
  { 676, 22, 21, 28, 3, -35 },
  { 734, 22, 25, 28, 3, -27 },
  { 803, 11, 15, 28, 9, -7 },
  { 824, 12, 4, 28, 8, -16 },
  { 830, 8, 8, 28, 10, -7 },
  { 838, 20, 48, 28, 4, -39 },
  { 958, 22, 36, 28, 3, -35 },
  { 1057, 19, 35, 28, 5, -35 },
  { 1141, 22, 35, 28, 3, -35 },
  { 1238, 21, 36, 28, 4, -35 },
  { 1333, 24, 35, 28, 2, -35 },
  { 1438, 21, 36, 28, 4, -35 },
  { 1533, 22, 36, 28, 3, -35 },
  { 1632, 22, 35, 28, 4, -35 },
  { 1729, 22, 36, 28, 3, -35 },
  { 1828, 22, 35, 28, 3, -35 },
  { 1925, 8, 26, 28, 10, -25 },
  { 1951, 11, 33, 28, 7, -25 },
  { 1997, 23, 22, 28, 3, -25 },
  { 2061, 22, 14, 28, 3, -22 },
  { 2100, 23, 22, 28, 3, -25 },
  { 2164, 17, 36, 28, 6, -35 },
  { 2241, 23, 43, 28, 3, -35 },
  { 2365, 28, 35, 28, 0, -35 },
  { 2488, 22, 35, 28, 3, -35 },
  { 2585, 23, 36, 28, 3, -35 },
  { 2689, 23, 35, 28, 3, -35 },
  { 2790, 20, 35, 28, 6, -35 },
  { 2878, 19, 35, 28, 6, -35 },
  { 2962, 22, 36, 28, 3, -35 },
  { 3061, 24, 35, 28, 2, -35 },
  { 3166, 16, 35, 28, 6, -35 },
  { 3236, 20, 36, 28, 3, -35 },
  { 3326, 24, 35, 28, 4, -35 },
  { 3431, 21, 35, 28, 5, -35 },
  { 3523, 24, 35, 28, 2, -35 },
  { 3628, 22, 35, 28, 3, -35 },
  { 3725, 24, 36, 28, 2, -35 },
  { 3833, 21, 35, 28, 4, -35 },
  { 3925, 24, 44, 28, 2, -35 },
  { 4057, 23, 35, 28, 3, -35 },
  { 4158, 22, 36, 28, 3, -35 },
  { 4257, 24, 35, 28, 2, -35 },
  { 4362, 22, 36, 28, 3, -35 },
  { 4461, 26, 35, 28, 1, -35 },
  { 4575, 24, 35, 28, 2, -35 },
  { 4680, 24, 35, 28, 2, -35 },
  { 4785, 26, 35, 28, 1, -35 },
  { 4899, 23, 35, 28, 3, -35 },
  { 5000, 13, 48, 28, 8, -39 },
  { 5078, 20, 48, 28, 4, -39 },
  { 5198, 13, 48, 28, 7, -39 },
  { 5276, 22, 19, 28, 3, -35 },
  { 5329, 28, 3, 28, 0, 6 },
  { 5340, 9, 10, 28, 9, -39 },
  { 5352, 21, 28, 28, 3, -27 },
  { 5426, 22, 40, 28, 4, -39 },
  { 5536, 22, 28, 28, 3, -27 },
  { 5613, 22, 40, 28, 2, -39 },
  { 5723, 23, 28, 28, 2, -27 },
  { 5804, 23, 39, 28, 4, -39 },
  { 5917, 22, 36, 28, 2, -27 },
  { 6016, 20, 39, 28, 4, -39 },
  { 6114, 22, 39, 28, 3, -38 },
  { 6222, 17, 48, 28, 4, -38 },
  { 6324, 23, 39, 28, 4, -39 },
  { 6437, 22, 40, 28, 3, -39 },
  { 6547, 24, 27, 28, 2, -27 },
  { 6628, 20, 26, 28, 4, -26 },
  { 6693, 24, 28, 28, 2, -27 },
  { 6777, 22, 35, 28, 4, -26 },
  { 6874, 22, 35, 28, 2, -26 },
  { 6971, 18, 27, 28, 6, -27 },
  { 7032, 20, 28, 28, 4, -27 },
  { 7102, 21, 35, 28, 4, -34 },
  { 7194, 20, 27, 28, 4, -26 },
  { 7262, 24, 26, 28, 2, -26 },
  { 7340, 26, 26, 28, 1, -26 },
  { 7425, 24, 26, 28, 2, -26 },
  { 7503, 24, 35, 28, 2, -26 },
  { 7608, 20, 26, 28, 4, -26 },
  { 7673, 19, 48, 28, 5, -39 },
  { 7787, 4, 48, 28, 12, -39 },
  { 7811, 19, 48, 28, 4, -39 },
  { 7925, 24, 8, 28, 2, -19 },
};

const GFXfont UbuntuSansMono_Regular50pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular50pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular50pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _UBUNTUSANSMONO_REGULAR50PT7B_H_
