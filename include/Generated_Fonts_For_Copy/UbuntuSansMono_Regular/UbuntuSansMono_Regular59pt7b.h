#ifndef _UBUNTUSANSMONO_REGULAR59PT7B_H_
#define _UBUNTUSANSMONO_REGULAR59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x70, 0x1C,
  0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x01,
  0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0,
  0x3C, 0x00, 0x3E, 0x03, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x01,
  0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0,
  0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x01,
  0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0,
  0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0x03, 0x83, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x7F, 0xC0, 0x01,
  0xE1, 0xE3, 0xC0, 0x07, 0x87, 0x83, 0xC0, 0x0F, 0x0F, 0x07, 0x80, 0x3C,
  0x1C, 0x0F, 0x00, 0xF8, 0x38, 0x0E, 0x01, 0xE0, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0xF8, 0x0F,
  0x01, 0xC1, 0xE0, 0x0E, 0x03, 0x87, 0x80, 0x1C, 0x0F, 0x0F, 0x00, 0x3C,
  0x1E, 0x3C, 0x00, 0x78, 0x3C, 0xF8, 0x00, 0x78, 0xF1, 0xE0, 0x00, 0x7F,
  0xC7, 0x80, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x0F,
  0x1F, 0xF0, 0x00, 0x3C, 0x7D, 0xF0, 0x00, 0xF8, 0xF0, 0xF0, 0x01, 0xE3,
  0xC1, 0xE0, 0x07, 0x87, 0x81, 0xC0, 0x0F, 0x0E, 0x03, 0x80, 0x3C, 0x1C,
  0x07, 0x80, 0xF8, 0x38, 0x0F, 0x01, 0xE0, 0x70, 0x1E, 0x07, 0x80, 0xE0,
  0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x3C, 0x03, 0x80, 0xE0, 0xF8, 0x07, 0x81,
  0xC1, 0xE0, 0x0F, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x0F, 0x00, 0x1E, 0x3C,
  0x3C, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x38, 0x03, 0xFE, 0x01, 0xE0, 0x3F, 0xF8, 0x0F, 0x03,
  0xF7, 0xE0, 0x78, 0x1F, 0x1F, 0x83, 0xC1, 0xF0, 0x7E, 0x1E, 0x0F, 0x81,
  0xF8, 0xE0, 0xF8, 0x07, 0xCF, 0x07, 0xC0, 0x3F, 0x78, 0x3E, 0x00, 0xFF,
  0xC3, 0xE0, 0x03, 0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x07,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0xFF, 0x07, 0xE0,
  0x0F, 0xFC, 0x1F, 0x80, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0x83, 0xFF, 0xFC,
  0x3E, 0x0F, 0xFF, 0xC1, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x39, 0xCE, 0x70, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x00, 0xF8,
  0x04, 0xF0, 0x3C, 0x1E, 0x7E, 0x1C, 0x3F, 0x7F, 0xCE, 0x7F, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xF0, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xC0,
  0x1C, 0x01, 0xC0, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x1F, 0x81,
  0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0xE3, 0xFE, 0x0F, 0xE0, 0x7E, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3F, 0x9F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x0E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x07, 0xDF, 0x03, 0xE0, 0x7F, 0xE0, 0xFE, 0x0F, 0xFC, 0x1F, 0xC1,
  0xFF, 0x83, 0xF8, 0x3F, 0xF0, 0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0xFF, 0xC0,
  0xFC, 0x1F, 0xF8, 0x0E, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xDF, 0x00, 0xFF, 0x9F, 0x00, 0x7E, 0x1F,
  0x00, 0x78, 0x1F, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFC,
  0xFF, 0xC7, 0xE0, 0x07, 0xE1, 0xE0, 0x01, 0xF8, 0x40, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xF8,
  0x7F, 0x81, 0xC0, 0x07, 0xE0, 0x40, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF3, 0x00, 0x07, 0xF1, 0xF8, 0x1F, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1F,
  0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1E,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x60, 0x00, 0xFC, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x3F, 0x00, 0x3E, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0x80, 0xFE, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xF0, 0x00,
  0x7C, 0xFC, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0xC0, 0x3E, 0x07, 0xF0,
  0x3E, 0x01, 0xFF, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0x9F,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xF3, 0xF0, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xE0, 0x0F,
  0x83, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3F, 0x00,
  0x07, 0xC7, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xF7, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C, 0x3F,
  0x9F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xFE, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xF9, 0xFC, 0x38, 0x01, 0xC0,
  0x3F, 0x81, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFE, 0x07,
  0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x7E, 0x07, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x8F, 0xFC, 0x3F, 0x81,
  0xF8, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x1F, 0xC4, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFC, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x7F, 0xF7, 0xC0, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0xF7, 0xC0, 0xFF, 0xFF,
  0x7C, 0x0F, 0xC1, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x3F, 0x01, 0xFF, 0x83,
  0xE0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3C, 0x01,
  0xFF, 0x83, 0xC0, 0x1F, 0xF8, 0x3C, 0x01, 0xFF, 0x83, 0xC0, 0x1F, 0xF8,
  0x3E, 0x01, 0xFF, 0xC3, 0xE0, 0x1F, 0xFC, 0x3E, 0x01, 0xF7, 0xC3, 0xE0,
  0x1F, 0x7C, 0x1F, 0x01, 0xF7, 0xC1, 0xF0, 0x1F, 0x7C, 0x0F, 0x81, 0xF7,
  0xE0, 0xFF, 0xFF, 0x3E, 0x07, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF, 0x3F, 0x00,
  0x7F, 0x81, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x03, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0x00, 0x3F, 0xC7, 0x80, 0x07, 0xF3, 0xC0, 0x01, 0xF9, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF8, 0xF0, 0x01, 0xF8, 0x78, 0x0F, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xC0, 0x03, 0xF9, 0xE0,
  0x00, 0x7E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xDE, 0x00, 0x07, 0xEF, 0x00, 0x0F, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xF1,
  0xFC, 0x0F, 0xE0, 0x03, 0x81, 0xF8, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x04, 0x0F, 0xF0, 0x01, 0x80, 0xFF, 0xC7, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xF0,
  0x07, 0xF8, 0x3C, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8,
  0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x3E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F,
  0x8F, 0x00, 0x07, 0xE3, 0xC0, 0x07, 0xF0, 0xF0, 0x07, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xE0, 0xFC, 0x0F, 0xE0, 0x03, 0x81,
  0xF8, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F,
  0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7E, 0x00,
  0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x3E, 0x0F, 0xE0, 0x07, 0xC0,
  0xFF, 0x83, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF3, 0x00, 0x03, 0xE7, 0x00, 0x1F,
  0xDF, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0xC0,
  0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0x00,
  0x7E, 0x00, 0xF0, 0x0F, 0xC0, 0x0F, 0x01, 0xF8, 0x00, 0xF0, 0x3F, 0x00,
  0x0F, 0x07, 0xE0, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0xF3,
  0xF0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x0F,
  0x0F, 0xE0, 0x00, 0xF0, 0x7F, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0xF0, 0x1F,
  0xC0, 0x0F, 0x00, 0xFC, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x3F, 0x00,
  0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x1F,
  0x8F, 0x00, 0x00, 0xFC, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7E, 0xF0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x3D,
  0xE0, 0x1D, 0xE1, 0xEF, 0x01, 0xEF, 0x0F, 0x78, 0x0F, 0x78, 0x79, 0xE0,
  0x73, 0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xC7,
  0x87, 0x8F, 0x1E, 0x3C, 0x3C, 0x78, 0xF1, 0xE1, 0xE1, 0xE7, 0x0F, 0x8F,
  0x0F, 0x78, 0x7C, 0xF8, 0x3B, 0xC3, 0xE7, 0xC1, 0xDC, 0x0F, 0x3E, 0x0F,
  0xE0, 0x79, 0xF0, 0x3F, 0x03, 0xCF, 0x01, 0xF0, 0x1E, 0x78, 0x0F, 0x80,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xF7, 0xC0, 0x07, 0xFB, 0xE0, 0x03, 0xFC, 0xF8, 0x01, 0xFE, 0x7C, 0x00,
  0xFF, 0x1F, 0x00, 0x7F, 0x87, 0x80, 0x3F, 0xC3, 0xE0, 0x1F, 0xE0, 0xF0,
  0x0F, 0xF0, 0x7C, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x81, 0xFE, 0x07,
  0xC0, 0xFF, 0x01, 0xF0, 0x7F, 0x80, 0xF8, 0x3F, 0xC0, 0x3C, 0x1F, 0xE0,
  0x1F, 0x0F, 0xF0, 0x07, 0x87, 0xF8, 0x03, 0xE3, 0xFC, 0x00, 0xF1, 0xFE,
  0x00, 0x7C, 0xFF, 0x00, 0x1E, 0x7F, 0x80, 0x0F, 0x3F, 0xC0, 0x03, 0xDF,
  0xE0, 0x01, 0xEF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0xC7,
  0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80,
  0x1F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF0, 0x01, 0xFC, 0x3C, 0x00,
  0x1F, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F,
  0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC3, 0xC0, 0x03, 0xF0, 0xF0,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x0F,
  0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xE1,
  0xFC, 0x00, 0x70, 0xF8, 0x00, 0x08, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF4, 0x00, 0x01, 0xF3, 0x80, 0x01, 0xF9, 0xFC, 0x07, 0xF9, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xF8, 0x01, 0xF8, 0x3F,
  0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x07,
  0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x0F, 0x80, 0xF3, 0xC0, 0x7C, 0x07,
  0x9F, 0x07, 0xE0, 0x3C, 0xF8, 0x3F, 0x81, 0xE7, 0xC1, 0xDC, 0x1F, 0x3E,
  0x1E, 0xF0, 0xF1, 0xF0, 0xF7, 0x87, 0x87, 0x87, 0x3C, 0x3C, 0x3C, 0x78,
  0xF1, 0xE1, 0xE3, 0xC7, 0x8F, 0x0F, 0x1C, 0x3C, 0x78, 0x79, 0xE0, 0xF3,
  0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x70, 0x3C, 0xF0, 0xF7, 0x80, 0xF7, 0x87,
  0xBC, 0x07, 0xBC, 0x3D, 0xE0, 0x3D, 0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x00, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x3E, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0x00, 0x00, 0x1C, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10,
  0x0C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x38, 0x04, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0x3F,
  0xE0, 0x7F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0xFE, 0x7C, 0x00,
  0xFE, 0x3F, 0xE7, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x18, 0x3F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x8F, 0x01, 0xFF, 0xF7, 0x83, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xF1, 0xF8, 0x01, 0xF9, 0xF8,
  0x00, 0x3D, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x7B, 0xE0, 0x00, 0x3D, 0xF8, 0x00, 0x1E, 0x7E, 0x00, 0x0F, 0x3F, 0x80,
  0x07, 0x8F, 0xE0, 0x03, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x04, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0,
  0x7C, 0x03, 0xF0, 0x00, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFE, 0x01, 0xF9,
  0xFC, 0x00, 0x3C, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0x3F,
  0x00, 0x1F, 0x8F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0x78, 0x07, 0xFE, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE2, 0x00, 0x03, 0xF1, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7D, 0xFF, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xE7, 0xF0, 0x1F, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x40, 0x03, 0xE7, 0x80, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8,
  0x7F, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFB, 0xFC, 0x00, 0x3E, 0x3F, 0x80, 0x0F, 0x87, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03,
  0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF0, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xFE, 0x0F, 0xFF, 0xBF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x3F, 0x83, 0xEF, 0x01, 0xF0, 0x3E, 0xF0, 0x1F, 0x01, 0xEF,
  0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F,
  0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F,
  0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00,
  0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0x80, 0x3F, 0x9F, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x01,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xC7, 0xC0, 0x07,
  0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x03, 0xEF, 0xFE, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0xF8, 0xFC, 0x00,
  0x3C, 0xFC, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7B,
  0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07,
  0x9F, 0x80, 0x07, 0xC7, 0xF0, 0x0F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x9E, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7E, 0x00, 0x18, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x80,
  0x00, 0x3E, 0xE0, 0x00, 0x7E, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xFC,
  0x00, 0x3C, 0xFC, 0x00, 0x79, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x1F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1E, 0x7C, 0x03, 0xC0, 0x7C, 0x78,
  0x0F, 0x80, 0xF8, 0xF0, 0x1F, 0x01, 0xE1, 0xE0, 0x3F, 0x03, 0xC3, 0xC0,
  0xFE, 0x07, 0x87, 0xC1, 0xFC, 0x0F, 0x0F, 0x83, 0xBC, 0x3E, 0x1F, 0x0F,
  0x78, 0x7C, 0x1E, 0x1E, 0xF0, 0xF0, 0x3C, 0x38, 0xF1, 0xE0, 0x78, 0xF1,
  0xE3, 0xC0, 0xF1, 0xE3, 0xC7, 0x81, 0xF7, 0x83, 0xDF, 0x03, 0xEF, 0x07,
  0xBE, 0x03, 0xDE, 0x07, 0x78, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x01,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0xFF, 0xF0, 0x07,
  0xBF, 0xFF, 0x00, 0xF7, 0x87, 0xF8, 0x3D, 0xE0, 0x3F, 0xFF, 0xBC, 0x01,
  0xFF, 0xE7, 0x00, 0x1F, 0xF8, 0x20, 0x00, 0xFE, 0x00,
};

const GFXglyph UbuntuSansMono_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 8, 42, 33, 12, -41 },
  { 43, 15, 16, 33, 9, -45 },
  { 73, 29, 41, 33, 2, -41 },
  { 222, 25, 52, 33, 4, -46 },
  { 385, 31, 43, 33, 1, -42 },
  { 552, 29, 43, 33, 2, -42 },
  { 708, 5, 17, 33, 14, -45 },
  { 719, 17, 57, 33, 8, -46 },
  { 841, 17, 57, 33, 8, -46 },
  { 963, 25, 24, 33, 4, -41 },
  { 1038, 27, 29, 33, 3, -32 },
  { 1136, 13, 18, 33, 10, -9 },
  { 1166, 13, 4, 33, 10, -19 },
  { 1173, 9, 10, 33, 12, -9 },
  { 1185, 23, 57, 33, 5, -46 },
  { 1349, 27, 43, 33, 3, -42 },
  { 1495, 24, 41, 33, 5, -41 },
  { 1618, 25, 42, 33, 4, -42 },
  { 1750, 25, 43, 33, 4, -42 },
  { 1885, 28, 41, 33, 3, -41 },
  { 2029, 24, 42, 33, 5, -41 },
  { 2155, 26, 42, 33, 4, -41 },
  { 2292, 26, 41, 33, 4, -41 },
  { 2426, 25, 43, 33, 4, -42 },
  { 2561, 26, 42, 33, 3, -42 },
  { 2698, 9, 32, 33, 12, -31 },
  { 2734, 13, 40, 33, 8, -31 },
  { 2799, 27, 26, 33, 3, -30 },
  { 2887, 27, 17, 33, 3, -26 },
  { 2945, 27, 26, 33, 3, -30 },
  { 3033, 20, 43, 33, 7, -42 },
  { 3141, 28, 51, 33, 3, -42 },
  { 3320, 31, 41, 33, 1, -41 },
  { 3479, 25, 41, 33, 4, -41 },
  { 3608, 27, 43, 33, 3, -42 },
  { 3754, 26, 41, 33, 4, -41 },
  { 3888, 23, 41, 33, 7, -41 },
  { 4006, 22, 41, 33, 7, -41 },
  { 4119, 27, 43, 33, 3, -42 },
  { 4265, 27, 41, 33, 3, -41 },
  { 4404, 19, 41, 33, 7, -41 },
  { 4502, 23, 42, 33, 4, -41 },
  { 4623, 28, 41, 33, 5, -41 },
  { 4767, 24, 41, 33, 6, -41 },
  { 4890, 29, 41, 33, 2, -41 },
  { 5039, 25, 41, 33, 4, -41 },
  { 5168, 29, 43, 33, 2, -42 },
  { 5324, 25, 41, 33, 5, -41 },
  { 5453, 29, 53, 33, 2, -42 },
  { 5646, 26, 41, 33, 4, -41 },
  { 5780, 25, 43, 33, 4, -42 },
  { 5915, 27, 41, 33, 3, -41 },
  { 6054, 27, 42, 33, 3, -41 },
  { 6196, 31, 41, 33, 1, -41 },
  { 6355, 29, 41, 33, 2, -41 },
  { 6504, 29, 41, 33, 2, -41 },
  { 6653, 31, 41, 33, 1, -41 },
  { 6812, 26, 41, 33, 4, -41 },
  { 6946, 15, 57, 33, 10, -46 },
  { 7053, 23, 57, 33, 5, -46 },
  { 7217, 15, 57, 33, 8, -46 },
  { 7324, 27, 22, 33, 3, -41 },
  { 7399, 32, 4, 33, 1, 7 },
  { 7415, 10, 12, 33, 11, -46 },
  { 7430, 24, 32, 33, 4, -31 },
  { 7526, 25, 47, 33, 5, -46 },
  { 7673, 27, 32, 33, 3, -31 },
  { 7781, 25, 47, 33, 3, -46 },
  { 7928, 27, 32, 33, 3, -31 },
  { 8036, 27, 46, 33, 5, -46 },
  { 8192, 25, 42, 33, 3, -31 },
  { 8324, 23, 46, 33, 5, -46 },
  { 8457, 25, 46, 33, 4, -45 },
  { 8601, 20, 56, 33, 5, -45 },
  { 8741, 26, 46, 33, 5, -46 },
  { 8891, 25, 46, 33, 4, -45 },
  { 9035, 28, 31, 33, 3, -31 },
  { 9144, 23, 31, 33, 5, -31 },
  { 9234, 27, 32, 33, 3, -31 },
  { 9342, 25, 42, 33, 5, -31 },
  { 9474, 25, 42, 33, 3, -31 },
  { 9606, 22, 31, 33, 7, -31 },
  { 9692, 24, 32, 33, 5, -31 },
  { 9788, 24, 41, 33, 5, -40 },
  { 9911, 23, 32, 33, 5, -31 },
  { 10003, 29, 31, 33, 2, -31 },
  { 10116, 31, 31, 33, 1, -31 },
  { 10237, 29, 31, 33, 2, -31 },
  { 10350, 27, 42, 33, 3, -31 },
  { 10492, 23, 31, 33, 5, -31 },
  { 10582, 23, 57, 33, 5, -46 },
  { 10746, 5, 57, 33, 14, -46 },
  { 10782, 23, 57, 33, 5, -46 },
  { 10946, 27, 9, 33, 3, -22 },
};

const GFXfont UbuntuSansMono_Regular59pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular59pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular59pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _UBUNTUSANSMONO_REGULAR59PT7B_H_
