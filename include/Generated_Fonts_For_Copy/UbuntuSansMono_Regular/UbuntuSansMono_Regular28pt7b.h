#ifndef _UBUNTUSANSMONO_REGULAR28PT7B_H_
#define _UBUNTUSANSMONO_REGULAR28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x40, 0x04, 0xFF, 0xE0, 0xC7,
  0x8F, 0x1E, 0x34, 0x68, 0x50, 0x80, 0x06, 0x38, 0x30, 0xC0, 0xC3, 0x03,
  0x0C, 0x0C, 0x33, 0xFF, 0xFF, 0xFF, 0xC6, 0x18, 0x18, 0x60, 0x61, 0x81,
  0x8E, 0x0E, 0x30, 0xFF, 0xFF, 0xFF, 0xF3, 0x0C, 0x0C, 0x30, 0x71, 0x81,
  0x86, 0x06, 0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3F, 0xE7,
  0x8C, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xE0, 0x1F, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x7F, 0x3E, 0xFF, 0xC0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x07, 0xF0, 0x6C, 0xC3, 0xB3,
  0x0C, 0x84, 0x62, 0x11, 0x88, 0x4C, 0x33, 0x70, 0xFD, 0x81, 0xEC, 0x00,
  0x30, 0x01, 0x9E, 0x0E, 0xD8, 0x32, 0x31, 0x98, 0xC6, 0x63, 0x31, 0x8D,
  0xC6, 0x36, 0x0C, 0xF0, 0x3E, 0x0F, 0x00, 0x7E, 0x03, 0x9C, 0x0C, 0x30,
  0x70, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x1F, 0x00, 0x78, 0x23, 0xE1,
  0x1D, 0xCC, 0x63, 0xB3, 0x86, 0xCE, 0x0F, 0x30, 0x38, 0xE0, 0xF3, 0x83,
  0xC7, 0xFB, 0x8F, 0xC7, 0xFF, 0xFF, 0x02, 0x07, 0x0E, 0x1C, 0x38, 0x30,
  0x70, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x02, 0x40, 0xE0, 0x70,
  0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0x40,
  0x06, 0x00, 0x60, 0x06, 0x0E, 0x66, 0xFF, 0xF1, 0xF8, 0x0F, 0x01, 0xB8,
  0x39, 0xC7, 0x1C, 0x10, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x38, 0xF3, 0xCF, 0x1C, 0x6F, 0x38, 0xFF, 0xF0, 0xEF, 0xFF,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x00, 0x0F, 0x03, 0xF8, 0x71, 0xC6, 0x0E, 0xE0, 0x6C, 0x07, 0xC0,
  0x7C, 0x03, 0xC6, 0x3C, 0xF3, 0xCF, 0x3C, 0x63, 0xC0, 0x3C, 0x03, 0xC0,
  0x7E, 0x06, 0x60, 0x67, 0x0E, 0x3F, 0xC1, 0xF8, 0x06, 0x03, 0xC0, 0xF8,
  0x7B, 0x0C, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xFD, 0xFF, 0x80, 0x1F,
  0x07, 0xFC, 0xE1, 0xC4, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xFC, 0x61, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0xF0, 0x0F, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x07, 0x00, 0x78, 0x0E, 0xFF, 0xCF, 0xF8, 0x00,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xD8, 0x06, 0x60, 0x31, 0x81, 0xC6, 0x06,
  0x18, 0x30, 0x60, 0xC1, 0x86, 0x06, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3F, 0xE3, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x7F, 0x80, 0x3C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x70, 0x07, 0x80, 0xE7, 0xFC,
  0xFF, 0x80, 0x00, 0x20, 0x3E, 0x0F, 0xC1, 0xC0, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xCF, 0x0F, 0xFC, 0xE0, 0xEC, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xE0, 0x76, 0x06, 0x3D, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x00, 0x0F, 0x03, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x6C, 0x07, 0xE0, 0x6E,
  0x06, 0x70, 0xC3, 0xF8, 0x3F, 0xC7, 0x1E, 0xE0, 0x6C, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x7E, 0x06, 0x79, 0xE3, 0xFC, 0x0F, 0x03, 0xFC, 0x70, 0xCE,
  0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0x7F, 0xF3,
  0xFF, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x78, 0x7E, 0x07,
  0x80, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0x38, 0xF3, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x8F, 0x3C, 0xF1, 0xC6, 0xF3, 0x80, 0x00, 0x30,
  0x0F, 0x03, 0xE1, 0xF0, 0x7C, 0x0E, 0x00, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x0C, 0x00, 0x3E, 0x3F,
  0xC4, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xC0,
  0x60, 0x18, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0F, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0x3F, 0xC1, 0xC3, 0x0E, 0x06, 0x30, 0x19, 0xC0, 0x76, 0x01, 0xD8,
  0x7F, 0x63, 0xDD, 0x8C, 0x76, 0x71, 0xF9, 0x87, 0xE6, 0x1D, 0x98, 0x76,
  0x61, 0xD9, 0xC7, 0x63, 0x9D, 0xC7, 0xF3, 0x07, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x33,
  0x00, 0x66, 0x01, 0x8C, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x60, 0x61, 0x80, 0xC3, 0xFF, 0xC7, 0xFF, 0x9C, 0x03, 0x30, 0x06, 0x60,
  0x0E, 0xC0, 0x0F, 0x80, 0x18, 0x38, 0x0F, 0xF8, 0xC3, 0xCC, 0x0E, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xC1, 0xCF, 0xF8, 0xFF, 0xCC, 0x0E, 0xC0,
  0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x0E, 0xFF, 0xCF, 0xF8, 0x07,
  0xC1, 0xFF, 0x3C, 0x37, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x81, 0x3F, 0xF0, 0xFF, 0x30, 0x0F, 0xF0, 0xC7, 0xCC, 0x0C, 0xC0,
  0x6C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x1C, 0xFF, 0x8F, 0xE0, 0xFF,
  0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF,
  0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xFF, 0xDF, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x00, 0x07, 0xC1, 0xFF, 0x3C, 0x37, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x36, 0x03, 0x70, 0x33, 0x83, 0x3F, 0xF0, 0xFF, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x3F, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x80, 0xDE, 0xF9, 0xFE, 0x00, 0xC0, 0x7E, 0x03,
  0x30, 0x39, 0x83, 0x8C, 0x38, 0x63, 0x83, 0x38, 0x1B, 0x80, 0xF8, 0x07,
  0xE0, 0x33, 0x81, 0x8E, 0x0C, 0x38, 0x60, 0xE3, 0x03, 0x98, 0x0C, 0xC0,
  0x76, 0x01, 0xF0, 0x06, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x70, 0x31, 0xC1, 0xC7, 0x87,
  0x9E, 0x1E, 0x78, 0xD9, 0xB3, 0x66, 0xCD, 0x9B, 0x26, 0x67, 0x99, 0x9E,
  0x66, 0x31, 0xB8, 0xC6, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0,
  0x1B, 0x00, 0x7C, 0x01, 0xC0, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xD8,
  0x3D, 0x83, 0xCC, 0x3C, 0xC3, 0xC6, 0x3C, 0x63, 0xC3, 0x3C, 0x33, 0xC1,
  0xBC, 0x1B, 0xC1, 0xBC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x70, 0x07, 0x80,
  0x7F, 0x83, 0x87, 0x1C, 0x0C, 0x60, 0x3B, 0x80, 0x6E, 0x01, 0xB0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0x98, 0x06, 0x60, 0x38, 0xC1, 0xC3, 0xFE, 0x03, 0xF0, 0x1E, 0x0F, 0xFC,
  0xE1, 0xEE, 0x06, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x06,
  0xE3, 0xEF, 0xFC, 0xF8, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x80, 0x7F, 0x83, 0x87, 0x1C, 0x0C, 0x60, 0x3B,
  0x80, 0x6E, 0x01, 0xB0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0x98, 0x06, 0x60, 0x38, 0xC1, 0xC3, 0xFE,
  0x07, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x38, 0x38,
  0x0F, 0xF8, 0xC3, 0xCC, 0x0E, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0,
  0x6C, 0x0C, 0xFF, 0xCF, 0xF0, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0,
  0xEC, 0x06, 0xC0, 0x7C, 0x03, 0x0F, 0x83, 0xFE, 0x70, 0x66, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x78, 0x06, 0xFF, 0xE7, 0xF8, 0xFF,
  0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x67, 0xFE, 0x3F, 0xC0, 0xE0,
  0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8E, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x30, 0xC0, 0x61, 0x80, 0xC7, 0x01,
  0xCC, 0x01, 0x98, 0x03, 0x70, 0x07, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6E, 0x01, 0xB8,
  0xC6, 0x67, 0x19, 0x9E, 0x66, 0x59, 0x9B, 0x26, 0x6C, 0xD9, 0xA3, 0x67,
  0x8D, 0x9E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x03, 0x00, 0xE0, 0x1D, 0xC0,
  0xC3, 0x07, 0x0E, 0x18, 0x18, 0xE0, 0x73, 0x00, 0xDC, 0x01, 0xE0, 0x07,
  0x00, 0x1E, 0x00, 0xF8, 0x03, 0x30, 0x18, 0xE0, 0x61, 0x83, 0x07, 0x0C,
  0x0C, 0x60, 0x39, 0x80, 0x6E, 0x01, 0xC0, 0xE0, 0x0E, 0xE0, 0x1C, 0xC0,
  0x31, 0xC0, 0xE1, 0x81, 0x83, 0x87, 0x03, 0x0C, 0x07, 0x30, 0x06, 0x60,
  0x0F, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8,
  0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0xFF, 0xF8, 0x07, 0x00, 0x3C, 0x03, 0x60, 0x19, 0x81, 0x8E, 0x1C, 0x30,
  0xC0, 0xCE, 0x06, 0x60, 0x1E, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x47,
  0x18, 0x61, 0x88, 0x7F, 0x07, 0xF8, 0x83, 0x80, 0x30, 0x06, 0x00, 0xC3,
  0xF9, 0xFF, 0x70, 0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x06, 0xFF, 0xCF, 0xF8,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xF0,
  0xFF, 0xCF, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x0E, 0xFF, 0xCF, 0xF8, 0x07, 0xE1, 0xFF,
  0x78, 0x27, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x7B, 0x1F, 0xF3, 0x87, 0x70,
  0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x70,
  0x33, 0x83, 0x1F, 0xF0, 0xFF, 0x07, 0x80, 0xFF, 0x0E, 0x1C, 0xE0, 0x76,
  0x01, 0xB0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x1F, 0xF8, 0x3F, 0xC0, 0x01, 0xE0, 0x3F, 0xC3, 0x86, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x1F, 0xFC, 0xFF, 0xE0, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x07, 0xE1, 0xFF, 0x38, 0x37, 0x03,
  0x60, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x37, 0x03,
  0x3D, 0xF1, 0xFF, 0x02, 0x30, 0x03, 0x00, 0x30, 0x07, 0x7F, 0xE7, 0xFC,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xF8, 0xFF,
  0xDC, 0x3F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0x80, 0xF0, 0x38, 0x06, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x7F, 0xBF, 0xC0,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x06, 0xE0, 0x67, 0x06, 0x38, 0x61, 0xCE, 0x0E, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0xE7, 0x07, 0x1C, 0x38, 0x71, 0xC1, 0xCE, 0x07, 0x70, 0x1C,
  0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0x7C, 0xE3, 0xFF,
  0xEE, 0x71, 0xB8, 0xC6, 0xE3, 0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0,
  0x3F, 0x1F, 0xFB, 0x87, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x18, 0x07, 0x80, 0xFF,
  0x0E, 0x3C, 0xE0, 0x66, 0x03, 0xB0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xD8, 0x06, 0xE0, 0x73, 0x07, 0x1F, 0xF0, 0x3F, 0x00, 0x3F, 0x0F,
  0xFC, 0xE1, 0xEE, 0x06, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0x8E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0xC1, 0xFF, 0x3C, 0x37, 0x03, 0x60, 0x36,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x37, 0x03, 0x30, 0x33,
  0xFF, 0x0F, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x3F, 0xFF,
  0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0xC3, 0xFE, 0x70, 0x2E, 0x00, 0xE0,
  0x07, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x80,
  0x6F, 0xFE, 0xFF, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0x07, 0xF0, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81,
  0xB0, 0x37, 0x06, 0x7F, 0xC7, 0xF8, 0xE0, 0x1F, 0x80, 0x66, 0x01, 0x98,
  0x0E, 0x70, 0x30, 0xC0, 0xC3, 0x07, 0x0E, 0x18, 0x18, 0x60, 0x73, 0x00,
  0xCC, 0x03, 0x60, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC3, 0x1F, 0x0C, 0x6E, 0x79, 0x99, 0xE6, 0x65,
  0x99, 0xB3, 0x66, 0xCD, 0x9E, 0x3C, 0x38, 0x70, 0xC1, 0xC3, 0x03, 0x00,
  0xE0, 0x19, 0xC0, 0xC3, 0x07, 0x06, 0x18, 0x1C, 0xC0, 0x3F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x33, 0x01, 0xCE, 0x0E, 0x1C, 0x30, 0x31, 0x80,
  0xEE, 0x01, 0xC0, 0x60, 0x1B, 0x00, 0xDC, 0x0E, 0xE0, 0x73, 0x03, 0x1C,
  0x18, 0x61, 0xC3, 0x0C, 0x1C, 0x60, 0x63, 0x03, 0x30, 0x0D, 0x80, 0x6C,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x30, 0x1F, 0x81, 0xF0, 0x00,
  0x7F, 0xEF, 0xFC, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xC3, 0xF1,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x70, 0x3C, 0x0F, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x03, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x1F, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0xC0, 0xF8, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x1F, 0xC3, 0xF0, 0x00, 0x3E, 0x0B, 0xF8, 0xF0, 0xFC, 0x81, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 7, 7, 16, 4, -21 },
  { 18, 14, 19, 16, 1, -19 },
  { 52, 12, 25, 16, 2, -22 },
  { 90, 14, 20, 16, 1, -20 },
  { 125, 14, 20, 16, 1, -20 },
  { 160, 2, 8, 16, 7, -21 },
  { 162, 8, 27, 16, 4, -22 },
  { 189, 8, 27, 16, 4, -22 },
  { 216, 12, 11, 16, 2, -19 },
  { 233, 12, 14, 16, 2, -15 },
  { 254, 6, 8, 16, 5, -4 },
  { 260, 6, 2, 16, 5, -9 },
  { 262, 4, 4, 16, 6, -4 },
  { 264, 11, 27, 16, 2, -22 },
  { 302, 12, 20, 16, 2, -20 },
  { 332, 11, 19, 16, 3, -19 },
  { 359, 12, 20, 16, 2, -20 },
  { 389, 12, 20, 16, 2, -20 },
  { 419, 14, 19, 16, 1, -19 },
  { 453, 12, 19, 16, 2, -19 },
  { 482, 12, 20, 16, 2, -20 },
  { 512, 12, 19, 16, 2, -19 },
  { 541, 12, 20, 16, 2, -20 },
  { 571, 12, 20, 16, 2, -20 },
  { 601, 4, 14, 16, 6, -14 },
  { 608, 6, 18, 16, 4, -14 },
  { 622, 12, 12, 16, 2, -14 },
  { 640, 12, 8, 16, 2, -12 },
  { 652, 12, 12, 16, 2, -14 },
  { 670, 10, 20, 16, 3, -20 },
  { 695, 14, 24, 16, 1, -20 },
  { 737, 15, 19, 16, 0, -19 },
  { 773, 12, 20, 16, 2, -20 },
  { 803, 12, 20, 16, 2, -20 },
  { 833, 12, 20, 16, 2, -20 },
  { 863, 11, 19, 16, 3, -19 },
  { 890, 11, 19, 16, 3, -19 },
  { 917, 12, 20, 16, 2, -20 },
  { 947, 13, 19, 16, 1, -19 },
  { 978, 10, 19, 16, 3, -19 },
  { 1002, 11, 19, 16, 2, -19 },
  { 1029, 13, 19, 16, 2, -19 },
  { 1060, 11, 19, 16, 3, -19 },
  { 1087, 14, 19, 16, 1, -19 },
  { 1121, 12, 19, 16, 2, -19 },
  { 1150, 14, 20, 16, 1, -20 },
  { 1185, 12, 20, 16, 2, -20 },
  { 1215, 14, 25, 16, 1, -20 },
  { 1259, 12, 20, 16, 2, -20 },
  { 1289, 12, 20, 16, 2, -20 },
  { 1319, 13, 19, 16, 1, -19 },
  { 1350, 12, 19, 16, 2, -19 },
  { 1379, 15, 19, 16, 0, -19 },
  { 1415, 14, 19, 16, 1, -19 },
  { 1449, 14, 19, 16, 1, -19 },
  { 1483, 15, 19, 16, 0, -19 },
  { 1519, 12, 19, 16, 2, -19 },
  { 1548, 7, 27, 16, 5, -22 },
  { 1572, 11, 27, 16, 2, -22 },
  { 1610, 7, 27, 16, 4, -22 },
  { 1634, 13, 10, 16, 1, -19 },
  { 1651, 15, 2, 16, 0, 3 },
  { 1655, 5, 6, 16, 5, -22 },
  { 1659, 11, 15, 16, 2, -15 },
  { 1680, 12, 22, 16, 2, -22 },
  { 1713, 12, 15, 16, 2, -15 },
  { 1736, 12, 22, 16, 1, -22 },
  { 1769, 13, 15, 16, 1, -15 },
  { 1794, 13, 22, 16, 2, -22 },
  { 1830, 12, 20, 16, 1, -15 },
  { 1860, 11, 22, 16, 2, -22 },
  { 1891, 12, 21, 16, 2, -21 },
  { 1923, 10, 26, 16, 2, -21 },
  { 1956, 13, 22, 16, 2, -22 },
  { 1992, 12, 22, 16, 2, -22 },
  { 2025, 14, 15, 16, 1, -15 },
  { 2052, 11, 15, 16, 2, -15 },
  { 2073, 13, 15, 16, 1, -15 },
  { 2098, 12, 20, 16, 2, -15 },
  { 2128, 12, 20, 16, 1, -15 },
  { 2158, 10, 15, 16, 4, -15 },
  { 2177, 12, 15, 16, 2, -15 },
  { 2200, 12, 19, 16, 2, -19 },
  { 2229, 11, 15, 16, 2, -15 },
  { 2250, 14, 15, 16, 1, -15 },
  { 2277, 14, 15, 16, 1, -15 },
  { 2304, 14, 15, 16, 1, -15 },
  { 2331, 13, 20, 16, 1, -15 },
  { 2364, 11, 15, 16, 2, -15 },
  { 2385, 10, 27, 16, 3, -22 },
  { 2419, 2, 27, 16, 7, -22 },
  { 2426, 11, 27, 16, 2, -22 },
  { 2464, 13, 4, 16, 1, -10 },
};

const GFXfont UbuntuSansMono_Regular28pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular28pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular28pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUSANSMONO_REGULAR28PT7B_H_
