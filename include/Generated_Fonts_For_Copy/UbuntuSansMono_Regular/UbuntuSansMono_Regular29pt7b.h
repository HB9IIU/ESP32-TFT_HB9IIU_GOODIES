#ifndef _UBUNTUSANSMONO_REGULAR29PT7B_H_
#define _UBUNTUSANSMONO_REGULAR29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F, 0xFF, 0xC7,
  0x8F, 0x1E, 0x38, 0x70, 0xA1, 0x42, 0x06, 0x18, 0x18, 0x60, 0xE3, 0x83,
  0x0E, 0x0C, 0x33, 0xFF, 0xFF, 0xFF, 0xC7, 0x1C, 0x18, 0x70, 0x61, 0x81,
  0x86, 0x06, 0x18, 0x38, 0x63, 0xFF, 0xFF, 0xFF, 0xCC, 0x30, 0x30, 0xC0,
  0xC3, 0x07, 0x1C, 0x18, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x1F,
  0xE7, 0xFE, 0x70, 0x2E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x07, 0xFF,
  0xEF, 0xFC, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x10, 0x00, 0xF8, 0x1B,
  0x30, 0x66, 0x21, 0xC8, 0x63, 0x10, 0xCC, 0x21, 0x98, 0x62, 0x60, 0xCD,
  0xC0, 0xFB, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x67, 0xC0, 0xD9, 0x83, 0x31,
  0x0C, 0x43, 0x18, 0x86, 0x61, 0x0C, 0xC3, 0x33, 0x06, 0x6C, 0x07, 0x80,
  0x02, 0x00, 0x7E, 0x03, 0x9C, 0x0C, 0x38, 0x30, 0x60, 0xC3, 0x83, 0x0C,
  0x0C, 0x70, 0x3B, 0x80, 0x7C, 0x01, 0xE1, 0x8F, 0x86, 0x77, 0x19, 0x8E,
  0x4E, 0x1F, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xC7, 0x0F, 0x9F, 0xF6, 0x3F,
  0x1C, 0xFF, 0xFF, 0x02, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0x60,
  0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x40, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x38, 0x70, 0xE0, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x04, 0x63, 0xF6, 0xF7, 0xFF, 0x06, 0x00, 0xF0, 0x19,
  0x83, 0x9C, 0x30, 0xE1, 0x08, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3C, 0xF3, 0xCF, 0x0C, 0x7F, 0xBC,
  0x80, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x02,
  0x00, 0xFC, 0x0F, 0xF0, 0xE1, 0xC6, 0x07, 0x70, 0x3B, 0x80, 0xD8, 0x06,
  0xC2, 0x36, 0x39, 0xF3, 0xCF, 0x8E, 0x7C, 0x63, 0xE0, 0x1B, 0x00, 0xDC,
  0x06, 0xE0, 0x73, 0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF8, 0x00, 0x06, 0x01,
  0xC0, 0x78, 0x3F, 0x0E, 0x61, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF,
  0xBF, 0xF0, 0x0C, 0x03, 0xFC, 0xFF, 0xE4, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x04, 0x07,
  0xF8, 0x7F, 0xC4, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0xF8, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x80, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00,
  0xFC, 0x07, 0x70, 0x19, 0xC0, 0xC7, 0x07, 0x1C, 0x18, 0x70, 0xC1, 0xC3,
  0x07, 0x18, 0x1C, 0x60, 0x73, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x3F, 0xF3, 0xFF, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x74, 0x07, 0x7F, 0xEF, 0xFC, 0x01,
  0xE0, 0x3F, 0x07, 0x80, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xDF, 0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x03, 0x60, 0x1F, 0x00, 0xFC,
  0x06, 0x60, 0x33, 0x83, 0x8F, 0x78, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x00, 0x02, 0x01, 0xFC, 0x79, 0xE6, 0x07, 0xE0,
  0x7C, 0x03, 0xE0, 0x3E, 0x07, 0x70, 0x67, 0x8C, 0x1F, 0x83, 0xFE, 0x70,
  0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x77, 0xFE, 0x3F,
  0xC0, 0x06, 0x03, 0xFC, 0x79, 0xE6, 0x06, 0xE0, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0x70, 0x77, 0xFF, 0x1F, 0xB0, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x1C, 0x07, 0x87, 0xF0, 0x78, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0xC7, 0xCF, 0x06, 0x1C, 0xF3, 0xC4, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x80, 0x07, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x08, 0x3F,
  0xC6, 0x78, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0,
  0x30, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0xC0, 0xF0, 0x1C,
  0x00, 0x01, 0x00, 0x7F, 0x0F, 0xFC, 0x60, 0x67, 0x03, 0xB0, 0x0F, 0x80,
  0x7C, 0x1F, 0xC3, 0xFE, 0x38, 0xF1, 0x87, 0x9C, 0x3C, 0xE1, 0xE7, 0x0F,
  0x38, 0x79, 0xC3, 0xC6, 0x1F, 0x3C, 0xF8, 0xFE, 0xC1, 0xC7, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xFC, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x30, 0x0C, 0x3F, 0xFC, 0x3F, 0xFC,
  0x30, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xFF, 0x8F,
  0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x6C, 0x0E, 0xC7, 0xCF,
  0xF8, 0xC7, 0xEC, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x0F, 0xFF, 0xEF, 0xF8, 0x01, 0x80, 0x7F, 0xC7, 0xFC, 0x70, 0x27, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x02, 0x3F,
  0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x30, 0x79, 0x80, 0xCC, 0x07, 0x60,
  0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x66, 0x0F, 0x3F, 0xE1, 0xFE, 0x00,
  0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0xFC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x01, 0x00,
  0x7F, 0xC7, 0xBC, 0x70, 0x27, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07,
  0x60, 0x3B, 0x81, 0xCE, 0x0E, 0x3F, 0xF0, 0xFF, 0x80, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x3F, 0xE7, 0xFC,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x68, 0x1F, 0xFF, 0x3F,
  0xC0, 0xE0, 0x3B, 0x81, 0xCE, 0x06, 0x38, 0x38, 0xE1, 0xC3, 0x8E, 0x0E,
  0x70, 0x3B, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xE0, 0x3B, 0xC0, 0xE3, 0x83,
  0x87, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xB8, 0x07,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x30, 0x39, 0xC0, 0xE7, 0x83, 0x9E,
  0x1E, 0x78, 0x79, 0xB1, 0x66, 0xCD, 0x9B, 0x36, 0x66, 0x9D, 0x9E, 0x36,
  0x38, 0xD8, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xD8,
  0x3D, 0x83, 0xCC, 0x3C, 0xC3, 0xC6, 0x3C, 0x63, 0xC3, 0x3C, 0x33, 0xC1,
  0xBC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0x01,
  0x00, 0x7F, 0x83, 0xCF, 0x0C, 0x0E, 0x70, 0x19, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x07, 0x60, 0x1D, 0xC0, 0x63, 0x03, 0x8F, 0xFC, 0x0F, 0xE0,
  0xFF, 0x8F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x06,
  0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x7F, 0x83, 0xCF, 0x0C,
  0x0E, 0x70, 0x19, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x07, 0x60, 0x1D,
  0xC0, 0x63, 0x03, 0x8F, 0xFC, 0x0F, 0xE0, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF8, 0x00, 0xE0, 0xFF, 0x87, 0xFE, 0x30, 0x39, 0x80, 0xCC, 0x07,
  0x60, 0x1B, 0x01, 0xD8, 0x0E, 0xC0, 0x66, 0x0F, 0x3F, 0xF1, 0xFE, 0x0C,
  0x38, 0x60, 0xC3, 0x03, 0x18, 0x18, 0xC0, 0x66, 0x03, 0xB0, 0x0D, 0x80,
  0x70, 0x02, 0x01, 0xFF, 0x3D, 0xE7, 0x02, 0x60, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x80, 0x7F, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xE0, 0x33,
  0x03, 0x9F, 0xF8, 0x7F, 0x80, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x70,
  0x06, 0x30, 0x0E, 0x30, 0x0C, 0x38, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x1C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0E, 0x30, 0x06, 0x70, 0x06,
  0x60, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xD8, 0x03, 0x63,
  0x0D, 0x9E, 0x36, 0x78, 0x99, 0xA6, 0x6C, 0xD9, 0xB3, 0x66, 0xC5, 0x9E,
  0x1E, 0x78, 0x79, 0xE0, 0xE7, 0x03, 0x8C, 0x0E, 0xE0, 0x1D, 0xC0, 0x63,
  0x03, 0x8E, 0x1C, 0x18, 0x60, 0x73, 0x80, 0xCC, 0x03, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0C, 0xE0, 0x71, 0x81, 0x87, 0x0C, 0x0C,
  0x30, 0x39, 0xC0, 0x66, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x70, 0x06, 0x70,
  0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x0E, 0x30, 0x06,
  0x70, 0x07, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xF0, 0xE0, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x07, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x1F, 0xF0, 0x06, 0x00, 0x78, 0x03, 0xE0, 0x33, 0x03, 0x9C,
  0x18, 0x61, 0xC1, 0x8C, 0x0C, 0xC0, 0x36, 0x01, 0xD0, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0x27, 0x18, 0x61, 0x8C, 0x3F, 0xC3, 0xFE, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x1F, 0xF7, 0xFF, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x37, 0xFF, 0x3F, 0xF0, 0x20, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xC7, 0xFF, 0x38, 0x1D, 0xC0,
  0x6E, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0D,
  0xC0, 0xEE, 0x0E, 0x7F, 0xF3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x9E, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0F, 0xD9, 0xFF,
  0xCE, 0x0E, 0xE0, 0x36, 0x01, 0xB0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1B,
  0x00, 0xD8, 0x06, 0xE0, 0x33, 0x81, 0x8F, 0xFC, 0x3F, 0xE0, 0x0F, 0xE0,
  0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x19, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0x40, 0x0F, 0xF0, 0xFF, 0x83, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0xFF, 0xF3, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0xCE, 0x06, 0xE0,
  0x36, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06,
  0xE0, 0x73, 0xFF, 0x8F, 0xFC, 0x08, 0x60, 0x07, 0x00, 0x38, 0x03, 0x8F,
  0xFC, 0xFF, 0x80, 0x20, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xCF, 0xFE, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x30, 0x0C, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0x03,
  0x03, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0xFF, 0xBF, 0x81, 0x00, 0x20, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x3F, 0x03, 0x38,
  0x31, 0xC7, 0x0E, 0x70, 0x77, 0x03, 0xF0, 0x1F, 0x80, 0xEE, 0x07, 0x3C,
  0x38, 0xF1, 0xC1, 0xCE, 0x07, 0x70, 0x1B, 0x80, 0xE0, 0xFE, 0x0F, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0xF0, 0x3F, 0xFE, 0xFB, 0xFF, 0xEE, 0x31, 0xF8,
  0xC3, 0xE3, 0x0F, 0x8C, 0x3E, 0x30, 0xF8, 0xC3, 0xE3, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xC0, 0xFF, 0xCF, 0xFE,
  0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0x0F, 0xC0, 0x7F, 0xC3,
  0x87, 0x1C, 0x0E, 0x60, 0x19, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D,
  0x80, 0x76, 0x01, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0xC0, 0xFC, 0x00, 0xFF,
  0x87, 0xFF, 0x38, 0x39, 0xC0, 0xEE, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0D, 0xC0, 0xEE, 0x07, 0x7F, 0xF3, 0xFF, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xCE,
  0x06, 0xE0, 0x36, 0x01, 0xB0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x00,
  0xD8, 0x06, 0xE0, 0x33, 0x83, 0x9F, 0xFC, 0x3F, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x3F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x3E, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x40, 0x7F, 0xFE, 0x7F, 0xC0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x70,
  0x33, 0xFF, 0x1F, 0xF0, 0xE0, 0x0D, 0x80, 0x76, 0x01, 0x9C, 0x06, 0x30,
  0x38, 0xC0, 0xC3, 0x83, 0x06, 0x1C, 0x18, 0x60, 0x73, 0x80, 0xCC, 0x03,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x80, 0x1B, 0x00,
  0x36, 0x00, 0x6C, 0x30, 0xDC, 0x71, 0x99, 0xE3, 0x33, 0xCE, 0x66, 0xD8,
  0xD9, 0xB1, 0xB3, 0x63, 0xC3, 0xC3, 0x87, 0x87, 0x06, 0x0C, 0x0C, 0x00,
  0xE0, 0x1D, 0xC0, 0xE3, 0x87, 0x07, 0x18, 0x0E, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x33, 0x81, 0xC6, 0x0E, 0x1C, 0x30, 0x39, 0x80,
  0x6E, 0x01, 0xC0, 0x60, 0x1D, 0xC0, 0x67, 0x01, 0x8C, 0x06, 0x38, 0x38,
  0xE0, 0xC1, 0x83, 0x07, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xE6, 0x01, 0xB0,
  0x07, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x05, 0xE0,
  0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xE1, 0xFC, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xE0, 0x3C, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x3C, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x1F, 0x01, 0xF0, 0x1C, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x1E, 0x0F, 0xC0, 0x18, 0x09, 0xF8, 0x36, 0x79, 0xB0, 0x7E,
  0x00, 0x60,
};

const GFXglyph UbuntuSansMono_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 7, 8, 16, 5, -22 },
  { 18, 14, 20, 16, 1, -20 },
  { 53, 12, 26, 16, 2, -23 },
  { 92, 15, 21, 16, 1, -21 },
  { 132, 14, 21, 16, 1, -21 },
  { 169, 2, 8, 16, 7, -22 },
  { 171, 8, 28, 16, 4, -23 },
  { 199, 8, 28, 16, 4, -23 },
  { 227, 12, 12, 16, 2, -20 },
  { 245, 13, 15, 16, 2, -16 },
  { 270, 6, 9, 16, 5, -4 },
  { 277, 6, 2, 16, 5, -9 },
  { 279, 4, 4, 16, 6, -4 },
  { 281, 12, 28, 16, 2, -23 },
  { 323, 13, 21, 16, 2, -21 },
  { 358, 11, 20, 16, 3, -20 },
  { 386, 12, 21, 16, 2, -21 },
  { 418, 12, 21, 16, 2, -21 },
  { 450, 14, 20, 16, 1, -20 },
  { 485, 12, 20, 16, 2, -20 },
  { 515, 13, 20, 16, 2, -20 },
  { 548, 13, 20, 16, 2, -20 },
  { 581, 12, 21, 16, 2, -21 },
  { 613, 12, 21, 16, 2, -21 },
  { 645, 4, 15, 16, 6, -15 },
  { 653, 7, 20, 16, 4, -15 },
  { 671, 13, 13, 16, 2, -15 },
  { 693, 13, 9, 16, 2, -13 },
  { 708, 13, 13, 16, 2, -15 },
  { 730, 10, 21, 16, 3, -21 },
  { 757, 13, 25, 16, 2, -21 },
  { 798, 16, 20, 16, 0, -20 },
  { 838, 12, 20, 16, 2, -20 },
  { 868, 13, 21, 16, 2, -21 },
  { 903, 13, 20, 16, 2, -20 },
  { 936, 12, 20, 16, 3, -20 },
  { 966, 11, 20, 16, 3, -20 },
  { 994, 13, 21, 16, 2, -21 },
  { 1029, 14, 20, 16, 1, -20 },
  { 1064, 10, 20, 16, 3, -20 },
  { 1089, 11, 20, 16, 2, -20 },
  { 1117, 14, 20, 16, 2, -20 },
  { 1152, 12, 20, 16, 3, -20 },
  { 1182, 14, 20, 16, 1, -20 },
  { 1217, 12, 20, 16, 2, -20 },
  { 1247, 14, 21, 16, 1, -21 },
  { 1284, 12, 20, 16, 3, -20 },
  { 1314, 14, 26, 16, 1, -21 },
  { 1360, 13, 20, 16, 2, -20 },
  { 1393, 12, 21, 16, 2, -21 },
  { 1425, 14, 20, 16, 1, -20 },
  { 1460, 13, 20, 16, 2, -20 },
  { 1493, 16, 20, 16, 0, -20 },
  { 1533, 14, 20, 16, 1, -20 },
  { 1568, 14, 20, 16, 1, -20 },
  { 1603, 16, 20, 16, 0, -20 },
  { 1643, 13, 20, 16, 2, -20 },
  { 1676, 7, 28, 16, 5, -23 },
  { 1701, 12, 28, 16, 2, -23 },
  { 1743, 7, 28, 16, 4, -23 },
  { 1768, 13, 11, 16, 2, -20 },
  { 1786, 16, 2, 16, 0, 3 },
  { 1790, 5, 6, 16, 5, -23 },
  { 1794, 12, 15, 16, 2, -15 },
  { 1817, 13, 23, 16, 2, -23 },
  { 1855, 13, 15, 16, 2, -15 },
  { 1880, 13, 23, 16, 1, -23 },
  { 1918, 14, 15, 16, 1, -15 },
  { 1945, 14, 23, 16, 2, -23 },
  { 1986, 13, 20, 16, 1, -15 },
  { 2019, 12, 23, 16, 2, -23 },
  { 2054, 12, 22, 16, 2, -22 },
  { 2087, 9, 28, 16, 3, -22 },
  { 2119, 13, 23, 16, 2, -23 },
  { 2157, 12, 22, 16, 2, -22 },
  { 2190, 14, 15, 16, 1, -15 },
  { 2217, 12, 15, 16, 2, -15 },
  { 2240, 14, 15, 16, 1, -15 },
  { 2267, 13, 20, 16, 2, -15 },
  { 2300, 13, 20, 16, 1, -15 },
  { 2333, 10, 15, 16, 4, -15 },
  { 2352, 12, 15, 16, 2, -15 },
  { 2375, 12, 20, 16, 2, -20 },
  { 2405, 12, 15, 16, 2, -15 },
  { 2428, 14, 15, 16, 1, -15 },
  { 2455, 15, 15, 16, 1, -15 },
  { 2484, 14, 15, 16, 1, -15 },
  { 2511, 14, 20, 16, 1, -15 },
  { 2546, 12, 15, 16, 2, -15 },
  { 2569, 11, 28, 16, 3, -23 },
  { 2608, 2, 28, 16, 7, -23 },
  { 2615, 12, 28, 16, 2, -23 },
  { 2657, 14, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_Regular29pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular29pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular29pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUSANSMONO_REGULAR29PT7B_H_
