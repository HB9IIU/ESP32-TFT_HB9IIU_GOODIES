#ifndef _UBUNTUSANSMONO_REGULAR30PT7B_H_
#define _UBUNTUSANSMONO_REGULAR30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x62, 0x00, 0x06, 0xFF, 0x70,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x06, 0x1C, 0x0C, 0x30, 0x18,
  0x60, 0x70, 0xC0, 0xE1, 0x81, 0x87, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x30,
  0x38, 0x60, 0x61, 0xC0, 0xC3, 0x81, 0x86, 0x1F, 0xFF, 0xFF, 0xFF, 0x98,
  0x70, 0x30, 0xE0, 0x61, 0x80, 0xC3, 0x03, 0x86, 0x06, 0x1C, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1F, 0x83, 0xFF, 0x3C, 0x11, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0xEF, 0xFF, 0x7F, 0xE0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x78, 0x0F, 0xD8, 0x1B, 0x18, 0x66,
  0x30, 0xCC, 0x63, 0x18, 0xCE, 0x31, 0x98, 0x63, 0x60, 0xEC, 0xC0, 0xF3,
  0x00, 0x0E, 0x00, 0x19, 0xC0, 0x67, 0xC0, 0xD8, 0xC3, 0x31, 0x8E, 0x63,
  0x18, 0xC6, 0x61, 0x8C, 0xC3, 0x1B, 0x07, 0x7E, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x80, 0xE3, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x30, 0x1C,
  0xE0, 0x1B, 0x80, 0x3E, 0x00, 0x78, 0x61, 0xB8, 0xC7, 0x39, 0x8C, 0x3B,
  0x38, 0x3E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xF1, 0xC3, 0xE3, 0xFE, 0xE1,
  0xF8, 0xE0, 0xFF, 0xFF, 0xB6, 0x40, 0x03, 0x03, 0xC3, 0x83, 0x81, 0xC1,
  0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xE0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xE0, 0x60, 0x10, 0x60, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x0C, 0x04, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xC1, 0x0C, 0x2F, 0x27, 0x7F, 0xFC, 0x7F, 0x00,
  0xE0, 0x0D, 0x80, 0xEE, 0x0E, 0x38, 0x21, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x7C, 0xF8,
  0xF0, 0xC3, 0x9E, 0x78, 0x40, 0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xE0, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x00, 0x1F, 0x81, 0xFF, 0x0C, 0x38, 0xE0, 0xE6, 0x03, 0x70,
  0x1F, 0x80, 0xF8, 0x07, 0xC7, 0x3E, 0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x33, 0x03, 0x9C, 0x18, 0x7F, 0xC1,
  0xFC, 0x00, 0x03, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0xF7, 0x0C, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xC3,
  0xFF, 0x38, 0x38, 0x80, 0xE0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x83, 0xFF,
  0x18, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x01, 0xC0,
  0x7C, 0x03, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xA0, 0x1D, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xE6, 0x01, 0x8C, 0x06, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x1C, 0x06, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x7F, 0xE7, 0xFE, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x78, 0x07, 0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x80, 0xEF, 0xFC, 0xFF, 0x80, 0x00, 0xF0, 0x1F, 0x83,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE3, 0x07, 0xFF,
  0x3E, 0x7D, 0x80, 0x6C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x3B,
  0x01, 0xDC, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x1F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0,
  0x6E, 0x03, 0x70, 0x1B, 0x80, 0xCC, 0x06, 0x70, 0x61, 0xFF, 0x07, 0xF0,
  0x73, 0xC6, 0x07, 0x70, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x01, 0xF8,
  0x1C, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0x81, 0xFF, 0x1C, 0x19, 0xC0, 0xEE,
  0x03, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xDE, 0x1E, 0x7F,
  0xF0, 0xF3, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0xFE, 0x07, 0x80, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xEF,
  0xFD, 0xC0, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE3, 0xE7, 0xC7, 0x86, 0x1C, 0xF3, 0xC2, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x60, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x01, 0xE0, 0x0C, 0x00, 0x00, 0x7F, 0x1F, 0xF9, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x0F, 0xE0,
  0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x70, 0x19, 0x80, 0x7E, 0x01, 0xF8, 0x7F,
  0xC3, 0xFF, 0x1C, 0x7C, 0x61, 0xF3, 0x87, 0xCE, 0x1F, 0x38, 0x7C, 0xE1,
  0xF1, 0x87, 0xE7, 0x1F, 0x8E, 0x7E, 0x1F, 0xDC, 0x10, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0x00, 0x01, 0xC0, 0x01, 0xF0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x67, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x18,
  0x70, 0x0C, 0x18, 0x06, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0x80, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF8, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x98, 0x01,
  0xCC, 0x00, 0x6E, 0x00, 0x38, 0xFF, 0x07, 0xFE, 0x30, 0x79, 0x80, 0xEC,
  0x07, 0x60, 0x1B, 0x00, 0xD8, 0x0C, 0xC0, 0xE7, 0xFE, 0x3F, 0xF1, 0x81,
  0xEC, 0x03, 0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x3D,
  0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0x06, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x02, 0x3F,
  0xF0, 0xFF, 0x80, 0xFE, 0x07, 0xFC, 0x30, 0x79, 0x80, 0xCC, 0x07, 0x60,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x03, 0xB0, 0x79, 0xFF, 0x8F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0x06, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0x70, 0x1B, 0x80, 0xCE,
  0x06, 0x3F, 0xF0, 0xFF, 0x80, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0C, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x40, 0xEF, 0xFC, 0x7F, 0x80, 0xE0, 0x1D, 0xC0, 0x73, 0x81, 0xC7, 0x07,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x73, 0x80, 0xEE, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x70, 0x70, 0xE0,
  0x71, 0xC0, 0x73, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xE0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x30, 0x18, 0x60, 0x71, 0xE0, 0xE3, 0xC1,
  0xE7, 0x86, 0xCD, 0x8D, 0x9B, 0x1B, 0x36, 0x66, 0x66, 0xCC, 0xCD, 0x99,
  0x8A, 0x33, 0x1C, 0x66, 0x38, 0xCC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0xE0,
  0x0D, 0xC0, 0x1B, 0x80, 0x37, 0x00, 0x7E, 0x00, 0xE0, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x3D, 0x81, 0xEC, 0x0F, 0x30, 0x79, 0x83, 0xC6, 0x1E,
  0x30, 0xF0, 0xC7, 0x86, 0x3C, 0x19, 0xE0, 0xCF, 0x07, 0x78, 0x1B, 0xC0,
  0xDE, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0x80, 0x0F, 0xE0, 0x3F, 0xE0,
  0xE0, 0xE3, 0x80, 0xC6, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xB0, 0x06, 0x60, 0x1C, 0xE0, 0x38, 0xE0, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0xFF, 0x0F, 0xFC, 0xC1, 0xEC, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x06, 0xC0, 0xEF, 0xFC, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xE0,
  0xE0, 0xE3, 0x80, 0xC6, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x06, 0x60, 0x1C, 0xE0, 0x38, 0xE0, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x78, 0xFF, 0x07, 0xFE,
  0x30, 0x39, 0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36,
  0x03, 0x30, 0xF9, 0xFF, 0x8F, 0xF8, 0x60, 0xC3, 0x07, 0x18, 0x18, 0xC0,
  0x66, 0x03, 0xB0, 0x0D, 0x80, 0x7C, 0x01, 0x80, 0x1F, 0xE1, 0xFF, 0x9C,
  0x0C, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xD0, 0x1D, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F,
  0x01, 0xDC, 0x1C, 0xFF, 0xC1, 0xFC, 0x00, 0xE0, 0x03, 0x60, 0x03, 0x70,
  0x07, 0x70, 0x07, 0x30, 0x06, 0x30, 0x06, 0x38, 0x0E, 0x38, 0x0C, 0x18,
  0x0C, 0x18, 0x0C, 0x1C, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0E, 0x38, 0x06,
  0x30, 0x06, 0x30, 0x07, 0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x01,
  0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x6E, 0x00, 0xDC, 0x01,
  0xB8, 0x03, 0x30, 0x06, 0x63, 0x8C, 0xC7, 0x19, 0x9E, 0x33, 0x36, 0x66,
  0x6C, 0xCD, 0x99, 0x9B, 0x1B, 0x36, 0x36, 0x68, 0x6C, 0xF0, 0x71, 0xE0,
  0xE3, 0xC1, 0xC3, 0x01, 0x80, 0xE0, 0x0E, 0xE0, 0x38, 0xC0, 0x61, 0xC1,
  0xC1, 0x87, 0x03, 0x8E, 0x03, 0x38, 0x07, 0x60, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0xEC, 0x01, 0x8C, 0x07, 0x1C, 0x0C, 0x18, 0x38,
  0x38, 0x60, 0x31, 0xC0, 0x73, 0x00, 0x6E, 0x00, 0xE0, 0xE0, 0x03, 0x70,
  0x07, 0x70, 0x06, 0x30, 0x0E, 0x38, 0x0C, 0x18, 0x1C, 0x1C, 0x18, 0x0C,
  0x38, 0x0E, 0x30, 0x07, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x3B, 0x01, 0x8C,
  0x1C, 0x60, 0xC1, 0x8E, 0x0E, 0x60, 0x36, 0x01, 0xF0, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC7, 0x18, 0x63, 0x88, 0x1F, 0x83, 0xFE, 0x20, 0xF0,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x31, 0xFF, 0x7F, 0xFF, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0x7F, 0xF3, 0xFF, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1D, 0xF0, 0xFF, 0xE7, 0xC7, 0xB8,
  0x1D, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x6E, 0x0F, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0xCF, 0x04, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xFF, 0xE1, 0xFF, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xFB,
  0x1F, 0xF9, 0xE3, 0xCC, 0x06, 0xE0, 0x36, 0x01, 0xB0, 0x0F, 0x80, 0x7C,
  0x03, 0x60, 0x1B, 0x00, 0xDC, 0x06, 0xE0, 0x33, 0x81, 0x8F, 0xFC, 0x3F,
  0xE0, 0x07, 0xC0, 0x7F, 0xC3, 0xC7, 0x8C, 0x06, 0x70, 0x1D, 0x80, 0x36,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0xE0, 0x43, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0xFF, 0xCF, 0x0E, 0xE0, 0x37, 0x01, 0xB0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xD8, 0x06, 0xE0, 0x37, 0x81, 0x9F, 0xFC, 0x7F, 0xE0, 0x63,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x73, 0xE7, 0xFE, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xF8, 0xFF, 0xEF,
  0x0E, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0x0C, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x83, 0xFC, 0x0F, 0xE0, 0x01,
  0x00, 0xE0, 0x78, 0x0E, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x6E, 0x7B, 0xFC, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x06, 0xE0, 0x33, 0x81, 0x8E, 0x1C, 0x38, 0xE0, 0xE7, 0x03, 0xB8,
  0x0F, 0xC0, 0x3F, 0x80, 0xEF, 0x03, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0xE0,
  0x73, 0x80, 0xEE, 0x01, 0xC0, 0xFE, 0x07, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x83, 0xFC, 0x0F, 0xE0, 0x7C, 0x71, 0xFF, 0xFB, 0x8E,
  0x77, 0x1C, 0x6E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F,
  0xC7, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0x3F, 0x8F, 0xFE, 0xE1, 0xEE, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0x07, 0xC0, 0x7F, 0x83, 0xC7, 0x0C, 0x0E, 0x70, 0x1D, 0x80, 0x76,
  0x00, 0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x36, 0x00, 0xDC, 0x07, 0x70, 0x18,
  0xE0, 0xE1, 0xFF, 0x03, 0xF8, 0x3F, 0x07, 0xFE, 0x38, 0x79, 0xC0, 0xEE,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF8, 0x3B, 0xFF, 0x9F, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xE0, 0xFF, 0xCF, 0x8E, 0x70, 0x37,
  0x01, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xD8, 0x06, 0xC0,
  0x37, 0x01, 0x9C, 0x1C, 0x7F, 0xE1, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x1F, 0xFF, 0xFB, 0x80, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x0F, 0xE3, 0xFF, 0x70, 0x26, 0x00, 0x60, 0x07, 0x00,
  0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x00, 0x34, 0x03,
  0x7F, 0xFF, 0xFC, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x0F, 0xFF, 0xFF,
  0xFC, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0xFE, 0x0F, 0xF0,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x37, 0x03, 0x3F, 0xF1, 0xFF,
  0xE0, 0x0F, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xE7, 0x01, 0x86, 0x07, 0x0E,
  0x0E, 0x1C, 0x18, 0x18, 0x70, 0x38, 0xC0, 0x31, 0x80, 0x77, 0x00, 0x6C,
  0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x30, 0xFC, 0x71, 0xB8, 0xE3, 0x33, 0xC6, 0x66, 0xCC, 0xCD,
  0x99, 0xB1, 0x73, 0x63, 0xC3, 0xC7, 0x87, 0x07, 0x0E, 0x0E, 0x18, 0x1C,
  0xE0, 0x0C, 0xE0, 0x30, 0xE0, 0xE0, 0xC3, 0x81, 0xC6, 0x01, 0xDC, 0x01,
  0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x0D, 0x80, 0x3B, 0x80, 0xE3, 0x83, 0x83,
  0x86, 0x03, 0x1C, 0x07, 0x70, 0x07, 0x60, 0x0D, 0xC0, 0x37, 0x01, 0xCC,
  0x07, 0x38, 0x18, 0xE0, 0x61, 0x83, 0x87, 0x0C, 0x1C, 0x30, 0x31, 0xC0,
  0xE6, 0x01, 0x98, 0x07, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x13, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x07, 0xE1, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x81, 0xE0, 0x3C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0xF0, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0xC0, 0xF8, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x7E, 0x0E, 0x00, 0x3C,
  0x05, 0xFC, 0x36, 0x3F, 0xF0, 0x3E,
};

const GFXglyph UbuntuSansMono_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 21, 17, 6, -21 },
  { 12, 7, 8, 17, 5, -23 },
  { 19, 15, 21, 17, 1, -21 },
  { 59, 13, 26, 17, 2, -23 },
  { 102, 15, 21, 17, 1, -21 },
  { 142, 15, 21, 17, 1, -21 },
  { 182, 3, 9, 17, 7, -23 },
  { 186, 9, 29, 17, 4, -23 },
  { 219, 9, 29, 17, 4, -23 },
  { 252, 13, 12, 17, 2, -21 },
  { 272, 13, 15, 17, 2, -16 },
  { 297, 7, 9, 17, 5, -4 },
  { 305, 7, 3, 17, 5, -10 },
  { 308, 5, 4, 17, 6, -4 },
  { 311, 11, 29, 17, 3, -23 },
  { 351, 13, 21, 17, 2, -21 },
  { 386, 12, 21, 17, 3, -21 },
  { 418, 13, 21, 17, 2, -21 },
  { 453, 13, 21, 17, 2, -21 },
  { 488, 15, 21, 17, 1, -21 },
  { 528, 12, 21, 17, 3, -21 },
  { 560, 13, 21, 17, 2, -21 },
  { 595, 13, 21, 17, 2, -21 },
  { 630, 13, 21, 17, 2, -21 },
  { 665, 13, 21, 17, 2, -21 },
  { 700, 5, 15, 17, 6, -15 },
  { 710, 7, 20, 17, 4, -15 },
  { 728, 13, 13, 17, 2, -15 },
  { 750, 13, 8, 17, 2, -13 },
  { 763, 13, 13, 17, 2, -15 },
  { 785, 11, 21, 17, 3, -21 },
  { 814, 14, 26, 17, 2, -21 },
  { 860, 17, 21, 17, 0, -21 },
  { 905, 13, 21, 17, 2, -21 },
  { 940, 13, 21, 17, 2, -21 },
  { 975, 13, 21, 17, 2, -21 },
  { 1010, 12, 21, 17, 3, -21 },
  { 1042, 12, 21, 17, 3, -21 },
  { 1074, 13, 21, 17, 2, -21 },
  { 1109, 14, 21, 17, 1, -21 },
  { 1146, 10, 21, 17, 3, -21 },
  { 1173, 12, 21, 17, 2, -21 },
  { 1205, 15, 21, 17, 2, -21 },
  { 1245, 12, 21, 17, 3, -21 },
  { 1277, 15, 21, 17, 1, -21 },
  { 1317, 13, 21, 17, 2, -21 },
  { 1352, 15, 21, 17, 1, -21 },
  { 1392, 12, 21, 17, 3, -21 },
  { 1424, 15, 26, 17, 1, -21 },
  { 1473, 13, 21, 17, 2, -21 },
  { 1508, 13, 21, 17, 2, -21 },
  { 1543, 14, 21, 17, 1, -21 },
  { 1580, 13, 21, 17, 2, -21 },
  { 1615, 16, 21, 17, 0, -21 },
  { 1657, 15, 21, 17, 1, -21 },
  { 1697, 15, 21, 17, 1, -21 },
  { 1737, 16, 21, 17, 0, -21 },
  { 1779, 13, 21, 17, 2, -21 },
  { 1814, 8, 29, 17, 5, -23 },
  { 1843, 11, 29, 17, 3, -23 },
  { 1883, 8, 29, 17, 4, -23 },
  { 1912, 13, 11, 17, 2, -21 },
  { 1930, 17, 2, 17, 0, 4 },
  { 1935, 5, 6, 17, 6, -23 },
  { 1939, 12, 16, 17, 2, -16 },
  { 1963, 13, 23, 17, 2, -23 },
  { 2001, 13, 16, 17, 2, -16 },
  { 2027, 13, 23, 17, 1, -23 },
  { 2065, 14, 16, 17, 1, -16 },
  { 2093, 14, 23, 17, 2, -23 },
  { 2134, 13, 22, 17, 1, -16 },
  { 2170, 12, 23, 17, 2, -23 },
  { 2205, 13, 23, 17, 2, -23 },
  { 2243, 10, 29, 17, 3, -23 },
  { 2280, 14, 23, 17, 2, -23 },
  { 2321, 13, 23, 17, 2, -23 },
  { 2359, 15, 16, 17, 1, -16 },
  { 2389, 12, 16, 17, 2, -16 },
  { 2413, 14, 16, 17, 1, -16 },
  { 2441, 13, 22, 17, 2, -16 },
  { 2477, 13, 22, 17, 1, -16 },
  { 2513, 11, 16, 17, 4, -16 },
  { 2535, 12, 16, 17, 2, -16 },
  { 2559, 13, 20, 17, 2, -20 },
  { 2592, 12, 16, 17, 2, -16 },
  { 2616, 15, 16, 17, 1, -16 },
  { 2646, 15, 16, 17, 1, -16 },
  { 2676, 15, 16, 17, 1, -16 },
  { 2706, 14, 22, 17, 1, -16 },
  { 2745, 11, 16, 17, 3, -16 },
  { 2767, 11, 29, 17, 3, -23 },
  { 2807, 2, 29, 17, 7, -23 },
  { 2815, 11, 29, 17, 3, -23 },
  { 2855, 14, 4, 17, 1, -11 },
};

const GFXfont UbuntuSansMono_Regular30pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular30pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular30pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUSANSMONO_REGULAR30PT7B_H_
