#ifndef _UBUNTUSANSMONO_REGULAR11PT7B_H_
#define _UBUNTUSANSMONO_REGULAR11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x43, 0xFC, 0x28, 0xAF, 0xCA, 0x4B, 0xF5, 0x14, 0x22, 0xD8,
  0xC3, 0x11, 0xE2, 0x46, 0xAA, 0x9C, 0x28, 0xD5, 0x77, 0x31, 0x45, 0x1C,
  0x6A, 0x68, 0x9D, 0xE0, 0x12, 0x44, 0x48, 0x84, 0x42, 0x10, 0x4C, 0x22,
  0x11, 0x12, 0x24, 0xC0, 0x22, 0xF6, 0x90, 0x21, 0x3E, 0x42, 0x00, 0x56,
  0xC0, 0x70, 0x11, 0x12, 0x22, 0x44, 0x48, 0x80, 0x64, 0xA5, 0x5E, 0xCA,
  0x4E, 0x26, 0xA2, 0x22, 0x2F, 0x69, 0x11, 0x24, 0x8F, 0xE1, 0x16, 0x11,
  0x1F, 0x08, 0x62, 0x92, 0x4B, 0xF0, 0x82, 0x78, 0x8E, 0x11, 0x1F, 0x32,
  0x21, 0xC9, 0x46, 0x5E, 0xF8, 0x84, 0x42, 0x21, 0x08, 0x69, 0x99, 0xF9,
  0x9F, 0x69, 0x99, 0xF1, 0x1E, 0x70, 0x70, 0x70, 0x76, 0x09, 0xB1, 0x83,
  0x80, 0xF8, 0x3E, 0x87, 0x06, 0x6C, 0x00, 0xE1, 0x12, 0x40, 0x06, 0x74,
  0x63, 0x7C, 0xE6, 0xB2, 0x41, 0x80, 0x30, 0xC2, 0x92, 0x49, 0xE8, 0x61,
  0xE9, 0x9B, 0xD9, 0x9F, 0x7C, 0x21, 0x08, 0x42, 0x0F, 0xE4, 0xA5, 0x18,
  0xC6, 0x5C, 0xF4, 0x21, 0x0F, 0x42, 0x1F, 0xF8, 0x88, 0xF8, 0x88, 0x7C,
  0x21, 0x08, 0xC6, 0x2F, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0xF2, 0x22, 0x22,
  0x2F, 0x71, 0x11, 0x11, 0x1F, 0x8C, 0xA9, 0x8C, 0x52, 0x51, 0x84, 0x21,
  0x08, 0x42, 0x1F, 0x49, 0x27, 0x5D, 0x56, 0x18, 0x61, 0x99, 0xDD, 0xBB,
  0x99, 0x31, 0x28, 0x61, 0x86, 0x14, 0x9E, 0xE4, 0xA3, 0x2F, 0x42, 0x10,
  0x31, 0x28, 0x61, 0x86, 0x14, 0x9E, 0x10, 0x20, 0xE4, 0xA5, 0x2E, 0x52,
  0x53, 0x78, 0x8C, 0x31, 0x1F, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x8C, 0x63,
  0x18, 0xC6, 0x5E, 0x86, 0x14, 0x52, 0x48, 0xA3, 0x0C, 0x86, 0x18, 0x65,
  0x75, 0xD4, 0x92, 0xC5, 0x22, 0x8C, 0x30, 0xA4, 0xB1, 0x85, 0x14, 0x8A,
  0x30, 0x41, 0x04, 0xF8, 0x84, 0x44, 0x22, 0x1F, 0xF2, 0x49, 0x24, 0x93,
  0x80, 0x88, 0x44, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80,
  0x23, 0x25, 0x30, 0xFC, 0xA4, 0xE1, 0x3D, 0x9F, 0x84, 0x21, 0xC9, 0x46,
  0x32, 0xF0, 0x74, 0x21, 0x08, 0x3C, 0x11, 0x17, 0x99, 0x99, 0xF0, 0x74,
  0xBF, 0x08, 0x78, 0x32, 0x51, 0xE4, 0x21, 0x08, 0x40, 0x79, 0x99, 0x97,
  0x1F, 0x88, 0x8E, 0x99, 0x99, 0x90, 0x40, 0xC4, 0x44, 0x43, 0x30, 0xF1,
  0x11, 0x11, 0x1E, 0x84, 0x21, 0x3A, 0x63, 0x96, 0x98, 0xC4, 0x44, 0x44,
  0x43, 0xF5, 0x6B, 0x58, 0xC4, 0xE9, 0x99, 0x99, 0x64, 0xA3, 0x19, 0x78,
  0xE4, 0xA3, 0x19, 0x7A, 0x10, 0x79, 0x99, 0x9F, 0x11, 0x78, 0x88, 0x88,
  0x78, 0xC3, 0x1F, 0x4F, 0x44, 0x44, 0x70, 0x99, 0x99, 0x9F, 0x85, 0x24,
  0x92, 0x30, 0xC0, 0x86, 0x19, 0x5D, 0x49, 0x20, 0xCD, 0x23, 0x0C, 0x4B,
  0x30, 0x45, 0x24, 0x8A, 0x30, 0x41, 0x38, 0xF1, 0x24, 0x8F, 0x34, 0x44,
  0x4C, 0x44, 0x44, 0x30, 0xFF, 0xE0, 0xC2, 0x22, 0x23, 0x22, 0x22, 0xC0,
  0x66, 0x60,
};

const GFXglyph UbuntuSansMono_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 8, 6, 2, -8 },
  { 3, 2, 3, 6, 2, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 4, 10, 6, 1, -9 },
  { 15, 6, 8, 6, 0, -8 },
  { 21, 6, 8, 6, 0, -8 },
  { 27, 1, 3, 6, 3, -8 },
  { 28, 4, 11, 6, 1, -9 },
  { 34, 4, 11, 6, 1, -9 },
  { 40, 4, 5, 6, 1, -8 },
  { 43, 5, 5, 6, 1, -6 },
  { 47, 2, 4, 6, 2, -2 },
  { 48, 2, 1, 6, 2, -4 },
  { 49, 2, 2, 6, 2, -2 },
  { 50, 4, 11, 6, 1, -9 },
  { 56, 5, 8, 6, 1, -8 },
  { 61, 4, 8, 6, 1, -8 },
  { 65, 4, 8, 6, 1, -8 },
  { 69, 4, 8, 6, 1, -8 },
  { 73, 6, 8, 6, 0, -8 },
  { 79, 4, 8, 6, 1, -8 },
  { 83, 5, 8, 6, 1, -8 },
  { 88, 5, 8, 6, 1, -8 },
  { 93, 4, 8, 6, 1, -8 },
  { 97, 4, 8, 6, 1, -8 },
  { 101, 2, 6, 6, 2, -6 },
  { 103, 2, 8, 6, 2, -6 },
  { 105, 5, 5, 6, 1, -6 },
  { 109, 5, 3, 6, 1, -5 },
  { 111, 5, 5, 6, 1, -6 },
  { 115, 4, 8, 6, 1, -8 },
  { 119, 5, 10, 6, 1, -8 },
  { 126, 6, 8, 6, 0, -8 },
  { 132, 4, 8, 6, 1, -8 },
  { 136, 5, 8, 6, 1, -8 },
  { 141, 5, 8, 6, 1, -8 },
  { 146, 5, 8, 6, 1, -8 },
  { 151, 4, 8, 6, 1, -8 },
  { 155, 5, 8, 6, 1, -8 },
  { 160, 5, 8, 6, 1, -8 },
  { 165, 4, 8, 6, 1, -8 },
  { 169, 4, 8, 6, 1, -8 },
  { 173, 5, 8, 6, 1, -8 },
  { 178, 5, 8, 6, 1, -8 },
  { 183, 6, 8, 6, 0, -8 },
  { 189, 4, 8, 6, 1, -8 },
  { 193, 6, 8, 6, 0, -8 },
  { 199, 5, 8, 6, 1, -8 },
  { 204, 6, 10, 6, 0, -8 },
  { 212, 5, 8, 6, 1, -8 },
  { 217, 4, 8, 6, 1, -8 },
  { 221, 5, 8, 6, 1, -8 },
  { 226, 5, 8, 6, 1, -8 },
  { 231, 6, 8, 6, 0, -8 },
  { 237, 6, 8, 6, 0, -8 },
  { 243, 6, 8, 6, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 5, 8, 6, 1, -8 },
  { 260, 3, 11, 6, 2, -9 },
  { 265, 4, 11, 6, 1, -9 },
  { 271, 3, 11, 6, 1, -9 },
  { 276, 5, 4, 6, 1, -8 },
  { 279, 6, 1, 6, 0, 1 },
  { 280, 2, 3, 6, 2, -9 },
  { 281, 4, 6, 6, 1, -6 },
  { 284, 5, 9, 6, 1, -9 },
  { 290, 5, 6, 6, 1, -6 },
  { 294, 4, 9, 6, 1, -9 },
  { 299, 5, 6, 6, 1, -6 },
  { 303, 5, 9, 6, 1, -9 },
  { 309, 4, 8, 6, 1, -6 },
  { 313, 4, 9, 6, 1, -9 },
  { 318, 4, 8, 6, 1, -8 },
  { 322, 4, 10, 6, 1, -8 },
  { 327, 5, 9, 6, 1, -9 },
  { 333, 4, 8, 6, 1, -8 },
  { 337, 5, 6, 6, 1, -6 },
  { 341, 4, 6, 6, 1, -6 },
  { 344, 5, 6, 6, 1, -6 },
  { 348, 5, 8, 6, 1, -6 },
  { 353, 4, 8, 6, 1, -6 },
  { 357, 4, 6, 6, 1, -6 },
  { 360, 4, 6, 6, 1, -6 },
  { 363, 4, 7, 6, 1, -7 },
  { 367, 4, 6, 6, 1, -6 },
  { 370, 6, 6, 6, 0, -6 },
  { 375, 6, 6, 6, 0, -6 },
  { 380, 6, 6, 6, 0, -6 },
  { 385, 6, 8, 6, 0, -6 },
  { 391, 4, 6, 6, 1, -6 },
  { 394, 4, 11, 6, 1, -9 },
  { 400, 1, 11, 6, 3, -9 },
  { 402, 4, 11, 6, 1, -9 },
  { 408, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_Regular11pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular11pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUSANSMONO_REGULAR11PT7B_H_
