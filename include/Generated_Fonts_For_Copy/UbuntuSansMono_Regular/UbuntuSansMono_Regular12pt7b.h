#ifndef _UBUNTUSANSMONO_REGULAR12PT7B_H_
#define _UBUNTUSANSMONO_REGULAR12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x47, 0xB6, 0x80, 0x24, 0x9F, 0xCA, 0x4B, 0xF4, 0x94, 0x23,
  0xA1, 0x06, 0x08, 0x31, 0xF1, 0x00, 0x42, 0x9A, 0xAA, 0x50, 0xB3, 0x55,
  0xCC, 0x31, 0x24, 0x94, 0x21, 0x54, 0xB2, 0x74, 0xE0, 0x2A, 0x49, 0x24,
  0x88, 0x80, 0x89, 0x12, 0x49, 0x4A, 0x00, 0x27, 0xC9, 0xA5, 0x00, 0x21,
  0x3E, 0x42, 0x00, 0x4D, 0x40, 0xE0, 0x70, 0x18, 0x84, 0x42, 0x10, 0x88,
  0x42, 0x20, 0x26, 0xA3, 0x1A, 0xD6, 0x31, 0x70, 0x27, 0x08, 0x42, 0x10,
  0x8F, 0x64, 0x82, 0x21, 0x11, 0x10, 0xF8, 0x64, 0x82, 0x26, 0x0C, 0x21,
  0xF0, 0x11, 0x95, 0x29, 0x7C, 0x42, 0x7A, 0x11, 0xE0, 0x84, 0x3E, 0x3A,
  0x21, 0xE8, 0xC6, 0x2E, 0xF8, 0x84, 0x42, 0x11, 0x08, 0x26, 0xA3, 0x17,
  0x4E, 0x31, 0xF0, 0x26, 0xA3, 0x18, 0xBC, 0x22, 0xE0, 0x70, 0x70, 0x70,
  0x76, 0x0B, 0xA0, 0xC1, 0x80, 0xF8, 0x3E, 0x83, 0x82, 0x6C, 0x00, 0x69,
  0x11, 0x22, 0x02, 0x60, 0x22, 0xE3, 0x3A, 0xD6, 0xB5, 0x92, 0x0E, 0x30,
  0x50, 0xA2, 0x44, 0x4F, 0xA1, 0x43, 0xF4, 0x65, 0xC9, 0xC6, 0x3E, 0x32,
  0x61, 0x08, 0x42, 0x10, 0x78, 0xF4, 0x63, 0x18, 0xC6, 0x7E, 0xFC, 0x21,
  0xE8, 0x42, 0x1F, 0xFC, 0x21, 0xF8, 0x42, 0x10, 0x32, 0x61, 0x08, 0x46,
  0x31, 0x78, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF2, 0x22, 0x22, 0x2F, 0x78,
  0x42, 0x10, 0x84, 0x5E, 0x8A, 0x4A, 0x30, 0xA2, 0x48, 0xA3, 0x84, 0x21,
  0x08, 0x42, 0x1F, 0x4D, 0xB6, 0xDD, 0x55, 0x18, 0x61, 0x8E, 0x73, 0x5A,
  0xCE, 0x71, 0x11, 0xA4, 0x61, 0x86, 0x14, 0x51, 0x38, 0xFC, 0x63, 0x1F,
  0x42, 0x10, 0x11, 0xA4, 0x61, 0x86, 0x14, 0x51, 0x38, 0x40, 0xC0, 0xF4,
  0x63, 0x2E, 0x4A, 0x51, 0x26, 0xE1, 0x06, 0x08, 0x21, 0xF0, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0x86, 0x89, 0x12, 0x22,
  0x85, 0x0A, 0x08, 0x85, 0x14, 0x55, 0x75, 0xB4, 0xD1, 0x44, 0xA2, 0x84,
  0x28, 0xA4, 0x71, 0xC6, 0x89, 0xA1, 0x41, 0x02, 0x04, 0x08, 0xF8, 0x84,
  0x44, 0x22, 0x1F, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x82, 0x10, 0x82, 0x10,
  0x82, 0x10, 0x86, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x62, 0xA5, 0x10, 0xFE,
  0x90, 0xF0, 0x5F, 0x18, 0xFC, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0xF0, 0x7C,
  0x21, 0x08, 0x3C, 0x08, 0x43, 0xF8, 0xC6, 0x31, 0x78, 0xF4, 0x7F, 0x08,
  0x3C, 0x3A, 0x11, 0xF4, 0x21, 0x08, 0x40, 0xFC, 0x63, 0x18, 0xBC, 0x3E,
  0x84, 0x21, 0xE8, 0xC6, 0x31, 0x88, 0x62, 0x01, 0xC2, 0x10, 0x84, 0x38,
  0x31, 0x07, 0x11, 0x11, 0x11, 0xF0, 0x84, 0x21, 0x3A, 0x62, 0x92, 0x88,
  0xE1, 0x08, 0x42, 0x10, 0x84, 0x38, 0xFD, 0x6B, 0x58, 0xC4, 0xF4, 0x63,
  0x18, 0xC4, 0xF4, 0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0xFC,
  0x63, 0x18, 0xBC, 0x21, 0xF8, 0x88, 0x88, 0xF4, 0x18, 0x20, 0xF8, 0x42,
  0x3E, 0x84, 0x21, 0x07, 0x8C, 0x63, 0x18, 0xBC, 0xC5, 0x14, 0x8A, 0x28,
  0x40, 0x86, 0x55, 0x5B, 0x6D, 0x30, 0x44, 0xA1, 0x0A, 0x4B, 0x10, 0x8C,
  0x54, 0xA5, 0x10, 0x98, 0xF8, 0x88, 0x8C, 0x7C, 0x39, 0x08, 0x44, 0x61,
  0x04, 0x21, 0x0E, 0xFF, 0xE0, 0xE1, 0x08, 0x42, 0x0C, 0x84, 0x21, 0x38,
  0xF8,
};

const GFXglyph UbuntuSansMono_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 3, 7, 2, -9 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 10, 7, 1, -9 },
  { 18, 6, 9, 7, 0, -9 },
  { 25, 6, 9, 7, 0, -9 },
  { 32, 1, 3, 7, 3, -9 },
  { 33, 3, 11, 7, 2, -9 },
  { 38, 3, 11, 7, 2, -9 },
  { 43, 5, 5, 7, 1, -8 },
  { 47, 5, 5, 7, 1, -6 },
  { 51, 3, 4, 7, 2, -2 },
  { 53, 3, 1, 7, 2, -4 },
  { 54, 2, 2, 7, 2, -2 },
  { 55, 5, 11, 7, 1, -9 },
  { 62, 5, 9, 7, 1, -9 },
  { 68, 5, 8, 7, 1, -8 },
  { 73, 5, 9, 7, 1, -9 },
  { 79, 5, 9, 7, 1, -9 },
  { 85, 5, 8, 7, 1, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 5, 8, 7, 1, -8 },
  { 105, 5, 9, 7, 1, -9 },
  { 111, 5, 9, 7, 1, -9 },
  { 117, 2, 6, 7, 2, -6 },
  { 119, 2, 8, 7, 2, -6 },
  { 121, 5, 5, 7, 1, -6 },
  { 125, 5, 3, 7, 1, -5 },
  { 127, 5, 5, 7, 1, -6 },
  { 131, 4, 9, 7, 1, -9 },
  { 136, 5, 11, 7, 1, -9 },
  { 143, 7, 8, 7, 0, -8 },
  { 150, 5, 8, 7, 1, -8 },
  { 155, 5, 9, 7, 1, -9 },
  { 161, 5, 8, 7, 1, -8 },
  { 166, 5, 8, 7, 1, -8 },
  { 171, 5, 8, 7, 1, -8 },
  { 176, 5, 9, 7, 1, -9 },
  { 182, 5, 8, 7, 1, -8 },
  { 187, 4, 8, 7, 1, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 6, 8, 7, 1, -8 },
  { 202, 5, 8, 7, 1, -8 },
  { 207, 6, 8, 7, 0, -8 },
  { 213, 5, 8, 7, 1, -8 },
  { 218, 6, 9, 7, 0, -9 },
  { 225, 5, 8, 7, 1, -8 },
  { 230, 6, 11, 7, 0, -9 },
  { 239, 5, 8, 7, 1, -8 },
  { 244, 5, 9, 7, 1, -9 },
  { 250, 5, 8, 7, 1, -8 },
  { 255, 5, 8, 7, 1, -8 },
  { 260, 7, 8, 7, 0, -8 },
  { 267, 6, 8, 7, 0, -8 },
  { 273, 6, 8, 7, 0, -8 },
  { 279, 7, 8, 7, 0, -8 },
  { 286, 5, 8, 7, 1, -8 },
  { 291, 3, 11, 7, 2, -9 },
  { 296, 5, 11, 7, 1, -9 },
  { 303, 3, 11, 7, 2, -9 },
  { 308, 5, 4, 7, 1, -8 },
  { 311, 7, 1, 7, 0, 1 },
  { 312, 2, 2, 7, 2, -9 },
  { 313, 5, 6, 7, 1, -6 },
  { 317, 5, 9, 7, 1, -9 },
  { 323, 5, 6, 7, 1, -6 },
  { 327, 5, 9, 7, 1, -9 },
  { 333, 5, 6, 7, 1, -6 },
  { 337, 5, 9, 7, 1, -9 },
  { 343, 5, 8, 7, 1, -6 },
  { 348, 5, 9, 7, 1, -9 },
  { 354, 5, 9, 7, 1, -9 },
  { 360, 4, 11, 7, 1, -9 },
  { 366, 5, 9, 7, 1, -9 },
  { 372, 5, 9, 7, 1, -9 },
  { 378, 5, 6, 7, 1, -6 },
  { 382, 5, 6, 7, 1, -6 },
  { 386, 5, 6, 7, 1, -6 },
  { 390, 5, 8, 7, 1, -6 },
  { 395, 5, 8, 7, 1, -6 },
  { 400, 4, 6, 7, 2, -6 },
  { 403, 5, 6, 7, 1, -6 },
  { 407, 5, 8, 7, 1, -8 },
  { 412, 5, 6, 7, 1, -6 },
  { 416, 6, 6, 7, 0, -6 },
  { 421, 6, 6, 7, 0, -6 },
  { 426, 6, 6, 7, 0, -6 },
  { 431, 5, 8, 7, 1, -6 },
  { 436, 5, 6, 7, 1, -6 },
  { 440, 5, 11, 7, 1, -9 },
  { 447, 1, 11, 7, 3, -9 },
  { 449, 5, 11, 7, 1, -9 },
  { 456, 5, 1, 7, 1, -4 },
};

const GFXfont UbuntuSansMono_Regular12pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular12pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUSANSMONO_REGULAR12PT7B_H_
