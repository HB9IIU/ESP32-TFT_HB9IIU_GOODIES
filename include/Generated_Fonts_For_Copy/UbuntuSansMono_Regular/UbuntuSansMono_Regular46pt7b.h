#ifndef _UBUNTUSANSMONO_REGULAR46PT7B_H_
#define _UBUNTUSANSMONO_REGULAR46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x1C, 0x71, 0xC7, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x07, 0x3E, 0xFF, 0xFF,
  0xFE, 0x20, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x30, 0x01, 0xE0, 0x70, 0x07, 0x81,
  0xC0, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x0F, 0x03, 0x80,
  0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x81, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x3C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x78, 0x03,
  0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x03,
  0xC0, 0x1C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x78, 0x03, 0x81, 0xE0, 0x1E, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x08,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x40, 0x01, 0xE7, 0x00, 0x7C, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x1E,
  0x3F, 0xC0, 0x1C, 0x71, 0xC0, 0x3C, 0x70, 0xE0, 0x38, 0xE0, 0xE0, 0x70,
  0xE0, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xE0, 0xE0, 0xE1, 0xC0,
  0xE0, 0xE3, 0x80, 0xE0, 0xE7, 0x80, 0x70, 0xE7, 0x00, 0x71, 0xCF, 0x00,
  0x3F, 0xCE, 0x00, 0x1F, 0x9C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x79, 0xF8, 0x00, 0x73, 0xFC, 0x00, 0xE3, 0x9E, 0x00, 0xE7, 0x0E,
  0x01, 0xC7, 0x0E, 0x03, 0xC7, 0x07, 0x03, 0x87, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x07, 0x07, 0x1E, 0x07, 0x06, 0x1C, 0x07, 0x0E,
  0x38, 0x07, 0x8E, 0x38, 0x03, 0xFC, 0x70, 0x01, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1E,
  0x0F, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xF0, 0x1C, 0x03, 0xC0, 0xF0, 0x07, 0x07, 0x80, 0x1E, 0x1C, 0x00,
  0x3D, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x70, 0x7F,
  0x81, 0xC3, 0xDF, 0x07, 0x0F, 0x3E, 0x1C, 0x78, 0x7C, 0xE1, 0xC0, 0xFB,
  0x8F, 0x01, 0xEE, 0x3C, 0x03, 0xF8, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F,
  0x00, 0x3C, 0x3C, 0x01, 0xF8, 0xF8, 0x0F, 0xF1, 0xF0, 0x7F, 0xC7, 0xFF,
  0xE7, 0x8F, 0xFF, 0x1E, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE,
  0xEE, 0x60, 0x00, 0x10, 0x01, 0x80, 0x3E, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x60, 0x01, 0x00, 0x20, 0x01, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x06,
  0x0E, 0x06, 0x78, 0x61, 0xEF, 0xE6, 0x7E, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x79, 0xE0, 0x0F, 0x9F,
  0x01, 0xF0, 0xF8, 0x1E, 0x0F, 0x80, 0xE0, 0x70, 0x04, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x07, 0x83,
  0xE1, 0xF3, 0xF8, 0xFC, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C,
  0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x08, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3E, 0x07,
  0x83, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x06, 0x0F, 0xF0,
  0xF0, 0xFF, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xF0, 0xF0, 0xFF,
  0x06, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x3C, 0x03,
  0xC3, 0xE0, 0x78, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x07, 0xDC, 0x0F, 0xE7, 0x01, 0xE1, 0xC0, 0x60, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xF8,
  0x0F, 0x86, 0x00, 0x3C, 0x20, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0,
  0x00, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x30, 0x0F,
  0x82, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE6, 0x00, 0x7C, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9C, 0x00, 0x3C, 0x70, 0x01,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x01,
  0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0,
  0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xEC,
  0x00, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x7F, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x3E, 0x03,
  0xC1, 0xF9, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x3C, 0x03, 0xC7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC3, 0xC0, 0x3C, 0x3F, 0x07,
  0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1E, 0x1F, 0xC3, 0xC0,
  0x7C, 0x78, 0x03, 0xE7, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xE7,
  0xC0, 0x3E, 0x3F, 0x1F, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x40, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFB, 0xF8, 0x7C, 0x07,
  0xC7, 0x80, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xCE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xDF, 0xBE, 0x10, 0x0F, 0x07, 0xE1,
  0xF8, 0xFE, 0x3F, 0x87, 0xE1, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0xF8, 0x7E, 0x3F, 0xCF,
  0xF1, 0xFC, 0x7E, 0x07, 0x81, 0xE0, 0xF0, 0xF8, 0xFC, 0x3E, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE8, 0x00, 0x1F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x80, 0x7F,
  0xF0, 0xFF, 0xFC, 0x7D, 0xFE, 0x40, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x03, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0x80, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x03,
  0x87, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0x80, 0x03, 0xDE,
  0x00, 0xFF, 0x78, 0x0F, 0xFD, 0xE0, 0xFF, 0xF7, 0x87, 0xC3, 0xDE, 0x1E,
  0x0F, 0x78, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F,
  0xF0, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x8F, 0x03, 0xDE, 0x3C, 0x0F, 0x78,
  0xF0, 0x3D, 0xE3, 0xC0, 0xF7, 0x87, 0x83, 0xDE, 0x0F, 0x0F, 0x3C, 0x3F,
  0xFC, 0xF0, 0x3F, 0xF3, 0xE0, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x60, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x07,
  0x9C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xC7, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x0F, 0x00,
  0x1C, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x38, 0x00, 0x3C, 0x1C, 0x00,
  0x0E, 0x1E, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x73, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x01, 0xF8, 0xE0, 0x07, 0xCE,
  0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x03, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8E, 0x00, 0xFC, 0xE0, 0x03, 0xEE, 0x00,
  0x1E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xEE, 0x00, 0x3E, 0xE0, 0x0F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x07, 0x0F, 0x80, 0x08, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x18, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xC0, 0x7E, 0x0E,
  0x00, 0xF8, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x9C, 0x00, 0x3C, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80,
  0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0xF1,
  0xC0, 0x0F, 0x0E, 0x03, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0x80, 0x61, 0xF0, 0x02, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x3C, 0x00,
  0x73, 0xC0, 0x07, 0x1E, 0x00, 0x71, 0xF8, 0x07, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3D, 0x00,
  0x1E, 0x70, 0x0F, 0xBF, 0xBF, 0xCF, 0xFF, 0xE0, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x38, 0x00, 0xF1, 0xC0, 0x0F, 0x8E,
  0x00, 0xF8, 0x70, 0x07, 0x83, 0x80, 0x78, 0x1C, 0x07, 0x80, 0xE0, 0x7C,
  0x07, 0x07, 0xC0, 0x38, 0x7C, 0x01, 0xC7, 0xC0, 0x0E, 0x7C, 0x00, 0x77,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0x3E, 0x00,
  0x38, 0xF8, 0x01, 0xC3, 0xE0, 0x0E, 0x0F, 0x80, 0x70, 0x3E, 0x03, 0x80,
  0xF8, 0x1C, 0x03, 0xE0, 0xE0, 0x0F, 0x87, 0x00, 0x3E, 0x38, 0x00, 0xF1,
  0xC0, 0x07, 0xCE, 0x00, 0x1F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0E, 0xC7, 0x70, 0x3B,
  0x1D, 0xC0, 0xEE, 0x77, 0x07, 0x39, 0xCE, 0x1C, 0xE7, 0x38, 0x73, 0x9C,
  0xE3, 0x8E, 0x71, 0xCE, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0x9C, 0x3F,
  0x0E, 0x70, 0xFC, 0x39, 0xC1, 0xE0, 0xEF, 0x07, 0x83, 0xBC, 0x1E, 0x0E,
  0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xEE, 0x00, 0xFE, 0xF0, 0x0F, 0xE7, 0x80, 0xFE, 0x78, 0x0F, 0xE3, 0xC0,
  0xFE, 0x3C, 0x0F, 0xE1, 0xE0, 0xFE, 0x1E, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F,
  0x0F, 0xE0, 0x70, 0xFE, 0x07, 0x8F, 0xE0, 0x38, 0xFE, 0x03, 0xCF, 0xE0,
  0x1C, 0xFE, 0x01, 0xEF, 0xE0, 0x0E, 0xFE, 0x00, 0xEF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x07, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3D, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0x78, 0x0F, 0x81, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x07,
  0xCF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x07, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0x78, 0x0F, 0x81, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xF0,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x00, 0xF8, 0xF0, 0x07,
  0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0,
  0x07, 0xCF, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0x03, 0xC0, 0xF0, 0x1C, 0x0F, 0x01, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3E, 0x01, 0xC7, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x40, 0x01, 0xE6, 0x00, 0x3E, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x7C,
  0x03, 0xE3, 0xFB, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0x80,
  0x01, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x70, 0x3B,
  0xC1, 0xE0, 0xE7, 0x0F, 0x83, 0x9C, 0x3F, 0x0E, 0x70, 0xFC, 0x39, 0xC7,
  0x70, 0xE7, 0x1C, 0xE3, 0x9C, 0x73, 0x8E, 0x73, 0x8E, 0x39, 0xCE, 0x1C,
  0xE7, 0x38, 0x73, 0x9D, 0xC1, 0xCC, 0x77, 0x03, 0xB1, 0xDC, 0x0E, 0xC7,
  0xE0, 0x3B, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0,
  0x1F, 0x0F, 0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x3C, 0x03,
  0xC0, 0xF0, 0x07, 0x07, 0x80, 0x1E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xF7,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x07,
  0x87, 0x00, 0x1C, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0xF0, 0x1E, 0x01,
  0xE0, 0x70, 0x07, 0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x79,
  0xE0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x3C,
  0x00, 0xF0, 0xF0, 0x0F, 0x03, 0x80, 0x70, 0x1E, 0x07, 0x80, 0x70, 0x38,
  0x03, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x79, 0xE0, 0x01, 0xFE, 0x00, 0x07,
  0x30, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0xC3, 0xC3, 0x87, 0x87, 0x87, 0x07, 0x04,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x08, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x03, 0xDE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xF7,
  0xC0, 0x1E, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x28, 0x00,
  0x20, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE7, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xC0, 0xF8, 0xF0, 0x07, 0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xEE,
  0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01,
  0xEE, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00, 0x7C, 0xE0, 0x1F, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x02, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x11, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xFE, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xF0, 0x3F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x0F, 0x3C, 0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x0F, 0x1E, 0x00,
  0x79, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x02, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07,
  0xF7, 0xE0, 0x3C, 0x01, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0x0F,
  0x3E, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x3C,
  0x00, 0xF3, 0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFE, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x20, 0x03, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xE0,
  0x00, 0x20, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xEF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0,
  0x7E, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x01, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x40, 0x3E,
  0x7F, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0x80, 0x20, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0xF0,
  0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0xF8, 0x0E, 0x1F, 0x00, 0xE3, 0xE0,
  0x0E, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0E, 0x7E,
  0x00, 0xE3, 0xF0, 0x0E, 0x0F, 0x80, 0xE0, 0x7C, 0x0E, 0x03, 0xE0, 0xE0,
  0x1F, 0x0E, 0x00, 0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3E, 0xE0, 0x01, 0xEE,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x7F, 0xCF, 0xE3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xBC, 0x1E, 0x1E, 0xF0, 0x78, 0x3F, 0xC1, 0xE0,
  0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF,
  0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0x80, 0x7E, 0xE0,
  0x07, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03,
  0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0x9C, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x0F,
  0x0F, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0x01, 0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xEE, 0x00,
  0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE,
  0x00, 0x1E, 0xE0, 0x03, 0xCF, 0x00, 0x7C, 0xFC, 0x0F, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0E, 0xFF, 0xC0, 0xE0, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xF8, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x0F, 0x7C, 0x00, 0xF3, 0xC0, 0x0F, 0x1F, 0x03, 0xF1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xEF, 0x00, 0x60, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xE0, 0x04,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xE0, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0xF0, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x20, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0xB0, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0,
  0x0F, 0x7C, 0x03, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x79, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C,
  0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x8F, 0x00,
  0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7C,
  0x1C, 0x78, 0x7E, 0x1C, 0x38, 0x7E, 0x1C, 0x38, 0xEE, 0x1C, 0x38, 0xE7,
  0x3C, 0x3C, 0xE7, 0x3C, 0x3D, 0xC3, 0xB8, 0x3D, 0xC3, 0xB8, 0x1F, 0x83,
  0xB8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x00,
  0xF0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0xF8, 0x00, 0x79, 0xE0, 0x03,
  0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xC0, 0x3C, 0x1E, 0x00,
  0x78, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xF0,
  0x01, 0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xE0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x07, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x80,
  0x07, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0x3F, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x10, 0xFF, 0x80,
  0x73, 0xFF, 0x03, 0x9C, 0x3F, 0x1E, 0x60, 0x3F, 0xF3, 0x80, 0x7F, 0x82,
  0x00, 0x7C, 0x00,
};

const GFXglyph UbuntuSansMono_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 33, 26, 10, -32 },
  { 26, 11, 12, 26, 7, -35 },
  { 43, 22, 32, 26, 2, -32 },
  { 131, 20, 41, 26, 3, -36 },
  { 234, 24, 34, 26, 1, -33 },
  { 336, 22, 33, 26, 2, -33 },
  { 427, 4, 13, 26, 11, -35 },
  { 434, 13, 45, 26, 6, -36 },
  { 508, 14, 45, 26, 6, -36 },
  { 587, 20, 19, 26, 3, -32 },
  { 635, 21, 23, 26, 2, -25 },
  { 696, 10, 14, 26, 8, -7 },
  { 714, 10, 4, 26, 8, -15 },
  { 719, 7, 8, 26, 9, -7 },
  { 726, 18, 45, 26, 4, -36 },
  { 828, 20, 34, 26, 3, -33 },
  { 913, 18, 32, 26, 4, -32 },
  { 985, 20, 33, 26, 3, -33 },
  { 1068, 20, 34, 26, 3, -33 },
  { 1153, 22, 32, 26, 2, -32 },
  { 1241, 19, 33, 26, 4, -32 },
  { 1320, 20, 33, 26, 3, -32 },
  { 1403, 21, 32, 26, 3, -32 },
  { 1487, 20, 34, 26, 3, -33 },
  { 1572, 20, 33, 26, 3, -33 },
  { 1655, 7, 25, 26, 9, -24 },
  { 1677, 10, 31, 26, 7, -24 },
  { 1716, 21, 20, 26, 3, -23 },
  { 1769, 21, 13, 26, 2, -20 },
  { 1804, 21, 20, 26, 3, -23 },
  { 1857, 16, 34, 26, 5, -33 },
  { 1925, 22, 40, 26, 2, -33 },
  { 2035, 25, 32, 26, 0, -32 },
  { 2135, 20, 32, 26, 3, -32 },
  { 2215, 21, 34, 26, 3, -33 },
  { 2305, 21, 32, 26, 3, -32 },
  { 2389, 19, 32, 26, 5, -32 },
  { 2465, 18, 32, 26, 5, -32 },
  { 2537, 20, 34, 26, 3, -33 },
  { 2622, 21, 32, 26, 2, -32 },
  { 2706, 16, 32, 26, 5, -32 },
  { 2770, 18, 33, 26, 3, -32 },
  { 2845, 21, 32, 26, 4, -32 },
  { 2929, 19, 32, 26, 5, -32 },
  { 3005, 22, 32, 26, 2, -32 },
  { 3093, 20, 32, 26, 3, -32 },
  { 3173, 22, 34, 26, 2, -33 },
  { 3267, 19, 32, 26, 4, -32 },
  { 3343, 22, 41, 26, 2, -33 },
  { 3456, 20, 32, 26, 3, -32 },
  { 3536, 20, 34, 26, 3, -33 },
  { 3621, 22, 32, 26, 2, -32 },
  { 3709, 20, 33, 26, 3, -32 },
  { 3792, 24, 32, 26, 1, -32 },
  { 3888, 22, 32, 26, 2, -32 },
  { 3976, 22, 32, 26, 2, -32 },
  { 4064, 24, 32, 26, 1, -32 },
  { 4160, 21, 32, 26, 3, -32 },
  { 4244, 12, 45, 26, 8, -36 },
  { 4312, 18, 45, 26, 4, -36 },
  { 4414, 12, 45, 26, 6, -36 },
  { 4482, 21, 17, 26, 2, -32 },
  { 4527, 25, 4, 26, 0, 5 },
  { 4540, 7, 9, 26, 9, -36 },
  { 4548, 19, 25, 26, 3, -24 },
  { 4608, 20, 37, 26, 4, -36 },
  { 4701, 20, 25, 26, 3, -24 },
  { 4764, 20, 37, 26, 2, -36 },
  { 4857, 21, 25, 26, 2, -24 },
  { 4923, 21, 36, 26, 4, -36 },
  { 5018, 20, 33, 26, 2, -24 },
  { 5101, 18, 36, 26, 4, -36 },
  { 5182, 20, 36, 26, 3, -35 },
  { 5272, 16, 44, 26, 4, -35 },
  { 5360, 20, 36, 26, 4, -36 },
  { 5450, 20, 36, 26, 3, -35 },
  { 5540, 22, 24, 26, 2, -24 },
  { 5606, 18, 24, 26, 4, -24 },
  { 5660, 22, 25, 26, 2, -24 },
  { 5729, 20, 33, 26, 4, -24 },
  { 5812, 20, 33, 26, 2, -24 },
  { 5895, 16, 24, 26, 6, -24 },
  { 5943, 18, 25, 26, 4, -24 },
  { 6000, 19, 32, 26, 4, -31 },
  { 6076, 18, 25, 26, 4, -24 },
  { 6133, 22, 24, 26, 2, -24 },
  { 6199, 24, 24, 26, 1, -24 },
  { 6271, 22, 24, 26, 2, -24 },
  { 6337, 22, 33, 26, 2, -24 },
  { 6428, 18, 24, 26, 4, -24 },
  { 6482, 18, 45, 26, 4, -36 },
  { 6584, 4, 45, 26, 11, -36 },
  { 6607, 17, 45, 26, 4, -36 },
  { 6703, 22, 7, 26, 2, -17 },
};

const GFXfont UbuntuSansMono_Regular46pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular46pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular46pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUSANSMONO_REGULAR46PT7B_H_
