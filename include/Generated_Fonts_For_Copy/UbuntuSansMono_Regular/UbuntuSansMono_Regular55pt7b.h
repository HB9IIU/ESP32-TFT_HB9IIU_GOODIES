#ifndef _UBUNTUSANSMONO_REGULAR55PT7B_H_
#define _UBUNTUSANSMONO_REGULAR55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF,
  0xFF, 0x7F, 0x7E, 0x18, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0x70, 0x1B, 0x80, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x3E, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x3C,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x03, 0xC3, 0xF0, 0x00,
  0x87, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF4, 0x00, 0x07,
  0xDE, 0x00, 0x3F, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0x8F, 0xFC, 0x00, 0x78, 0xF1, 0xE0,
  0x07, 0x87, 0x87, 0x80, 0x3C, 0x38, 0x1C, 0x03, 0xC3, 0xC0, 0xE0, 0x3C,
  0x1E, 0x07, 0x01, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x0E, 0x0F, 0x01, 0xE0, 0x70, 0xF0, 0x0F, 0x03, 0x87, 0x80, 0x38, 0x1C,
  0x78, 0x01, 0xE1, 0xE3, 0xC0, 0x0F, 0x0E, 0x3C, 0x00, 0x3F, 0xF3, 0xC0,
  0x00, 0xFF, 0x1E, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x78, 0xFF, 0x00, 0x07,
  0x8F, 0xFC, 0x00, 0x3C, 0xF0, 0xF0, 0x03, 0xC7, 0x87, 0x80, 0x3C, 0x38,
  0x1C, 0x01, 0xE3, 0xC0, 0xE0, 0x1E, 0x1E, 0x07, 0x00, 0xF0, 0xF0, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x78,
  0x07, 0x03, 0x83, 0xC0, 0x38, 0x1C, 0x3C, 0x01, 0xE1, 0xE3, 0xC0, 0x07,
  0x9E, 0x1E, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xC0, 0xFF, 0xC0, 0x70, 0x3E,
  0xF8, 0x0E, 0x0F, 0x8F, 0x83, 0xC1, 0xF0, 0xF8, 0x78, 0x7C, 0x0F, 0x8F,
  0x0F, 0x80, 0xF9, 0xC1, 0xE0, 0x1F, 0xF8, 0x7C, 0x01, 0xFF, 0x0F, 0x80,
  0x1F, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x3F, 0xE1, 0xF8, 0x0F, 0xFC, 0x1F, 0xC7,
  0xF7, 0xC1, 0xFF, 0xFC, 0x7C, 0x1F, 0xFF, 0x0F, 0x81, 0xFF, 0x80, 0xF8,
  0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xE7, 0x39,
  0xCE, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0x10,
  0x00, 0x38, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x18, 0x0E, 0x07, 0x7E, 0x1C, 0x3E, 0xFF, 0x39, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF0, 0x1E, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF0, 0xFE, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE,
  0x0F, 0x80, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x07,
  0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x38, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC,
  0x3F, 0x87, 0xFE, 0x1F, 0xC3, 0xFF, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE0, 0x70, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xCF, 0x80, 0xFE, 0x3E, 0x01,
  0xE0, 0xF8, 0x04, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0x0F, 0x00,
  0x3F, 0x18, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xC0, 0x7F, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF9, 0x00, 0x03, 0xE7, 0xC0, 0x3F, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x3E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFB,
  0x00, 0x07, 0xEF, 0x80, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFD, 0xFF, 0x0F, 0xC0, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF3,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3C, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x3F, 0x00,
  0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0xE1, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0x87, 0xF8, 0x1F, 0x01, 0xFC, 0x3E, 0x00,
  0x7E, 0x3C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F, 0x00,
  0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3F, 0x00,
  0x7F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x3F,
  0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xF9, 0xFD,
  0xFF, 0xFF, 0xFF, 0xDF, 0xCF, 0xC1, 0xC0, 0x07, 0xC0, 0xFE, 0x0F, 0xE1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC6, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xE0, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x7F, 0xF7, 0x80, 0x7F, 0xFD, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xC7, 0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xE0, 0x7F,
  0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1E, 0x01, 0xFF, 0x87, 0x80,
  0x7F, 0xE1, 0xE0, 0x1F, 0xF8, 0x78, 0x07, 0xFE, 0x1E, 0x01, 0xFF, 0x87,
  0x80, 0x7F, 0xE1, 0xE0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F, 0x01, 0xF7,
  0x83, 0xC0, 0x7D, 0xF0, 0xF8, 0x1F, 0x7C, 0x1F, 0x87, 0xDF, 0x03, 0xFF,
  0xF3, 0xE0, 0x7F, 0xFC, 0xF8, 0x07, 0xFC, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xF8, 0x07, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xF8, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xFE, 0xF8, 0x0F,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x01, 0xF0, 0x7E, 0x00, 0x18, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x40,
  0xFF, 0x01, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x01, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0x83, 0xFF, 0x07, 0xC0, 0x1F, 0xC3, 0xE0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0xFE, 0x1F, 0xCF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0x00, 0xF0, 0x7E, 0x00,
  0x10, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xF8, 0x01, 0xE0, 0xFF, 0x01, 0xF0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x40, 0x01, 0xF1,
  0x80, 0x0F, 0xCF, 0x80, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFB, 0xF8,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xF8,
  0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x7F, 0x0E, 0xE0, 0x1F, 0xE1, 0xDE, 0x03, 0xFC, 0x3B, 0xC0, 0x77,
  0x87, 0x38, 0x0E, 0xF0, 0xE7, 0x83, 0xCE, 0x1C, 0xF0, 0x71, 0xC3, 0x8E,
  0x0E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0xC3, 0x8E, 0x1C,
  0x78, 0x7B, 0xC3, 0xCF, 0x07, 0x70, 0x79, 0xE0, 0xEE, 0x0F, 0x3C, 0x1F,
  0xC1, 0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x3E, 0x07, 0x9E, 0x07, 0xC0, 0xF3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x0F, 0xF7, 0x80, 0x1F, 0xEF, 0x80, 0x3F, 0xCF, 0x00, 0x7F, 0x9F,
  0x00, 0xFF, 0x1E, 0x01, 0xFE, 0x3E, 0x03, 0xFC, 0x3C, 0x07, 0xF8, 0x7C,
  0x0F, 0xF0, 0x78, 0x1F, 0xE0, 0xF8, 0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xE0,
  0xFF, 0x01, 0xE1, 0xFE, 0x03, 0xC3, 0xFC, 0x03, 0xC7, 0xF8, 0x07, 0x8F,
  0xF0, 0x07, 0x9F, 0xE0, 0x0F, 0x3F, 0xC0, 0x1E, 0x7F, 0x80, 0x1E, 0xFF,
  0x00, 0x3D, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x3D, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0xFF, 0x1E, 0x00,
  0x3F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB,
  0xC0, 0x03, 0xE7, 0x80, 0x0F, 0xCF, 0x00, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0x80, 0x7F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x03,
  0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x7F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x1F,
  0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xE1,
  0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3E, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xF8, 0x07, 0x87, 0xC0, 0x03, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x79, 0x80, 0x01, 0xF7, 0xE0, 0x1F, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0xF8, 0x1E, 0x78, 0x1F, 0x03,
  0xCF, 0x07, 0xE0, 0x79, 0xE0, 0xFE, 0x0F, 0x3C, 0x1D, 0xC1, 0xE7, 0x87,
  0xB8, 0x38, 0xF0, 0xE7, 0x87, 0x1E, 0x1C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C,
  0x78, 0xE1, 0xE3, 0x87, 0x1C, 0x3C, 0x70, 0xE7, 0x83, 0x8E, 0x1C, 0xF0,
  0x7B, 0xC3, 0x9C, 0x0F, 0x78, 0x77, 0x80, 0xEF, 0x0E, 0xF0, 0x1F, 0xE1,
  0xDC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0x81, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x3E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE0, 0xF0,
  0x00, 0x78, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x3E, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0x8F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF8, 0x03,
  0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xE6, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x0C,
  0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x10,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x10,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xFC, 0x01, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x10,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xC7, 0xC0, 0x0F, 0xCF, 0x00, 0x0F, 0x9E,
  0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x0F, 0xDE, 0x00, 0x3F,
  0x3C, 0x00, 0xFC, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x20, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0x07, 0xFE, 0x07, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0xE7, 0x81,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7E, 0x03, 0xF9, 0xF0,
  0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0xF7,
  0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0xE0, 0x07, 0x8F, 0xF8, 0x7F, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xF8, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x80, 0x02, 0x0F, 0xF8, 0x3E, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0xD0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFE,
  0x07, 0x80, 0x7E, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x03, 0xDF, 0x80,
  0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x80, 0x0F, 0x9F,
  0xC0, 0x7F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFC, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x80, 0x03, 0xF1, 0xFE, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x10, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xDF,
  0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3E, 0x00, 0xFD,
  0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1E, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x40, 0x1F, 0xC7, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7D, 0x00, 0x3E, 0x7E, 0x7F, 0xBF, 0xFF, 0xCF,
  0xFF, 0xE0, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03,
  0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x3F, 0x00, 0xF0, 0x7E,
  0x00, 0xF0, 0xFC, 0x00, 0xF1, 0xF0, 0x00, 0xF7, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xF3, 0xF8,
  0x00, 0xF1, 0xFC, 0x00, 0xF0, 0x7E, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x1F,
  0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x01,
  0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x40, 0x1F, 0x87, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0x80, 0x3F, 0xC1, 0xF8, 0x7F, 0xFB, 0xFF, 0x3F,
  0xFF, 0xFF, 0xDF, 0x9F, 0xF7, 0xEF, 0x03, 0xE0, 0xFF, 0x81, 0xE0, 0x3F,
  0xC0, 0xF8, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E, 0x07, 0xF8, 0x0F, 0x03,
  0xFC, 0x07, 0x81, 0xFE, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x7F, 0x80, 0xF0,
  0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E, 0x07, 0xF8, 0x0F,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78,
  0x1F, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00,
  0x3F, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x0F,
  0xF3, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0x00, 0x7F, 0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0x78,
  0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x7C,
  0xFC, 0x01, 0xF1, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0x7F, 0xF0, 0x1E, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x01, 0xE7, 0xE0,
  0x03, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0x9F, 0x00, 0x0F, 0x3F, 0x00, 0x7E, 0x3F, 0xE7, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFD, 0xE0, 0x03, 0x83, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xE0, 0x01, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x60,
  0x00, 0x7C, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x02, 0x03, 0xFC, 0x3C, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0xC0,
  0x0F, 0x3F, 0xC0, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0x5E, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x0F,
  0x3E, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x07, 0x00, 0xF7, 0x80, 0x78, 0x0F, 0x7C, 0x0F, 0x81, 0xE3, 0xC0, 0xF8,
  0x1E, 0x3C, 0x0F, 0x81, 0xE3, 0xC1, 0xFC, 0x1E, 0x3C, 0x1F, 0xC1, 0xE3,
  0xC1, 0xDC, 0x1E, 0x3C, 0x3D, 0xE3, 0xC1, 0xE3, 0x8E, 0x3C, 0x1E, 0x78,
  0xE3, 0xC1, 0xE7, 0x8F, 0x3C, 0x1E, 0x70, 0x73, 0xC1, 0xEF, 0x07, 0xBC,
  0x1E, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x0F,
  0x00, 0x70, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF9, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x78, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0x78, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x0F,
  0x00, 0x3E, 0x03, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x06, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x1F, 0xF8, 0x01, 0xDF, 0xFF,
  0x01, 0xEF, 0x1F, 0xC0, 0xEF, 0x03, 0xFF, 0xF7, 0x00, 0x7F, 0xF3, 0x80,
  0x1F, 0xF0, 0x00, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 39, 31, 11, -38 },
  { 40, 13, 15, 31, 9, -42 },
  { 65, 27, 38, 31, 2, -38 },
  { 194, 23, 49, 31, 4, -43 },
  { 335, 29, 40, 31, 1, -39 },
  { 480, 27, 40, 31, 2, -39 },
  { 615, 5, 16, 31, 13, -42 },
  { 625, 16, 53, 31, 7, -43 },
  { 731, 16, 53, 31, 7, -43 },
  { 837, 23, 22, 31, 4, -38 },
  { 901, 25, 27, 31, 3, -30 },
  { 986, 12, 17, 31, 10, -8 },
  { 1012, 13, 4, 31, 9, -18 },
  { 1019, 9, 9, 31, 11, -8 },
  { 1030, 21, 53, 31, 5, -43 },
  { 1170, 25, 40, 31, 3, -39 },
  { 1295, 22, 38, 31, 5, -38 },
  { 1400, 23, 39, 31, 4, -39 },
  { 1513, 23, 40, 31, 4, -39 },
  { 1628, 27, 38, 31, 2, -38 },
  { 1757, 22, 39, 31, 5, -38 },
  { 1865, 25, 39, 31, 3, -38 },
  { 1987, 24, 38, 31, 4, -38 },
  { 2101, 24, 40, 31, 3, -39 },
  { 2221, 24, 39, 31, 3, -39 },
  { 2338, 9, 29, 31, 11, -28 },
  { 2371, 12, 37, 31, 8, -28 },
  { 2427, 25, 24, 31, 3, -28 },
  { 2502, 25, 16, 31, 3, -24 },
  { 2552, 25, 24, 31, 3, -28 },
  { 2627, 19, 40, 31, 6, -39 },
  { 2722, 26, 47, 31, 3, -39 },
  { 2875, 29, 38, 31, 1, -38 },
  { 3013, 24, 39, 31, 3, -39 },
  { 3130, 25, 40, 31, 3, -39 },
  { 3255, 25, 39, 31, 3, -39 },
  { 3377, 22, 38, 31, 6, -38 },
  { 3482, 21, 38, 31, 6, -38 },
  { 3582, 25, 40, 31, 3, -39 },
  { 3707, 25, 38, 31, 3, -38 },
  { 3826, 19, 38, 31, 6, -38 },
  { 3917, 22, 39, 31, 4, -38 },
  { 4025, 26, 38, 31, 4, -38 },
  { 4149, 22, 38, 31, 6, -38 },
  { 4254, 27, 38, 31, 2, -38 },
  { 4383, 23, 38, 31, 4, -38 },
  { 4493, 27, 40, 31, 2, -39 },
  { 4628, 23, 39, 31, 5, -39 },
  { 4741, 27, 49, 31, 2, -39 },
  { 4907, 25, 39, 31, 3, -39 },
  { 5029, 23, 40, 31, 4, -39 },
  { 5144, 25, 38, 31, 3, -38 },
  { 5263, 25, 39, 31, 3, -38 },
  { 5385, 29, 38, 31, 1, -38 },
  { 5523, 27, 38, 31, 2, -38 },
  { 5652, 27, 38, 31, 2, -38 },
  { 5781, 29, 38, 31, 1, -38 },
  { 5919, 25, 38, 31, 3, -38 },
  { 6038, 14, 53, 31, 9, -43 },
  { 6131, 21, 53, 31, 5, -43 },
  { 6271, 14, 53, 31, 7, -43 },
  { 6364, 25, 20, 31, 3, -38 },
  { 6427, 30, 4, 31, 0, 6 },
  { 6442, 10, 11, 31, 10, -43 },
  { 6456, 22, 30, 31, 4, -29 },
  { 6539, 23, 44, 31, 5, -43 },
  { 6666, 25, 30, 31, 3, -29 },
  { 6760, 23, 44, 31, 3, -43 },
  { 6887, 25, 30, 31, 3, -29 },
  { 6981, 26, 43, 31, 4, -43 },
  { 7121, 23, 39, 31, 3, -29 },
  { 7234, 21, 43, 31, 5, -43 },
  { 7347, 23, 43, 31, 4, -42 },
  { 7471, 18, 52, 31, 5, -42 },
  { 7588, 24, 43, 31, 5, -43 },
  { 7717, 23, 43, 31, 4, -42 },
  { 7841, 25, 29, 31, 3, -29 },
  { 7932, 21, 29, 31, 5, -29 },
  { 8009, 25, 30, 31, 3, -29 },
  { 8103, 23, 39, 31, 5, -29 },
  { 8216, 23, 39, 31, 3, -29 },
  { 8329, 20, 29, 31, 7, -29 },
  { 8402, 23, 30, 31, 4, -29 },
  { 8489, 23, 38, 31, 4, -37 },
  { 8599, 22, 29, 31, 4, -28 },
  { 8679, 27, 28, 31, 2, -28 },
  { 8774, 28, 28, 31, 1, -28 },
  { 8872, 27, 28, 31, 2, -28 },
  { 8967, 26, 38, 31, 2, -28 },
  { 9091, 21, 28, 31, 5, -28 },
  { 9165, 21, 53, 31, 5, -43 },
  { 9305, 4, 53, 31, 13, -43 },
  { 9332, 21, 53, 31, 5, -43 },
  { 9472, 25, 8, 31, 3, -20 },
};

const GFXfont UbuntuSansMono_Regular55pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular55pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular55pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _UBUNTUSANSMONO_REGULAR55PT7B_H_
