#ifndef _NOTOSANS_CONDENSED_ITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x44, 0x0C, 0xC0, 0xDB, 0xAA, 0x0B, 0x12, 0x12,
  0x7F, 0x34, 0x24, 0x24, 0xFE, 0x48, 0x48, 0x50, 0x08, 0x3C, 0xA9, 0x42,
  0x86, 0x06, 0x0E, 0x15, 0x5B, 0xE1, 0x02, 0x00, 0x20, 0x28, 0x94, 0x92,
  0x49, 0x44, 0xDE, 0xAA, 0xA9, 0x14, 0x92, 0x59, 0x48, 0xE0, 0x08, 0x14,
  0x36, 0x24, 0x3C, 0x18, 0x31, 0x4A, 0xCA, 0x8C, 0xCC, 0x76, 0xEA, 0x18,
  0x88, 0x44, 0x21, 0x08, 0xC6, 0x30, 0x84, 0x20, 0x10, 0xC6, 0x11, 0x8C,
  0x62, 0x11, 0x88, 0xC4, 0x40, 0x25, 0x3E, 0xC9, 0x08, 0x30, 0xC3, 0x3F,
  0x30, 0xC3, 0x00, 0x2D, 0x60, 0xF0, 0x70, 0x03, 0x06, 0x04, 0x0C, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x10, 0xF4, 0x51, 0xC6, 0x38, 0xE2,
  0x8A, 0x69, 0x38, 0x37, 0xA2, 0x22, 0x64, 0x44, 0xC0, 0x08, 0x7C, 0x08,
  0x10, 0x60, 0x82, 0x08, 0x30, 0xC3, 0x17, 0xC0, 0x08, 0x7C, 0x08, 0x10,
  0x43, 0x8E, 0x06, 0x04, 0x1A, 0x27, 0x80, 0x06, 0x1C, 0x70, 0xA2, 0x4D,
  0x93, 0x7F, 0x08, 0x10, 0x60, 0x3E, 0x40, 0x81, 0x07, 0x81, 0x81, 0x02,
  0x05, 0x13, 0xC0, 0x0C, 0xF6, 0x10, 0xC2, 0xEC, 0xA2, 0x8A, 0x29, 0xBC,
  0x7E, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x00, 0x08, 0x7C,
  0x89, 0x12, 0x67, 0x8E, 0x26, 0xC5, 0x0B, 0x33, 0xC0, 0x08, 0x78, 0x9B,
  0x14, 0x68, 0xDB, 0x1A, 0x04, 0x10, 0x67, 0x80, 0x24, 0x00, 0x06, 0xC0,
  0x11, 0x00, 0x00, 0x02, 0x64, 0xC0, 0x0C, 0x66, 0x30, 0x70, 0x70, 0x40,
  0xFC, 0x00, 0x3F, 0xFC, 0x81, 0x81, 0x83, 0x3B, 0x88, 0x00, 0x27, 0xC2,
  0x31, 0x11, 0x08, 0x80, 0x21, 0x00, 0x1F, 0x10, 0x50, 0x29, 0xD9, 0x2D,
  0x26, 0x93, 0x4A, 0xBF, 0x40, 0x20, 0x0F, 0x80, 0x06, 0x14, 0x28, 0xD1,
  0x26, 0x4F, 0x91, 0x62, 0x87, 0x08, 0x3E, 0x33, 0x23, 0x22, 0x3E, 0x7C,
  0x46, 0x46, 0x46, 0x4C, 0xF8, 0x0C, 0x7D, 0x82, 0x0C, 0x18, 0x20, 0x40,
  0x81, 0x03, 0x03, 0xC0, 0x3E, 0x33, 0x21, 0x21, 0x21, 0x63, 0x43, 0x42,
  0x46, 0x4C, 0xF8, 0x3E, 0x60, 0x81, 0x03, 0xCF, 0x90, 0x20, 0x40, 0x83,
  0xE0, 0x3E, 0x60, 0x81, 0x02, 0x0F, 0x90, 0x20, 0x40, 0x83, 0x00, 0x0C,
  0x3F, 0x60, 0x40, 0xC0, 0xC0, 0x8E, 0x86, 0x86, 0x84, 0xC4, 0x7C, 0x31,
  0x98, 0xC8, 0x44, 0x23, 0xF3, 0xF9, 0x08, 0x84, 0x42, 0x21, 0x31, 0x80,
  0x1E, 0x10, 0x60, 0x81, 0x02, 0x04, 0x18, 0x20, 0x43, 0xC0, 0x0C, 0x30,
  0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0x08, 0x23, 0x00, 0x33, 0x99, 0x09,
  0x05, 0x83, 0x83, 0xC1, 0xA0, 0x90, 0x4C, 0x26, 0x31, 0x00, 0x31, 0x88,
  0x42, 0x31, 0x08, 0x42, 0x3E, 0x38, 0x73, 0x86, 0x38, 0xA2, 0x8E, 0x29,
  0x66, 0x94, 0x4A, 0x44, 0xA4, 0x4C, 0xC4, 0xC8, 0xCC, 0x80, 0x30, 0x9C,
  0x4A, 0x25, 0x32, 0x93, 0x49, 0x34, 0x8E, 0x47, 0x23, 0x31, 0x80, 0x0C,
  0x3E, 0x63, 0x43, 0xC3, 0xC3, 0x82, 0x82, 0x86, 0x84, 0xCC, 0x78, 0x3E,
  0x64, 0x89, 0x12, 0x6F, 0x9C, 0x20, 0x40, 0x83, 0x00, 0x0C, 0x3E, 0x63,
  0x43, 0xC3, 0xC3, 0x82, 0x82, 0x86, 0x84, 0xCC, 0x78, 0x10, 0x18, 0x08,
  0x3E, 0x64, 0x89, 0x12, 0x6F, 0x92, 0x24, 0x4C, 0x9B, 0x10, 0x0C, 0x7C,
  0x83, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x1A, 0x27, 0x80, 0xFE, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x30, 0x40, 0x83, 0x00, 0x63, 0x42, 0x42, 0x42, 0xC6,
  0xC6, 0x84, 0x84, 0x84, 0x88, 0xF8, 0xC3, 0xC6, 0x44, 0x4C, 0x48, 0x58,
  0x50, 0x50, 0x60, 0x60, 0x60, 0xC6, 0x3C, 0x62, 0xCA, 0x6C, 0xA4, 0xDA,
  0xCD, 0x28, 0xD2, 0x8E, 0x30, 0xE3, 0x0E, 0x30, 0xC6, 0x00, 0x11, 0x89,
  0x86, 0x81, 0x80, 0xC0, 0x40, 0x70, 0x68, 0x24, 0x22, 0x31, 0x80, 0xC6,
  0x99, 0x22, 0xC5, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x00, 0x1F, 0x02, 0x06,
  0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x40, 0xFC, 0x3C, 0x82, 0x08, 0x21,
  0x84, 0x10, 0x41, 0x0C, 0x20, 0xE3, 0x80, 0xAA, 0xB5, 0x54, 0x1C, 0x30,
  0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0x08, 0xE3, 0x80, 0x18, 0x30, 0x91,
  0x24, 0x58, 0x40, 0xF8, 0xCC, 0x35, 0xBC, 0xE3, 0x8A, 0x28, 0xA6, 0xF8,
  0x10, 0x60, 0x81, 0x63, 0x64, 0x58, 0xA3, 0x46, 0x8B, 0x35, 0xC0, 0x3B,
  0x71, 0x08, 0x42, 0x10, 0xF0, 0x01, 0x03, 0x03, 0x1A, 0x36, 0x66, 0x46,
  0x44, 0x44, 0xC4, 0x4C, 0x7C, 0x18, 0xD6, 0x51, 0x79, 0x0C, 0x10, 0x78,
  0x07, 0x04, 0x0C, 0x0E, 0x18, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x60, 0xC0, 0x1A, 0x6D, 0x9A, 0x34, 0x48, 0xB1, 0x26, 0x7C,
  0x10, 0x24, 0xCF, 0x00, 0x10, 0x60, 0x81, 0x63, 0x64, 0xD9, 0xA2, 0x44,
  0x8B, 0x36, 0x60, 0x13, 0x02, 0x22, 0x64, 0x44, 0xCC, 0x04, 0x30, 0x02,
  0x08, 0x21, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x86, 0x30, 0x10, 0x60, 0x81,
  0x12, 0x45, 0x1E, 0x38, 0x78, 0xB3, 0x26, 0x40, 0x13, 0x22, 0x22, 0x64,
  0x44, 0xCC, 0x2C, 0xC6, 0xE8, 0x99, 0xB2, 0x24, 0x44, 0x88, 0x91, 0x36,
  0x64, 0xC8, 0x80, 0x2C, 0x6D, 0x9B, 0x34, 0x48, 0x91, 0x66, 0xCC, 0x31,
  0xAC, 0xE3, 0x8E, 0x28, 0xA6, 0xF0, 0x16, 0x1B, 0x11, 0x31, 0x23, 0x23,
  0x22, 0x66, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x1A, 0x6D, 0x9A, 0x34, 0x48,
  0xB1, 0x26, 0x7C, 0x10, 0x20, 0x41, 0x80, 0x2C, 0xE2, 0x18, 0x41, 0x04,
  0x30, 0xC0, 0x3D, 0xA4, 0x18, 0x30, 0x41, 0xA4, 0xF0, 0x24, 0x7C, 0x4C,
  0x88, 0x88, 0xC0, 0x45, 0x1C, 0xF3, 0x8A, 0x29, 0xA6, 0xF0, 0x8E, 0x28,
  0xA4, 0x92, 0x8A, 0x30, 0xC0, 0x88, 0xCC, 0x66, 0x53, 0x2A, 0xB5, 0x53,
  0x29, 0x98, 0xCC, 0x00, 0x33, 0x12, 0x14, 0x1C, 0x18, 0x18, 0x28, 0x6C,
  0xC4, 0x11, 0x88, 0x84, 0x42, 0x41, 0x20, 0xA0, 0x50, 0x38, 0x18, 0x0C,
  0x04, 0x06, 0x0E, 0x00, 0x7C, 0x21, 0x84, 0x21, 0x84, 0x20, 0xF0, 0x0C,
  0x41, 0x04, 0x10, 0x8C, 0x08, 0x21, 0x86, 0x10, 0x70, 0x40, 0xFF, 0xFF,
  0x18, 0x20, 0x82, 0x18, 0x60, 0xC4, 0x10, 0xC2, 0x08, 0xE2, 0x00, 0x46,
  0xF0,
};

const GFXglyph NotoSans_Condensed_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 6, 2, -11 },
  { 9, 8, 11, 8, 0, -11 },
  { 20, 7, 13, 7, 0, -12 },
  { 32, 9, 12, 11, 1, -12 },
  { 46, 8, 12, 8, 0, -12 },
  { 58, 2, 4, 3, 2, -11 },
  { 59, 5, 14, 4, 0, -11 },
  { 68, 5, 14, 4, -1, -11 },
  { 77, 5, 6, 7, 2, -12 },
  { 81, 6, 7, 8, 1, -9 },
  { 87, 3, 4, 3, -1, -2 },
  { 89, 4, 1, 4, 0, -5 },
  { 90, 2, 2, 3, 0, -2 },
  { 91, 8, 11, 5, -1, -11 },
  { 102, 6, 12, 7, 1, -12 },
  { 111, 4, 11, 7, 2, -11 },
  { 117, 7, 12, 7, 0, -12 },
  { 128, 7, 12, 7, 0, -12 },
  { 139, 7, 11, 7, 0, -11 },
  { 149, 7, 11, 7, 0, -11 },
  { 159, 6, 12, 7, 1, -12 },
  { 168, 7, 11, 7, 1, -11 },
  { 178, 7, 12, 7, 0, -12 },
  { 189, 7, 12, 7, 0, -12 },
  { 200, 3, 9, 4, 0, -9 },
  { 204, 4, 11, 4, -1, -9 },
  { 210, 6, 7, 8, 1, -9 },
  { 216, 6, 5, 8, 1, -8 },
  { 220, 6, 7, 8, 1, -9 },
  { 226, 5, 12, 5, 1, -12 },
  { 234, 9, 12, 11, 1, -11 },
  { 248, 7, 11, 7, -1, -11 },
  { 258, 8, 11, 8, 0, -11 },
  { 269, 7, 12, 7, 1, -12 },
  { 280, 8, 11, 8, 0, -11 },
  { 291, 7, 11, 7, 0, -11 },
  { 301, 7, 11, 6, 0, -11 },
  { 311, 8, 12, 9, 1, -12 },
  { 323, 9, 11, 9, 0, -11 },
  { 336, 7, 11, 4, -1, -11 },
  { 346, 6, 14, 4, -2, -11 },
  { 357, 9, 11, 7, 0, -11 },
  { 370, 5, 11, 6, 0, -11 },
  { 377, 12, 11, 11, 0, -11 },
  { 394, 9, 11, 9, 0, -11 },
  { 407, 8, 12, 9, 1, -12 },
  { 419, 7, 11, 7, 0, -11 },
  { 429, 8, 15, 9, 1, -12 },
  { 444, 7, 11, 7, 0, -11 },
  { 454, 7, 12, 7, 0, -12 },
  { 465, 7, 11, 6, 1, -11 },
  { 475, 8, 11, 9, 1, -11 },
  { 486, 8, 11, 7, 1, -11 },
  { 497, 12, 11, 11, 1, -11 },
  { 514, 9, 11, 7, -1, -11 },
  { 527, 7, 11, 6, 1, -11 },
  { 537, 8, 11, 6, -1, -11 },
  { 548, 6, 14, 5, 0, -11 },
  { 559, 2, 11, 6, 2, -11 },
  { 562, 6, 14, 5, -1, -11 },
  { 573, 7, 6, 7, 0, -11 },
  { 579, 5, 1, 5, -1, 1 },
  { 580, 3, 2, 4, 2, -12 },
  { 581, 6, 9, 7, 1, -9 },
  { 588, 7, 12, 7, 0, -12 },
  { 599, 5, 9, 6, 1, -9 },
  { 605, 8, 12, 8, 0, -12 },
  { 617, 6, 9, 7, 0, -9 },
  { 624, 8, 16, 4, -2, -12 },
  { 640, 7, 13, 8, 0, -9 },
  { 652, 7, 12, 7, 0, -12 },
  { 663, 4, 12, 3, 0, -12 },
  { 669, 6, 16, 3, -2, -12 },
  { 681, 7, 12, 6, 0, -12 },
  { 692, 4, 12, 3, 0, -12 },
  { 698, 11, 9, 11, 0, -9 },
  { 711, 7, 9, 7, 0, -9 },
  { 719, 6, 9, 7, 1, -9 },
  { 726, 8, 13, 7, -1, -9 },
  { 739, 7, 13, 8, 0, -9 },
  { 751, 6, 9, 5, 0, -9 },
  { 758, 6, 9, 6, 0, -9 },
  { 765, 4, 11, 4, 1, -11 },
  { 771, 6, 9, 7, 1, -9 },
  { 778, 6, 9, 6, 1, -9 },
  { 785, 9, 9, 10, 1, -9 },
  { 796, 8, 9, 6, -1, -9 },
  { 805, 9, 13, 6, -2, -9 },
  { 820, 6, 9, 5, 0, -9 },
  { 827, 6, 14, 5, 0, -11 },
  { 838, 1, 16, 7, 3, -12 },
  { 840, 6, 14, 5, -1, -11 },
  { 851, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Italic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_ITALIC16PT7B_H_
