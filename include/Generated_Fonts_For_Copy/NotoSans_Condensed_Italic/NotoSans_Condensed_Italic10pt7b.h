#ifndef _NOTOSANS_CONDENSED_ITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x20, 0xB4, 0x29, 0x9E, 0xAF, 0x32, 0x80, 0x13, 0x66,
  0x23, 0xD6, 0x40, 0xCE, 0xB9, 0xF5, 0xB6, 0x60, 0x32, 0x94, 0xCA, 0xCB,
  0xC0, 0xC0, 0x29, 0x49, 0x24, 0x40, 0x24, 0x92, 0x4A, 0x80, 0x39, 0xD0,
  0x22, 0xF2, 0x20, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x35, 0x59,
  0x99, 0x60, 0x75, 0x24, 0xA0, 0x71, 0x12, 0x24, 0xE0, 0x71, 0x16, 0x11,
  0xE0, 0x13, 0x55, 0xA7, 0x20, 0x34, 0x43, 0x11, 0xE0, 0x3A, 0x18, 0xA9,
  0x49, 0x80, 0x78, 0x84, 0x42, 0x23, 0x00, 0x75, 0x56, 0x99, 0xE0, 0x75,
  0x57, 0x12, 0xE0, 0x40, 0x80, 0x20, 0x05, 0x80, 0x12, 0xC3, 0x10, 0xE3,
  0x80, 0x83, 0x06, 0xC8, 0x00, 0x71, 0x24, 0x40, 0x80, 0x3D, 0x15, 0xEB,
  0xAE, 0xE8, 0x1C, 0x18, 0xCA, 0x53, 0xA7, 0x20, 0x7A, 0x52, 0xE5, 0x4B,
  0x80, 0x3A, 0x10, 0x88, 0x41, 0xC0, 0x7A, 0x52, 0x94, 0xCB, 0x80, 0x7A,
  0x10, 0xE4, 0x43, 0x80, 0x7A, 0x10, 0xE4, 0x42, 0x00, 0x3D, 0x04, 0x26,
  0x8A, 0x27, 0x00, 0x45, 0x24, 0x9E, 0x4A, 0x49, 0x00, 0x69, 0x24, 0xB0,
  0x11, 0x11, 0x12, 0x22, 0xC0, 0x4A, 0x98, 0xC6, 0x4A, 0x40, 0x49, 0x25,
  0x38, 0x62, 0xCD, 0x9B, 0x56, 0xD6, 0xAD, 0x00, 0x65, 0x96, 0x96, 0x5A,
  0x69, 0x00, 0x3A, 0x52, 0x98, 0xC5, 0xC0, 0x72, 0x52, 0xE4, 0x42, 0x00,
  0x3A, 0x52, 0x98, 0xC5, 0xC2, 0x10, 0x72, 0x52, 0xE6, 0x4A, 0x40, 0x74,
  0x42, 0x11, 0xE0, 0xF4, 0x44, 0x88, 0x80, 0x4D, 0x24, 0x92, 0x8A, 0x47,
  0x00, 0x99, 0xAA, 0xCC, 0x80, 0x93, 0x6A, 0xD6, 0xAD, 0x93, 0x24, 0x00,
  0x24, 0xA1, 0x04, 0x31, 0x4D, 0x80, 0x9A, 0xCC, 0x88, 0x80, 0x78, 0x88,
  0x44, 0x43, 0x80, 0x74, 0x44, 0x48, 0x88, 0xC0, 0xAA, 0x54, 0x31, 0x12,
  0x22, 0x22, 0xC0, 0x25, 0x59, 0xF0, 0x90, 0x7A, 0xA5, 0x27, 0x00, 0x24,
  0x47, 0x59, 0x9E, 0x74, 0x88, 0x60, 0x08, 0x4A, 0xA5, 0x4A, 0x4E, 0x75,
  0xE8, 0x60, 0x19, 0x0C, 0xC2, 0x11, 0x08, 0x46, 0x00, 0x7A, 0xA5, 0x2F,
  0x13, 0x80, 0x24, 0x47, 0x55, 0x99, 0x45, 0x68, 0x20, 0x92, 0x92, 0xC0,
  0x24, 0x45, 0x66, 0xAA, 0x29, 0x24, 0xA4, 0x7E, 0xA5, 0x54, 0xA9, 0x40,
  0x75, 0x59, 0x90, 0x75, 0x99, 0x60, 0x75, 0x59, 0xE8, 0x80, 0x7A, 0xA5,
  0x2F, 0x10, 0x80, 0x74, 0x48, 0x80, 0x74, 0x62, 0xE0, 0x4F, 0x25, 0x30,
  0x5A, 0xA5, 0x2E, 0x00, 0xBB, 0x48, 0xAF, 0x7D, 0x6A, 0x00, 0x56, 0x46,
  0xA0, 0x29, 0x4C, 0x42, 0x13, 0x00, 0x72, 0x48, 0xE0, 0x32, 0x24, 0xC4,
  0x44, 0x40, 0xFF, 0xC0, 0x31, 0x22, 0x12, 0x24, 0x80, 0xF8,
};

const GFXglyph NotoSans_Condensed_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 2, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 4, 9, 4, 0, -8 },
  { 15, 5, 7, 7, 1, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 2, 2, 1, -7 },
  { 26, 3, 9, 3, 0, -7 },
  { 30, 3, 9, 3, -1, -7 },
  { 34, 3, 4, 4, 1, -8 },
  { 36, 4, 5, 5, 0, -6 },
  { 39, 1, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 0, -1 },
  { 42, 4, 7, 3, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 3, 7, 4, 1, -7 },
  { 53, 4, 7, 4, 0, -7 },
  { 57, 4, 7, 4, 0, -7 },
  { 61, 4, 7, 4, 0, -7 },
  { 65, 4, 7, 4, 0, -7 },
  { 69, 5, 7, 4, 0, -7 },
  { 74, 5, 7, 4, 0, -7 },
  { 79, 4, 7, 4, 0, -7 },
  { 83, 4, 7, 4, 0, -7 },
  { 87, 2, 5, 2, 0, -5 },
  { 89, 3, 6, 2, -1, -5 },
  { 92, 4, 5, 5, 0, -6 },
  { 95, 3, 3, 5, 1, -5 },
  { 97, 5, 5, 5, 0, -6 },
  { 101, 4, 7, 3, 0, -7 },
  { 105, 6, 8, 7, 0, -7 },
  { 111, 5, 7, 5, -1, -7 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 5, 7, 4, 0, -7 },
  { 126, 5, 7, 5, 0, -7 },
  { 131, 5, 7, 4, 0, -7 },
  { 136, 5, 7, 4, 0, -7 },
  { 141, 6, 7, 5, 0, -7 },
  { 147, 6, 7, 5, 0, -7 },
  { 153, 3, 7, 3, 0, -7 },
  { 156, 4, 9, 2, -2, -7 },
  { 161, 5, 7, 5, 0, -7 },
  { 166, 3, 7, 4, 0, -7 },
  { 169, 7, 7, 7, 0, -7 },
  { 176, 6, 7, 6, 0, -7 },
  { 182, 5, 7, 6, 0, -7 },
  { 187, 5, 7, 5, 0, -7 },
  { 192, 5, 9, 6, 0, -7 },
  { 198, 5, 7, 5, 0, -7 },
  { 203, 4, 7, 4, 0, -7 },
  { 207, 4, 7, 4, 1, -7 },
  { 211, 6, 7, 5, 0, -7 },
  { 217, 4, 7, 4, 1, -7 },
  { 221, 7, 7, 7, 1, -7 },
  { 228, 6, 7, 4, -1, -7 },
  { 234, 4, 7, 4, 1, -7 },
  { 238, 5, 7, 4, 0, -7 },
  { 243, 4, 9, 3, 0, -7 },
  { 248, 2, 7, 3, 1, -7 },
  { 250, 4, 9, 3, -1, -7 },
  { 255, 4, 4, 5, 0, -7 },
  { 257, 4, 1, 3, -1, 1 },
  { 258, 2, 2, 3, 1, -8 },
  { 259, 5, 5, 5, 0, -5 },
  { 263, 4, 8, 5, 0, -8 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 5, 8, 5, 0, -8 },
  { 275, 4, 5, 4, 0, -5 },
  { 278, 5, 10, 3, -1, -8 },
  { 285, 5, 7, 5, 0, -5 },
  { 290, 4, 8, 5, 0, -8 },
  { 294, 2, 7, 2, 0, -7 },
  { 296, 3, 9, 2, -1, -7 },
  { 300, 4, 8, 4, 0, -8 },
  { 304, 3, 8, 2, 0, -8 },
  { 307, 7, 5, 7, 0, -5 },
  { 312, 4, 5, 5, 0, -5 },
  { 315, 4, 5, 5, 0, -5 },
  { 318, 4, 7, 5, 0, -5 },
  { 322, 5, 7, 5, 0, -5 },
  { 327, 4, 5, 3, 0, -5 },
  { 330, 4, 5, 4, 0, -5 },
  { 333, 3, 7, 3, 0, -7 },
  { 336, 5, 5, 5, 0, -5 },
  { 340, 3, 5, 4, 1, -5 },
  { 342, 5, 5, 6, 1, -5 },
  { 346, 4, 5, 4, 0, -5 },
  { 349, 5, 7, 4, -1, -5 },
  { 354, 4, 5, 3, 0, -5 },
  { 357, 4, 9, 3, 0, -7 },
  { 362, 1, 10, 4, 2, -8 },
  { 364, 4, 9, 3, -1, -7 },
  { 369, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Italic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_ITALIC10PT7B_H_
