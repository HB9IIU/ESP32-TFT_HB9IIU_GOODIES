#ifndef _NOTOSANS_CONDENSED_ITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x84, 0xF6, 0x80, 0x28, 0xA7, 0xCC, 0x53, 0xE5, 0x28,
  0x13, 0xD8, 0xC3, 0x1A, 0xC8, 0x40, 0x4A, 0xAB, 0x37, 0xF5, 0x55, 0x66,
  0x31, 0x54, 0x46, 0xCE, 0x5D, 0xE8, 0x32, 0x44, 0x88, 0x88, 0x84, 0x21,
  0x11, 0x12, 0x22, 0x48, 0x2F, 0xE2, 0x44, 0xF4, 0x40, 0xE0, 0xE0, 0x80,
  0x0C, 0x21, 0x04, 0x20, 0x84, 0x30, 0x32, 0x52, 0x98, 0xCA, 0x4C, 0x3C,
  0x94, 0x92, 0x70, 0x42, 0x22, 0x11, 0x1E, 0x70, 0x42, 0x65, 0x08, 0x5C,
  0x08, 0xCC, 0xA5, 0x7C, 0x84, 0x3A, 0x10, 0xE1, 0x08, 0x5C, 0x19, 0x10,
  0xE5, 0x4A, 0x4C, 0x78, 0x44, 0x22, 0x11, 0x18, 0x32, 0x52, 0x65, 0x4A,
  0x5E, 0x32, 0x52, 0x97, 0x08, 0x5C, 0x40, 0x20, 0x20, 0x00, 0xB0, 0x3C,
  0xC2, 0x10, 0xF0, 0xF0, 0xC2, 0x3C, 0x80, 0x71, 0x12, 0x44, 0x0C, 0x1C,
  0x45, 0x7B, 0x5A, 0xB5, 0x6F, 0x20, 0x78, 0x08, 0xC6, 0x52, 0xBD, 0x39,
  0x3A, 0x52, 0xF5, 0x26, 0x7E, 0x3A, 0x21, 0x08, 0x42, 0x1C, 0x39, 0x24,
  0x51, 0x49, 0x29, 0x38, 0x3A, 0x10, 0xE4, 0x22, 0x1E, 0x3A, 0x10, 0x87,
  0x22, 0x10, 0x3A, 0x21, 0x0B, 0xCA, 0x5E, 0x25, 0x14, 0x5E, 0x49, 0x28,
  0xA2, 0x72, 0x44, 0x44, 0x4C, 0x08, 0x84, 0x21, 0x08, 0x84, 0x26, 0x00,
  0x25, 0x25, 0x18, 0x61, 0x49, 0x24, 0x29, 0x24, 0xA7, 0x23, 0x23, 0x66,
  0x66, 0x6A, 0x6A, 0x92, 0x94, 0x24, 0x96, 0x55, 0x55, 0x69, 0xA2, 0x18,
  0x94, 0x51, 0x46, 0x24, 0x9C, 0x32, 0x52, 0x97, 0x22, 0x10, 0x18, 0x94,
  0x51, 0x46, 0x24, 0x9C, 0x10, 0x40, 0x3A, 0x52, 0x97, 0x2A, 0x52, 0x3A,
  0x10, 0xC3, 0x08, 0x5C, 0xF4, 0x44, 0x48, 0x88, 0x4C, 0x63, 0x29, 0x4A,
  0x5C, 0x8C, 0xA5, 0x4A, 0x63, 0x18, 0x91, 0x92, 0xB2, 0xB4, 0xB4, 0xD4,
  0xD8, 0x98, 0x24, 0x91, 0x84, 0x10, 0xC4, 0xB2, 0x99, 0xAA, 0x44, 0x88,
  0x78, 0x84, 0x42, 0x22, 0x1E, 0x34, 0x44, 0x44, 0x88, 0x8C, 0xAA, 0x55,
  0x31, 0x11, 0x12, 0x22, 0x2C, 0x21, 0x94, 0x98, 0x80, 0xF0, 0x80, 0x3A,
  0x53, 0x29, 0x38, 0x22, 0x1C, 0x94, 0xA6, 0x5E, 0x34, 0x48, 0x86, 0x0C,
  0x23, 0x92, 0x4A, 0x49, 0x1C, 0x35, 0x78, 0x87, 0x18, 0x8C, 0x42, 0x11,
  0x08, 0x42, 0x20, 0x3A, 0x53, 0x29, 0x38, 0x54, 0xC0, 0x22, 0x1E, 0x94,
  0xAA, 0x52, 0x21, 0x24, 0xA4, 0x10, 0x22, 0x22, 0x44, 0x44, 0x80, 0x22,
  0x12, 0xA6, 0x32, 0x92, 0x29, 0x24, 0xA4, 0x76, 0x95, 0x4A, 0x99, 0x32,
  0x80, 0x7A, 0x52, 0xA9, 0x48, 0x32, 0x53, 0x29, 0x30, 0x72, 0x52, 0x99,
  0x7A, 0x10, 0x80, 0x3A, 0x53, 0x29, 0x38, 0x42, 0x20, 0x74, 0x44, 0x88,
  0x74, 0x42, 0x2E, 0x6D, 0x25, 0x30, 0x4A, 0x52, 0xA9, 0x78, 0x9A, 0xAC,
  0xC8, 0xA6, 0x9E, 0xBA, 0x92, 0x40, 0x5A, 0x98, 0xC6, 0x50, 0x24, 0xA2,
  0x8C, 0x30, 0x82, 0x10, 0x80, 0x72, 0x24, 0x8E, 0x12, 0x22, 0xC4, 0x44,
  0x44, 0xFF, 0xE0, 0x31, 0x11, 0x13, 0x22, 0x4C, 0x9F,
};

const GFXglyph NotoSans_Condensed_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 4, 1, -8 },
  { 6, 6, 8, 5, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 6, 8, 7, 1, -8 },
  { 24, 5, 8, 6, 0, -8 },
  { 29, 2, 3, 2, 1, -8 },
  { 30, 4, 10, 3, 0, -8 },
  { 35, 4, 10, 3, -1, -8 },
  { 40, 4, 4, 5, 1, -8 },
  { 42, 4, 5, 5, 1, -6 },
  { 45, 2, 2, 2, 0, -1 },
  { 46, 3, 1, 3, 0, -3 },
  { 47, 1, 1, 2, 0, -1 },
  { 48, 6, 8, 4, -1, -8 },
  { 54, 5, 8, 5, 0, -8 },
  { 59, 3, 8, 5, 1, -8 },
  { 62, 5, 8, 5, 0, -8 },
  { 67, 5, 8, 5, 0, -8 },
  { 72, 5, 8, 5, 0, -8 },
  { 77, 5, 8, 5, 0, -8 },
  { 82, 5, 8, 5, 0, -8 },
  { 87, 5, 8, 5, 0, -8 },
  { 92, 5, 8, 5, 0, -8 },
  { 97, 5, 8, 5, 0, -8 },
  { 102, 2, 6, 2, 0, -6 },
  { 104, 3, 7, 2, -1, -6 },
  { 107, 4, 5, 5, 1, -6 },
  { 110, 4, 3, 5, 1, -5 },
  { 112, 4, 5, 5, 1, -6 },
  { 115, 4, 8, 4, 0, -8 },
  { 119, 7, 9, 7, 0, -8 },
  { 127, 5, 8, 5, -1, -8 },
  { 132, 5, 8, 5, 0, -8 },
  { 137, 5, 8, 5, 1, -8 },
  { 142, 6, 8, 6, 0, -8 },
  { 148, 5, 8, 5, 0, -8 },
  { 153, 5, 8, 4, 0, -8 },
  { 158, 5, 8, 6, 1, -8 },
  { 163, 6, 8, 6, 0, -8 },
  { 169, 4, 8, 3, 0, -8 },
  { 173, 5, 10, 2, -2, -8 },
  { 180, 6, 8, 5, 0, -8 },
  { 186, 3, 8, 4, 0, -8 },
  { 189, 8, 8, 8, 0, -8 },
  { 197, 6, 8, 6, 0, -8 },
  { 203, 6, 8, 6, 0, -8 },
  { 209, 5, 8, 5, 0, -8 },
  { 214, 6, 10, 6, 0, -8 },
  { 222, 5, 8, 5, 0, -8 },
  { 227, 5, 8, 5, 0, -8 },
  { 232, 4, 8, 4, 1, -8 },
  { 236, 5, 8, 6, 1, -8 },
  { 241, 5, 8, 5, 1, -8 },
  { 246, 8, 8, 8, 1, -8 },
  { 254, 6, 8, 5, -1, -8 },
  { 260, 4, 8, 4, 1, -8 },
  { 264, 5, 8, 4, 0, -8 },
  { 269, 4, 10, 3, 0, -8 },
  { 274, 2, 8, 4, 1, -8 },
  { 276, 4, 10, 3, -1, -8 },
  { 281, 5, 5, 5, 0, -8 },
  { 285, 4, 1, 4, -1, 1 },
  { 286, 1, 1, 3, 2, -8 },
  { 287, 5, 6, 5, 0, -6 },
  { 291, 5, 8, 5, 0, -8 },
  { 296, 4, 6, 4, 0, -6 },
  { 299, 6, 8, 5, 0, -8 },
  { 305, 4, 6, 5, 0, -6 },
  { 308, 5, 11, 3, -1, -8 },
  { 315, 5, 9, 5, 0, -6 },
  { 321, 5, 8, 5, 0, -8 },
  { 326, 3, 8, 2, 0, -8 },
  { 329, 4, 11, 2, -1, -8 },
  { 335, 5, 8, 4, 0, -8 },
  { 340, 3, 8, 2, 0, -8 },
  { 343, 7, 6, 8, 0, -6 },
  { 349, 5, 6, 5, 0, -6 },
  { 353, 5, 6, 5, 0, -6 },
  { 357, 5, 9, 5, 0, -6 },
  { 363, 5, 9, 5, 0, -6 },
  { 369, 4, 6, 3, 0, -6 },
  { 372, 4, 6, 4, 0, -6 },
  { 375, 3, 7, 3, 0, -7 },
  { 378, 5, 6, 5, 0, -6 },
  { 382, 4, 6, 4, 1, -6 },
  { 385, 6, 6, 7, 1, -6 },
  { 390, 5, 6, 4, 0, -6 },
  { 394, 6, 9, 4, -1, -6 },
  { 401, 4, 6, 4, 0, -6 },
  { 404, 4, 10, 4, 0, -8 },
  { 409, 1, 11, 5, 2, -8 },
  { 411, 4, 10, 4, -1, -8 },
  { 416, 4, 2, 5, 1, -5 },
};

const GFXfont NotoSans_Condensed_Italic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_ITALIC11PT7B_H_
