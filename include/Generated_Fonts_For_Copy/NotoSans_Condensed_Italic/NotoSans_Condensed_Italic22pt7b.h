#ifndef _NOTOSANS_CONDENSED_ITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_ITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x82, 0x18, 0x01, 0x0E,
  0x30, 0x66, 0xD9, 0x32, 0x6C, 0x99, 0x00, 0x06, 0x60, 0xC8, 0x11, 0x02,
  0x60, 0xC8, 0x7F, 0xC2, 0x60, 0xC8, 0x11, 0x02, 0x63, 0xFF, 0x11, 0x02,
  0x60, 0xCC, 0x19, 0x02, 0x60, 0x02, 0x00, 0x80, 0xF8, 0x7F, 0x32, 0x0D,
  0x03, 0x40, 0xF0, 0x1C, 0x03, 0x80, 0xB0, 0x24, 0x09, 0x22, 0xCF, 0xE1,
  0xF0, 0x10, 0x04, 0x00, 0x18, 0x31, 0xE1, 0x19, 0x18, 0x88, 0x84, 0x48,
  0x66, 0xC3, 0x24, 0xD9, 0x6F, 0xDA, 0xDB, 0xA4, 0xC3, 0x66, 0x13, 0x31,
  0x91, 0x08, 0x98, 0xC6, 0x8C, 0x3C, 0x07, 0x01, 0xB0, 0x66, 0x0C, 0xC1,
  0x98, 0x36, 0x07, 0x80, 0x60, 0x3C, 0x2C, 0xC9, 0x9B, 0x61, 0x4C, 0x39,
  0x86, 0x3B, 0xE3, 0xEE, 0x6D, 0xA5, 0x80, 0x04, 0x21, 0x8C, 0x31, 0x86,
  0x10, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x00, 0x0C, 0x08,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x82, 0x0C,
  0x30, 0x63, 0x80, 0x0C, 0x08, 0x48, 0xFB, 0x1F, 0x38, 0x6C, 0x44, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0x36,
  0x64, 0xC0, 0x7F, 0xE0, 0x5F, 0x00, 0x00, 0xC0, 0x30, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x04,
  0x03, 0x00, 0x0E, 0x0F, 0x8C, 0x44, 0x36, 0x1B, 0x0B, 0x05, 0x86, 0xC3,
  0x61, 0xB0, 0xD0, 0xC8, 0x66, 0x63, 0x70, 0xF0, 0x19, 0xDF, 0xB9, 0x18,
  0xC6, 0x31, 0x18, 0xC6, 0x31, 0x18, 0x0F, 0x07, 0xE1, 0x18, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xF3, 0xF8, 0x0F, 0x07, 0xE1, 0x18, 0x03, 0x00, 0x80, 0x60, 0x30, 0x78,
  0x1E, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCC, 0xE3, 0xF0, 0x01, 0xC0,
  0x60, 0x28, 0x1E, 0x05, 0x82, 0x41, 0x90, 0x4C, 0x23, 0x18, 0xCC, 0x23,
  0xFE, 0xFF, 0x81, 0x80, 0x60, 0x30, 0x0F, 0xC7, 0xE1, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0xC0, 0xFC, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0xCC,
  0xE3, 0xF0, 0x07, 0x87, 0xC6, 0x06, 0x06, 0x03, 0x01, 0x39, 0xFC, 0xE3,
  0x61, 0xB0, 0xD8, 0x6C, 0x66, 0x33, 0xB0, 0xF0, 0x7F, 0xBF, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x81, 0x80, 0x07, 0x07, 0xE1, 0x8C, 0xC3, 0x30, 0xC4, 0x61, 0xB0, 0x38,
  0x3E, 0x1C, 0xC6, 0x33, 0x04, 0xC1, 0x30, 0xC6, 0x71, 0xF8, 0x0F, 0x0F,
  0xCC, 0x66, 0x12, 0x09, 0x05, 0x86, 0xC3, 0x33, 0x9E, 0xC0, 0x40, 0x60,
  0x20, 0x32, 0x71, 0xF0, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x02, 0x39, 0x80,
  0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0x61, 0x08, 0x00,
  0x00, 0x81, 0xC3, 0x87, 0x8F, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xC0,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x1C, 0x38, 0x70, 0xE0, 0x40, 0x00, 0x3C, 0xFC, 0x18, 0x30, 0x60,
  0x83, 0x0C, 0x30, 0xC1, 0x82, 0x00, 0x08, 0x30, 0x60, 0x03, 0xC0, 0x7B,
  0x86, 0x06, 0x60, 0x12, 0x10, 0xB3, 0xE5, 0x13, 0x39, 0x11, 0xC8, 0x8C,
  0xCC, 0xE6, 0x65, 0x33, 0x69, 0xEE, 0x42, 0x23, 0x00, 0x08, 0x00, 0x73,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x1E, 0x06, 0x83, 0x20, 0xC8,
  0x62, 0x18, 0x87, 0xE3, 0xF8, 0xC2, 0x60, 0x98, 0x3C, 0x0F, 0x03, 0x0F,
  0x03, 0xF8, 0x63, 0x8C, 0x31, 0x86, 0x61, 0x8C, 0x71, 0xF8, 0x3F, 0x84,
  0x31, 0x82, 0x30, 0xC6, 0x18, 0xC3, 0x1F, 0xC7, 0xF0, 0x07, 0xC3, 0xF1,
  0x80, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x38, 0x07, 0x60, 0xF8, 0x0F, 0x03, 0xF8, 0x63, 0x8C, 0x31, 0x86,
  0x60, 0xCC, 0x19, 0x83, 0x30, 0x64, 0x0D, 0x83, 0x30, 0x66, 0x18, 0xC7,
  0x1F, 0xC7, 0xE0, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xFC, 0x3F, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xE3, 0xF8, 0x0F,
  0xC7, 0xF1, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x07, 0xC1, 0xFC, 0x60, 0x98,
  0x07, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC3, 0xD8, 0x1B, 0x03, 0x60, 0x4C,
  0x19, 0xC3, 0x1C, 0xE1, 0xFC, 0x08, 0x31, 0x83, 0x18, 0x31, 0x83, 0x18,
  0x21, 0x06, 0x30, 0x63, 0xFE, 0x3F, 0xE2, 0x04, 0x60, 0xC6, 0x0C, 0x60,
  0xC6, 0x08, 0x41, 0x8C, 0x18, 0x1F, 0x87, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC1, 0xF0, 0x01,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0xB0, 0xE0, 0x08, 0x31, 0x86, 0x18, 0xC1,
  0x98, 0x1B, 0x83, 0x30, 0x36, 0x03, 0xC0, 0x3E, 0x03, 0x60, 0x66, 0x06,
  0x60, 0x63, 0x06, 0x30, 0x43, 0x0C, 0x18, 0x08, 0x30, 0x60, 0xC1, 0x86,
  0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0x0C, 0x07, 0x1C,
  0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x14, 0x1E, 0x34, 0x16, 0x36, 0x36, 0x36,
  0x24, 0x36, 0x6C, 0x26, 0x4C, 0x66, 0xCC, 0x66, 0x8C, 0x67, 0x98, 0x67,
  0x18, 0x47, 0x18, 0xC6, 0x18, 0x0C, 0x18, 0xE0, 0xC7, 0x04, 0x38, 0x21,
  0x63, 0x1B, 0x18, 0xD8, 0xC6, 0x44, 0x33, 0x61, 0x1B, 0x18, 0xD8, 0xC2,
  0xC6, 0x14, 0x30, 0xE1, 0x07, 0x18, 0x38, 0x07, 0x83, 0xF8, 0x63, 0x98,
  0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0x78, 0x1B, 0x03, 0x60, 0x6C,
  0x19, 0x87, 0x1D, 0xC1, 0xF0, 0x0F, 0x07, 0xE1, 0x8C, 0x63, 0x18, 0xCC,
  0x33, 0x0C, 0xC6, 0x3F, 0x0F, 0x86, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03,
  0x00, 0x07, 0x83, 0xF8, 0x63, 0x98, 0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03,
  0xC0, 0x78, 0x1B, 0x03, 0x60, 0x6C, 0x19, 0x87, 0x1D, 0xC1, 0xF0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x0F, 0x07, 0xF1, 0x8C, 0x63, 0x18, 0xCC,
  0x33, 0x0C, 0xC6, 0x3F, 0x09, 0x86, 0x61, 0x88, 0x63, 0x18, 0xC4, 0x33,
  0x0E, 0x0F, 0x87, 0xF3, 0x08, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x01, 0xCD, 0xE3, 0xF0, 0xFF, 0xFF, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x32, 0x0C, 0xC1, 0x98, 0x33, 0x06,
  0x60, 0x88, 0x33, 0x06, 0x60, 0xCC, 0x11, 0x86, 0x39, 0x83, 0xE0, 0xC0,
  0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31, 0x8C, 0x63, 0x10, 0xCC, 0x33, 0x0D,
  0x83, 0x60, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xC1, 0x83, 0x87, 0x0F, 0x0E,
  0x1E, 0x1C, 0x6C, 0x78, 0xD8, 0xB3, 0x33, 0x66, 0x66, 0xCC, 0xC9, 0xB1,
  0xB3, 0x63, 0x46, 0x87, 0x8F, 0x0E, 0x14, 0x1C, 0x38, 0x38, 0x70, 0x60,
  0xC0, 0x18, 0x30, 0x86, 0x0C, 0x40, 0xCC, 0x0D, 0x80, 0x58, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x1B, 0x01, 0x30, 0x33, 0x06, 0x30, 0x61, 0x0C,
  0x18, 0xC1, 0xE1, 0xB0, 0xD8, 0xC4, 0x42, 0x61, 0xE0, 0xF0, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0x0F, 0xE3, 0xFC, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x1F, 0xC7, 0xF8, 0x0F, 0x1F, 0x18, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xF0,
  0xF0, 0xCC, 0x44, 0x46, 0x66, 0x66, 0x22, 0x33, 0x33, 0x07, 0x87, 0xC0,
  0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x08, 0x0C, 0x1E, 0x1F, 0x00, 0x06, 0x01, 0x80, 0xE0,
  0x2C, 0x1B, 0x0C, 0x43, 0x19, 0x86, 0xC0, 0xC0, 0xFF, 0xCD, 0x90, 0x1C,
  0x9F, 0xD8, 0xEC, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC6, 0x63, 0x33, 0x8E,
  0xC0, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0xE3, 0xF8, 0xE3, 0x30,
  0xCC, 0x32, 0x09, 0x86, 0x61, 0x98, 0x66, 0x33, 0xDC, 0xDE, 0x00, 0x1E,
  0x7D, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x23, 0xC0, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x87, 0x63, 0xF9, 0x8E, 0x63, 0x30, 0xCC, 0x33,
  0x0C, 0xC3, 0x31, 0x8C, 0x63, 0x38, 0x76, 0x00, 0x1E, 0x3F, 0x63, 0x63,
  0xC6, 0xFC, 0xF0, 0x80, 0x80, 0xC0, 0xC4, 0x7C, 0x00, 0xE0, 0x3C, 0x04,
  0x01, 0x80, 0x30, 0x0F, 0x83, 0xE0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x01, 0xE0, 0x00, 0x0E, 0x47, 0xF3, 0x1C, 0xC6, 0x61, 0x98, 0x66, 0x19,
  0x86, 0x63, 0x18, 0xC6, 0x71, 0xEC, 0x02, 0x01, 0x80, 0x62, 0x30, 0xF8,
  0x00, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xBC, 0xFE, 0x71, 0x31, 0x98,
  0xC8, 0x6C, 0x36, 0x13, 0x19, 0x0D, 0x86, 0xC3, 0x00, 0x18, 0xC0, 0x01,
  0x18, 0xC6, 0x31, 0x18, 0xC6, 0x23, 0x18, 0x03, 0x03, 0x00, 0x00, 0x02,
  0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x30, 0xE0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x73,
  0x18, 0xCC, 0x36, 0x0F, 0x03, 0xC1, 0xF0, 0x6C, 0x19, 0x84, 0x63, 0x18,
  0xC7, 0x00, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC2, 0x18, 0x61,
  0x84, 0x30, 0xC0, 0x17, 0x3C, 0xFF, 0xF3, 0x9C, 0x4C, 0x61, 0x31, 0x8C,
  0x86, 0x36, 0x10, 0xD8, 0xC2, 0x63, 0x09, 0x0C, 0x6C, 0x31, 0xB0, 0x86,
  0x17, 0x9F, 0xCE, 0x26, 0x33, 0x19, 0x0D, 0x86, 0xC2, 0x63, 0x21, 0xB0,
  0xD8, 0x60, 0x1E, 0x3F, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0x82, 0xC6,
  0xCC, 0x78, 0x0B, 0xC3, 0xD8, 0x71, 0x8C, 0x31, 0x86, 0x20, 0x8C, 0x31,
  0x86, 0x30, 0xC6, 0x30, 0xEE, 0x37, 0x86, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x00, 0x1C, 0x9F, 0xD8, 0xEC, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC6,
  0x63, 0x33, 0x9E, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x17, 0x3E,
  0x38, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x1F, 0x3E,
  0x60, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x04, 0x0C, 0x9C, 0xF8, 0x30, 0xC7,
  0xFE, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0xD3, 0x80, 0x21, 0xB0, 0xD8,
  0x4C, 0x64, 0x36, 0x1B, 0x0D, 0x84, 0xC6, 0x63, 0x37, 0x9E, 0xC0, 0xC3,
  0xC3, 0xC6, 0xC6, 0xC4, 0xCC, 0x48, 0x58, 0x50, 0x70, 0x70, 0x60, 0xC3,
  0x1E, 0x38, 0xF1, 0xCD, 0x9E, 0x6C, 0xB2, 0x65, 0xB3, 0x6D, 0x1A, 0x78,
  0xF3, 0xC7, 0x1C, 0x38, 0xE1, 0xC6, 0x00, 0x18, 0xC6, 0x61, 0x98, 0x2C,
  0x0E, 0x03, 0x80, 0xC0, 0x78, 0x36, 0x0D, 0x86, 0x33, 0x0C, 0x18, 0x63,
  0x0C, 0x61, 0x04, 0x60, 0x88, 0x13, 0x02, 0x40, 0x58, 0x0B, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x1F, 0x8F,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x1F, 0xC0,
  0x01, 0x83, 0x81, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x38, 0x3C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x10, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x1E, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x07, 0x0F, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0xE0, 0x78,
  0xEF, 0xE0, 0x80,
};

const GFXglyph NotoSans_Condensed_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 5, 0, -16 },
  { 13, 7, 6, 8, 2, -16 },
  { 19, 11, 16, 11, 0, -16 },
  { 41, 10, 18, 10, 0, -17 },
  { 64, 13, 16, 15, 1, -16 },
  { 90, 11, 16, 11, 0, -16 },
  { 112, 3, 6, 4, 2, -16 },
  { 115, 6, 19, 6, 1, -16 },
  { 130, 7, 19, 6, -2, -16 },
  { 147, 8, 8, 9, 2, -17 },
  { 155, 9, 10, 10, 1, -13 },
  { 167, 4, 5, 5, -1, -2 },
  { 170, 6, 2, 6, 0, -7 },
  { 172, 3, 3, 5, 0, -3 },
  { 174, 10, 16, 8, -1, -16 },
  { 194, 9, 16, 10, 1, -16 },
  { 212, 5, 16, 10, 3, -16 },
  { 222, 10, 16, 10, 0, -16 },
  { 242, 10, 16, 10, 0, -16 },
  { 262, 10, 16, 10, 0, -16 },
  { 282, 10, 16, 10, 0, -16 },
  { 302, 9, 16, 10, 1, -16 },
  { 320, 9, 16, 10, 1, -16 },
  { 338, 10, 16, 10, 0, -16 },
  { 358, 9, 16, 10, 0, -16 },
  { 376, 5, 12, 5, 0, -12 },
  { 384, 6, 15, 5, -1, -12 },
  { 396, 9, 10, 10, 1, -13 },
  { 408, 9, 6, 10, 1, -11 },
  { 415, 9, 10, 10, 1, -13 },
  { 427, 7, 16, 7, 1, -16 },
  { 441, 13, 18, 15, 1, -16 },
  { 471, 10, 16, 10, -1, -16 },
  { 491, 11, 16, 11, 0, -16 },
  { 513, 10, 16, 10, 1, -16 },
  { 533, 11, 16, 12, 0, -16 },
  { 555, 10, 16, 9, 0, -16 },
  { 575, 10, 16, 8, 0, -16 },
  { 595, 11, 16, 12, 1, -16 },
  { 617, 12, 16, 12, 0, -16 },
  { 641, 9, 16, 6, -1, -16 },
  { 659, 8, 20, 5, -3, -16 },
  { 679, 12, 16, 10, 0, -16 },
  { 703, 7, 16, 8, 0, -16 },
  { 717, 16, 16, 16, 0, -16 },
  { 749, 13, 16, 13, 0, -16 },
  { 775, 11, 16, 12, 1, -16 },
  { 797, 10, 16, 10, 0, -16 },
  { 817, 11, 20, 12, 1, -16 },
  { 845, 10, 16, 10, 0, -16 },
  { 865, 10, 16, 9, 0, -16 },
  { 885, 8, 16, 9, 2, -16 },
  { 901, 11, 16, 12, 1, -16 },
  { 923, 10, 16, 10, 2, -16 },
  { 943, 15, 16, 16, 2, -16 },
  { 973, 12, 16, 9, -1, -16 },
  { 997, 9, 16, 9, 2, -16 },
  { 1015, 11, 16, 9, -1, -16 },
  { 1037, 8, 20, 6, 0, -16 },
  { 1057, 4, 16, 8, 2, -16 },
  { 1065, 9, 20, 6, -2, -16 },
  { 1088, 10, 9, 10, 0, -16 },
  { 1100, 8, 1, 7, -2, 2 },
  { 1101, 3, 4, 6, 3, -17 },
  { 1103, 9, 12, 10, 1, -12 },
  { 1117, 10, 17, 10, 0, -17 },
  { 1139, 7, 12, 8, 1, -12 },
  { 1150, 10, 17, 10, 1, -17 },
  { 1172, 8, 12, 9, 1, -12 },
  { 1184, 11, 22, 6, -3, -17 },
  { 1215, 10, 17, 10, 0, -12 },
  { 1237, 9, 17, 10, 0, -17 },
  { 1257, 5, 16, 5, 0, -16 },
  { 1267, 8, 21, 5, -3, -16 },
  { 1288, 10, 17, 9, 0, -17 },
  { 1310, 6, 17, 5, 0, -17 },
  { 1323, 14, 12, 15, 0, -12 },
  { 1344, 9, 12, 10, 0, -12 },
  { 1358, 8, 12, 10, 1, -12 },
  { 1370, 11, 17, 10, -1, -12 },
  { 1394, 9, 17, 10, 1, -12 },
  { 1414, 8, 12, 7, 0, -12 },
  { 1426, 8, 12, 8, 0, -12 },
  { 1438, 6, 14, 6, 1, -14 },
  { 1449, 9, 12, 10, 1, -12 },
  { 1463, 8, 12, 8, 1, -12 },
  { 1475, 13, 12, 13, 1, -12 },
  { 1495, 10, 12, 8, -1, -12 },
  { 1510, 11, 17, 8, -2, -12 },
  { 1534, 9, 12, 7, -1, -12 },
  { 1548, 9, 19, 7, 0, -16 },
  { 1570, 2, 22, 9, 4, -17 },
  { 1576, 8, 19, 7, -1, -16 },
  { 1595, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Italic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Italic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Italic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_ITALIC22PT7B_H_
